******* DOWNLOAD DEVELOPMENT SWITCHES *********************************
YES	equ	1
NO	equ	0
DOWNLOAD	equ	YES

	ifne	DOWNLOAD
	include	transmit.s
	org	$20000

Code_Start
Exec_Addr
	ENDC







begin
	movea.l	a7,a5
	lea	l002b,a7
	movea.l	4(a5),a5
	move.l	12(a5),d0
	add.l	20(a5),d0
	add.l	28(a5),d0
	addi.l	#$100,d0
	move.l	d0,-(a7)
	move.l	a5,-(a7)
	move.w	#0,-(a7)
	move.w	#$4a,-(a7)
	trap	#1
	adda.l	#$c,a7

	ifeq	DOWNLOAD
	pea	0.l
	move.w	#$20,-(a7)
	trap	#1
	addq.l	#6,a7
	endc

	clr.w	-(a7)		;low rez
	pea	$ffffffff.l
	pea	$ffffffff.l
	move.w	#5,-(a7)
	trap	#$e

	dc.w	$a00a		;no mouse

	move.w	#$18,$fffffc02.w

	lea	storage,a0
	move.l	$70.w,(a0)+
	move.l	$120.w,(a0)+
	move.b	$fffffa1b.w,(a0)+
	move.b	$fffffa21.w,(a0)+
	move.b	$fffffa07.w,(a0)+
	move.b	$fffffa09.w,(a0)+
	move.b	$fffffa13.w,(a0)+
	move.b	$ffff8201.w,(a0)+
	move.b	$ffff8203.w,(a0)+
	move.b	$484.w,(a0)+

	move.b	#6,$484.l

	movem.l	$ffff8240.w,d0-d7
	movem.l	d0-d7,old_pal

	movem.l	black,d0-d7
	movem.l	d0-d7,$ffff8240.w

	move.l	$44e.l,d0		;screen base
	subi.l	#$2000,d0
	move.l	d0,l002e
	subi.l	#$a000,d0
	move.l	d0,l002d

	movea.l	l002d,a0
	move.l	#$4e1f,d0
l0000	clr.l	(a0)+
	dbf	d0,l0000

	lea	l0033,a0
	lea	l0034,a1
	bsr	copydata

	lea	l0036,a0
	lea	l0037,a1
	bsr	copydata

	lea	l0039,a0
	lea	l003a,a1
	bsr	copydata

	lea	l003c,a0
	lea	l003d,a1
	bsr	copydata

	lea	l003f,a0
	lea	l0040,a1
	bsr	copydata

	lea	l0042,a0
	lea	l0043,a1
	bsr	copydata

	lea	l0045,a0
	lea	l0046,a1
	bsr	copydata

	lea	l0048,a0
	lea	l0049,a1
	bsr	copydata

	lea	l004b,a0
	lea	l004c,a1
	bsr	copydata


	move.w	#1,d0
	jsr	music

	move	#$2700,sr
	move.l	#vbl,$70.w
	clr.b	$fffffa07.w
	clr.b	$fffffa09.w
	move	#$2300,sr
l0001	btst	#0,$fffffc00.w
	beq.s	l0001

	cmpi.b	#$39,$fffffc02.w
	bne.s	l0001

	move	#$2700,sr
	lea	storage,a0
	move.l	(a0)+,$70.w
	move.l	(a0)+,$120.w
	move.b	(a0)+,$fffffa1b.w
	move.b	(a0)+,$fffffa21.w
	move.b	(a0)+,$fffffa07.w
	move.b	(a0)+,$fffffa09.w
	move.b	(a0)+,$fffffa13.w
	move.b	(a0)+,$ffff8201.w
	move.b	(a0)+,$ffff8203.w
	move.b	(a0)+,$484.w
	move	#$2300,sr
	movea.l	$44e.w,a0
	move.l	#$270f,d0
l0002	clr.l	(a0)+
	dbf	d0,l0002
	dc.b	$a0,9
	move.w	#8,$fffffc02.w
	movem.l	old_pal,d0-d7
	movem.l	d0-d7,$ffff8240.w

	ifne	DOWNLOAD
	move.l	4.w,-(sp)
	rts
	endc

	pea	0.l
	trap	#1


vbl	lea	l002f,a0
	lea	$ffff8242.w,a1
	move.w	(a0)+,(a1)+
	move.l	(a0),(a1)
	cmpi.b	#$f,$fffffc02.w
	bne.s	l0004
	move.w	#$30,$ffff8240.w
l0004	cmpi.w	#$53b9,l0014
	bne.s	l0007
	move.l	l0010,d1
	moveq	#$28,d0
	moveq	#7,d2
l0005	cmp.l	d0,d1
	bne.s	l0006
	bsr	l001a
l0006	subq.l	#5,d0
	dbf	d2,l0005
l0007	cmpi.w	#$52b9,l0014
	bne.s	l000a
	move.l	l0010,d1
	moveq	#$28,d0
	moveq	#7,d2
l0008	cmp.l	d0,d1
	bne.s	l0009
	bsr	l001f
l0009	subq.l	#5,d0
	dbf	d2,l0008
l000a	movea.l	l002d,a0
	lea	1632(a0),a0
	moveq	#0,d0
	move.l	#$a6,d1
	move.l	#$a0,d2
l000b	move.l	d0,(a0)
	move.l	d0,8(a0)
	move.l	d0,16(a0)
	move.l	d0,24(a0)
	move.l	d0,32(a0)
	move.l	d0,40(a0)
	move.l	d0,48(a0)
	move.l	d0,56(a0)
	move.l	d0,64(a0)
	move.l	d0,72(a0)
	move.l	d0,80(a0)
	adda.l	d2,a0
	dbf	d1,l000b
	cmpi.b	#$f,$fffffc02.w
	bne.s	l000c
	move.w	#$50,$ffff8240.w
l000c	movea.l	l0027,a1
l000d	equ	*-4
	lea	360(a1),a2
	move.l	#$2ce,d4
l000e	equ	*-4
	lea	l000e,a0
	addq.l	#2,(a0)
	cmpi.l	#$436,(a0)
	bne.s	l000f
	move.l	#$2ce,(a0)
l000f	move.l	#1,d7
l0010	equ	*-4
	cmpi.l	#0,l0010
	bne.s	l0013
	lea	l0028,a0
	addq.l	#6,(a0)
	cmpi.l	#l002a,(a0)
	bne.s	l0011
	move.l	#l0029,(a0)
l0011	lea	l000d,a0
	addq.l	#4,(a0)
	cmpi.l	#l0028,(a0)
	bne.s	l0012
	move.l	#l0027,(a0)
l0012	move.w	#$52b9,l0014
	move.l	#l0010,l0015
l0013	cmpi.l	#$b3,l0010
	bne.s	l0014
	move.w	#$4e71,l0014
	move.l	#$4e714e71,l0015
	addq.w	#1,l0030
	cmpi.w	#$c8,l0030
	bls.s	l0014
	clr.w	l0030
	move.w	#$53b9,l0014
	move.l	#l0010,l0015
l0014	addq.l	#1,l0010
l0015	equ	*-4
	lea	l0017,a3
	movea.l	l002d,a4
	lea	2(a1),a5
	adda.w	d4,a5
l0016	movea.l	a4,a0
	adda.w	(a1)+,a0
	adda.w	(a5)+,a0
	move.w	(a2)+,d6
	jsr	0(a3,d6.w)
	dbf	d7,l0016
	move.l	l002d,d0
	lsr.l	#8,d0
	move.b	d0,$ffff8203.w
	lsr.w	#8,d0
	move.b	d0,$ffff8201.w
	move.l	l002d,d0
	move.l	l002e,l002d
	move.l	d0,l002e

	jsr	music+$22
	clr.w	$ffff8240.w
	rte

l0017	move.l	#$1ff01ff,d1
	move.l	#$c7ffc7ff,d2
	move.l	#$83ff83ff,d3
	and.l	d2,(a0)
	ori.w	#$3800,(a0)
	and.l	d3,160(a0)
	ori.l	#$c007000,160(a0)
	and.l	d1,320(a0)
	ori.l	#$ae007000,320(a0)
	and.l	d1,480(a0)
	ori.l	#$8e007000,480(a0)
	and.l	d1,640(a0)
	ori.w	#$fe00,640(a0)
	and.l	d3,800(a0)
	ori.l	#$78000400,800(a0)
	and.l	d2,960(a0)
	ori.l	#$20001800,960(a0)
	rts

	move.l	#$80ff80ff,d1
	move.l	#$e3ffe3ff,d2
	move.l	#$c1ffc1ff,d3
	and.l	d2,(a0)
	ori.w	#$1c00,(a0)
	and.l	d3,160(a0)
	ori.l	#$6003800,160(a0)
	and.l	d1,320(a0)
	ori.l	#$57003800,320(a0)
	and.l	d1,480(a0)
	ori.l	#$47003800,480(a0)
	and.l	d1,640(a0)
	ori.w	#$7f00,640(a0)
	and.l	d3,800(a0)
	ori.w	#$3e00,800(a0)
	and.l	d2,960(a0)
	ori.l	#$10000c00,960(a0)
	rts

	move.l	#$c07fc07f,d1
	move.l	#$f1fff1ff,d2
	move.l	#$e0ffe0ff,d3
	and.l	d2,(a0)
	ori.w	#$e00,(a0)
	and.l	d3,160(a0)
	ori.l	#$3001c00,160(a0)
	and.l	d1,320(a0)
	ori.l	#$2b801c00,320(a0)
	and.l	d1,480(a0)
	ori.l	#$23801c00,480(a0)
	and.l	d1,640(a0)
	ori.w	#$3f80,640(a0)
	and.l	d3,800(a0)
	ori.l	#$1e000100,800(a0)
	and.l	d2,960(a0)
	ori.l	#$8000600,960(a0)
	rts

	move.l	#$e03fe03f,d1
	move.l	#$f8fff8ff,d2
	move.l	#$f07ff07f,d3
	and.l	d2,(a0)
	ori.w	#$700,(a0)
	and.l	d3,160(a0)
	ori.l	#$1800e00,160(a0)
	and.l	d1,320(a0)
	ori.l	#$15c00e00,320(a0)
	and.l	d1,480(a0)
	ori.l	#$11c00e00,480(a0)
	and.l	d1,640(a0)
	ori.w	#$1fc0,640(a0)
	and.l	d3,800(a0)
	ori.l	#$f000080,800(a0)
	and.l	d2,960(a0)
	ori.l	#$4000300,960(a0)
	rts

	move.l	#$f01ff01f,d1
	move.l	#$fc7ffc7f,d2
	move.l	#$f83ff83f,d3
	and.l	d2,(a0)
	ori.w	#$380,(a0)
	and.l	d3,160(a0)
	ori.l	#$c00700,160(a0)
	and.l	d1,320(a0)
	ori.l	#$ae00700,320(a0)
	and.l	d1,480(a0)
	ori.l	#$8e00700,480(a0)
	and.l	d1,640(a0)
	ori.w	#$fe0,640(a0)
	and.l	d3,800(a0)
	ori.l	#$7800040,800(a0)
	and.l	d2,960(a0)
	ori.l	#$2000180,960(a0)
	rts

	move.l	#$f80ff80f,d1
	move.l	#$fe3ffe3f,d2
	move.l	#$fc1ffc1f,d3
	and.l	d2,(a0)
	ori.w	#$1c0,(a0)
	and.l	d3,160(a0)
	ori.l	#$600380,160(a0)
	and.l	d1,320(a0)
	ori.l	#$5700380,320(a0)
	and.l	d1,480(a0)
	ori.l	#$4700380,480(a0)
	and.l	d1,640(a0)
	ori.w	#$7f0,640(a0)
	and.l	d3,800(a0)
	ori.l	#$3c00020,800(a0)
	and.l	d2,960(a0)
	ori.l	#$10000c0,960(a0)
	rts

	move.l	#$fc07fc07,d1
	move.l	#$ff1fff1f,d2
	move.l	#$fe0ffe0f,d3
	and.l	d2,(a0)
	ori.w	#$e0,(a0)
	and.l	d3,160(a0)
	ori.l	#$3001c0,160(a0)
	and.l	d1,320(a0)
	ori.l	#$2b801c0,320(a0)
	and.l	d1,480(a0)
	ori.l	#$23801c0,480(a0)
	and.l	d1,640(a0)
	ori.w	#$3f8,640(a0)
	and.l	d3,800(a0)
	ori.l	#$1e00010,800(a0)
	and.l	d2,960(a0)
	ori.l	#$800060,960(a0)
	rts

	move.l	#$fe03fe03,d1
	move.l	#$ff8fff8f,d2
	move.l	#$ff07ff07,d3
	and.l	d2,(a0)
	ori.w	#$70,(a0)
	and.l	d3,160(a0)
	ori.l	#$1800e0,160(a0)
	and.l	d1,320(a0)
	ori.l	#$15c00e0,320(a0)
	and.l	d1,480(a0)
	ori.l	#$11c00e0,480(a0)
	and.l	d1,640(a0)
	ori.w	#$1fc,640(a0)
	and.l	d3,800(a0)
	ori.l	#$f00008,800(a0)
	and.l	d2,960(a0)
	ori.l	#$400030,960(a0)
	rts

	move.l	#$ff01ff01,d1
	move.l	#$ffc7ffc7,d2
	move.l	#$ff83ff83,d3
	and.l	d2,(a0)
	ori.w	#$38,(a0)
	and.l	d3,160(a0)
	ori.l	#$c0070,160(a0)
	and.l	d1,320(a0)
	ori.l	#$ae0070,320(a0)
	and.l	d1,480(a0)
	ori.l	#$8e0070,480(a0)
	and.l	d1,640(a0)
	ori.w	#$fe,640(a0)
	and.l	d3,800(a0)
	ori.l	#$780004,800(a0)
	and.l	d2,960(a0)
	ori.l	#$200018,960(a0)
	rts

	move.l	#$ff80ff80,d1
	move.l	#$ffe3ffe3,d2
	move.l	#$ffc1ffc1,d3
	and.l	d2,(a0)
	ori.w	#$1c,(a0)
	and.l	d3,160(a0)
	ori.l	#$60038,160(a0)
	and.l	d1,320(a0)
	ori.l	#$570038,320(a0)
	and.l	d1,480(a0)
	ori.l	#$470038,480(a0)
	and.l	d1,640(a0)
	ori.w	#$7f,640(a0)
	and.l	d3,800(a0)
	ori.l	#$3c0002,800(a0)
	and.l	d2,960(a0)
	ori.l	#$10000c,960(a0)
	rts

	move.l	#$ffe0ffe0,d0
	move.l	#$ffc0ffc0,d1
	move.l	#$fff1fff1,d2
	move.l	#$7fff7fff,d3
	and.l	d2,(a0)
	ori.w	#$e,(a0)
	and.l	d0,160(a0)
	ori.l	#$3001c,160(a0)
	and.l	d1,320(a0)
	ori.l	#$2b001c,320(a0)
	and.l	d3,328(a0)
	ori.w	#$8000,328(a0)
	and.l	d1,480(a0)
	ori.l	#$23001c,480(a0)
	and.l	d3,488(a0)
	ori.w	#$8000,488(a0)
	and.l	d1,640(a0)
	ori.w	#$3f,640(a0)
	and.l	d3,648(a0)
	ori.w	#$8000,648(a0)
	and.l	d0,800(a0)
	ori.l	#$1e0001,800(a0)
	and.l	d2,960(a0)
	ori.l	#$80006,960(a0)
	rts

	move.l	#$7fff7fff,d0
	move.l	#$ffe0ffe0,d1
	move.l	#$3fff3fff,d2
	move.l	#$fff0fff0,d3
	andi.l	#$fff8fff8,(a0)
	ori.w	#7,(a0)
	and.l	d3,160(a0)
	ori.l	#$1000e,160(a0)
	and.l	d0,168(a0)
	ori.w	#$8000,168(a0)
	and.l	d1,320(a0)
	ori.l	#$15000e,320(a0)
	and.l	d2,328(a0)
	ori.w	#$c000,328(a0)
	and.l	d1,480(a0)
	ori.l	#$11000e,480(a0)
	and.l	d2,488(a0)
	ori.w	#$c000,488(a0)
	and.l	d1,640(a0)
	ori.w	#$1f,640(a0)
	and.l	d2,648(a0)
	ori.w	#$c000,648(a0)
	and.l	d3,800(a0)
	ori.w	#$f,800(a0)
	and.l	d0,808(a0)
	ori.w	#$8000,810(a0)
	andi.l	#$fff8fff8,960(a0)
	ori.l	#$40003,960(a0)
	rts

	move.l	#$7fff7fff,d0
	move.l	#$1fff1fff,d1
	move.l	#$fffcfffc,d2
	move.l	#$fff0fff0,d3
	and.l	d2,(a0)
	ori.w	#3,(a0)
	and.l	d0,968(a0)
	ori.w	#$8000,968(a0)
	andi.l	#$fff8fff8,160(a0)
	ori.w	#7,162(a0)
	andi.l	#$3fff3fff,168(a0)
	ori.w	#$c000,168(a0)
	and.l	d3,320(a0)
	ori.l	#$a0007,320(a0)
	and.l	d1,328(a0)
	ori.w	#$e000,328(a0)
	and.l	d3,480(a0)
	ori.l	#$80007,480(a0)
	and.l	d1,488(a0)
	ori.w	#$e000,488(a0)
	and.l	d3,640(a0)
	ori.w	#$f,640(a0)
	and.l	d1,648(a0)
	ori.w	#$e000,648(a0)
	andi.l	#$fff8fff8,800(a0)
	ori.w	#7,800(a0)
	andi.l	#$3fff3fff,808(a0)
	ori.l	#$80004000,808(a0)
	and.l	d2,960(a0)
	ori.l	#$20001,960(a0)
	and.l	d0,968(a0)
	ori.w	#$8000,970(a0)
	rts

	move.l	#$fffcfffc,d0
	move.l	#$fff8fff8,d1
	move.l	#$fff0fff,d2
	move.l	#$70008000,d3
	andi.l	#$fffefffe,(a0)
	ori.w	#1,(a0)
	andi.l	#$3fff3fff,8(a0)
	ori.w	#$c000,8(a0)
	and.l	d0,160(a0)
	ori.w	#3,162(a0)
	andi.l	#$1fff1fff,168(a0)
	ori.l	#$60008000,168(a0)
	and.l	d1,320(a0)
	ori.l	#$50003,320(a0)
	and.l	d2,328(a0)
	or.l	d3,328(a0)
	and.l	d1,480(a0)
	ori.l	#$40003,480(a0)
	and.l	d2,488(a0)
	or.l	d3,488(a0)
	and.l	d1,640(a0)
	ori.w	#7,640(a0)
	and.l	d2,648(a0)
	ori.w	#$f000,648(a0)
	and.l	d0,800(a0)
	ori.w	#3,800(a0)
	andi.l	#$1fff1fff,808(a0)
	ori.l	#$c0002000,808(a0)
	andi.l	#$fffefffe,960(a0)
	ori.w	#1,960(a0)
	andi.l	#$3fff3fff,968(a0)
	ori.w	#$c000,970(a0)
	rts

	move.l	#$1fff1fff,d0
	move.l	#$fffcfffc,d1
	move.l	#$7ff07ff,d2
	move.l	#$fffefffe,d3
	and.l	d0,8(a0)
	ori.w	#$e000,8(a0)
	and.l	d3,160(a0)
	ori.w	#1,162(a0)
	andi.l	#$fff0fff,168(a0)
	ori.l	#$3000c000,168(a0)
	and.l	d1,320(a0)
	ori.l	#$20001,320(a0)
	and.l	d2,328(a0)
	ori.l	#$b800c000,328(a0)
	and.l	d1,480(a0)
	ori.l	#$20001,480(a0)
	and.l	d2,488(a0)
	ori.l	#$3800c000,488(a0)
	and.l	d1,640(a0)
	ori.w	#3,640(a0)
	and.l	d2,648(a0)
	ori.w	#$f800,648(a0)
	and.l	d3,800(a0)
	ori.w	#1,800(a0)
	andi.l	#$fff0fff,808(a0)
	ori.l	#$e0001000,808(a0)
	and.l	d0,968(a0)
	ori.l	#$80006000,968(a0)
	rts

	move.l	#$7ff07ff,d0
	move.l	#$fffefffe,d1
	move.l	#$3ff03ff,d2
	move.l	#$8fff8fff,d3
	and.l	d3,8(a0)
	ori.w	#$7000,8(a0)
	and.l	d0,168(a0)
	ori.l	#$1800e000,168(a0)
	and.l	d1,320(a0)
	ori.w	#1,320(a0)
	and.l	d2,328(a0)
	ori.l	#$5c00e000,328(a0)
	and.l	d1,480(a0)
	ori.w	#1,480(a0)
	and.l	d2,488(a0)
	ori.l	#$1c00e000,488(a0)
	and.l	d1,640(a0)
	ori.w	#1,640(a0)
	and.l	d2,648(a0)
	ori.w	#$fc00,648(a0)
	and.l	d0,808(a0)
	ori.l	#$f0000800,808(a0)
	and.l	d3,968(a0)
	ori.l	#$40003000,968(a0)
	rts

copydata	move.w	#90-1,d0
.loop		move.l	(a0)+,(a1)+
		dbf	d0,.loop
		rts

l001a	movem.l	a0/d0-d3,-(a7)
	moveq	#2,d3
	lea	l002f,a0
l001b	move.w	(a0),d0
	andi.w	#$777,d0
	move.w	d0,d1
	move.w	d0,d2
	andi.w	#$f00,d0
	andi.w	#$f0,d1
	andi.w	#$f,d2
	subi.w	#$100,d0
	bpl.s	l001c
	moveq	#0,d0
l001c	subi.w	#$10,d1
	bpl.s	l001d
	moveq	#0,d1
l001d	subq.w	#1,d2
	bpl.s	l001e
	moveq	#0,d2
l001e	add.w	d1,d0
	add.w	d2,d0
	move.w	d0,(a0)+
	dbf	d3,l001b
	movem.l	(a7)+,a0/d0-d3
	rts

l001f	movem.l	a0-a1/d0-d3,-(a7)
	moveq	#2,d3
	lea	l002f,a0
	movea.l	l0028,a1
l0020	move.w	(a1)+,d0
	andi.w	#$777,d0
	move.w	d0,d1
	move.w	d0,d2
	andi.w	#$f00,d0
	andi.w	#$f0,d1
	andi.w	#$f,d2
	move.w	d0,l0021
	move.w	d1,l0023
	move.w	d2,l0025
	move.w	(a0),d0
	andi.w	#$777,d0
	move.w	d0,d1
	move.w	d0,d2
	andi.w	#$f00,d0
	andi.w	#$f0,d1
	andi.w	#$f,d2
	cmp.w	#0,d0
l0021	equ	*-2
	beq.s	l0022
	addi.w	#$100,d0
l0022	cmp.w	#0,d1
l0023	equ	*-2
	beq.s	l0024
	addi.w	#$10,d1
l0024	cmp.w	#0,d2
l0025	equ	*-2
	beq.s	l0026
	addq.w	#1,d2
l0026	add.w	d1,d0
	add.w	d2,d0
	move.w	d0,(a0)+
	dbf	d3,l0020
	movem.l	(a7)+,a0-a1/d0-d3
	rts

l0027	dc.l	l0035
	dc.l	l003b
	dc.l	l0032
	dc.l	l0038
	dc.l	l003e
	dc.l	l0041
	dc.l	l0044
	dc.l	l0047
	dc.l	l004a
l0028	dc.l	l0029
l0029	dc.b	3,3,5,5,7,'g',0,'3'
	dc.b	0,'U',6,'w',3,'0',5,'P'
	dc.b	7,'v',3,0,5,0,7,0
	dc.b	0,'7',0,'W',0,'w',0,'0'
	dc.b	0,'P',0,'p',0,3,0,5
	dc.b	0,7
l002a	dcb.w	128
l002b	dcb.w	20

old_pal	dcb.w	16

l002d	dcb.w	2
l002e	dcb.w	2
l002f	dcb.w	3
l0030	dc.b	0,0
l0032	dc.b	0,'H',0,'H',0,'P',0,'P'
	dc.b	0,'P',0,'X',0,'X',0,'X'
	dc.b	0,'X',0,'X',0,'X',0,'X'
	dc.b	0,'X',0,'X',0,'X',0,'X'
	dc.b	0,'X',0,'P',0,'P',0,'P'
	dc.b	0,'P',0,'P',0,'P',0,'P'
	dc.b	0,'P',0,'X',0,'X',0,'X'
	dc.b	0,'X',0,'`',0,'`',0,'`'
	dc.b	0,'h',0,'h',0,'h',0,'h'
	dc.b	0,'p',0,'p',0,'p',0,'p'
	dc.b	0,'p',0,'p',0,'h',0,'h'
	dc.b	0,'h',0,'h',0,'`',0,'`'
	dc.b	0,'`',0,'`',0,'X',0,'X'
	dc.b	0,'X',0,'X',0,'X',0,'X'
	dc.b	0,'X',0,'`',0,'`',0,'`'
	dc.b	0,'`',0,'`',0,'`',0,'h'
	dc.b	0,'h',0,'h',0,'h',0,'h'
	dc.b	0,'h',0,'h',0,'`',0,'`'
	dc.b	0,'`',0,'X',0,'X',0,'X'
	dc.b	0,'P',0,'P',0,'P',0,'H'
	dc.b	0,'H',0,'H',0,'H',0,'H'
	dc.b	0,'@',0,'@',0,'@',0,'H'
	dc.b	0,'H',0,'H',0,'H',0,'H'
	dc.b	0,'H',0,'H',0,'H',0,'H'
	dc.b	0,'H',0,'H',0,'H',0,'H'
	dc.b	0,'H',0,'@',0,'@',0,'@'
	dc.b	0,'8',0,'8',0,'8',0,'0'
	dc.b	0,'0',0,'0',0,'(',0,'('
	dc.b	0,'(',0,'(',0,'(',0,'('
	dc.b	0,'(',0,'(',0,'(',0,'('
	dc.b	0,'0',0,'0',0,'0',0,'0'
	dc.b	0,'0',0,'0',0,'0',0,'8'
	dc.b	0,'0',0,'0',0,'0',0,'0'
	dc.b	0,'0',0,'0',0,'(',0,'('
	dc.b	0,'(',0,'(',0,' ',0,' '
	dc.b	0,' ',0,' ',0,' ',0,' '
	dc.b	0,' ',0,' ',0,' ',0,'('
	dc.b	0,'(',0,'(',0,'0',0,'0'
	dc.b	0,'0',0,'8',0,'8',0,'8'
	dc.b	0,'8',0,'8',0,'@',0,'@'
	dc.b	0,'@',0,'8',0,'8',0,'8'
	dc.b	0,'8',0,'8',0,'8',0,'8'
	dc.b	0,'8',0,'8',0,'8',0,'8'
	dc.b	0,'8',0,'8',0,'8',0,'8'
	dc.b	0,'8',0,'@',0,'@',0,'@'
	dc.b	2,'>',4,$e0,0,$be,2,$fe
	dc.b	5,$9a,0,'`',1,$de,2,$fe
	dc.b	3,$be,4,'B',4,'B',4,'B'
	dc.b	3,$be,2,$fe,2,'>',1,'~'
	dc.b	0,'`',7,0,5,$9a,4,$e0
	dc.b	4,'B',4,'B',4,'B',5,$9a
	dc.b	7,0,0,$be,2,'>',3,$be
	dc.b	7,0,1,'~',3,'^',7,0
	dc.b	1,'~',2,$fe,4,$e0,7,0
	dc.b	0,$be,1,$1e,1,'~',1,$1e
	dc.b	0,$be,0,0,5,$9a,3,'^'
	dc.b	2,'>',0,$be,5,$9a,3,'^'
	dc.b	1,$de,0,$be,7,0,5,$9a
	dc.b	4,$e0,4,'B',4,$e0,5,$9a
	dc.b	6,'X',0,'`',1,$1e,2,'>'
	dc.b	3,'^',5,$9a,7,0,0,$be
	dc.b	1,'~',1,$de,1,$de,1,$de
	dc.b	1,$1e,0,'`',5,$9a,3,'^'
	dc.b	1,$de,7,0,3,'^',1,'~'
	dc.b	6,'X',2,$fe,0,$be,5,$9a
	dc.b	3,'^',1,$de,0,$be,0,0
	dc.b	7,0,7,0,7,0,0,0
	dc.b	0,$be,1,$1e,2,'>',2,$fe
	dc.b	3,'^',4,'B',4,$e0,4,$e0
	dc.b	4,$e0,4,'B',3,'^',2,'>'
	dc.b	0,$be,6,'X',3,'^',1,$1e
	dc.b	5,$9a,2,$fe,0,$be,4,$e0
	dc.b	2,'>',0,$be,6,'X',3,$be
	dc.b	2,$fe,2,'>',2,'>',2,'>'
	dc.b	2,$9e,3,'^',4,$e0,6,'X'
	dc.b	0,$be,1,$de,2,$fe,3,$be
	dc.b	5,$9a,6,'X',7,0,0,0
	dc.b	7,0,6,'X',4,$e0,3,'^'
	dc.b	2,'>',0,$be,6,'X',3,$be
	dc.b	1,$de,0,$be,6,'X',4,'B'
	dc.b	3,'^',2,$fe,2,$9e,2,$fe
	dc.b	3,'^',4,$e0,7,0,1,$1e
	dc.b	2,$9e,4,$e0,0,$be,2,$9e
	dc.b	4,$e0,0,'`',1,$de,3,'^'
	dc.b	4,$e0,6,'X',0,0,0,0
	dc.b	0,0,7,0,6,'X',4,$e0
	dc.b	3,$be,2,$fe,1,$de,1,$1e
	dc.b	0,'`',0,0,0,0,0,0
	dc.b	0,'`',1,$1e,2,'>',3,$be
	dc.b	6,'X',1,$1e,3,'^',7,0

l0033	dc.b	'j@i',$a0,'i',0,'g '
	dc.b	'e@c``@]',$c0
	dc.b	'Z',$a0,'W',$80,'U',0,'R',$80
	dc.b	'P',0,'N L',$e0,'K',$a0
	dc.b	'K',$a0,'K',$a0,'L@L',$e0
	dc.b	'N P',0,'Q',$e0,'S '
	dc.b	'U',0,'V@W',$80,'X '
	dc.b	'X X W',$80,'U',$a0
	dc.b	'S',$c0,'Q@N K',0
	dc.b	'G@C',$80,'?',$c0,'<',0
	dc.b	'8@4',$80,'2',0,'.',$e0
	dc.b	'-',0,'+',$c0,'*',$80,')',$e0
	dc.b	')',$e0,'*',$80,'+ ,`'
	dc.b	'-',$a0,'.',$e0,'0 1`'
	dc.b	'2',0,'2',$a0,'2',$a0,'2',$a0
	dc.b	'2',0,'0 .@+',$c0
	dc.b	')@& #',0,$1f,'@'
	dc.b	$1b,$80,$18,'`',$15,'@',$12,' '
	dc.b	$f,$a0,$d,' ',$b,$e0,$b,'@'
	dc.b	$a,$a0,$a,$a0,$b,$e0,$c,$80
	dc.b	$e,'`',$10,'@',$12,$c0,$14,$a0
	dc.b	$17,' ',$19,0,$1a,$e0,$1c,$c0
	dc.b	$1e,0,$1e,$a0,$1f,'@',$1e,$a0
	dc.b	$1e,0,$1c,$c0,$1a,$e0,$19,0
	dc.b	$17,' ',$14,$a0,$12,$c0,$10,'@'
	dc.b	$e,'`',$c,$80,$b,$e0,$a,$a0
	dc.b	$a,$a0,$b,'@',$b,$e0,$d,' '
	dc.b	$f,$a0,$12,' ',$15,'@',$18,'`'
	dc.b	$1b,$80,$1f,'@#',0,'& '
	dc.b	')@+',$c0,'.@0 '
	dc.b	'2',0,'2',$a0,'2',$a0,'2',$a0
	dc.b	'2',0,'1`0 .',$e0
	dc.b	'-',$a0,',`+ *',$80
	dc.b	')',$e0,')',$e0,'*',$80,'+',$c0
	dc.b	'-',0,'.',$e0,'2',0,'4',$80
	dc.b	'8@<',0,'?',$c0,'C',$80
	dc.b	'G@K',0,'N Q@'
	dc.b	'S',$c0,'U',$a0,'W',$80,'X '
	dc.b	'X X W',$80,'V@'
	dc.b	'U',0,'S Q',$e0,'P',0
	dc.b	'N L',$e0,'L@K',$a0
	dc.b	'K',$a0,'K',$a0,'L',$e0,'N '
	dc.b	'P',0,'R',$80,'U',0,'W',$80
	dc.b	'Z',$a0,']',$c0,'`@c`'
	dc.b	'e@g i',0,'i',$a0

l0034	dcb.w	180
l0035	dc.b	0,'H',0,'H',0,'P',0,'P'
	dc.b	0,'P',0,'X',0,'X',0,'X'
	dc.b	0,'X',0,'X',0,'X',0,'X'
	dc.b	0,'X',0,'X',0,'X',0,'X'
	dc.b	0,'X',0,'P',0,'P',0,'P'
	dc.b	0,'P',0,'P',0,'P',0,'P'
	dc.b	0,'P',0,'X',0,'X',0,'X'
	dc.b	0,'X',0,'`',0,'`',0,'`'
	dc.b	0,'h',0,'h',0,'h',0,'h'
	dc.b	0,'p',0,'p',0,'p',0,'p'
	dc.b	0,'p',0,'p',0,'h',0,'h'
	dc.b	0,'h',0,'h',0,'`',0,'`'
	dc.b	0,'`',0,'`',0,'X',0,'X'
	dc.b	0,'X',0,'X',0,'X',0,'X'
	dc.b	0,'X',0,'`',0,'`',0,'`'
	dc.b	0,'`',0,'`',0,'`',0,'h'
	dc.b	0,'h',0,'h',0,'h',0,'h'
	dc.b	0,'h',0,'h',0,'`',0,'`'
	dc.b	0,'`',0,'X',0,'X',0,'X'
	dc.b	0,'P',0,'P',0,'P',0,'H'
	dc.b	0,'H',0,'H',0,'H',0,'H'
	dc.b	0,'@',0,'@',0,'@',0,'H'
	dc.b	0,'H',0,'H',0,'H',0,'H'
	dc.b	0,'H',0,'H',0,'H',0,'H'
	dc.b	0,'H',0,'H',0,'H',0,'H'
	dc.b	0,'H',0,'@',0,'@',0,'@'
	dc.b	0,'8',0,'8',0,'8',0,'0'
	dc.b	0,'0',0,'0',0,'(',0,'('
	dc.b	0,'(',0,'(',0,'(',0,'('
	dc.b	0,'(',0,'(',0,'(',0,'('
	dc.b	0,'0',0,'0',0,'0',0,'0'
	dc.b	0,'0',0,'0',0,'0',0,'8'
	dc.b	0,'0',0,'0',0,'0',0,'0'
	dc.b	0,'0',0,'0',0,'(',0,'('
	dc.b	0,'(',0,'(',0,' ',0,' '
	dc.b	0,' ',0,' ',0,' ',0,' '
	dc.b	0,' ',0,' ',0,' ',0,'('
	dc.b	0,'(',0,'(',0,'0',0,'0'
	dc.b	0,'0',0,'8',0,'8',0,'8'
	dc.b	0,'8',0,'8',0,'@',0,'@'
	dc.b	0,'@',0,'8',0,'8',0,'8'
	dc.b	0,'8',0,'8',0,'8',0,'8'
	dc.b	0,'8',0,'8',0,'8',0,'8'
	dc.b	0,'8',0,'8',0,'8',0,'8'
	dc.b	0,'8',0,'@',0,'@',0,'@'
	dc.b	2,'>',4,$e0,0,$be,2,$fe
	dc.b	5,$9a,0,'`',1,$de,2,$fe
	dc.b	3,$be,4,'B',4,'B',4,'B'
	dc.b	3,$be,2,$fe,2,'>',1,'~'
	dc.b	0,'`',7,0,5,$9a,4,$e0
	dc.b	4,'B',4,'B',4,'B',5,$9a
	dc.b	7,0,0,$be,2,'>',3,$be
	dc.b	7,0,1,'~',3,'^',7,0
	dc.b	1,'~',2,$fe,4,$e0,7,0
	dc.b	0,$be,1,$1e,1,'~',1,$1e
	dc.b	0,$be,0,0,5,$9a,3,'^'
	dc.b	2,'>',0,$be,5,$9a,3,'^'
	dc.b	1,$de,0,$be,7,0,5,$9a
	dc.b	4,$e0,4,'B',4,$e0,5,$9a
	dc.b	6,'X',0,'`',1,$1e,2,'>'
	dc.b	3,'^',5,$9a,7,0,0,$be
	dc.b	1,'~',1,$de,1,$de,1,$de
	dc.b	1,$1e,0,'`',5,$9a,3,'^'
	dc.b	1,$de,7,0,3,'^',1,'~'
	dc.b	6,'X',2,$fe,0,$be,5,$9a
	dc.b	3,'^',1,$de,0,$be,0,0
	dc.b	7,0,7,0,7,0,0,0
	dc.b	0,$be,1,$1e,2,'>',2,$fe
	dc.b	3,'^',4,'B',4,$e0,4,$e0
	dc.b	4,$e0,4,'B',3,'^',2,'>'
	dc.b	0,$be,6,'X',3,'^',1,$1e
	dc.b	5,$9a,2,$fe,0,$be,4,$e0
	dc.b	2,'>',0,$be,6,'X',3,$be
	dc.b	2,$fe,2,'>',2,'>',2,'>'
	dc.b	2,$9e,3,'^',4,$e0,6,'X'
	dc.b	0,$be,1,$de,2,$fe,3,$be
	dc.b	5,$9a,6,'X',7,0,0,0
	dc.b	7,0,6,'X',4,$e0,3,'^'
	dc.b	2,'>',0,$be,6,'X',3,$be
	dc.b	1,$de,0,$be,6,'X',4,'B'
	dc.b	3,'^',2,$fe,2,$9e,2,$fe
	dc.b	3,'^',4,$e0,7,0,1,$1e
	dc.b	2,$9e,4,$e0,0,$be,2,$9e
	dc.b	4,$e0,0,'`',1,$de,3,'^'
	dc.b	4,$e0,6,'X',0,0,0,0
	dc.b	0,0,7,0,6,'X',4,$e0
	dc.b	3,$be,2,$fe,1,$de,1,$1e
	dc.b	0,'`',0,0,0,0,0,0
	dc.b	0,'`',1,$1e,2,'>',3,$be
	dc.b	6,'X',1,$1e,3,'^',7,0

l0036	dc.b	'j@i',$a0,'i',0,'g',$c0
	dc.b	'f',$80,'d',$a0,'b',$c0,'`',$e0
	dc.b	'^`[',$e0,'X',$c0,'V@'
	dc.b	'S',$c0,'Q',$e0,'O`M',$80
	dc.b	'L@K',0,'I',$c0,'I '
	dc.b	'I I I I',$c0
	dc.b	'K',0,'K',$a0,'L',$e0,'N '
	dc.b	'O`P',0,'Q@Q',$e0
	dc.b	'Q',$e0,'Q',$e0,'Q',$e0,'Q@'
	dc.b	'P',0,'N',$c0,'L',$e0,'J`'
	dc.b	'G',$e0,'E`B@? '
	dc.b	';`8@4',$80,'0',$c0
	dc.b	'-',$a0,'*',$80,'(',0,'%',$80
	dc.b	'#',0,'! ',$1f,$e0,$1e,$a0
	dc.b	$1e,0,$1e,0,$1e,0,$1e,0
	dc.b	$1f,'@',$1f,$e0,' ',$80,'!',$c0
	dc.b	'#',0,'$@$',$e0,'& '
	dc.b	'&',$c0,'&',$c0,'&',$c0,'&',$c0
	dc.b	'& $',$e0,'#',$a0,'"`'
	dc.b	' ',$80,$1e,0,$1c,' ',$19,$a0
	dc.b	$17,' ',$14,0,$11,$80,$f,0
	dc.b	$d,' ',$b,'@',9,'`',8,' '
	dc.b	6,$e0,6,'@',6,'@',6,'@'
	dc.b	6,$e0,8,' ',9,'`',$b,'@'
	dc.b	$d,' ',$f,0,$11,$80,$14,0
	dc.b	$17,' ',$19,$a0,$1c,' ',$1e,0
	dc.b	' ',$80,'"`#',$a0,'$',$e0
	dc.b	'& &',$c0,'&',$c0,'&',$c0
	dc.b	'&',$c0,'& $',$e0,'$@'
	dc.b	'#',0,'!',$c0,' ',$80,$1f,$e0
	dc.b	$1f,'@',$1e,0,$1e,0,$1e,0
	dc.b	$1e,0,$1e,$a0,$1f,$e0,'! '
	dc.b	'#',0,'%',$80,'(',0,'*',$80
	dc.b	'-',$a0,'0',$c0,'4',$80,'8@'
	dc.b	';`? B@E`'
	dc.b	'G',$e0,'J`L',$e0,'N',$c0
	dc.b	'P',0,'Q@Q',$e0,'Q',$e0
	dc.b	'Q',$e0,'Q',$e0,'Q@P',0
	dc.b	'O`N L',$e0,'K',$a0
	dc.b	'K',0,'I',$c0,'I I '
	dc.b	'I I I',$c0,'K',0
	dc.b	'L@M',$80,'O`Q',$e0
	dc.b	'S',$c0,'V@X',$c0,'[',$e0
	dc.b	'^``',$e0,'b',$c0,'d',$a0
	dc.b	'f',$80,'g',$c0,'i',0,'i',$a0

l0037	dcb.w	180

l0038	dc.b	0,'H',0,'H',0,'H',0,'P'
	dc.b	0,'P',0,'P',0,'P',0,'X'
	dc.b	0,'X',0,'X',0,'X',0,'`'
	dc.b	0,'`',0,'`',0,'`',0,'`'
	dc.b	0,'`',0,'`',0,'`',0,'h'
	dc.b	0,'h',0,'h',0,'h',0,'h'
	dc.b	0,'h',0,'h',0,'h',0,'`'
	dc.b	0,'`',0,'`',0,'`',0,'`'
	dc.b	0,'`',0,'`',0,'`',0,'X'
	dc.b	0,'X',0,'X',0,'X',0,'P'
	dc.b	0,'P',0,'P',0,'P',0,'H'
	dc.b	0,'H',0,'H',0,'H',0,'@'
	dc.b	0,'@',0,'@',0,'@',0,'8'
	dc.b	0,'8',0,'8',0,'8',0,'0'
	dc.b	0,'0',0,'0',0,'0',0,'0'
	dc.b	0,'0',0,'0',0,'(',0,'('
	dc.b	0,'(',0,'(',0,'(',0,'('
	dc.b	0,'(',0,'(',0,'(',0,'('
	dc.b	0,'(',0,'(',0,'0',0,'0'
	dc.b	0,'0',0,'0',0,'0',0,'0'
	dc.b	0,'0',0,'8',0,'8',0,'8'
	dc.b	0,'8',0,'@',0,'@',0,'@'
	dc.b	0,'@',0,'H',0,'H',0,'H'
	dc.b	0,'H',0,'P',0,'P',0,'P'
	dc.b	0,'P',0,'X',0,'X',0,'X'
	dc.b	0,'X',0,'`',0,'`',0,'`'
	dc.b	0,'`',0,'`',0,'`',0,'`'
	dc.b	0,'`',0,'h',0,'h',0,'h'
	dc.b	0,'h',0,'h',0,'h',0,'h'
	dc.b	0,'h',0,'`',0,'`',0,'`'
	dc.b	0,'`',0,'`',0,'`',0,'`'
	dc.b	0,'`',0,'X',0,'X',0,'X'
	dc.b	0,'X',0,'P',0,'P',0,'P'
	dc.b	0,'P',0,'H',0,'H',0,'H'
	dc.b	0,'H',0,'@',0,'@',0,'@'
	dc.b	0,'@',0,'8',0,'8',0,'8'
	dc.b	0,'8',0,'0',0,'0',0,'0'
	dc.b	0,'0',0,'0',0,'0',0,'0'
	dc.b	0,'(',0,'(',0,'(',0,'('
	dc.b	0,'(',0,'(',0,'(',0,'('
	dc.b	0,'(',0,'(',0,'(',0,'('
	dc.b	0,'0',0,'0',0,'0',0,'0'
	dc.b	0,'0',0,'0',0,'0',0,'8'
	dc.b	0,'8',0,'8',0,'8',0,'@'
	dc.b	0,'@',0,'@',0,'@',0,'H'
	dc.b	2,'>',3,$be,6,'X',0,$be
	dc.b	2,$9e,4,'B',6,'X',0,$be
	dc.b	2,'>',3,'^',5,$9a,0,0
	dc.b	1,$1e,1,$de,2,$fe,3,$be
	dc.b	4,$e0,6,'X',7,0,0,0
	dc.b	0,'`',0,$be,0,$be,0,$be
	dc.b	0,$be,0,'`',0,0,7,0
	dc.b	6,'X',4,$e0,3,$be,2,$fe
	dc.b	1,$de,1,$1e,0,0,5,$9a
	dc.b	3,'^',2,'>',0,$be,6,'X'
	dc.b	4,'B',2,$9e,0,$be,6,'X'
	dc.b	3,$be,2,'>',0,$be,6,'X'
	dc.b	3,$be,1,$de,0,'`',6,'X'
	dc.b	3,$be,2,'>',1,$1e,7,0
	dc.b	4,$e0,3,'^',2,$9e,1,'~'
	dc.b	0,$be,0,0,6,'X',5,$9a
	dc.b	4,$e0,4,'B',3,$be,3,$be
	dc.b	3,$be,3,$be,4,'B',4,$e0
	dc.b	5,$9a,6,'X',0,0,0,$be
	dc.b	1,'~',2,$9e,3,'^',4,$e0
	dc.b	7,0,1,$1e,2,'>',3,$be
	dc.b	6,'X',0,'`',1,$de,3,$be
	dc.b	6,'X',0,$be,2,'>',3,$be
	dc.b	6,'X',0,$be,2,$9e,4,'B'
	dc.b	6,'X',0,$be,2,'>',3,'^'
	dc.b	5,$9a,0,0,1,$1e,1,$de
	dc.b	2,$fe,3,$be,4,$e0,6,'X'
	dc.b	7,0,0,0,0,'`',0,$be
	dc.b	0,$be,0,$be,0,$be,0,'`'
	dc.b	0,0,7,0,6,'X',4,$e0
	dc.b	3,$be,2,$fe,1,$de,1,$1e
	dc.b	0,0,5,$9a,3,'^',2,'>'
	dc.b	0,$be,6,'X',4,'B',2,$9e
	dc.b	0,$be,6,'X',3,$be,2,'>'
	dc.b	0,$be,6,'X',3,$be,1,$de
	dc.b	0,'`',6,'X',3,$be,2,'>'
	dc.b	1,$1e,7,0,4,$e0,3,'^'
	dc.b	2,$9e,1,'~',0,$be,0,0
	dc.b	6,'X',5,$9a,4,$e0,4,'B'
	dc.b	3,$be,3,$be,3,$be,3,$be
	dc.b	4,'B',4,$e0,5,$9a,6,'X'
	dc.b	0,0,0,$be,1,'~',2,$9e
	dc.b	3,'^',4,$e0,7,0,1,$1e
	dc.b	2,'>',3,$be,6,'X',0,'`'
	dc.b	1,$de,3,$be,6,'X',0,$be
l0039	dc.b	']',$c0,']',$c0,']',$c0,']',$c0
	dc.b	'] ] ] \',$80
	dc.b	'\',$80,'[',$e0,'[@[@'
	dc.b	'Z',$a0,'Z',0,'Y`X',$c0
	dc.b	'X W',$80,'V',$e0,'U',$a0
	dc.b	'U',0,'T`S R',$80
	dc.b	'Q@P',$a0,'O`N '
	dc.b	'M',$80,'L@K',0,'I',$c0
	dc.b	'H',$80,'G@F',0,'E`'
	dc.b	'D B',$e0,'A',$a0,'?',$c0
	dc.b	'>',$80,'=@<',0,':',$c0
	dc.b	'9',$80,'8@7',0,'5',$c0
	dc.b	'4',$80,'3@2',0,'0',$c0
	dc.b	'.',$e0,'-',$a0,',`+ '
	dc.b	'*',$80,')@(',0,'&',$c0
	dc.b	'%',$80,'$@#',0,'"`'
	dc.b	'! ',$1f,$e0,$1f,'@',$1e,0
	dc.b	$1d,'`',$1c,' ',$1b,$80,$1a,$e0
	dc.b	$19,$a0,$19,0,$18,'`',$17,$c0
	dc.b	$17,' ',$16,$80,$15,$e0,$15,'@'
	dc.b	$15,'@',$14,$a0,$14,0,$14,0
	dc.b	$13,'`',$13,'`',$13,'`',$12,$c0
	dc.b	$12,$c0,$12,$c0,$12,$c0,$12,$c0
	dc.b	$12,$c0,$12,$c0,$13,'`',$13,'`'
	dc.b	$13,'`',$14,0,$14,0,$14,$a0
	dc.b	$15,'@',$15,'@',$15,$e0,$16,$80
	dc.b	$17,' ',$17,$c0,$18,'`',$19,0
	dc.b	$19,$a0,$1a,$e0,$1b,$80,$1c,' '
	dc.b	$1d,'`',$1e,0,$1f,'@',$1f,$e0
	dc.b	'! "`#',0,'$@'
	dc.b	'%',$80,'&',$c0,'(',0,')@'
	dc.b	'*',$80,'+ ,`-',$a0
	dc.b	'.',$e0,'0',$c0,'2',0,'3@'
	dc.b	'4',$80,'5',$c0,'7',0,'8@'
	dc.b	'9',$80,':',$c0,'<',0,'=@'
	dc.b	'>',$80,'?',$c0,'A',$a0,'B',$e0
	dc.b	'D E`F',0,'G@'
	dc.b	'H',$80,'I',$c0,'K',0,'L@'
	dc.b	'M',$80,'N O`P',$a0
	dc.b	'Q@R',$80,'S T`'
	dc.b	'U',0,'U',$a0,'V',$e0,'W',$80
	dc.b	'X X',$c0,'Y`Z',0
	dc.b	'Z',$a0,'[@[@[',$e0
	dc.b	'\',$80,'\',$80,'] ] '
	dc.b	'] ]',$c0,']',$c0,']',$c0

l003a	dcb.w	180
l003b	dc.b	0,'H',0,'H',0,'H',0,'H'
	dc.b	0,'H',0,'P',0,'P',0,'P'
	dc.b	0,'P',0,'P',0,'P',0,'P'
	dc.b	0,'P',0,'X',0,'X',0,'X'
	dc.b	0,'X',0,'X',0,'X',0,'X'
	dc.b	0,'X',0,'X',0,'`',0,'`'
	dc.b	0,'`',0,'`',0,'`',0,'`'
	dc.b	0,'`',0,'`',0,'`',0,'`'
	dc.b	0,'`',0,'`',0,'`',0,'`'
	dc.b	0,'`',0,'h',0,'h',0,'h'
	dc.b	0,'h',0,'h',0,'h',0,'h'
	dc.b	0,'h',0,'h',0,'h',0,'h'
	dc.b	0,'h',0,'h',0,'h',0,'h'
	dc.b	0,'h',0,'h',0,'`',0,'`'
	dc.b	0,'`',0,'`',0,'`',0,'`'
	dc.b	0,'`',0,'`',0,'`',0,'`'
	dc.b	0,'`',0,'`',0,'`',0,'`'
	dc.b	0,'`',0,'X',0,'X',0,'X'
	dc.b	0,'X',0,'X',0,'X',0,'X'
	dc.b	0,'X',0,'X',0,'P',0,'P'
	dc.b	0,'P',0,'P',0,'P',0,'P'
	dc.b	0,'P',0,'P',0,'H',0,'H'
	dc.b	0,'H',0,'H',0,'H',0,'H'
	dc.b	0,'H',0,'H',0,'@',0,'@'
	dc.b	0,'@',0,'@',0,'@',0,'@'
	dc.b	0,'@',0,'@',0,'8',0,'8'
	dc.b	0,'8',0,'8',0,'8',0,'8'
	dc.b	0,'8',0,'8',0,'0',0,'0'
	dc.b	0,'0',0,'0',0,'0',0,'0'
	dc.b	0,'0',0,'0',0,'0',0,'0'
	dc.b	0,'0',0,'0',0,'0',0,'('
	dc.b	0,'(',0,'(',0,'(',0,'('
	dc.b	0,'(',0,'(',0,'(',0,'('
	dc.b	0,'(',0,'(',0,'(',0,'('
	dc.b	0,'(',0,'(',0,'(',0,'('
	dc.b	0,'(',0,'(',0,'(',0,'('
	dc.b	0,'(',0,'(',0,'(',0,'('
	dc.b	0,'0',0,'0',0,'0',0,'0'
	dc.b	0,'0',0,'0',0,'0',0,'0'
	dc.b	0,'0',0,'0',0,'0',0,'0'
	dc.b	0,'0',0,'8',0,'8',0,'8'
	dc.b	0,'8',0,'8',0,'8',0,'8'
	dc.b	0,'8',0,'@',0,'@',0,'@'
	dc.b	0,'@',0,'@',0,'@',0,'@'
	dc.b	0,'@',0,'H',0,'H',0,'H'
	dc.b	2,'>',2,$fe,3,$be,4,$e0
	dc.b	6,'X',0,0,0,$be,1,$de
	dc.b	2,$9e,3,'^',4,'B',4,$e0
	dc.b	6,'X',0,0,0,$be,1,'~'
	dc.b	2,'>',2,$fe,3,'^',4,'B'
	dc.b	5,$9a,6,'X',0,0,0,'`'
	dc.b	1,$1e,1,'~',1,$de,2,$9e
	dc.b	2,$fe,3,'^',3,$be,4,'B'
	dc.b	4,$e0,5,$9a,6,'X',6,'X'
	dc.b	7,0,0,0,0,0,0,'`'
	dc.b	0,'`',0,'`',0,$be,0,$be
	dc.b	0,$be,0,$be,0,$be,0,$be
	dc.b	0,$be,0,'`',0,'`',0,'`'
	dcb.w	2
	dc.b	7,0,6,'X',6,'X',5,$9a
	dc.b	4,$e0,4,'B',3,$be,3,'^'
	dc.b	2,$fe,2,$9e,1,$de,1,'~'
	dc.b	1,$1e,0,'`',0,0,6,'X'
	dc.b	5,$9a,4,'B',3,'^',2,$fe
	dc.b	2,'>',1,'~',0,$be,0,0
	dc.b	6,'X',4,$e0,4,'B',3,'^'
	dc.b	2,$9e,1,$de,0,$be,0,0
	dc.b	6,'X',4,$e0,3,$be,2,$fe
	dc.b	2,'>',1,'~',0,$be,0,0
	dc.b	6,'X',4,$e0,3,$be,2,$9e
	dc.b	1,$de,1,$1e,0,'`',0,0
	dc.b	6,'X',4,$e0,3,$be,2,$fe
	dc.b	2,'>',1,'~',1,$1e,0,'`'
	dc.b	7,0,6,'X',4,$e0,4,'B'
	dc.b	3,'^',2,$fe,2,$9e,1,$de
	dc.b	1,'~',1,$1e,0,$be,0,'`'
	dc.b	0,0,7,0,6,'X',6,'X'
	dc.b	5,$9a,4,$e0,4,$e0,4,'B'
	dc.b	4,'B',4,'B',3,$be,3,$be
	dc.b	3,$be,3,$be,3,$be,3,$be
	dc.b	3,$be,4,'B',4,'B',4,'B'
	dc.b	4,$e0,4,$e0,5,$9a,6,'X'
	dc.b	6,'X',7,0,0,0,0,'`'
	dc.b	0,$be,1,$1e,1,'~',1,$de
	dc.b	2,$9e,2,$fe,3,'^',4,'B'
	dc.b	4,$e0,6,'X',7,0,0,'`'
	dc.b	1,$1e,1,'~',2,'>',2,$fe
	dc.b	3,$be,4,$e0,6,'X',0,0
	dc.b	0,'`',1,$1e,1,$de,2,$9e
	dc.b	3,$be,4,$e0,6,'X',0,0
	dc.b	0,$be,1,'~'
l003c	dc.b	']',$c0,']',$c0,']',$c0,']',$c0
	dc.b	'] ] ] \',$80
	dc.b	'\',$80,'[',$e0,'[@[@'
	dc.b	'Z',$a0,'Z',0,'Y`X',$c0
	dc.b	'X W',$80,'V',$e0,'U',$a0
	dc.b	'U',0,'T`S R',$80
	dc.b	'Q@P',$a0,'O`N '
	dc.b	'M',$80,'L@K',0,'I',$c0
	dc.b	'H',$80,'G@F',0,'E`'
	dc.b	'D B',$e0,'A',$a0,'?',$c0
	dc.b	'>',$80,'=@<',0,':',$c0
	dc.b	'9',$80,'8@7',0,'5',$c0
	dc.b	'4',$80,'3@2',0,'0',$c0
	dc.b	'.',$e0,'-',$a0,',`+ '
	dc.b	'*',$80,')@(',0,'&',$c0
	dc.b	'%',$80,'$@#',0,'"`'
	dc.b	'! ',$1f,$e0,$1f,'@',$1e,0
	dc.b	$1d,'`',$1c,' ',$1b,$80,$1a,$e0
	dc.b	$19,$a0,$19,0,$18,'`',$17,$c0
	dc.b	$17,' ',$16,$80,$15,$e0,$15,'@'
	dc.b	$15,'@',$14,$a0,$14,0,$14,0
	dc.b	$13,'`',$13,'`',$13,'`',$12,$c0
	dc.b	$12,$c0,$12,$c0,$12,$c0,$12,$c0
	dc.b	$12,$c0,$12,$c0,$13,'`',$13,'`'
	dc.b	$13,'`',$14,0,$14,0,$14,$a0
	dc.b	$15,'@',$15,'@',$15,$e0,$16,$80
	dc.b	$17,' ',$17,$c0,$18,'`',$19,0
	dc.b	$19,$a0,$1a,$e0,$1b,$80,$1c,' '
	dc.b	$1d,'`',$1e,0,$1f,'@',$1f,$e0
	dc.b	'! "`#',0,'$@'
	dc.b	'%',$80,'&',$c0,'(',0,')@'
	dc.b	'*',$80,'+ ,`-',$a0
	dc.b	'.',$e0,'0',$c0,'2',0,'3@'
	dc.b	'4',$80,'5',$c0,'7',0,'8@'
	dc.b	'9',$80,':',$c0,'<',0,'=@'
	dc.b	'>',$80,'?',$c0,'A',$a0,'B',$e0
	dc.b	'D E`F',0,'G@'
	dc.b	'H',$80,'I',$c0,'K',0,'L@'
	dc.b	'M',$80,'N O`P',$a0
	dc.b	'Q@R',$80,'S T`'
	dc.b	'U',0,'U',$a0,'V',$e0,'W',$80
	dc.b	'X X',$c0,'Y`Z',0
	dc.b	'Z',$a0,'[@[@[',$e0
	dc.b	'\',$80,'\',$80,'] ] '
	dc.b	'] ]',$c0,']',$c0,']',$c0

l003d	dcb.w	180
l003e	dc.b	0,'H',0,'H',0,'H',0,'P'
	dc.b	0,'P',0,'P',0,'X',0,'X'
	dc.b	0,'X',0,'X',0,'`',0,'`'
	dc.b	0,'`',0,'`',0,'h',0,'h'
	dc.b	0,'h',0,'h',0,'h',0,'h'
	dc.b	0,'h',0,'h',0,'h',0,'p'
	dc.b	0,'p',0,'p',0,'h',0,'h'
	dc.b	0,'h',0,'h',0,'h',0,'h'
	dc.b	0,'h',0,'h',0,'h',0,'`'
	dc.b	0,'`',0,'`',0,'`',0,'`'
	dc.b	0,'X',0,'X',0,'X',0,'X'
	dc.b	0,'P',0,'P',0,'P',0,'P'
	dc.b	0,'H',0,'H',0,'H',0,'H'
	dc.b	0,'@',0,'@',0,'@',0,'@'
	dc.b	0,'8',0,'8',0,'8',0,'8'
	dc.b	0,'8',0,'8',0,'0',0,'0'
	dc.b	0,'0',0,'0',0,'0',0,'0'
	dc.b	0,'0',0,'0',0,'0',0,'0'
	dc.b	0,'0',0,'0',0,'0',0,'0'
	dc.b	0,'0',0,'0',0,'8',0,'8'
	dc.b	0,'8',0,'8',0,'8',0,'8'
	dc.b	0,'@',0,'@',0,'@',0,'@'
	dc.b	0,'@',0,'H',0,'H',0,'H'
	dc.b	0,'H',0,'P',0,'P',0,'P'
	dc.b	0,'P',0,'P',0,'X',0,'X'
	dc.b	0,'X',0,'X',0,'X',0,'X'
	dc.b	0,'X',0,'X',0,'`',0,'`'
	dc.b	0,'`',0,'`',0,'`',0,'`'
	dc.b	0,'`',0,'`',0,'`',0,'`'
	dc.b	0,'`',0,'X',0,'X',0,'X'
	dc.b	0,'X',0,'X',0,'X',0,'X'
	dc.b	0,'P',0,'P',0,'P',0,'P'
	dc.b	0,'H',0,'H',0,'H',0,'H'
	dc.b	0,'@',0,'@',0,'@',0,'@'
	dc.b	0,'8',0,'8',0,'8',0,'8'
	dc.b	0,'0',0,'0',0,'0',0,'0'
	dc.b	0,'(',0,'(',0,'(',0,'('
	dc.b	0,'(',0,'(',0,'(',0,' '
	dc.b	0,' ',0,' ',0,' ',0,' '
	dc.b	0,' ',0,' ',0,' ',0,' '
	dc.b	0,' ',0,' ',0,'(',0,'('
	dc.b	0,'(',0,'(',0,'(',0,'('
	dc.b	0,'0',0,'0',0,'0',0,'0'
	dc.b	0,'8',0,'8',0,'8',0,'8'
	dc.b	0,'@',0,'@',0,'@',0,'H'
	dc.b	2,'>',3,$be,7,0,1,'~'
	dc.b	3,'^',5,$9a,0,$be,2,$9e
	dc.b	4,'B',7,0,1,$1e,2,$9e
	dc.b	3,$be,6,'X',0,'`',1,$1e
	dc.b	2,'>',2,$fe,3,$be,4,$e0
	dc.b	5,$9a,7,0,7,0,0,0
	dcb.w	2
	dc.b	7,0,7,0,6,'X',4,$e0
	dc.b	4,'B',3,'^',2,$9e,1,'~'
	dc.b	0,$be,7,0,4,$e0,3,'^'
	dc.b	1,$de,0,'`',6,'X',3,$be
	dc.b	2,'>',0,$be,6,'X',3,$be
	dc.b	1,$de,0,'`',5,$9a,3,'^'
	dc.b	1,$de,0,'`',5,$9a,3,'^'
	dc.b	1,$de,0,$be,6,'X',4,'B'
	dc.b	2,$fe,1,$de,1,$1e,0,'`'
	dc.b	6,'X',5,$9a,4,'B',3,$be
	dc.b	3,'^',2,$fe,2,$9e,2,$9e
	dc.b	2,$9e,2,$fe,2,$fe,3,'^'
	dc.b	3,$be,4,$e0,5,$9a,7,0
	dc.b	0,'`',1,$1e,2,'>',2,$fe
	dc.b	4,'B',6,'X',0,'`',1,'~'
	dc.b	2,$fe,4,'B',7,0,0,$be
	dc.b	2,'>',3,'^',4,$e0,0,0
	dc.b	1,$1e,2,$9e,3,$be,5,$9a
	dc.b	0,0,1,$1e,1,$de,2,$fe
	dc.b	3,$be,4,$e0,6,'X',7,0
	dc.b	0,'`',0,$be,1,$1e,1,$1e
	dc.b	1,'~',1,'~',1,'~',1,$1e
	dc.b	0,$be,0,'`',0,0,6,'X'
	dc.b	5,$9a,3,$be,2,$fe,2,'>'
	dc.b	1,$1e,0,0,5,$9a,3,'^'
	dc.b	2,'>',0,$be,6,'X',3,$be
	dc.b	2,'>',0,$be,6,'X',3,$be
	dc.b	2,'>',0,$be,5,$9a,3,'^'
	dc.b	1,$de,0,'`',5,$9a,3,$be
	dc.b	2,'>',0,$be,7,0,4,$e0
	dc.b	3,'^',2,$9e,1,'~',0,$be
	dc.b	0,0,7,0,5,$9a,4,$e0
	dc.b	4,$e0,4,'B',4,'B',4,'B'
	dc.b	4,$e0,4,$e0,6,'X',7,0
	dc.b	0,'`',1,$1e,1,$de,2,$fe
	dc.b	3,$be,5,$9a,0,'`',1,'~'
	dc.b	2,$fe,4,$e0,0,0,1,'~'
	dc.b	3,'^',6,'X',0,$be,2,$9e
	dc.b	4,$e0,0,'`'
l003f	dc.b	'j@i',$a0,'i',$a0,'i',0
	dc.b	'h`g',$c0,'f',$80,'e@'
	dc.b	'd',0,'b `@^`'
	dc.b	'\',$80,'Z',0,'X U',$a0
	dc.b	'S P',$a0,'M',$80,'K',0
	dc.b	'G',$e0,'E`B@? '
	dc.b	'<',$a0,'9',$80,'6`3',$e0
	dc.b	'0',$c0,'.@+',$c0,'(',$a0
	dc.b	'& #',$a0,'!',$c0,$1f,'@'
	dc.b	$1d,'`',$1b,$80,$19,$a0,$18,'`'
	dc.b	$17,' ',$15,$e0,$14,$a0,$13,'`'
	dc.b	$12,$c0,$12,$c0,$12,' ',$12,' '
	dc.b	$12,' ',$12,' ',$12,$c0,$13,'`'
	dc.b	$14,0,$14,$a0,$15,$e0,$17,' '
	dc.b	$18,'`',$19,$a0,$1b,$80,$1d,'`'
	dc.b	$1f,'@! #',0,'$',$e0
	dc.b	$27,'`)@+',$c0,'.@'
	dc.b	'0 2',$a0,'5 7',0
	dc.b	'9',$80,';`=',$e0,'?',$c0
	dc.b	'A',$a0,'C',$80,'E`G@'
	dc.b	'I J`K',$a0,'L',$e0
	dc.b	'N N',$c0,'O`P',0
	dc.b	'P',$a0,'P',$a0,'Q@P',$a0
	dc.b	'P',$a0,'P',0,'O`N',$c0
	dc.b	'N L',$e0,'K',$a0,'J`'
	dc.b	'I G@E`C',$80
	dc.b	'A',$a0,'?',$c0,'=',$e0,';`'
	dc.b	'9',$80,'7',0,'5 2',$a0
	dc.b	'0 .@+',$c0,')@'
	dc.b	$27,'`$',$e0,'#',0,'! '
	dc.b	$1f,'@',$1d,'`',$1b,$80,$19,$a0
	dc.b	$18,'`',$17,' ',$15,$e0,$14,$a0
	dc.b	$14,0,$13,'`',$12,$c0,$12,' '
	dc.b	$12,' ',$12,' ',$12,' ',$12,$c0
	dc.b	$12,$c0,$13,'`',$14,$a0,$15,$e0
	dc.b	$17,' ',$18,'`',$19,$a0,$1b,$80
	dc.b	$1d,'`',$1f,'@!',$c0,'#',$a0
	dc.b	'& (',$a0,'+',$c0,'.@'
	dc.b	'0',$c0,'3',$e0,'6`9',$80
	dc.b	'<',$a0,'? B@E`'
	dc.b	'G',$e0,'K',0,'M',$80,'P',$a0
	dc.b	'S U',$a0,'X Z',0
	dc.b	'\',$80,'^``@b '
	dc.b	'd',0,'e@f',$80,'g',$c0
	dc.b	'h`i',0,'i',$a0,'i',$a0

l0040	dcb.w	180
l0041	dc.b	0,'h',0,'h',0,'h',0,'h'
	dc.b	0,'h',0,'h',0,'h',0,'h'
	dc.b	0,'`',0,'`',0,'`',0,'`'
	dc.b	0,'`',0,'`',0,'`',0,'`'
	dc.b	0,'`',0,'`',0,'`',0,'`'
	dc.b	0,'`',0,'`',0,'`',0,'X'
	dc.b	0,'X',0,'X',0,'X',0,'X'
	dc.b	0,'X',0,'X',0,'X',0,'X'
	dc.b	0,'X',0,'P',0,'P',0,'P'
	dc.b	0,'P',0,'P',0,'P',0,'P'
	dc.b	0,'P',0,'H',0,'H',0,'H'
	dc.b	0,'H',0,'H',0,'H',0,'H'
	dc.b	0,'@',0,'@',0,'@',0,'@'
	dc.b	0,'@',0,'@',0,'@',0,'@'
	dc.b	0,'8',0,'8',0,'8',0,'8'
	dc.b	0,'8',0,'8',0,'8',0,'8'
	dc.b	0,'8',0,'0',0,'0',0,'0'
	dc.b	0,'0',0,'0',0,'0',0,'0'
	dc.b	0,'0',0,'0',0,'0',0,'0'
	dc.b	0,'0',0,'0',0,'(',0,'('
	dc.b	0,'(',0,'(',0,'(',0,'('
	dc.b	0,'(',0,'(',0,'(',0,'('
	dc.b	0,'(',0,'(',0,'(',0,'('
	dc.b	0,'(',0,'(',0,'(',0,'('
	dc.b	0,'(',0,'(',0,'(',0,'('
	dc.b	0,'(',0,'(',0,'(',0,'0'
	dc.b	0,'0',0,'0',0,'0',0,'0'
	dc.b	0,'0',0,'0',0,'0',0,'0'
	dc.b	0,'0',0,'0',0,'0',0,'0'
	dc.b	0,'8',0,'8',0,'8',0,'8'
	dc.b	0,'8',0,'8',0,'8',0,'8'
	dc.b	0,'8',0,'@',0,'@',0,'@'
	dc.b	0,'@',0,'@',0,'@',0,'@'
	dc.b	0,'@',0,'H',0,'H',0,'H'
	dc.b	0,'H',0,'H',0,'H',0,'H'
	dc.b	0,'P',0,'P',0,'P',0,'P'
	dc.b	0,'P',0,'P',0,'P',0,'P'
	dc.b	0,'X',0,'X',0,'X',0,'X'
	dc.b	0,'X',0,'X',0,'X',0,'X'
	dc.b	0,'X',0,'X',0,'`',0,'`'
	dc.b	0,'`',0,'`',0,'`',0,'`'
	dc.b	0,'`',0,'`',0,'`',0,'`'
	dc.b	0,'`',0,'`',0,'`',0,'`'
	dc.b	0,'`',0,'h',0,'h',0,'h'
	dc.b	0,'h',0,'h',0,'h',0,'h'
	dc.b	0,$be,0,'`',0,'`',0,'`'
	dc.b	0,'`',0,'`',0,0,0,0
	dc.b	7,0,7,0,6,'X',5,$9a
	dc.b	4,$e0,4,'B',3,$be,3,'^'
	dc.b	2,$fe,2,$9e,2,'>',1,$de
	dc.b	1,$1e,0,$be,0,'`',7,0
	dc.b	6,'X',4,$e0,3,$be,3,'^'
	dc.b	2,$9e,1,$de,1,'~',0,$be
	dc.b	0,0,6,'X',4,$e0,3,$be
	dc.b	2,$fe,2,'>',1,'~',0,$be
	dc.b	0,0,6,'X',4,$e0,3,$be
	dc.b	2,$fe,2,'>',1,$1e,0,'`'
	dc.b	7,0,5,$9a,4,'B',3,'^'
	dc.b	2,$9e,1,$de,1,$1e,0,'`'
	dc.b	7,0,5,$9a,4,'B',3,'^'
	dc.b	2,$fe,2,'>',1,'~',0,$be
	dc.b	0,'`',7,0,5,$9a,4,$e0
	dc.b	3,$be,3,'^',2,$fe,2,'>'
	dc.b	1,$de,1,'~',1,$1e,0,$be
	dc.b	0,'`',0,0,7,0,6,'X'
	dc.b	5,$9a,4,$e0,4,$e0,4,'B'
	dc.b	4,'B',3,$be,3,$be,3,$be
	dc.b	3,$be,3,$be,3,$be,3,$be
	dc.b	3,$be,3,$be,3,$be,3,$be
	dc.b	4,'B',4,'B',4,$e0,4,$e0
	dc.b	5,$9a,6,'X',7,0,0,0
	dc.b	0,'`',0,$be,1,$1e,1,'~'
	dc.b	1,$de,2,'>',2,$fe,3,'^'
	dc.b	3,$be,4,$e0,5,$9a,7,0
	dc.b	0,'`',0,$be,1,'~',2,'>'
	dc.b	2,$fe,3,'^',4,'B',5,$9a
	dc.b	7,0,0,'`',1,$1e,1,$de
	dc.b	2,$9e,3,'^',4,'B',5,$9a
	dc.b	7,0,0,'`',1,$1e,2,'>'
	dc.b	2,$fe,3,$be,4,$e0,6,'X'
	dc.b	0,0,0,$be,1,'~',2,'>'
	dc.b	2,$fe,3,$be,4,$e0,6,'X'
	dc.b	0,0,0,$be,1,'~',1,$de
	dc.b	2,$9e,3,'^',3,$be,4,$e0
	dc.b	6,'X',7,0,0,'`',0,$be
	dc.b	1,$1e,1,$de,2,'>',2,$9e
	dc.b	2,$fe,3,'^',3,$be,4,'B'
	dc.b	4,$e0,5,$9a,6,'X',7,0
	dc.b	7,0,0,0,0,0,0,'`'
	dc.b	0,'`',0,'`',0,'`',0,'`'
l0042	dc.b	'8@:',$c0,'=@?',$c0
	dc.b	'B@D',$c0,'G@I',$c0
	dc.b	'K',$a0,'N P',0,'Q',$e0
	dc.b	'S',$c0,'U',$a0,'V',$e0,'X '
	dc.b	'Y`Z',$a0,'[',$e0,'\',$80
	dc.b	'] ] ] ] '
	dc.b	'] ] \',$80,'[',$e0
	dc.b	'Z',$a0,'Y`X V',$e0
	dc.b	'U',$a0,'S',$c0,'Q',$e0,'P',0
	dc.b	'N K',$a0,'I',$c0,'G@'
	dc.b	'D',$c0,'B@?',$c0,'=@'
	dc.b	':',$c0,'8@5 2',$a0
	dc.b	'0 -',$a0,'+ (',$a0
	dc.b	'& $@!',$c0,$1f,$e0
	dc.b	$1e,0,$1c,' ',$1a,'@',$19,0
	dc.b	$17,$c0,$16,$80,$15,'@',$14,0
	dc.b	$13,'`',$12,$c0,$12,$c0,$12,$c0
	dc.b	$12,$c0,$12,$c0,$12,$c0,$13,'`'
	dc.b	$14,0,$15,'@',$16,$80,$17,$c0
	dc.b	$19,0,$1a,'@',$1c,' ',$1e,0
	dc.b	$1f,$e0,'!',$c0,'$@& '
	dc.b	'(',$a0,'+ -',$a0,'0 '
	dc.b	'2',$a0,'5 8@:',$c0
	dc.b	'=@?',$c0,'B@D',$c0
	dc.b	'G@I',$c0,'K',$a0,'N '
	dc.b	'P',0,'Q',$e0,'S',$c0,'U',$a0
	dc.b	'V',$e0,'X Y`Z',$a0
	dc.b	'[',$e0,'\',$80,'] ] '
	dc.b	'] ] ] ] '
	dc.b	'\',$80,'[',$e0,'Z',$a0,'Y`'
	dc.b	'X V',$e0,'U',$a0,'S',$c0
	dc.b	'Q',$e0,'P',0,'N K',$a0
	dc.b	'I',$c0,'G@D',$c0,'B@'
	dc.b	'?',$c0,'=@:',$c0,'8@'
	dc.b	'5 2',$a0,'0 -',$a0
	dc.b	'+ (',$a0,'& $@'
	dc.b	'!',$c0,$1f,$e0,$1e,0,$1c,' '
	dc.b	$1a,'@',$19,0,$17,$c0,$16,$80
	dc.b	$15,'@',$14,0,$13,'`',$12,$c0
	dc.b	$12,$c0,$12,$c0,$12,$c0,$12,$c0
	dc.b	$12,$c0,$13,'`',$14,0,$15,'@'
	dc.b	$16,$80,$17,$c0,$19,0,$1a,'@'
	dc.b	$1c,' ',$1e,0,$1f,$e0,'!',$c0
	dc.b	'$@& (',$a0,'+ '
	dc.b	'-',$a0,'0 2',$a0,'5 '

l0043	dcb.w	180
l0044	dc.b	0,'h',0,'h',0,'h',0,'h'
	dc.b	0,'h',0,'h',0,'h',0,'h'
	dc.b	0,'`',0,'`',0,'`',0,'`'
	dc.b	0,'`',0,'X',0,'X',0,'X'
	dc.b	0,'X',0,'X',0,'P',0,'P'
	dc.b	0,'P',0,'P',0,'P',0,'P'
	dc.b	0,'P',0,'P',0,'P',0,'P'
	dc.b	0,'P',0,'P',0,'P',0,'P'
	dc.b	0,'P',0,'P',0,'P',0,'P'
	dc.b	0,'P',0,'P',0,'P',0,'P'
	dc.b	0,'P',0,'P',0,'P',0,'P'
	dc.b	0,'P',0,'P',0,'P',0,'P'
	dc.b	0,'P',0,'P',0,'H',0,'H'
	dc.b	0,'H',0,'H',0,'@',0,'@'
	dc.b	0,'@',0,'8',0,'8',0,'8'
	dc.b	0,'8',0,'0',0,'0',0,'0'
	dc.b	0,'0',0,'0',0,'0',0,'('
	dc.b	0,'(',0,'(',0,'(',0,'('
	dc.b	0,'(',0,'(',0,'(',0,'0'
	dc.b	0,'0',0,'0',0,'0',0,'0'
	dc.b	0,'0',0,'0',0,'0',0,'8'
	dc.b	0,'8',0,'8',0,'8',0,'8'
	dc.b	0,'8',0,'8',0,'8',0,'8'
	dc.b	0,'8',0,'8',0,'8',0,'8'
	dc.b	0,'8',0,'8',0,'0',0,'0'
	dc.b	0,'0',0,'0',0,'0',0,'0'
	dc.b	0,'0',0,'0',0,'(',0,'('
	dc.b	0,'(',0,'(',0,'(',0,'('
	dc.b	0,'(',0,'(',0,'0',0,'0'
	dc.b	0,'0',0,'0',0,'0',0,'0'
	dc.b	0,'8',0,'8',0,'8',0,'8'
	dc.b	0,'@',0,'@',0,'@',0,'H'
	dc.b	0,'H',0,'H',0,'H',0,'P'
	dc.b	0,'P',0,'P',0,'P',0,'P'
	dc.b	0,'P',0,'P',0,'P',0,'P'
	dc.b	0,'P',0,'P',0,'P',0,'P'
	dc.b	0,'P',0,'P',0,'P',0,'P'
	dc.b	0,'P',0,'P',0,'P',0,'P'
	dc.b	0,'P',0,'P',0,'P',0,'P'
	dc.b	0,'P',0,'P',0,'P',0,'P'
	dc.b	0,'P',0,'P',0,'P',0,'X'
	dc.b	0,'X',0,'X',0,'X',0,'X'
	dc.b	0,'`',0,'`',0,'`',0,'`'
	dc.b	0,'`',0,'h',0,'h',0,'h'
	dc.b	0,'h',0,'h',0,'h',0,'h'
	dc.b	4,$e0,4,'B',4,'B',3,'^'
	dc.b	2,$fe,2,'>',1,'~',0,'`'
	dc.b	6,'X',4,'B',2,$fe,1,$de
	dc.b	0,'`',6,'X',3,$be,2,$9e
	dc.b	1,'~',0,'`',6,'X',4,'B'
	dc.b	3,'^',2,$9e,2,'>',1,'~'
	dc.b	1,$1e,1,$1e,1,$1e,1,$1e
	dc.b	1,$1e,1,'~',1,$de,1,$de
	dc.b	2,$9e,2,$fe,3,'^',3,$be
	dc.b	4,'B',4,$e0,5,$9a,5,$9a
	dc.b	6,'X',5,$9a,5,$9a,4,$e0
	dc.b	4,'B',3,$be,2,$fe,1,$de
	dc.b	1,$1e,0,0,4,$e0,2,$fe
	dc.b	1,$de,0,0,4,$e0,2,$fe
	dc.b	1,$1e,7,0,4,'B',2,$9e
	dc.b	1,$1e,7,0,4,'B',2,$fe
	dc.b	1,$de,1,$1e,0,0,7,0
	dc.b	6,'X',5,$9a,4,$e0,4,$e0
	dc.b	5,$9a,6,'X',7,0,0,0
	dc.b	0,$be,1,'~',2,'>',2,$fe
	dc.b	3,$be,4,$e0,6,'X',0,0
	dc.b	0,$be,1,'~',1,$de,2,'>'
	dc.b	2,$9e,2,$9e,2,$fe,2,$9e
	dc.b	2,$9e,2,'>',1,$de,1,'~'
	dc.b	0,$be,0,0,6,'X',4,$e0
	dc.b	3,$be,2,$fe,2,'>',1,'~'
	dc.b	0,$be,0,0,7,0,6,'X'
	dc.b	5,$9a,4,$e0,4,$e0,5,$9a
	dc.b	6,'X',7,0,0,0,1,$1e
	dc.b	1,$de,2,$fe,4,'B',7,0
	dc.b	1,$1e,2,$9e,4,'B',7,0
	dc.b	1,$1e,2,$fe,4,$e0,0,0
	dc.b	1,$de,2,$fe,4,$e0,0,0
	dc.b	1,$1e,1,$de,2,$fe,3,$be
	dc.b	4,'B',4,$e0,5,$9a,5,$9a
	dc.b	6,'X',5,$9a,5,$9a,4,$e0
	dc.b	4,'B',3,$be,3,'^',2,$fe
	dc.b	2,$9e,1,$de,1,$de,1,'~'
	dc.b	1,$1e,1,$1e,1,$1e,1,$1e
	dc.b	1,$1e,1,'~',2,'>',2,$9e
	dc.b	3,'^',4,'B',6,'X',0,'`'
	dc.b	1,'~',2,$9e,3,$be,6,'X'
	dc.b	0,'`',1,$de,2,$fe,4,'B'
	dc.b	6,'X',0,'`',1,'~',2,'>'
	dc.b	2,$fe,3,'^',4,'B',4,'B'
l0045	dc.b	'8@:',$c0,'=',$e0,'A',0
	dc.b	'D F',$a0,'I',$c0,'L@'
	dc.b	'O`Q',$e0,'S',$c0,'V@'
	dc.b	'X',$c0,'Z',$a0,'\',$80,']',$c0
	dc.b	'_',0,'`@a',$80,'b '
	dc.b	'b',$c0,'c`c`c`'
	dc.b	'c`b',$c0,'b a',$80
	dc.b	'`@_',0,']',$c0,'\',$80
	dc.b	'Z',$a0,'X',$c0,'V@S',$c0
	dc.b	'Q',$e0,'O`L@I',$c0
	dc.b	'F',$a0,'D A',0,'=',$e0
	dc.b	':',$c0,'8@5 2',0
	dc.b	'.',$e0,'+',$c0,')@& '
	dc.b	'#',$a0,' ',$80,$1e,0,$1c,' '
	dc.b	$19,$a0,$17,' ',$15,'@',$13,'`'
	dc.b	$12,' ',$10,$e0,$f,$a0,$e,'`'
	dc.b	$d,$c0,$d,' ',$c,$80,$c,$80
	dc.b	$c,$80,$c,$80,$d,' ',$d,$c0
	dc.b	$e,'`',$f,$a0,$10,$e0,$12,' '
	dc.b	$13,'`',$15,'@',$17,' ',$19,$a0
	dc.b	$1c,' ',$1e,0,' ',$80,'#',$a0
	dc.b	'& )@+',$c0,'.',$e0
	dc.b	'2',0,'5 8@:',$c0
	dc.b	'=',$e0,'A',0,'D F',$a0
	dc.b	'I',$c0,'L@O`Q',$e0
	dc.b	'S',$c0,'V@X',$c0,'Z',$a0
	dc.b	'\',$80,']',$c0,'_',0,'`@'
	dc.b	'a',$80,'b b',$c0,'c`'
	dc.b	'c`c`c`b',$c0
	dc.b	'b a',$80,'`@_',0
	dc.b	']',$c0,'\',$80,'Z',$a0,'X',$c0
	dc.b	'V@S',$c0,'Q',$e0,'O`'
	dc.b	'L@I',$c0,'F',$a0,'D '
	dc.b	'A',0,'=',$e0,':',$c0,'8@'
	dc.b	'5 2',0,'.',$e0,'+',$c0
	dc.b	')@& #',$a0,' ',$80
	dc.b	$1e,0,$1c,' ',$19,$a0,$17,' '
	dc.b	$15,'@',$13,'`',$12,' ',$10,$e0
	dc.b	$f,$a0,$e,'`',$d,$c0,$d,' '
	dc.b	$c,$80,$c,$80,$c,$80,$c,$80
	dc.b	$d,' ',$d,$c0,$e,'`',$f,$a0
	dc.b	$10,$e0,$12,' ',$13,'`',$15,'@'
	dc.b	$17,' ',$19,$a0,$1c,' ',$1e,0
	dc.b	' ',$80,'#',$a0,'& )@'
	dc.b	'+',$c0,'.',$e0,'2',0,'5 '

l0046	dcb.w	180
l0047	dc.b	0,'H',0,'H',0,'P',0,'P'
	dc.b	0,'P',0,'X',0,'X',0,'X'
	dc.b	0,'`',0,'`',0,'`',0,'`'
	dc.b	0,'h',0,'h',0,'h',0,'h'
	dc.b	0,'h',0,'p',0,'p',0,'p'
	dc.b	0,'p',0,'p',0,'p',0,'p'
	dc.b	0,'p',0,'p',0,'p',0,'p'
	dc.b	0,'p',0,'h',0,'h',0,'h'
	dc.b	0,'h',0,'h',0,'`',0,'`'
	dc.b	0,'`',0,'`',0,'X',0,'X'
	dc.b	0,'X',0,'P',0,'P',0,'P'
	dc.b	0,'H',0,'H',0,'H',0,'@'
	dc.b	0,'@',0,'@',0,'8',0,'8'
	dc.b	0,'8',0,'0',0,'0',0,'0'
	dc.b	0,'(',0,'(',0,'(',0,'('
	dc.b	0,'(',0,' ',0,' ',0,' '
	dc.b	0,' ',0,' ',0,' ',0,' '
	dc.b	0,' ',0,' ',0,' ',0,' '
	dc.b	0,' ',0,' ',0,' ',0,'('
	dc.b	0,'(',0,'(',0,'(',0,'('
	dc.b	0,'0',0,'0',0,'0',0,'8'
	dc.b	0,'8',0,'8',0,'@',0,'@'
	dc.b	0,'@',0,'H',0,'H',0,'H'
	dc.b	0,'P',0,'P',0,'P',0,'X'
	dc.b	0,'X',0,'X',0,'`',0,'`'
	dc.b	0,'`',0,'`',0,'h',0,'h'
	dc.b	0,'h',0,'h',0,'h',0,'p'
	dc.b	0,'p',0,'p',0,'p',0,'p'
	dc.b	0,'p',0,'p',0,'p',0,'p'
	dc.b	0,'p',0,'p',0,'p',0,'h'
	dc.b	0,'h',0,'h',0,'h',0,'h'
	dc.b	0,'`',0,'`',0,'`',0,'`'
	dc.b	0,'X',0,'X',0,'X',0,'P'
	dc.b	0,'P',0,'P',0,'H',0,'H'
	dc.b	0,'H',0,'@',0,'@',0,'@'
	dc.b	0,'8',0,'8',0,'8',0,'0'
	dc.b	0,'0',0,'0',0,'(',0,'('
	dc.b	0,'(',0,'(',0,'(',0,' '
	dc.b	0,' ',0,' ',0,' ',0,' '
	dc.b	0,' ',0,' ',0,' ',0,' '
	dc.b	0,' ',0,' ',0,' ',0,' '
	dc.b	0,' ',0,'(',0,'(',0,'('
	dc.b	0,'(',0,'(',0,'0',0,'0'
	dc.b	0,'0',0,'8',0,'8',0,'8'
	dc.b	0,'@',0,'@',0,'@',0,'H'
	dc.b	2,'>',4,$e0,0,'`',2,$9e
	dc.b	4,$e0,0,'`',2,$9e,4,$e0
	dc.b	0,0,1,$de,3,'^',6,'X'
	dc.b	0,'`',1,$de,2,$fe,4,'B'
	dc.b	6,'X',0,0,0,$be,1,'~'
	dc.b	1,$de,2,'>',2,'>',2,'>'
	dc.b	2,'>',1,$de,1,'~',0,$be
	dc.b	0,0,6,'X',4,'B',2,$fe
	dc.b	1,$de,0,'`',6,'X',3,'^'
	dc.b	1,$de,0,0,4,$e0,2,$9e
	dc.b	0,'`',4,$e0,2,$9e,0,'`'
	dc.b	4,$e0,2,'>',0,0,4,'B'
	dc.b	1,$de,0,0,4,'B',1,$de
	dc.b	0,0,4,$e0,2,$9e,1,$1e
	dc.b	6,'X',4,'B',2,$9e,1,'~'
	dc.b	0,'`',6,'X',4,$e0,3,$be
	dc.b	2,$fe,2,$9e,2,'>',2,'>'
	dc.b	2,'>',2,'>',2,$9e,2,$fe
	dc.b	3,$be,4,$e0,6,'X',0,'`'
	dc.b	1,'~',2,$9e,4,'B',6,'X'
	dc.b	1,$1e,2,$9e,4,$e0,0,0
	dc.b	1,$de,4,'B',0,0,1,$de
	dc.b	4,'B',0,0,2,'>',4,$e0
	dc.b	0,'`',2,$9e,4,$e0,0,'`'
	dc.b	2,$9e,4,$e0,0,0,1,$de
	dc.b	3,'^',6,'X',0,'`',1,$de
	dc.b	2,$fe,4,'B',6,'X',0,0
	dc.b	0,$be,1,'~',1,$de,2,'>'
	dc.b	2,'>',2,'>',2,'>',1,$de
	dc.b	1,'~',0,$be,0,0,6,'X'
	dc.b	4,'B',2,$fe,1,$de,0,'`'
	dc.b	6,'X',3,'^',1,$de,0,0
	dc.b	4,$e0,2,$9e,0,'`',4,$e0
	dc.b	2,$9e,0,'`',4,$e0,2,'>'
	dc.b	0,0,4,'B',1,$de,0,0
	dc.b	4,'B',1,$de,0,0,4,$e0
	dc.b	2,$9e,1,$1e,6,'X',4,'B'
	dc.b	2,$9e,1,'~',0,'`',6,'X'
	dc.b	4,$e0,3,$be,2,$fe,2,$9e
	dc.b	2,'>',2,'>',2,'>',2,'>'
	dc.b	2,$9e,2,$fe,3,$be,4,$e0
	dc.b	6,'X',0,'`',1,'~',2,$9e
	dc.b	4,'B',6,'X',1,$1e,2,$9e
	dc.b	4,$e0,0,0,1,$de,4,'B'
	dc.b	0,0,1,$de,4,'B',0,0
l0048	dc.b	'j@j@i',$a0,'i',$a0
	dc.b	'h`g',$c0,'f',$80,'e@'
	dc.b	'd',0,'b',$c0,'`',$e0,'_',0
	dc.b	'\',$80,'Z',$a0,'X U',$a0
	dc.b	'S P',$a0,'N K',0
	dc.b	'H',$80,'E`B@?',$c0
	dc.b	'<',$a0,'9',$80,'7',0,'3',$e0
	dc.b	'1`.@+',$c0,')@'
	dc.b	'&',$c0,'$@!',$c0,$1f,$e0
	dc.b	$1e,0,$1c,' ',$1a,'@',$18,'`'
	dc.b	$17,' ',$15,$e0,$14,$a0,$14,0
	dc.b	$13,'`',$12,$c0,$12,' ',$12,' '
	dc.b	$12,' ',$12,$c0,$12,$c0,$13,'`'
	dc.b	$14,0,$15,'@',$15,$e0,$17,' '
	dc.b	$18,'`',$1a,'@',$1b,$80,$1d,'`'
	dc.b	$1f,'@! #',0,'%',$80
	dc.b	$27,'`)',$e0,'+',$c0,'.@'
	dc.b	'0',$c0,'2',$a0,'5 7',$a0
	dc.b	'9',$80,'<',0,'=',$e0,'@`'
	dc.b	'B@D F',0,'G',$e0
	dc.b	'I K',0,'L@M',$80
	dc.b	'N O`P',0,'P',$a0
	dc.b	'P',$a0,'Q@Q@Q@'
	dc.b	'P',$a0,'P',$a0,'P',0,'O`'
	dc.b	'N M',$80,'L@K',0
	dc.b	'I G',$e0,'F',0,'D '
	dc.b	'B@@`=',$e0,'<',0
	dc.b	'9',$80,'7',$a0,'5 2',$a0
	dc.b	'0',$c0,'.@+',$c0,')',$e0
	dc.b	$27,'`%',$80,'#',0,'! '
	dc.b	$1f,'@',$1d,'`',$1b,$80,$1a,'@'
	dc.b	$18,'`',$17,' ',$15,$e0,$15,'@'
	dc.b	$14,0,$13,'`',$12,$c0,$12,$c0
	dc.b	$12,' ',$12,' ',$12,' ',$12,$c0
	dc.b	$13,'`',$14,0,$14,$a0,$15,$e0
	dc.b	$17,' ',$18,'`',$1a,'@',$1c,' '
	dc.b	$1e,0,$1f,$e0,'!',$c0,'$@'
	dc.b	'&',$c0,')@+',$c0,'.@'
	dc.b	'1`3',$e0,'7',0,'9',$80
	dc.b	'<',$a0,'?',$c0,'B@E`'
	dc.b	'H',$80,'K',0,'N P',$a0
	dc.b	'S U',$a0,'X Z',$a0
	dc.b	'\',$80,'_',0,'`',$e0,'b',$c0
	dc.b	'd',0,'e@f',$80,'g',$c0
	dc.b	'h`i',$a0,'i',$a0,'j@'

l0049	dcb.w	180
l004a	dc.b	0,'H',0,'H',0,'H',0,'P'
	dc.b	0,'P',0,'P',0,'P',0,'P'
	dc.b	0,'X',0,'X',0,'X',0,'X'
	dc.b	0,'X',0,'`',0,'`',0,'`'
	dc.b	0,'`',0,'`',0,'`',0,'`'
	dc.b	0,'h',0,'h',0,'h',0,'h'
	dc.b	0,'h',0,'h',0,'h',0,'h'
	dc.b	0,'h',0,'h',0,'h',0,'h'
	dc.b	0,'h',0,'h',0,'h',0,'h'
	dc.b	0,'h',0,'h',0,'h',0,'h'
	dc.b	0,'h',0,'h',0,'h',0,'h'
	dc.b	0,'h',0,'h',0,'h',0,'`'
	dc.b	0,'`',0,'`',0,'`',0,'`'
	dc.b	0,'`',0,'`',0,'`',0,'`'
	dc.b	0,'`',0,'X',0,'X',0,'X'
	dc.b	0,'X',0,'X',0,'X',0,'X'
	dc.b	0,'X',0,'X',0,'P',0,'P'
	dc.b	0,'P',0,'P',0,'P',0,'P'
	dc.b	0,'P',0,'P',0,'P',0,'P'
	dc.b	0,'P',0,'P',0,'P',0,'H'
	dc.b	0,'H',0,'H',0,'H',0,'H'
	dc.b	0,'H',0,'H',0,'H',0,'H'
	dc.b	0,'H',0,'H',0,'H',0,'H'
	dc.b	0,'H',0,'H',0,'H',0,'H'
	dc.b	0,'H',0,'H',0,'H',0,'@'
	dc.b	0,'@',0,'@',0,'@',0,'@'
	dc.b	0,'@',0,'@',0,'@',0,'@'
	dc.b	0,'@',0,'@',0,'@',0,'@'
	dc.b	0,'@',0,'8',0,'8',0,'8'
	dc.b	0,'8',0,'8',0,'8',0,'8'
	dc.b	0,'8',0,'8',0,'8',0,'0'
	dc.b	0,'0',0,'0',0,'0',0,'0'
	dc.b	0,'0',0,'0',0,'0',0,'0'
	dc.b	0,'(',0,'(',0,'(',0,'('
	dc.b	0,'(',0,'(',0,'(',0,'('
	dc.b	0,'(',0,'(',0,'(',0,'('
	dc.b	0,'(',0,'(',0,'(',0,'('
	dc.b	0,'(',0,'(',0,'(',0,'('
	dc.b	0,'(',0,'(',0,'(',0,'('
	dc.b	0,'(',0,'(',0,'(',0,'('
	dc.b	0,'(',0,'(',0,'0',0,'0'
	dc.b	0,'0',0,'0',0,'0',0,'0'
	dc.b	0,'0',0,'8',0,'8',0,'8'
	dc.b	0,'8',0,'8',0,'@',0,'@'
	dc.b	0,'@',0,'@',0,'@',0,'H'
	dc.b	2,'>',3,'^',5,$9a,0,0
	dc.b	1,'~',2,$9e,4,'B',6,'X'
	dc.b	0,'`',1,'~',2,$9e,3,$be
	dc.b	5,$9a,0,0,1,$1e,1,$de
	dc.b	2,$fe,3,$be,4,$e0,6,'X'
	dc.b	0,0,0,$be,1,'~',1,$de
	dc.b	2,'>',2,$fe,3,'^',3,$be
	dc.b	3,$be,4,'B',4,'B',4,$e0
	dc.b	4,$e0,4,$e0,4,$e0,4,'B'
	dc.b	4,'B',3,$be,3,$be,3,'^'
	dc.b	2,$fe,2,$9e,2,'>',1,$de
	dc.b	1,$1e,0,$be,0,'`',7,0
	dc.b	6,'X',4,$e0,3,$be,3,'^'
	dc.b	2,$9e,1,$de,1,$1e,0,$be
	dc.b	0,0,6,'X',4,$e0,3,$be
	dc.b	3,'^',2,$9e,1,$de,1,'~'
	dc.b	0,$be,0,0,7,0,5,$9a
	dc.b	4,$e0,3,$be,3,'^',2,$fe
	dc.b	2,'>',1,$de,1,'~',1,$1e
	dc.b	0,$be,0,'`',0,0,7,0
	dc.b	6,'X',5,$9a,4,$e0,4,'B'
	dc.b	3,$be,3,$be,3,'^',2,$fe
	dc.b	2,$9e,2,$9e,2,'>',1,$de
	dc.b	1,$de,1,'~',1,$1e,0,$be
	dc.b	0,$be,0,'`',0,0,7,0
	dc.b	6,'X',5,$9a,4,$e0,4,'B'
	dc.b	3,$be,3,'^',2,$fe,2,$9e
	dc.b	2,'>',1,'~',1,$1e,0,$be
	dc.b	0,0,7,0,5,$9a,4,$e0
	dc.b	3,$be,2,$fe,2,$9e,1,$de
	dc.b	1,$1e,0,$be,0,0,6,'X'
	dc.b	4,$e0,3,$be,3,'^',2,$9e
	dc.b	1,$de,1,$1e,0,$be,0,0
	dc.b	6,'X',5,$9a,4,'B',3,$be
	dc.b	3,'^',2,$9e,2,'>',1,$de
	dc.b	1,'~',1,$1e,0,$be,0,$be
	dc.b	0,'`',0,'`',0,0,0,0
	dcb.w	2
	dc.b	0,'`',0,'`',0,$be,0,$be
	dc.b	1,$1e,1,'~',2,'>',2,$9e
	dc.b	2,$fe,3,$be,4,$e0,6,'X'
	dc.b	0,0,0,$be,1,'~',2,$9e
	dc.b	3,'^',4,$e0,7,0,0,$be
	dc.b	1,$de,2,$fe,4,'B',6,'X'
	dc.b	0,'`',1,$de,2,$fe,4,$e0
	dc.b	7,0,1,$1e
l004b	dc.b	'j@j@i',$a0,'i',$a0
	dc.b	'h`g',$c0,'f',$80,'e@'
	dc.b	'd',0,'b',$c0,'`',$e0,'_',0
	dc.b	'\',$80,'Z',$a0,'X U',$a0
	dc.b	'S P',$a0,'N K',0
	dc.b	'H',$80,'E`B@?',$c0
	dc.b	'<',$a0,'9',$80,'7',0,'3',$e0
	dc.b	'1`.@+',$c0,')@'
	dc.b	'&',$c0,'$@!',$c0,$1f,$e0
	dc.b	$1e,0,$1c,' ',$1a,'@',$18,'`'
	dc.b	$17,' ',$15,$e0,$14,$a0,$14,0
	dc.b	$13,'`',$12,$c0,$12,' ',$12,' '
	dc.b	$12,' ',$12,$c0,$12,$c0,$13,'`'
	dc.b	$14,0,$15,'@',$15,$e0,$17,' '
	dc.b	$18,'`',$1a,'@',$1b,$80,$1d,'`'
	dc.b	$1f,'@! #',0,'%',$80
	dc.b	$27,'`)',$e0,'+',$c0,'.@'
	dc.b	'0',$c0,'2',$a0,'5 7',$a0
	dc.b	'9',$80,'<',0,'=',$e0,'@`'
	dc.b	'B@D F',0,'G',$e0
	dc.b	'I K',0,'L@M',$80
	dc.b	'N O`P',0,'P',$a0
	dc.b	'P',$a0,'Q@Q@Q@'
	dc.b	'P',$a0,'P',$a0,'P',0,'O`'
	dc.b	'N M',$80,'L@K',0
	dc.b	'I G',$e0,'F',0,'D '
	dc.b	'B@@`=',$e0,'<',0
	dc.b	'9',$80,'7',$a0,'5 2',$a0
	dc.b	'0',$c0,'.@+',$c0,')',$e0
	dc.b	$27,'`%',$80,'#',0,'! '
	dc.b	$1f,'@',$1d,'`',$1b,$80,$1a,'@'
	dc.b	$18,'`',$17,' ',$15,$e0,$15,'@'
	dc.b	$14,0,$13,'`',$12,$c0,$12,$c0
	dc.b	$12,' ',$12,' ',$12,' ',$12,$c0
	dc.b	$13,'`',$14,0,$14,$a0,$15,$e0
	dc.b	$17,' ',$18,'`',$1a,'@',$1c,' '
	dc.b	$1e,0,$1f,$e0,'!',$c0,'$@'
	dc.b	'&',$c0,')@+',$c0,'.@'
	dc.b	'1`3',$e0,'7',0,'9',$80
	dc.b	'<',$a0,'?',$c0,'B@E`'
	dc.b	'H',$80,'K',0,'N P',$a0
	dc.b	'S U',$a0,'X Z',$a0
	dc.b	'\',$80,'_',0,'`',$e0,'b',$c0
	dc.b	'd',0,'e@f',$80,'g',$c0
	dc.b	'h`i',$a0,'i',$a0,'j@'
l004c	dcb.w	180

music	incbin "dungeon.mus"

	ifeq	DOWNLOAD
	section BSS
	endc

black	ds.w	16
storage	ds.b	16

	IFNE	DOWNLOAD
Code_End
Code_Length	equ	Code_End-Code_Start
	ENDC



