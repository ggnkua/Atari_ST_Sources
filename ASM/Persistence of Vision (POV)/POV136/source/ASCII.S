







aeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeb
g	PERSISTENCE OF VISION 136      h
dffffffffffffffffffffffffffffffffffffffc^








aeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeb
g		ATARI STE	       h
dffffffffffffffffffffffffffffffffffffffc^








aeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeb
g		CREDITS:	       h
dffffffffffffffffffffffffffffffffffffffc

	     MENU CODED BY:

	      MAC SYS DATA^







eeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeee

 I'M SORRY BUT YOU DON'T APPEAR TO HAVE
THE NECESSARY STE HARDWARE TO RUN ANY OF
	THE DEMOS ON THIS DISC.

THE INTRO YOU SEE WAS DESIGNED FOR ATARI
STFM COMPUTERS, THE PROPER MENU FEATURES

	    DMA 25KHZ TRACKER
       VERTICAL HARDWARE SCROLLING
        24 BY 32 PIXEL SCROLLER
		RASTERS
eeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeee^





iiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiii



  iiiiiii         iiiii       i       i
  i      i       i     i      i       i
  i       i     i       i     i       i
  i       i     i       i     i       i
  i      i      i       i     i       i
  iiiiiii       i       i     i       i
  i             i       i      i     i
  i             i       i       i   i
  i              i     i         i i
  i               iiiii           i



iiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiiii^






eeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeee
	      CONTACT POV AT:

	   PERSISTENCE OF VISION
	        P.O. BOX 40
	    THORNTON-CLEVELEYS
	        LANCASHIRE
	         FY5 3PH
		 ENGLAND

eeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeee^
eeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeee
     P.O.V SENDS IT'S GREETINGS TO:
               ADRENALIN UK
               ANIMAL MINE
              BLIND BASTARD
                  CHAOS
                  CYNIX
                  D-BUG
           DEL (D.W.STABLES PD)
               DELTA FORCE
                 DR SYNE
              ERIK PLANKTON
              ETERNITY (LORD)
                 FUZION
              GEORGE (BART)
              INNER CIRCLE
                LEGOLAND
               MAD VISION
                 MUG UK
                 PAL PD
               PIXEL TWINS
               PURE ENERGY
                REPLICANTS
                RIPPED OFF
                  STAX
                 SYNERGY
              THE SYNDICATE
        ZEEDYA (DIAMOND DESIGN)
eeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeeee^
     WRAP
      WRAP
       WRAP
	WRAP
	 WRAP
	  WRAP
	   WRAP
	    WRAP
	     WRAP
	      WRAP
	       WRAP
		WRAP
		 WRAP
		  WRAP
		   WRAP
		    WRAP
		     WRAP
		      WRAP
		       WRAP
		        WRAP
			 WRAP
			  WRAP
			   WRAP
			    WRAP
			     WRAP
			      WRAP
			       WRAP
				WRAP^
