----------------------------------------
  WELCOME TO PERSISTENCE OF VISION 144
----------------------------------------

		CREDITS:

	     MENU CODED BY:

	      MAC SYS DATA


		ART BY:

	      OZYMANDIAS


	       MUSIC BY:

	       HORIZON^


    abbbbbbbbbbbbbbbbbbbbbbbbbbbbc
    h   1: CRISTINA IS A DREAM   d
    h                            d
    h      2: ETERNITY 1 MEG     d
    h                            d
    h       3: ARMADA 1 MEG      d
    h                            d
    h        4: ICE INTRO        d
    h                            d
    h          5: COPIER         d
    gffffffffffffffffffffffffffffe^




	    QUICK GREETS TO

	      ADRENALIN UK
                 D-BUG
	      DIGIT OF TSN
      EDGE OF SANITY (ANNHILATOR)
	      PURE ENERGY^

----------------------------------------
	          NOTE:

     DO NOT SEND ANY MORE MAIL TO...

	  PERSISTENCE OF VISION
		P.O. BOX 40
	    THORNTON-CLEVELEYS
		LANCASHIRE
		 FY5 3PH
		 ENGLAND

----------------------------------------^



          PERSISTENCE OF VISION
 ARE ACTIVE ON THE FOLLOWING PLATFORMS

	    APPLE MAC LC II
		ATARI ST
DIGITAL EQUIPMENT CORPORATION VAX (VMS)
	     NINTENDO SNES
	      SEGA MEGA CD
	     SEGA MEGADRIVE^
