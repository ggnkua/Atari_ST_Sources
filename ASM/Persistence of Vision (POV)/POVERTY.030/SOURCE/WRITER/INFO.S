*POVerty Falcon 030 1.44Meg version

LOADER
       Side:	 0
Start track:     6
  End track:     7
	
INTRO
       Side:	 0
Start track:	10
  End track:	26

MAIN
       Side:	 1
Start track:	10
  End track:	73

END
       Side:	 0
Start track:	30
  End track:	61
