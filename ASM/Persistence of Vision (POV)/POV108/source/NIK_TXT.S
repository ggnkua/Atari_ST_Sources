******* Converter program to convert Boris' absolute offset text to
******* byte offset (modified ASCII).
*******
******* Written by MSD 'cos Boris fucked the menu up!
*******
*******
	bra	skip
filename	dc.b	"text.txt",0	;destination name
	even
A	EQU	0
B	EQU	34*4
C	EQU	34*4*2
D	EQU	34*4*3
E	EQU	34*4*4
F	EQU	34*4*5
G	EQU	34*4*6
H	EQU	34*4*7
I	EQU	34*4*8
J	EQU	34*4*9
K	EQU	34*4*10
L	EQU	34*4*11
M	EQU	34*4*12
N	EQU	34*4*13
O	EQU	34*4*14
P	EQU	34*4*15
Q	EQU	34*4*16
R	EQU	34*4*17
S	EQU	34*4*18
T	EQU	34*4*19
U	EQU	34*4*20
V	EQU	34*4*21
W	EQU	34*4*22
X	EQU	34*4*23
Y	EQU	34*4*24
Z	EQU	34*4*25
COMMA	EQU	34*4*26
DOT	EQU	34*4*27
COLON	EQU	34*4*29
_1	EQU	34*4*30
_2	EQU	34*4*31
_3	EQU	34*4*32
_4	EQU	34*4*33
_5	EQU	34*4*34
_6	EQU	34*4*35
_7	EQU	34*4*36
_8	EQU	34*4*37
_9	EQU	34*4*38
_0	EQU	34*4*39
MINUS	EQU	34*4*42
BACK	EQU	34*4*44
APOS	EQU	34*4*47
POV	EQU	34*4*48
OZ	EQU	34*4*49
SPACE	EQU	34*4*50

ASCII	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,SPACE,SPACE

	DC.W	W,E,L,C,O,M,E,SPACE,T,O,SPACE,POV
	DC.W	SPACE,D,I,S,C,SPACE
	DC.W	_1,_0,_8,SPACE,SPACE,SPACE,SPACE,SPACE,R,E,L,E,A,S,E
	DC.W	SPACE,D,A,T,E,SPACE
	DC.W	_2,_7,BACK,_9,BACK,_9,_2,SPACE
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	SPACE,C,O,D,I,N,G,SPACE
	DC.W	B,Y,SPACE,B,O,R,I,S
	DC.W	DOT,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,G,R,A,P,H,I,C,S,SPACE,A,N,D,SPACE,F,O,N,T,SPACE
	DC.W	B,Y,SPACE,OZ
	DC.W	DOT,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,M,U,S,I,C,SPACE
	DC.W	B,Y,SPACE,L,A,P,SPACE,MINUS
	DC.W	SPACE,R,I,P,P,E,D,SPACE
	DC.W	B,Y,SPACE,M,A,C,SPACE,S,Y,S,SPACE,D,A,T,A,DOT
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,SPACE,SPACE
 DC.W	T,H,I,S,SPACE
 DC.W	D,I,S,C,SPACE
 DC.W	W,A,S,SPACE
 DC.W	P,U,T,SPACE
 DC.W	T,O,G,E,T,H,E,R,SPACE
 DC.W	B,Y,SPACE
 DC.W	M,A,C,SPACE
 DC.W	S,Y,S,SPACE
 DC.W	D,A,T,A,SPACE
 DC.W	A,N,D,SPACE
 DC.W	I,S,SPACE
 DC.W	V,E,R,S,I,O,N,SPACE,_2,DOT
 DC.W	SPACE,SPACE,SPACE
 DC.W	I,APOS,V,E,SPACE
 DC.W	L,E,F,T,SPACE
 DC.W	B,O,R,I,S,APOS,SPACE
 DC.W	O,R,I,G,I,N,A,L,SPACE
 DC.W	T,E,X,T,SPACE
 DC.W	I,N,SPACE
 DC.W	B,U,T,SPACE
 DC.W	I,SPACE
 DC.W	W,O,U,L,D,SPACE
 DC.W	L,I,K,E,SPACE
 DC.W	T,O,SPACE
 DC.W	P,O,I,N,T,SPACE
 DC.W	O,U,T,SPACE
 DC.W	T,H,A,T,SPACE
 DC.W	I,SPACE
 DC.W	A,L,S,O,SPACE
 DC.W	H,A,D,SPACE
 DC.W	T,O,SPACE
 DC.W	D,I,S,A,S,S,E,M,B,L,E,SPACE
 DC.W	T,H,E,SPACE
 DC.W	M,E,N,U,SPACE
 DC.W	U,S,I,N,G,SPACE
 DC.W	E,A,S,Y,R,I,D,E,R,SPACE
 DC.W	A,S,SPACE
 DC.W	B,O,R,I,S,SPACE
 DC.W	D,I,D,N,APOS,T,SPACE
 DC.W	S,E,N,D,SPACE
 DC.W	M,E,SPACE
 DC.W	T,H,E,SPACE
 DC.W	S,O,U,R,C,E,SPACE
 DC.W	C,O,D,E,DOT,SPACE,SPACE,SPACE,SPACE,SPACE,SPACE
 DC.W	O,K,A,Y,SPACE
 DC.W	H,E,R,E,SPACE
 DC.W	I,S,SPACE
 DC.W	T,H,E,SPACE
 DC.W	O,R,I,G,I,N,A,L,SPACE
 DC.W	T,E,X,T,DOT,DOT,DOT,DOT,DOT,DOT,DOT
	DC.W	SPACE,SPACE,P,R,E,S,S,SPACE
	DC.W	APOS,_0,APOS,SPACE
	DC.W	T,O,SPACE,T,O,G,G,L,E,SPACE,_5,_0
	DC.W	BACK,_6,_0,SPACE,H,Z,SPACE,M,O,D,E,DOT
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	SPACE,P,R,E,S,S,SPACE,C,O,N,T,R,O,L,COMMA,A,L,T,E,R,N,A,T,E
	DC.W	SPACE,A,N,D,SPACE,D,E,L,E,T,E,SPACE,T,O,SPACE,R,E,S,E,T
	DC.W	DOT,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,SPACE,O,H,COMMA,SPACE,D,E,A,R,$17E8
	DC.W	SPACE,A,N,O,T,H,E,R
	DC.W	SPACE,L,A,T,E,SPACE,D,I,S,C,$17E8,SPACE
	DC.W	T,H,I,S,SPACE,I,S,SPACE
	DC.W	G,E,T,T,I,N,G
	DC.W	SPACE
	DC.W	T,O
	DC.W	SPACE
	DC.W	B,E
	DC.W	SPACE
	DC.W	T,O,O,SPACE,M,U,C,H,SPACE,O,F,SPACE,A,SPACE
	DC.W	H,A,B,I,T,DOT,SPACE,SPACE
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	T,H,I,S
	DC.W	SPACE,D,I,S,C,SPACE,N,E,A,R,L,Y
	DC.W	SPACE,D,I,D,N,APOS,T,SPACE
	DC.W	S,E,E,SPACE
	DC.W	I,T,SPACE,T,O,SPACE,T,H,E,SPACE,L,I,G,H,T,SPACE
	DC.W	O,F,SPACE,D,A,Y,DOT,SPACE
	DC.W	I,SPACE,W,A,S,SPACE,T,R,Y,I,N,G
	DC.W	SPACE,T,O,SPACE
	DC.W	W,R,I,T,E,SPACE,A,SPACE
	DC.W	F,A,S,T
	DC.W	SPACE,R,A,M
	DC.W	SPACE,D,I,S,K,COMMA,SPACE,S,O,SPACE,I,SPACE
	DC.W	C,O,P,I,E,D,SPACE,A,L,L,SPACE,T,H,E,SPACE,S,O,U,R,C,E
	DC.W	SPACE,C,O,D,E,SPACE,A,N,D,SPACE,D,A,T,A,SPACE
	DC.W	F,O,R,SPACE
	DC.W	T,H,I,S
	DC.W	SPACE,M,E,N
	DC.W	U,SPACE,T,O
	DC.W	SPACE,T,H,E
	DC.W	SPACE,R,A,M
	DC.W	SPACE,D,I,S
	DC.W	K,DOT,SPACE,T
	DC.W	H,E,N,COMMA
	DC.W	SPACE,B,Y,SPACE
	DC.W	M,I,S,T
	DC.W	A,K,E,COMMA
	DC.W	SPACE,I,SPACE,D
	DC.W	E,L,E,T
	DC.W	E,D,SPACE,A
	DC.W	L,L,SPACE,T
	DC.W	H,E,SPACE,S
	DC.W	O,U,R,C
	DC.W	E,SPACE,C,O
	DC.W	D,E,SPACE,A
	DC.W	N,D,SPACE,D
	DC.W	A,T,A,SPACE
	DC.W	F,R,O,M
	DC.W	SPACE,T,H,E
	DC.W	SPACE,H,A,R
	DC.W	D,SPACE,D,I
	DC.W	S,K,SPACE,I
	DC.W	N,S,T,E
	DC.W	A,D,SPACE,O
	DC.W	F,SPACE,F,R
	DC.W	O,M,SPACE,T,H,E,SPACE,R,A,M,SPACE,D,I,S,K,$17E8
	DC.W	SPACE,I,SPACE,I,M,M,E,D,I,A,T,E
	DC.W	L,Y,SPACE,C
	DC.W	O,P,I,E
	DC.W	D,SPACE,A,L
	DC.W	L,SPACE,T,H
	DC.W	E,SPACE,F,I
	DC.W	L,E,S,SPACE
	DC.W	B,A,C,K
	DC.W	SPACE,T,O,SPACE
	DC.W	T,H,E,SPACE
	DC.W	H,A,R,D
	DC.W	SPACE,D,I,S
	DC.W	K,COMMA,SPACE,H
	DC.W	O,P,I,N
	DC.W	G,SPACE,T,H
	DC.W	E,SPACE,R,A
	DC.W	M,SPACE,D,I
	DC.W	S,K,SPACE,W
	DC.W	O,R,K,E
	DC.W	D,SPACE,P,R
	DC.W	O,P,E,R
	DC.W	L,Y,DOT,SPACE
	DC.W	M,O,S,T
	DC.W	SPACE,O,F,SPACE
	DC.W	T,H,E,SPACE
	DC.W	D,A,T,A
	DC.W	SPACE,F,I,L
	DC.W	E,S,SPACE,W
	DC.W	E,R,E,SPACE
	DC.W	R,E,C,O
	DC.W	V,E,R,E
	DC.W	D,SPACE,B,U
	DC.W	T,SPACE,U,N
	DC.W	F,O,R,T
	DC.W	U,N,A,T
	DC.W	E,L,Y,COMMA
	DC.W	SPACE,T,H,E
	DC.W	SPACE,R,A,M
	DC.W	SPACE,D,I,S
	DC.W	K,SPACE,W,A
	DC.W	S,SPACE,S,L
	DC.W	I,G,H,T
	DC.W	L,Y,SPACE,B
	DC.W	U,G,G,E
	DC.W	D,SPACE,A,N
	DC.W	D,SPACE,T,H
	DC.W	E,SPACE,S,O
	DC.W	U,R,C,E
	DC.W	SPACE,C,O,D
	DC.W	E,SPACE,F,I
	DC.W	L,E,SPACE,C
	DC.W	O,U,L,D
	DC.W	SPACE,N,O,T
	DC.W	SPACE,B,E,SPACE
	DC.W	R,E,C,O
	DC.W	V,E,R,E
	DC.W	D,$17E8,SPACE,S
	DC.W	I,M,P,L
	DC.W	E,COMMA,SPACE,E
	DC.W	H,$1870,SPACE,R
	DC.W	E,S,T,O
	DC.W	R,E,SPACE,F
	DC.W	R,O,M,SPACE
	DC.W	T,H,E,SPACE
	DC.W	L,A,S,T
	DC.W	SPACE,B,A,C
	DC.W	K,U,P,$17E8
	DC.W	SPACE,H,A,SPACE
	DC.W	MINUS,SPACE,N,O
	DC.W	SPACE,B,A,C
	DC.W	K,U,P,$17E8
	DC.W	SPACE,S,T,U
	DC.W	P,I,D,L
	DC.W	Y,COMMA,SPACE,I
	DC.W	SPACE,H,A,D
	DC.W	SPACE,N,E,V
	DC.W	E,R,SPACE,M
	DC.W	A,D,E,SPACE
	DC.W	A,SPACE,B,A
	DC.W	C,K,U,P
	DC.W	SPACE,O,F,SPACE
	DC.W	T,H,I,S
	DC.W	SPACE,M,E,N
	DC.W	U,$17E8,SPACE,S
	DC.W	O,COMMA,SPACE,I
	DC.W	SPACE,T,O,O
	DC.W	K,SPACE,T,H
	DC.W	E,SPACE,P,A
	DC.W	C,K,E,D
	DC.W	SPACE,E,X,E
	DC.W	C,U,T,A
	DC.W	B,L,E,SPACE
	DC.W	P,R,O,G
	DC.W	R,A,M,SPACE
	DC.W	F,R,O,M
	DC.W	SPACE,T,H,E
	DC.W	SPACE,T,E,S
	DC.W	T,SPACE,D,I
	DC.W	S,C,COMMA,SPACE
	DC.W	U,N,P,A
	DC.W	C,K,E,D
	DC.W	SPACE,I,T,COMMA
	DC.W	SPACE,T,H,E
	DC.W	N,SPACE,U,S
	DC.W	E,D,SPACE,APOS
	DC.W	E,A,S,Y
	DC.W	SPACE,R,I,D
	DC.W	E,R,SPACE,$1188
	DC.W	APOS,SPACE,O,N
	DC.W	SPACE,I,T,SPACE
	DC.W	T,O,SPACE,G
	DC.W	E,T,SPACE,I
	DC.W	T,SPACE,B,A
	DC.W	C,K,SPACE,I
	DC.W	N,T,O,SPACE
	DC.W	S,O,U,R
	DC.W	C,E,SPACE,C
	DC.W	O,D,E,DOT
	DC.W	SPACE,N,E,X
	DC.W	T,SPACE,I,SPACE
	DC.W	H,A,D,SPACE
	DC.W	T,O,SPACE,C
	DC.W	H,A,N,G
	DC.W	E,SPACE,A,L
	DC.W	L,SPACE,T,H
	DC.W	E,SPACE,APOS,D
	DC.W	C,DOT,$1870,APOS
	DC.W	SPACE,S,E,C
	DC.W	T,I,O,N
	DC.W	S,SPACE,I,N
	DC.W	T,O,SPACE,T
	DC.W	H,E,SPACE,C
	DC.W	O,R,R,E
	DC.W	C,T,SPACE,APOS
	DC.W	I,N,C,B
	DC.W	I,N,S,APOS
	DC.W	DOT,SPACE,W,E
	DC.W	L,L,COMMA,SPACE
	DC.W	A,S,SPACE,Y
	DC.W	O,U,SPACE,C
	DC.W	A,N,SPACE,S
	DC.W	E,E,COMMA,SPACE
	DC.W	I,APOS,V,E
	DC.W	SPACE,M,A,N
	DC.W	A,G,E,D
	DC.W	SPACE,T,O,SPACE
	DC.W	R,E,C,O
	DC.W	V,E,R,SPACE
	DC.W	I,T,SPACE,F
	DC.W	A,I,R,L
	DC.W	Y,SPACE,W,E
	DC.W	L,L,SPACE,B
	DC.W	E,C,A,U
	DC.W	S,E,SPACE,T
	DC.W	H,E,R,E
	DC.W	SPACE,W,A,S
	DC.W	SPACE,N,O,SPACE
	DC.W	S,C,R,O
	DC.W	L,L,T,E
	DC.W	X,T,SPACE,I
	DC.W	N,SPACE,I,T
	DC.W	SPACE,B,E,F
	DC.W	O,R,E,DOT
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	SPACE,T,H,E
	DC.W	SPACE,M,O,R
	DC.W	A,L,SPACE,O
	DC.W	F,SPACE,T,H
	DC.W	I,S,SPACE,S
	DC.W	T,O,R,Y
	DC.W	SPACE,I,S,COLON
	DC.W	MINUS,SPACE,M,A
	DC.W	K,E,SPACE,B
	DC.W	A,C,K,U
	DC.W	P,S,$17E8,SPACE
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	SPACE,G,R,E
	DC.W	E,T,I,N
	DC.W	G,S,SPACE,A
	DC.W	T,SPACE,T,H
	DC.W	E,SPACE,E,N
	DC.W	D,DOT,DOT,DOT
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,A,P
	DC.W	O,L,O,G
	DC.W	I,E,S,SPACE
	DC.W	F,O,R,SPACE
	DC.W	A,N,Y,SPACE
	DC.W	R,U,B,B
	DC.W	I,S,H,SPACE
	DC.W	O,R,SPACE,O
	DC.W	F,F,E,N
	DC.W	S,I,V,E
	DC.W	SPACE,P,R,O
	DC.W	S,E,SPACE,I
	DC.W	N,SPACE,T,H
	DC.W	I,S,SPACE,T
	DC.W	E,X,T,SPACE
	DC.W	B,E,C,A
	DC.W	U,S,E,SPACE
	DC.W	I,APOS,V,E
	DC.W	SPACE,B,E,E
	DC.W	N,SPACE,D,R
	DC.W	I,N,K,I
	DC.W	N,G,SPACE,$1540
	DC.W	S,T,I,L
	DC.W	L,SPACE,A,M
	DC.W	COMMA,SPACE,A,C
	DC.W	T,U,A,L
	DC.W	L,Y,$17E8,$15C8
	DC.W	DOT,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,A,R
	DC.W	E,SPACE,Y,O
	DC.W	U,SPACE,A,SPACE
	DC.W	F,A,N,SPACE
	DC.W	O,F,SPACE,G
	DC.W	U,N,S,SPACE
	DC.W	APOS,N,APOS,SPACE
	DC.W	R,O,S,E
	DC.W	S,$1870,SPACE,D
	DC.W	I,D,SPACE,Y
	DC.W	O,U,SPACE,G
	DC.W	O,SPACE,T,O
	DC.W	SPACE,T,H,E
	DC.W	I,R,SPACE,R
	DC.W	E,C,E,N
	DC.W	T,SPACE,C,O
	DC.W	N,C,E,R
	DC.W	T,SPACE,A,T
	DC.W	SPACE,M,A,N,C,H,E,S,T,E,R,$1870
	DC.W	SPACE,W,H,A
	DC.W	T,SPACE,C,A,N,SPACE,I,SPACE
	DC.W	S,A,Y,$1870
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,B,A
	DC.W	S,T,A,R
	DC.W	D,S,$17E8,SPACE
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	F,I,R,S
	DC.W	T,SPACE,T,H
	DC.W	E,Y,SPACE,C
	DC.W	A,N,C,E
	DC.W	L,COMMA,SPACE,T
	DC.W	H,E,N,SPACE
	DC.W	T,H,E,Y
	DC.W	SPACE,C,O,M
	DC.W	E,SPACE,O,N
	DC.W	SPACE,S,T,A
	DC.W	G,E,SPACE,H
	DC.W	O,U,R,S
	DC.W	SPACE,L,A,T
	DC.W	E,SPACE,A,N
	DC.W	D,SPACE,M,A
	DC.W	K,E,SPACE,N
	DC.W	O,SPACE,A,P
	DC.W	O,L,O,G
	DC.W	Y,$17E8,SPACE,I
	DC.W	SPACE,L,I,K
	DC.W	E,SPACE,T,H
	DC.W	E,SPACE,M,U
	DC.W	S,I,C,SPACE
	DC.W	B,U,T,SPACE
	DC.W	I,SPACE,T,H
	DC.W	I,N,K,SPACE
	DC.W	T,H,E,SPACE
	DC.W	B,A,N,D
	DC.W	APOS,S,SPACE,A
	DC.W	T,T,I,T
	DC.W	U,D,E,SPACE
	DC.W	S,T,I,N
	DC.W	K,S,$17E8,SPACE
	DC.W	A,N,Y,W
	DC.W	A,Y,COMMA,SPACE
	DC.W	T,H,E,I
	DC.W	R,SPACE,L,I
	DC.W	V,E,SPACE,P
	DC.W	E,R,F,O
	DC.W	R,M,A,N
	DC.W	C,E,SPACE,H
	DC.W	A,S,SPACE,I
	DC.W	M,P,R,O
	DC.W	V,E,D,SPACE
	DC.W	C,O,N,S
	DC.W	I,D,E,R
	DC.W	A,B,L,Y
	DC.W	SPACE,S,I,N
	DC.W	C,E,SPACE,I
	DC.W	SPACE,S,A,W
	DC.W	SPACE,T,H,E
	DC.W	M,SPACE,O,N
	DC.W	SPACE,A,SPACE,L
	DC.W	I,V,E,SPACE
	DC.W	V,I,D,E
	DC.W	O,SPACE,A,B
	DC.W	O,U,T,SPACE
	DC.W	T,W,O,SPACE
	DC.W	Y,E,A,R
	DC.W	S,SPACE,A,G
	DC.W	O,DOT,SPACE,D
	DC.W	U,R,I,N
	DC.W	G,SPACE,T,H
	DC.W	E,SPACE,S,H
	DC.W	O,W,SPACE,A
	DC.W	N,SPACE,I,N
	DC.W	F,L,A,T
	DC.W	A,B,L,E
	DC.W	SPACE,V,E,R
	DC.W	S,I,O,N
	DC.W	SPACE,O,F,SPACE
	DC.W	T,H,E,SPACE
	DC.W	M,O,N,S
	DC.W	T,E,R,SPACE
	DC.W	O,N,SPACE,T
	DC.W	H,E,SPACE,O
	DC.W	L,D,SPACE,C
	DC.W	O,V,E,R
	DC.W	SPACE,O,F,SPACE
	DC.W	APOS,A,P,P
	DC.W	E,T,I,T
	DC.W	E,SPACE,F,O
	DC.W	R,SPACE,D,E
	DC.W	S,T,R,U
	DC.W	C,T,I,O
	DC.W	N,APOS,SPACE,W
	DC.W	A,S,SPACE,P
	DC.W	U,M,P,E
	DC.W	D,SPACE,U,P
	DC.W	COMMA,SPACE,B,U
	DC.W	T,SPACE,I,T
	DC.W	SPACE,B,E,C
	DC.W	A,M,E,SPACE
	DC.W	S,T,U,C
	DC.W	K,SPACE,I,N
	DC.W	SPACE,T,H,E
	DC.W	SPACE,S,C,A
	DC.W	F,F,O,L
	DC.W	D,I,N,G
	DC.W	DOT,SPACE,APOS,F
	DC.W	A,I,T,H
	DC.W	SPACE,N,O,SPACE
	DC.W	M,O,R,E
	DC.W	APOS,SPACE,W,A
	DC.W	S,SPACE,V,E
	DC.W	R,Y,SPACE,G
	DC.W	O,O,D,SPACE
	DC.W	A,S,SPACE,O
	DC.W	N,E,SPACE,O
	DC.W	F,SPACE,T,H
	DC.W	E,SPACE,S,U,P,P,O,R,T,SPACE,B,A,N,D,S,DOT
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,A,SPACE
	DC.W	Q,U,I,C,K,SPACE,M,E,S,S,A,G,E,SPACE,T,O
	DC.W	SPACE,A,L,L,SPACE,D,E,M,O,SPACE,R,E,V,I,E,W,E,R,S,COLON
	DC.W	MINUS,SPACE,G,E
	DC.W	T,SPACE,A,SPACE
	DC.W	L,I,F,E
	DC.W	COMMA,SPACE,Y,O
	DC.W	U,SPACE,L,A
	DC.W	M,E,R,S
	DC.W	$17E8,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,SPACE,G
	DC.W	R,E,E,T
	DC.W	I,N,G,S
	DC.W	SPACE,A,T,SPACE
	DC.W	T,H,E,SPACE
	DC.W	E,N,D,DOT
	DC.W	DOT,DOT,SPACE,SPACE
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	T,H,E,R,E
	DC.W	SPACE
	DC.W	I,S
	DC.W	SPACE,A,SPACE,N,E,W,SPACE,M,A,C,H,I,N,E,SPACE
	DC.W	F,R,O,M,SPACE
	DC.W	A,T,A,R,I,SPACE,C,A,L,L,E,D
	DC.W	SPACE,T,H,E
	DC.W	SPACE,APOS,F,A
	DC.W	L,C,O,N
	DC.W	APOS,SPACE,W,H
	DC.W	I,C,H,SPACE,S,H,O,U,L,D,SPACE,B,E,SPACE,R,E,L,E,A,S,E,D,SPACE
	DC.W	I,N,SPACE,G,E,R,M,A,N
	DC.W	Y,SPACE,B,Y
	DC.W	SPACE,T,H,E
	DC.W	SPACE,T,I,M,E,SPACE,Y,O,U,SPACE,R,E,A,D,SPACE
	DC.W	T,H,I,S,DOT
	DC.W	SPACE,I,T,SPACE
	DC.W	A,P,P,A,R,E,N,T,L,Y,SPACE
	DC.W	W,O,N,APOS,T
	DC.W	SPACE,B,E,SPACE
	DC.W	L,A,U,N,C,H,E,D
	DC.W	SPACE
	DC.W	H,E,R,E,SPACE
	DC.W	U,N,T,I,L,SPACE
	DC.W	C,H,R,I,S,T,M,A,S,SPACE,O,R
	DC.W	SPACE,E,V,E
	DC.W	N,SPACE,L,A
	DC.W	T,E,R,DOT
	DC.W	SPACE,F,R,O,M,SPACE,T,H,E,SPACE,S,P,E,C,I,F,I,C,A,T,I,O,N,SPACE
	DC.W	T,H,A,T
	DC.W	SPACE,I,SPACE,K
	DC.W	N,O,W,SPACE
	DC.W	A,B,O,U,T,COMMA,SPACE,I,T
	DC.W	SPACE,S,H
	DC.W	O,U,L,D
	DC.W	SPACE,B,E,A
	DC.W	T,SPACE,T,H
	DC.W	E,SPACE,N,E
	DC.W	W,SPACE,A,M
	DC.W	I,G,A,SPACE
	DC.W	A,_8,_0,_0
	DC.W	DOT,SPACE,R,U,M,O,U,R
	DC.W	SPACE,H,A,S
	DC.W	SPACE,I,T,SPACE
	DC.W	T,H,A,T
	DC.W	SPACE,A,T,A,R,I,SPACE
	DC.W	H,A,S,SPACE
	DC.W	B,E,N,T,SPACE
	DC.W	O,V,E,R,SPACE
	DC.W	B,A,C,K,W,A,R,D,S,SPACE
	DC.W	T,O,SPACE
	DC.W	K,E,E,P,SPACE
	DC.W	T,H,E,SPACE
	DC.W	F,A,L,C,O,N,SPACE
	DC.W	A,S,SPACE
	DC.W	C,O,M,P,A,T,I,B,L,E,SPACE
	DC.W	A,S,SPACE
	DC.W	P,O,S,S,I,B,L,E,SPACE
	DC.W	W,I,T,H
	DC.W	SPACE,T,H,E
	DC.W	SPACE,S,T,$1540
	DC.W	E,$15C8,SPACE
	DC.W	R,A,N,G,E
	DC.W	SPACE,W,H,I,L,E,SPACE
	DC.W	A,D,D,I,N,G,SPACE,S,O,M,E,SPACE
	DC.W	D,E,C,E,N,T,SPACE,E,X,T,R,A,SPACE
	DC.W	S,O,U,N,D,SPACE,A,N,D,SPACE,G,R,A,P,H,I,C,S,SPACE
	DC.W	C,H,I,P,S
	DC.W	DOT,SPACE,M,E,A,N,W,H,I,L,E,COMMA
	DC.W	SPACE,T,H,E
	DC.W	SPACE,A,M,I,G,A,SPACE,A
	DC.W	_8,_0,_0,SPACE
	DC.W	S,E,E,M
	DC.W	S,SPACE,T,O
	DC.W	SPACE,H,A,V
	DC.W	E,SPACE,B,E
	DC.W	E,N,SPACE,B,O,O,S,T,E,D,SPACE,I,N
	DC.W	SPACE,T,H
	DC.W	E,SPACE,S,O,U,N,D,SPACE
	DC.W	D,E,P,A,R,T,M,E,N,T,SPACE,O,N,L,Y,SPACE
	DC.W	MINUS,SPACE,APOS,C,H,I,P,APOS
	DC.W	SPACE,R,A,M
	DC.W	SPACE,M,U,S,T,SPACE,R,U,N,SPACE,A,T
	DC.W	SPACE,$1320,DOT,_8
	DC.W	$1188,M,H,Z
	DC.W	SPACE,S,O,SPACE
	DC.W	G,R,A,P,H,I,C,S
	DC.W	SPACE,I,M,P,R,O,V,E,M,E,N,T
	DC.W	S,SPACE,W,O,U,L,D,SPACE
	DC.W	B,E,SPACE,D,I,F,F,I,C,U,L,T
	DC.W	DOT,SPACE,A,N,Y,W,A,Y
	DC.W	COMMA,SPACE,I,SPACE,A,M,SPACE
	DC.W	I,N,V,O,L,V,E,D,SPACE
	DC.W	W,I,T,H
	DC.W	SPACE,S,O,M,E,SPACE,O,T,H,E,R,SPACE
	DC.W	P,E,O,P,L,E,SPACE,I,N,SPACE,W,R,I,T,I,N,G
	DC.W	SPACE,A,N
	DC.W	SPACE,I,N,E,X,P,E,N,S,I,V,E
	DC.W	SPACE,P,R,O,F,E,S,S,I,O,N,A,L,SPACE
	DC.W	D,E,V,E,L,O,P,M,E,N,T,SPACE,S,Y,S,T,E,M
	DC.W	SPACE,F,O,R
	DC.W	SPACE,T,H,E
	DC.W	SPACE,S,T,COMMA
	DC.W	SPACE,F,A,L,C,O,N,SPACE
	DC.W	A,N,D,SPACE
	DC.W	A,M,I,G,A,$1540,$17E8,$15C8
	DC.W	SPACE,B,A,S,E,D,SPACE,A,R,O,U,N
	DC.W	D,SPACE,A,N,Y,SPACE,S,T
	DC.W	SPACE,C,O,M,P,U,T,E,R,SPACE,MINUS,SPACE
	DC.W	M,O,S,T
	DC.W	SPACE,O,T,H,E,R,SPACE
	DC.W	S,Y,S,T,E,M,S,SPACE,A,R,E,SPACE
	DC.W	B,A,S,E,D
	DC.W	SPACE,O,N,SPACE
	DC.W	P,C,S,DOT
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,E,N
	DC.W	O,U,G,H
	DC.W	SPACE,C,I,D,E,R,SPACE,T,W,A,D,D,L,E,SPACE
	DC.W	F,O,R,SPACE,N,O,W,DOT,DOT
	DC.W	DOT,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,SPACE,G,R,E,E,T,I,N,G,S
	DC.W	SPACE,T,O,COLON
	DC.W	MINUS,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,B,A,R,T,SPACE,A,T,SPACE,T,O,W,E,R,SPACE
	DC.W	P,DOT,D,DOT
	DC.W	COMMA,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,P,R
	DC.W	O,P,H,E
	DC.W	C,Y,SPACE,P
	DC.W	DOT,D,DOT,COMMA
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	SPACE,K,DOT,G
	DC.W	DOT,B,DOT,SPACE
	DC.W	O,F,SPACE,F
	DC.W	R,A,N,C
	DC.W	E,COMMA,SPACE,SPACE
	DC.W	SPACE,SPACE,SPACE,N
	DC.W	O,D,SPACE,A
	DC.W	N,D,SPACE,P
	DC.W	I,X,E,L
	DC.W	SPACE,T,W,I
	DC.W	N,S,COMMA,SPACE
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	D,R,DOT,SPACE
	DC.W	S,Y,N,E
	DC.W	COMMA,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,E,R
	DC.W	I,K,SPACE,P
	DC.W	L,A,N,K
	DC.W	T,O,N,COMMA
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	SPACE,B,L,I
	DC.W	N,D,SPACE,B
	DC.W	A,S,T,A
	DC.W	R,D,COMMA,SPACE
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	T,H,E,SPACE
	DC.W	W,A,T,C
	DC.W	H,M,E,N
	DC.W	COMMA,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,R,I,P,P,E,D
	DC.W	SPACE,O,F,F
	DC.W	COMMA,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,T,H
	DC.W	E,SPACE,S,O
	DC.W	U,R,C,E
	DC.W	COMMA,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,S,L
	DC.W	A,Y,T,A
	DC.W	N,I,C,SPACE
	DC.W	C,U,L,T
	DC.W	COMMA,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,M,U
	DC.W	G,SPACE,U,DOT
	DC.W	K,DOT,COMMA,SPACE
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	P,U,R,E
	DC.W	SPACE,E,N,E
	DC.W	R,G,Y,COMMA
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	SPACE,T,H,E
	DC.W	SPACE,E,N,T
	DC.W	E,R,P,R
	DC.W	I,S,E,DOT
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,T,H
	DC.W	I,S,SPACE,D
	DC.W	I,S,C,SPACE
	DC.W	I,S,SPACE,_8
	DC.W	_0,SPACE,T,R,A,C,K,COMMA
	DC.W	SPACE,_8,_0,SPACE
	DC.W	S,E,C,T,O,R,COMMA,SPACE
	DC.W	S,K,E,W,E,D,BACK,F,A,S,T,SPACE
	DC.W	F,O,R,M,A,T,DOT,SPACE
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,SPACE,B,Y,E,COMMA,SPACE,B,Y,E,DOT
	DC.W	DOT,DOT,DOT,DOT
	DC.W	DOT,DOT,DOT,DOT
	DC.W	DOT,DOT,DOT,DOT
	DC.W	DOT,DOT,DOT,DOT
	DC.W	DOT,DOT,DOT,SPACE
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,SPACE,SPACE
	DC.W	SPACE,SPACE,SPACE
stop	DC.W	-1,-1
	even

skip	bsr	set_super

	lea	ASCII,a0
	lea	buffer,a1
.loop	move.w	(a0)+,d0
	divu	#34*4,d0
	ADD.B	#1,D0
	move.b	d0,(a1)+
	cmp.l	#stop,a0
	ble.s	.loop

	move.l	a1,a6
;now save
	bsr	f_create
	bsr	f_write
	bsr	f_close

wait	bsr	set_user

	MOVE.W	#$0,-(SP)	; RETURN TO GEM DESKTOP.
	TRAP	#1
	RTS

***********************
* SUBROUTINES SECTION *
***********************

f_create:
	move.w	#0,-(sp)
	pea	filename
	move.w	#$3c,-(sp)
	trap	#1
	add.l	#8,sp
	move.w	d0,handle
	rts

f_write:
	lea	buffer,a0
	move.l	a0,-(sp)
	sub.l	a0,a6
	move.l	a6,-(sp)
	move.w	handle,-(sp)
	move.w	#$40,-(sp)
	trap	#1
	add.l	#12,sp
	rts

f_close:
	move.w	handle,-(sp)
	move.w	#$3e,-(sp)
	trap	#1
	addq.l	#4,sp
	rts

pause:	move.w	d0,-(sp)
	move.w	#5000,d0
pau:	nop
	dbf	d0,pau
	move.w	(sp)+,d0
	rts

get_key:
	move.w	#7,-(sp)
	trap	#1
	addq.l	#2,sp
	rts

set_super:
	clr.l	-(sp)		;Set super stack equal
	move.w	#$20,-(sp)	; to user stack before call
	trap	#1
	addq.l	#6,sp		;correct stack
	move.l	d0,stack_save	;save old supervisor stack value
	rts
set_user:
	move.l	stack_save,-(sp)
	move.w	#$20,-(sp)
	trap	#1		;back to user
	addq.l	#6,sp		;correct stack
	rts


****************
* DATA SECTION *
****************
stack_save:	dc.l	0
screen_base	dc.l	0
original_rez:	dc.w	0
handle:		dc.w	0
old_palette:	ds.w	16
	even
buffer:	ds.b	(16*8)*20
	ds.b	(16*8)*20
	ds.b	(16*8)*20
eob:
