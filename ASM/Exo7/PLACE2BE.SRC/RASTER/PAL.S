;Palette of BARRES2.PI1: Saved by NEOchrome V2.24 by Chaos, Inc.
		dc.w	$0000,$0200,$0210,$0311,$0321,$0422,$0432,$0533
		dc.w	$0543,$0644,$0654,$0755,$0765,$0765,$0777,$0777
