cntCombination:		dc.w 121

textDemoWidthRawX16:	dc.l 54688

textDemoWidthX2:	dc.l 6888
textDemoWidthX4:	dc.l 13776

textDemoSize:		dc.w 20664	; 3444*6
