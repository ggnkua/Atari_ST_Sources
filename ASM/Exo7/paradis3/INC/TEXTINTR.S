textIntroWidthRawX16:	dc.l 6928

textIntroWidthX2:	dc.l 918
textIntroWidthX4:	dc.l 1836

textIntroSize:		dc.w 2754	; 459*6
