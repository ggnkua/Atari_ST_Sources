; Gianamix muzexx, ripped by Illegal Exception/TLT XXXXXX

 OPT D+

 CLR.L -(SP)
 MOVE.W #$20,-(SP)
 TRAP #1
 ADDQ.L #6,SP
 MOVE.L D0,SUPER

 MOVE.W #4,-(SP)
 TRAP #14
 ADDQ.L #2,SP
 MOVE.W D0,REZ

 DC.W $A00A

 MOVE.W #0,-(SP)
 MOVE.L #-1,-(SP)
 MOVE.L #-1,-(SP)
 MOVE.W #5,-(SP)
 TRAP #14
 ADD.L #12,SP

 MOVE.W #2,-(SP)
 TRAP #14
 ADDQ.L #2,SP
 MOVE.L D0,SCREEN

 MOVEM.L $FFFF8240.W,D0-D7
 MOVEM.L D0-D7,PALSAVE
 
 MOVE.L SCREEN,LED1
 MOVE.L SCREEN,LED2
 MOVE.L SCREEN,LED3
 ADD.L #160*40+64,LED1
 ADD.L #160*40+80,LED2
 ADD.L #160*40+96,LED3
 
 MOVEQ #1,D0	; 1-2
 JSR MUSIC

 CLR.W $FFFF8240.W
 MOVE.W #$777,$FFFF8242.W

 MOVE.W SR,SR_SAVE
 MOVE.W #$2700,SR
 LEA INTSAVE,A0
 MOVE.L $70,(A0)+
 MOVE.L $120,(A0)+
 MOVE.B $FFFFFA07.W,(A0)+
 MOVE.B $FFFFFA09.W,(A0)+
 MOVE.B $FFFFFA13.W,(A0)+
 MOVE.B $FFFFFA1B.W,(A0)+
 MOVE.B $FFFFFA21.W,(A0)+
 MOVE.B #1,$FFFFFA21.W
 MOVE.B #8,$FFFFFA1B.W
 MOVE.B #1,$FFFFFA07.W
 CLR.B $FFFFFA09.W
 MOVE.B #1,$FFFFFA13.W
 
 MOVE.L #VBL,$70
 MOVE.L #HBL,$120
 CLR.L RAST_POINT
 MOVE.W #$2300,SR

WAIT:
 CMP.B #185,$FFFFFC02.W
 BNE WAIT
 
 MOVE.W #$2700,SR
 LEA INTSAVE,A0
 MOVE.L (A0)+,$70
 MOVE.L (A0)+,$120
 MOVE.B (A0)+,$FFFFFA07.W
 MOVE.B (A0)+,$FFFFFA09.W
 MOVE.B (A0)+,$FFFFFA13.W
 MOVE.B (A0)+,$FFFFFA1B.W
 MOVE.B (A0)+,$FFFFFA21.W
 MOVE.W SR_SAVE,SR
 
 MOVE.L #$8080000,$FFFF8800.W
 MOVE.L #$9090000,$FFFF8800.W
 MOVE.L #$A0A0000,$FFFF8800.W
 MOVE.L #$707FF00,$FFFF8800.W
 MOVE.L #$E0EFE00,$FFFF8800.W

 MOVEM.L PALSAVE,D0-D7
 MOVEM.L D0-D7,$FFFF8240.W

 MOVE.W REZ,-(SP)
 MOVE.L #-1,-(SP)
 MOVE.L #-1,-(SP)
 MOVE.W #5,-(SP)
 TRAP #14
 ADD.L #12,SP

 MOVE.L SUPER,-(SP)
 MOVE.W #$20,-(SP)
 TRAP #1
 ADDQ.L #6,SP

 DC.W $A009
 
 CLR.W -(SP)
 TRAP #1

RELOCATE:
 MOVE.W $FFFF8240.W,-(SP)
 LEA MUSIC,A0
 MOVE.L #(MUSICEND-MUSIC),D2
 
LOOPY2:
 CMP.L #$37F60,(A0)   
 BLT NOT
 CMP.L #$37F60+(MUSICEND-MUSIC),(A0)
 BGT NOT 
 ADD.L #(MUSIC-$37F60),(A0)
NOT: 
 ADD.W #2,A0
 ADD.W #10,$FFFF8240.W
 DBRA D2,LOOPY2
 MOVE.W (SP)+,$FFFF8240.W
 RTS

VBL:
 MOVEM.L D0-D7/A0-A5,-(SP)
 LEA RASTBUFF1,A0
 LEA RASTBUFF2,A1
 MOVE.L #249,D5
 
UPDATE:
 MOVE.W (A0)+,(A1)+
 DBRA D5,UPDATE
 
 LEA RASTER,A0
 LEA RASTBUFF1,A1
 ADD.L RAST_POINT,A0
 MOVE.L #199,D5
 
UPDATE2:
 CMP.L #2*42,RAST_POINT
 BLT.S NOT_END
 CLR.L RAST_POINT

NOT_END:
 MOVE.W (A0)+,(A1)+
 DBRA D5,UPDATE2
 ADDQ.L #2,RAST_POINT
 
 JSR MUSIC+$8

 LEA RASTBUFF2,A6
 CLR.L D1
 CLR.L D2
 CLR.L D3
 MOVE.B #$8,$FFFF8800.W
 MOVE.B $FFFF8800.W,D1
 AND.B #15,D1
 MOVE.B #$9,$FFFF8800.W
 MOVE.B $FFFF8800.W,D2
 AND.B #15,D2
 MOVE.B #$A,$FFFF8800.W
 MOVE.B $FFFF8800.W,D3
 AND.B #15,D3

 LEA LED,A0
 MOVE.L LED1,A1
 MULU #256,D1
 ADDA.L D1,A0
 
 REPT 128
 MOVE.W (A0)+,(A1)+
 ADD.L #158,A1
 ENDR

 LEA LED,A0
 MOVE.L LED2,A1
 MULU #256,D2
 ADDA.L D2,A0
 
 REPT 128
 MOVE.W (A0)+,(A1)+
 ADD.L #158,A1
 ENDR

 LEA LED,A0
 MOVE.L LED3,A1
 MULU #256,D3
 ADDA.L D3,A0
 
 REPT 128
 MOVE.W (A0)+,(A1)+
 ADD.L #158,A1
 ENDR

EXIT:
 MOVEM.L (SP)+,D0-D7/A0-A5
 RTE
 
HBL:
 MOVE.W (A6)+,$FFFF8242.W
 BCLR #0,$FFFFFA0F.W
 RTE 

 EVEN
MUSIC:		INCBIN GIANAMIX.MUS
MUSICEND:
 EVEN
SUPER:		DC.L 0
SCREEN:		DC.L 0
SR_SAVE:	DC.W 0
REZ:		DC.W 0
LED1:		DC.L 0
LED2:		DC.L 0
LED3:		DC.L 0
RAST_POINT:	DC.L 0

RASTER:
 DC.W $100,$200,$300,$400,$500,$600,$700,$710
 DC.W $720,$730,$740,$750,$760,$770,$771,$772
 DC.W $773,$774,$775,$776,$777,$677,$577,$477
 DC.W $377,$277,$177,$077,$067,$057,$047,$037
 DC.W $027,$017,$007,$107,$207,$307,$407,$507
 DC.W $607,$707

 DC.W $100,$200,$300,$400,$500,$600,$700,$710
 DC.W $720,$730,$740,$750,$760,$770,$771,$772
 DC.W $773,$774,$775,$776,$777,$677,$577,$477
 DC.W $377,$277,$177,$077,$067,$057,$047,$037
 DC.W $027,$017,$007,$107,$207,$307,$407,$507
 DC.W $607,$707

 DC.W $100,$200,$300,$400,$500,$600,$700,$710
 DC.W $720,$730,$740,$750,$760,$770,$771,$772
 DC.W $773,$774,$775,$776,$777,$677,$577,$477
 DC.W $377,$277,$177,$077,$067,$057,$047,$037
 DC.W $027,$017,$007,$107,$207,$307,$407,$507
 DC.W $607,$707

 DC.W $100,$200,$300,$400,$500,$600,$700,$710
 DC.W $720,$730,$740,$750,$760,$770,$771,$772
 DC.W $773,$774,$775,$776,$777,$677,$577,$477
 DC.W $377,$277,$177,$077,$067,$057,$047,$037
 DC.W $027,$017,$007,$107,$207,$307,$407,$507
 DC.W $607,$707


 DC.W $100,$200,$300,$400,$500,$600,$700,$710
 DC.W $720,$730,$740,$750,$760,$770,$771,$772
 DC.W $773,$774,$775,$776,$777,$677,$577,$477
 DC.W $377,$277,$177,$077,$067,$057,$047,$037
 DC.W $027,$017,$007,$107,$207,$307,$407,$507
 DC.W $607,$707
RAST_END:
 
LED:
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$FFFF
 DC.W $FFFF,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$0000,$0000
 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

 DC.W $0000,$0000,$0000,$0000,$0000,$0000,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$0000,$0000,$0000,$0000,$0000,$0000

 DC.W $0000,$0000,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
 DC.W $FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$0000,$0000

 SECTION BSS
RASTBUFF1:	DS.W 250
RASTBUFF2:	DS.W 250
PALSAVE:	DS.W 16
INTSAVE:	DS.L 100
 END

	
