 MOVE.L A7,A5
 MOVE.L 4(A5),A5
 MOVE.L $C(A5),D0
 ADD.L $14(A5),D0
 ADD.L $1C(A5),D0
 ADD.L #$1100,D0
 MOVE.L A5,D1
 ADD.L D0,D1
 AND.L #-2,D1
 MOVE.L D1,A7
 MOVE.L D0,-(SP)
 MOVE.L A5,-(SP)
 MOVE.W D0,-(SP)
 MOVE.W #$4A,-(SP) 
 TRAP #1
 ADD.L #12,SP

 DC.W $A000
 DC.W $A00A

 MOVE.W #0,-(SP)
 MOVE.L #-1,-(SP)
 MOVE.L #-1,-(SP)
 MOVE.W #5,-(SP)
 TRAP #14
 ADD.L #12,SP

 CLR.L -(SP)
 MOVE.W #$20,-(SP)
 TRAP #1
 ADDQ.L #6,SP
 MOVE.L SUPER,D0
 
 MOVE.L #XDATA,SPX1
 MOVE.L #XDATA+8,SPX2
 MOVE.L #XDATA+16,SPX3
 MOVE.L #YDATA,SPY1
 MOVE.L #YDATA+4,SPY2
 MOVE.L #YDATA+8,SPY3

 MOVE.L SPX1,A0
 MOVE.W (A0),X
 MOVE.L SPX2,A0
 MOVE.W (A0),X2
 MOVE.L SPX3,A0
 MOVE.W (A0),X3
 ADD.L #2,SPX1
 ADD.L #2,SPX2
 ADD.L #2,SPX3

 MOVE.L SPY1,A0
 MOVE.W (A0),Y
 MOVE.L SPY2,A0
 MOVE.W (A0),Y2
 MOVE.L SPY3,A0
 MOVE.W (A0),Y3
 ADD.L #2,SPY1
 ADD.L #2,SPY2
 ADD.L #2,SPY3
 
 MOVE.W X,D0
 MOVE.W Y,D1
 MOVE.L #SPRITE,A0
 MOVE.L #SPRSAVE,A2
 DC.W $A00D

 MOVE.W X2,D0
 MOVE.W Y2,D1
 MOVE.L #SPRITE2,A0
 MOVE.L #SPRSAVE2,A2
 DC.W $A00D

 MOVE.W X3,D0
 MOVE.W Y3,D1
 MOVE.L #SPRITE3,A0
 MOVE.L #SPRSAVE3,A2
 DC.W $A00D

 MOVE.L #$4CE,A0
 MOVE.L #MAIN,A1
TEST0:
 ADD.L #4,A0
 TST.L (A0)
 BNE TEST0
 MOVE.L A1,(A0)

 MOVE.L SUPER,-(SP)
 MOVE.W #$20,-(SP)
 TRAP #1
 ADDQ.L #6,SP

 MOVE.W #0,-(SP)
 MOVE.L #4096,-(SP)
 MOVE.W #$31,-(SP)
 TRAP #1

MAIN:
 MOVEM.L A0-A6/D0-D7,-(SP)
 MOVE.L #SPRSAVE3,A2
 DC.W $A00C

 MOVE.L #SPRSAVE2,A2
 DC.W $A00C

 MOVE.L #SPRSAVE,A2
 DC.W $A00C

 SUB.W #80,Y
 SUB.W #80,Y2
 SUB.W #80,Y3

 MOVE.W X,D0
 MOVE.W Y,D1
 MOVE.L #SPRITE,A0
 MOVE.L #SPRSAVE,A2
 DC.W $A00D

 MOVE.W X2,D0
 MOVE.W Y2,D1
 MOVE.L #SPRITE2,A0
 MOVE.L #SPRSAVE2,A2
 DC.W $A00D

 MOVE.W X3,D0
 MOVE.W Y3,D1
 MOVE.L #SPRITE3,A0
 MOVE.L #SPRSAVE3,A2
 DC.W $A00D

NEW:
 MOVE.L SPX1,A0
 CMP.W #0,(A0)
 BNE CHECKX2
 MOVE.L #XDATA,SPX1

CHECKX2:
 MOVE.L SPX2,A0
 CMP.W #0,(A0)
 BNE CHECKX3
 MOVE.L #XDATA+8,SPX2

CHECKX3:
 MOVE.L SPX3,A0
 CMP.W #0,(A0)
 BNE CHECKY1
 MOVE.L #XDATA+16,SPX3

CHECKY1:
 MOVE.L SPY1,A0
 CMP.W #0,(A0)
 BNE CHECKY2
 MOVE.L #YDATA,SPY1

CHECKY2:
 MOVE.L SPY2,A0
 CMP.W #0,(A0)
 BNE CHECKY3
 MOVE.L #YDATA+4,SPY2

CHECKY3:
 MOVE.L SPY3,A0
 CMP.W #0,(A0)
 BNE CONT
 MOVE.L #YDATA+8,SPY3

CONT:
 MOVE.L SPX1,A0
 MOVE.W (A0),X
 MOVE.L SPX2,A0
 MOVE.W (A0),X2
 MOVE.L SPX3,A0
 MOVE.W (A0),X3
 ADD.L #2,SPX1
 ADD.L #2,SPX2
 ADD.L #2,SPX3

 MOVE.L SPY1,A0
 MOVE.W (A0),Y
 MOVE.L SPY2,A0
 MOVE.W (A0),Y2
 MOVE.L SPY3,A0
 MOVE.W (A0),Y3
 ADD.L #2,SPY1
 ADD.L #2,SPY2
 ADD.L #2,SPY3
 MOVEM.L (SP)+,A0-A6/D0-D7
 RTS

SPRITE:
 DC.W 0,0,0,3,1
 DC.W %0111111111111000,%0000000000000000
 DC.W %0111111111111000,%0011111111111100
 DC.W %0111111111111000,%0011111111111100
 DC.W %0111111111111000,%0011111111111100
 DC.W %0000000000000000,%0000000000000000
 DC.W %0000000000000000,%0000000000000000
 DC.W %0111111111110000,%0000000000000000
 DC.W %0111111111110000,%0011111111111000
 DC.W %0111111111110000,%0011111111111000
 DC.W %0111111111110000,%0011111111111000
 DC.W %0111100000000000,%0011110000000000
 DC.W %0111111111110000,%0011110000000000
 DC.W %0111111111110000,%0011111111111000
 DC.W %0111111111110000,%0011111111111000
 DC.W %0000000000000000,%0011111111111000
 DC.W %0000000000000000,%000000000000000

SPRSAVE:		DS.W 256

SPRITE2:
 DC.W 0,0,0,3,1
 DC.W %0111111111100000,%0000000000000000
 DC.W %0100000000000000,%0011111111110000
 DC.W %0100000000000000,%0011111111111000
 DC.W %0000000000000000,%0011111111111000
 DC.W %0000000010000000,%0000000001111000
 DC.W %0000000010000000,%0000000001111000
 DC.W %0111111110000000,%0000000001111000
 DC.W %0100000000000000,%0011111111111000
 DC.W %0100000000000000,%0011111111111000
 DC.W %0100000000000000,%0011111111110000
 DC.W %0100000000000000,%0011110000000000
 DC.W %0100000000000000,%0011110000000000
 DC.W %0100000000000000,%0011110000000000
 DC.W %0100000000000000,%0011110000000000
 DC.W %0000000000000000,%0011110000000000
 DC.W %0000000000000000,%0000000000000000

SPRSAVE2:		DS.W 256

SPRITE3:
 DC.W 0,0,0,3,1
 DC.W %0001111000000000,%0000000000000000
 DC.W %0000000000000000,%0000111100000000
 DC.W %0000100000000000,%0000011110000000
 DC.W %0000000000000000,%0000011110000000
 DC.W %0000010000000000,%0000001111000000
 DC.W %0000000000000000,%0000001111000000
 DC.W %0000001000000000,%0000000111100000
 DC.W %0000000000000000,%0000000111100000
 DC.W %0011110100000000,%0000000011110000
 DC.W %0010000000000000,%0001111011110000
 DC.W %0110000010000000,%0001111001111000
 DC.W %0100001110000000,%0011110001111000
 DC.W %0100000000000000,%0011111111111000
 DC.W %0100000000000000,%0011111111111000
 DC.W %0000000000000000,%0011111111111000
 DC.W %0000000000000000,%0000000000000000

SPRSAVE3:		DS.W 256
VBLSAVE:		DC.L 0
X:			DC.W 0
X2:			DC.W 0
X3:			DC.W 0
Y:			DC.W 0
Y2:			DC.W 0
Y3:			DC.W 0
SUPER:			DC.L 0
SPX1:			DC.L XDATA
SPX2:			DC.L XDATA+8
SPX3:			DC.L XDATA+16
SPY1:			DC.L YDATA
SPY2:			DC.L YDATA+4
SPY3:			DC.L YDATA+8

XDATA:
 DC.W $7C,$7E,$81,$83,$85,$88,$8A,$8C,$8F,$91,$93,$96,$98,$9A,$9C
 DC.W $9E,$A1,$A3,$A5,$A7,$A9,$AB,$AD,$AF,$B1,$B3,$B5,$B7,$B9,$BB
 DC.W $BC,$BE,$C0,$C1,$C3,$C5,$C6,$C7,$C9,$CA,$CC,$CD,$CE,$CF,$D0
 DC.W $D1,$D3,$D3,$D4,$D5,$D6,$D7,$D8,$D8,$D9,$DA,$DA,$DB,$DB,$DB
 DC.W $DB,$DB,$DB,$DB,$DB,$DB,$DB,$DB,$DB,$DA,$DA,$DA,$D9,$D8,$D8
 DC.W $D7,$D6,$D6,$D5,$D4,$D3,$D2,$D1,$D0,$CF,$CE,$CC,$CB,$CA,$C8
 DC.W $C7,$C5,$C4,$C2,$C1,$BF,$BD,$BB,$BA,$B8,$B6,$B4,$B2,$B0,$AE
 DC.W $AC,$AA,$A8,$A6,$A4,$A2,$A0,$9D,$9B,$99,$97,$94,$92,$90,$8E
 DC.W $8B,$89,$87,$84,$82,$80,$7D,0

YDATA:
 DC.W $7A,$7C,$7E,$81,$83,$85,$88,$8A,$8C,$8E,$91,$93,$95,$97,$99
 DC.W $9B,$9D,$9F,$A1,$A3,$A5,$A6,$A8,$AA,$AB,$AD,$AE,$AF,$B1,$B2
 DC.W $B3,$B4,$B5,$B6,$B6,$B7,$B8,$B8,$B9,$B9,$B9,$B9,$B9,$B9,$B9
 DC.W $B9,$B9,$B9,$B8,$B8,$B7,$B6,$B6,$B5,$B4,$B3,$B2,$B1,$AF,$AE
 DC.W $AD,$AB,$AA,$A8,$A6,$A5,$A3,$A1,$9F,$9D,$9B,$99,$97,$95,$93
 DC.W $91,$8E,$8C,$8A,$88,$85,$83,$81,$7E,$7C,$7A,0


 END












