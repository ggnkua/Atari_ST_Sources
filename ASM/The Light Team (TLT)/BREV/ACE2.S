
 PEA MUZAK
 MOVE.W #38,-(SP)
 TRAP #14
 ADDQ.L #6,SP

 PEA MUZAKOFF
 MOVE.W #38,-(SP)
 TRAP #14
 ADDQ.L #6,SP

 CLR.W -(SP)
 TRAP #1

MUZAK:
 LEA BUFFER,A0
 LEA $72000,A1
 MOVE.L #7007,D5
LOOP:
 MOVE.B (A1)+,(A0)+
 DBRA D5,LOOP

 LEA MUSIC,A0
 LEA $72000,A1
 MOVE.L #7007,D5
LOOP2:
 MOVE.B (A0)+,(A1)+
 DBRA D5,LOOP2

 JMP $72000
 MOVE.L #$7265C,$4D2
 RTS

MUZAKOFF:
 MOVE.W #7,-(SP)
 TRAP #1
 ADDQ.L #2,SP

 CLR.L $4D2
 JSR $72006
 
 LEA $72000,A0
 LEA BUFFER,A1
 MOVE.L #7007,D5
LOOP3:
 MOVE.B (A1)+,(A0)+
 DBRA D5,LOOP3
 RTS

MUSIC:             INCBIN C:\SOURCE.S\MUSIX\ACE2.MUS
BUFFER:            DS.B 7007
VSAVE:             DC.L 0
 END