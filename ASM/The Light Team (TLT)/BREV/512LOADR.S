	move.l 4(sp),a3		
	move.l #stack,sp
	move.l $c(a3),d0		
	add.l $14(a3),d0		
	add.l $1c(a3),d0		
	add.l #$100,d0		
	move.l d0,-(sp)
	move.l a3,-(sp)
	clr.w -(sp)
	move.w #$4a,-(sp)
	trap #1		
	lea 12(sp),sp
	move.w	#1,-(sp)
	move.l	#namn,-(sp)
	bsr Spectrum
	move.l	#5000000000,d7
loop	mulu	d0,d0
	mulu	d1,d1
	dbf	d7,loop
	move.w	#0,-(sp)
	move.l	#0,-(sp)
	bsr spectrum
	clr.l	-(sp)
	trap 	#1
no	 jmp no


Spectrum
   dc.b  $60,$1A,$00,$00,$07,$D4,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
   dc.b  $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$20,$2F,$00,$04
   dc.b  $41,$FA,$06,$7E,$20,$80,$30,$2F,$00,$08,$41,$FA,$06,$78,$20,$8F
   dc.b  $4F,$FA,$07,$BA,$B0,$7C,$00,$01,$67,$04,$60,$00,$05,$98,$61,$00
   dc.b  $01,$3E,$61,$00,$05,$D8,$61,$00,$06,$0A,$41,$FA,$06,$54,$20,$10
   dc.b  $61,$00,$05,$00,$41,$FA,$06,$8A,$20,$08,$61,$00,$01,$16,$61,$00
   dc.b  $01,$42,$41,$FA,$06,$9C,$20,$3C,$00,$00,$00,$0C,$61,$00,$05,$10
   dc.b  $20,$3A,$06,$8E,$B0,$BC,$53,$50,$00,$00,$67,$04,$60,$00,$00,$8E
   dc.b  $20,$3C,$00,$00,$7D,$00,$61,$00,$04,$A8,$41,$FA,$06,$20,$20,$80
   dc.b  $20,$40,$20,$3A,$06,$70,$61,$00,$04,$E6,$20,$7A,$06,$10,$22,$7A
   dc.b  $06,$18,$D3,$FC,$00,$00,$00,$A0,$20,$3A,$06,$5A,$61,$00,$04,$1C
   dc.b  $20,$3A,$05,$FA,$61,$00,$04,$90,$20,$3C,$00,$00,$4A,$A0,$61,$00
   dc.b  $04,$70,$41,$FA,$05,$F0,$20,$80,$20,$40,$20,$3A,$06,$3C,$61,$00
   dc.b  $04,$AE,$20,$3C,$00,$00,$4B,$00,$61,$00,$04,$56,$41,$FA,$05,$D2
   dc.b  $20,$80,$20,$3A,$06,$24,$20,$7A,$05,$CC,$22,$7A,$05,$C4,$54,$80
   dc.b  $61,$00,$03,$AC,$20,$3A,$05,$BE,$61,$00,$04,$4C,$30,$3A,$05,$AA
   dc.b  $61,$00,$04,$6A,$61,$00,$00,$C0,$60,$00,$04,$C4,$30,$3A,$05,$9A
   dc.b  $61,$00,$04,$5A,$41,$FA,$05,$8A,$20,$10,$61,$00,$04,$36,$20,$7A
   dc.b  $05,$98,$20,$3C,$00,$00,$7D,$00,$61,$00,$04,$54,$20,$3C,$00,$00
   dc.b  $4A,$A4,$61,$00,$03,$FC,$41,$FA,$05,$78,$20,$80,$20,$40,$20,$3C
   dc.b  $00,$00,$4A,$A0,$61,$00,$04,$38,$30,$3A,$05,$5E,$61,$00,$04,$1E
   dc.b  $61,$00,$00,$0A,$61,$00,$00,$70,$60,$00,$04,$74,$20,$7A,$05,$52
   dc.b  $30,$3C,$00,$C6,$42,$50,$D1,$FC,$00,$00,$00,$60,$51,$C8,$FF,$F6
   dc.b  $4E,$75,$2F,$00,$3F,$3C,$00,$06,$4E,$4E,$5C,$8F,$4E,$75,$4D,$FA
   dc.b  $05,$8C,$3C,$3C,$00,$00,$3F,$3C,$FF,$FF,$3F,$06,$3F,$3C,$00,$07
   dc.b  $4E,$4E,$5C,$8F,$3C,$C0,$06,$46,$00,$01,$BC,$7C,$00,$10,$66,$E6
   dc.b  $4E,$75,$3F,$3C,$00,$12,$3F,$3C,$00,$04,$3F,$3C,$00,$03,$4E,$4D
   dc.b  $5C,$8F,$4E,$75,$3F,$3C,$00,$08,$3F,$3C,$00,$04,$3F,$3C,$00,$03
   dc.b  $4E,$4D,$5C,$8F,$4E,$75,$48,$7A,$00,$0C,$3F,$3C,$00,$26,$4E,$4E
   dc.b  $5C,$8F,$4E,$75,$30,$39,$00,$00,$04,$54,$20,$79,$00,$00,$04,$56
   dc.b  $43,$FA,$04,$FA,$22,$88,$53,$40,$43,$FA,$04,$D2,$32,$00,$22,$D8
   dc.b  $51,$C9,$FF,$FC,$41,$FA,$04,$C6,$22,$18,$67,$00,$00,$08,$51,$C8
   dc.b  $FF,$F8,$4E,$75,$08,$39,$00,$01,$00,$FF,$82,$0A,$67,$00,$00,$08
   dc.b  $43,$FA,$01,$5C,$60,$04,$43,$FA,$00,$28,$21,$09,$43,$FA,$04,$9E
   dc.b  $23,$C9,$00,$00,$04,$56,$4E,$75,$48,$7A,$00,$0C,$3F,$3C,$00,$26
   dc.b  $4E,$4E,$5C,$8F,$4E,$75,$23,$FA,$04,$A4,$00,$00,$04,$56,$4E,$75
   dc.b  $40,$E7,$00,$7C,$07,$00,$3E,$3C,$00,$C6,$2A,$7C,$00,$FF,$82,$40
   dc.b  $42,$79,$00,$FF,$82,$40,$20,$7A,$04,$58,$42,$40,$4A,$39,$00,$FF
   dc.b  $82,$09,$66,$00,$00,$FE,$4A,$39,$00,$FF,$82,$09,$67,$F8,$10,$39
   dc.b  $00,$FF,$82,$09,$4E,$FB,$00,$00,$4E,$71,$4E,$71,$4E,$71,$4E,$71
   dc.b  $4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71
   dc.b  $4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71
   dc.b  $4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71
   dc.b  $4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71
   dc.b  $4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71
   dc.b  $4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71
   dc.b  $4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71
   dc.b  $4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71
   dc.b  $4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71
   dc.b  $4E,$71,$4E,$71,$22,$4D,$22,$D8,$22,$D8,$22,$D8,$22,$D8,$22,$D8
   dc.b  $22,$D8,$22,$D8,$22,$D8,$22,$4D,$24,$4D,$26,$4D,$4E,$71,$22,$D8
   dc.b  $22,$D8,$22,$D8,$22,$D8,$22,$D8,$22,$D8,$22,$D8,$22,$D8,$24,$D8
   dc.b  $24,$D8,$24,$D8,$24,$D8,$24,$D8,$24,$D8,$24,$D8,$24,$D8,$26,$D8
   dc.b  $26,$D8,$26,$D8,$26,$D8,$26,$D8,$26,$D8,$26,$D8,$26,$D8,$51,$CF
   dc.b  $FF,$C6,$33,$FC,$00,$00,$00,$FF,$82,$40,$46,$DF,$4E,$75,$40,$E7
   dc.b  $00,$7C,$07,$00,$3E,$3C,$00,$C6,$2A,$7C,$00,$FF,$82,$40,$42,$79
   dc.b  $00,$FF,$82,$40,$20,$7A,$03,$2A,$42,$40,$4A,$39,$00,$FF,$82,$09
   dc.b  $66,$00,$01,$00,$4A,$39,$00,$FF,$82,$09,$67,$F8,$10,$39,$00,$FF
   dc.b  $82,$09,$4E,$FB,$00,$00,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71
   dc.b  $4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71
   dc.b  $4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71
   dc.b  $4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71
   dc.b  $4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71
   dc.b  $4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71
   dc.b  $4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71
   dc.b  $4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71
   dc.b  $4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71
   dc.b  $4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71,$4E,$71
   dc.b  $4E,$71,$22,$4D,$22,$D8,$22,$D8,$22,$D8,$22,$D8,$22,$D8,$22,$D8
   dc.b  $22,$D8,$22,$D8,$22,$4D,$24,$4D,$26,$4D,$4E,$71,$4E,$71,$22,$D8
   dc.b  $22,$D8,$22,$D8,$22,$D8,$22,$D8,$22,$D8,$22,$D8,$22,$D8,$24,$D8
   dc.b  $24,$D8,$24,$D8,$24,$D8,$24,$D8,$24,$D8,$24,$D8,$24,$D8,$26,$D8
   dc.b  $26,$D8,$26,$D8,$26,$D8,$26,$D8,$26,$D8,$26,$D8,$26,$D8,$51,$CF
   dc.b  $FF,$C4,$33,$FC,$00,$00,$00,$FF,$82,$40,$46,$DF,$4E,$75,$E2,$48
   dc.b  $53,$40,$4A,$40,$6B,$22,$32,$18,$02,$41,$7F,$FE,$34,$3C,$00,$0F
   dc.b  $36,$01,$02,$43,$00,$01,$67,$06,$32,$D8,$53,$40,$60,$02,$42,$59
   dc.b  $E2,$49,$51,$CA,$FF,$EC,$60,$D8,$4E,$75,$96,$83,$24,$49,$53,$40
   dc.b  $4A,$40,$6B,$5A,$92,$41,$12,$18,$08,$01,$00,$07,$66,$26,$90,$41
   dc.b  $53,$40,$14,$D8,$2E,$0A,$08,$07,$00,$00,$66,$00,$00,$04,$5C,$8A
   dc.b  $52,$43,$B6,$7C,$1F,$18,$6D,$06,$54,$89,$24,$49,$96,$83,$51,$C9
   dc.b  $FF,$E2,$60,$CA,$44,$01,$52,$01,$14,$18,$53,$40,$14,$C2,$2E,$0A
   dc.b  $08,$07,$00,$00,$66,$00,$00,$04,$5C,$8A,$52,$43,$B6,$7C,$1F,$18
   dc.b  $6D,$06,$54,$89,$24,$49,$96,$83,$51,$C9,$FF,$E2,$60,$A0,$4E,$75
   dc.b  $2F,$00,$3F,$3C,$00,$48,$4E,$41,$5C,$8F,$4A,$80,$6B,$00,$00,$5C
   dc.b  $67,$00,$00,$58,$4E,$75,$2F,$00,$3F,$3C,$00,$49,$4E,$41,$5C,$8F
   dc.b  $4E,$75,$3F,$3C,$00,$00,$2F,$00,$3F,$3C,$00,$3D,$4E,$41,$50,$8F
   dc.b  $41,$FA,$01,$46,$30,$80,$6B,$00,$00,$4E,$4E,$75,$3F,$00,$3F,$3C
   dc.b  $00,$3E,$4E,$41,$58,$8F,$4A,$40,$6B,$00,$00,$3C,$4E,$75,$2F,$08
   dc.b  $2F,$00,$3F,$3A,$01,$24,$3F,$3C,$00,$3F,$4E,$41,$DF,$FC,$00,$00
   dc.b  $00,$0C,$4A,$40,$6B,$00,$00,$20,$4E,$75,$48,$7A,$00,$D4,$3F,$3C
   dc.b  $00,$09,$4E,$41,$5C,$8F,$60,$1A,$48,$7A,$00,$DA,$3F,$3C,$00,$09
   dc.b  $4E,$41,$5C,$8F,$60,$0C,$48,$7A,$00,$AA,$3F,$3C,$00,$09,$4E,$41
   dc.b  $5C,$8F,$58,$8F,$41,$FA,$01,$46,$20,$08,$61,$00,$FB,$A6,$2E,$7A
   dc.b  $00,$D4,$4E,$75,$20,$3A,$01,$06,$4A,$80,$67,$04,$61,$00,$FC,$4A
   dc.b  $20,$3A,$00,$CE,$4A,$80,$67,$04,$61,$00,$FF,$5C,$41,$FA,$01,$1E
   dc.b  $20,$08,$61,$00,$FB,$7E,$3F,$3A,$00,$B2,$2F,$3C,$FF,$FF,$FF,$FF
   dc.b  $2F,$3C,$FF,$FF,$FF,$FF,$3F,$3C,$00,$05,$4E,$4E,$DF,$FC,$00,$00
   dc.b  $00,$0C,$61,$00,$FB,$A0,$2E,$7A,$00,$8C,$4E,$75,$3F,$3C,$00,$04
   dc.b  $4E,$4E,$54,$8F,$41,$FA,$00,$84,$30,$80,$67,$24,$B0,$7C,$00,$02
   dc.b  $67,$00,$FF,$76,$3F,$3C,$00,$00,$2F,$3C,$FF,$FF,$FF,$FF,$2F,$3C
   dc.b  $FF,$FF,$FF,$FF,$3F,$3C,$00,$05,$4E,$4E,$DF,$FC,$00,$00,$00,$0C
   dc.b  $4E,$75,$3F,$3C,$00,$03,$4E,$4E,$54,$8F,$41,$FA,$00,$5C,$20,$80
   dc.b  $4E,$75,$46,$69,$6C,$65,$2D,$65,$72,$72,$6F,$72,$20,$21,$00,$00
   dc.b  $4E,$6F,$74,$20,$65,$6E,$6F,$75,$67,$68,$20,$6D,$65,$6D,$6F,$72
   dc.b  $79,$20,$21,$00,$53,$6F,$72,$72,$79,$2C,$20,$63,$6F,$6C,$6F,$72
   dc.b  $20,$64,$69,$73,$70,$6C,$61,$79,$20,$6F,$6E,$6C,$79,$20,$21,$00
   dc.b  $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
   dc.b  $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
   dc.b  $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
   dc.b  $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
   dc.b  $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
   dc.b  $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
   dc.b  $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
   dc.b  $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
   dc.b  $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
   dc.b  $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
   dc.b  $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
   dc.b  $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
   dc.b  $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
   dc.b  $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
   dc.b  $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
   dc.b  $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
   dc.b  $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
   dc.b  $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
   dc.b  $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
   dc.b  $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
   dc.b  $00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00,$00
	ds.l $400
stack

namn	dc.b "bee_512.spc",0