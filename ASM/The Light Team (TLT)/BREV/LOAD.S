 CLR.W -(SP)
 MOVE.L #FILENAME,-(SP)
 MOVE.W #$3D,-(SP)
 TRAP #1
 ADDQ.L #8,SP
 MOVE.W D0,HANDLE
 MOVE.L #LOADAMOUNT,-(SP)
 MOVE.L #LOADADR,-(SP)
 MOVE.W HANDLE,-(SP)
 MOVE.W #$3F,-(SP)
 TRAP #1
 ADD.L #12,SP
 MOVE.W HANDLE,-(SP)
 MOVE.W #$3E,-(SP)
 TRAP #1
 ADDQ.L #4,SP
 JMP $A0000

LOADAMOUNT:	DC.L 23448
LOADADR:	DC.L $A0000
HANDLE:		DC.W 0
FILENAME:	DC.B 'MONST2.PRG',0
 END