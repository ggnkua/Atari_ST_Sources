; Letterwriter Binary Font Conversion Utility. - Coded by Zaphod/TLT.

 OPT D+

 CLR.W	-(SP)
 PEA	-1
 PEA	-1
 MOVE.W	#5,-(SP)
 TRAP	#14
 LEA	12(SP),SP
 
 MOVE.W	#2,-(SP)
 TRAP	#14
 MOVE.L	D0,SCREEN
  
 LEA FONT+128,A0
 LEA FONTBIN,A1
 MOVE.L #6-1,D7
 
ROWS:
 REPT 20
 MOVE.B 160*0+0(A0),(A1)+
 MOVE.B 160*1+0(A0),(A1)+
 MOVE.B 160*2+0(A0),(A1)+
 MOVE.B 160*3+0(A0),(A1)+
 MOVE.B 160*4+0(A0),(A1)+
 MOVE.B 160*5+0(A0),(A1)+
 MOVE.B 160*6+0(A0),(A1)+
 MOVE.B 160*7+0(A0),(A1)+
 MOVE.B 160*0+1(A0),(A1)+
 MOVE.B 160*1+1(A0),(A1)+
 MOVE.B 160*2+1(A0),(A1)+
 MOVE.B 160*3+1(A0),(A1)+
 MOVE.B 160*4+1(A0),(A1)+
 MOVE.B 160*5+1(A0),(A1)+
 MOVE.B 160*6+1(A0),(A1)+
 MOVE.B 160*7+1(A0),(A1)+
 ADD.L #8,A0
 ENDR
 ADD.L #160*7,A0
 DBRA D7,ROWS
 
 LEA	FONTBIN,A0
* LEA	8*24(A0),A0	; Z???
 
AGAIN:
 MOVE.L	SCREEN,A1
 MOVE.L	#8-1,D7
 
TEST:
 MOVE.B	(A0)+,(A1)
 LEA	160(A1),A1
 DBRA	D7,TEST

 MOVEM.L A0-A1,-(SP)
 MOVE.W	#7,-(SP)
 TRAP	#1
 LEA	2(SP),SP
 MOVEM.L (SP)+,A0-A1
 
 CMP.B	#27,D0
 BEQ	EXIT
 BRA	AGAIN

EXIT:
 CLR.W -(SP)
 TRAP #1
 
FONT:		INCBIN 	E:\FONTS\FONT1.NEO
 EVEN
SCREEN:		DC.L	0 
 SECTION BSS
 
FONTBIN:	DS.B 	8*40*6
FONTEND:
 END