; *************************************************************
; *       TLT DEMO, CHOOSE MUSIX WITH KEYS A-Z+F1-F10         *
; *       CODED BY: THE DISK BUSTER OF THE LIGHT TEAM.        *
; *************************************************************
;
 MOVE.L A7,A5
 MOVE.L 4(A5),A5
 MOVE.L $C(A5),D0
 ADD.L $14(A5),D0
 ADD.L $1C(A5),D0
 ADD.L #$1100,D0
 MOVE.L A5,D1
 ADD.L D0,D1
 AND.L #-2,D1
 MOVE.L D1,A7
 MOVE.L D0,-(SP)
 MOVE.L A5,-(SP)
 MOVE.W D0,-(SP)
 MOVE.W #$4A,-(SP) 
 TRAP #1
 ADD.L #12,SP
;
 MOVE.W #0,-(SP)
 MOVE.L #-1,-(SP)
 MOVE.L #-1,-(SP)
 MOVE.W #5,-(SP)
 TRAP #14
 ADD.L #12,SP
;
 DC.W $A000
 DC.W $A00A
;
 CLR.L -(SP)
 MOVE.W #$20,-(SP)
 TRAP #1
 ADDQ.L #6,SP
 MOVE.L D0,SUPER
;
 MOVE.W #2,-(SP)
 TRAP #14
 ADDQ.L #2,SP
 MOVE.L D0,SCREEN
;
 MOVE.L #$FF8240,A2
 MOVE.L #15,D5
BLACKOUT:
 CLR.W (A2)+
 DBRA D5,BLACKOUT
;
 MOVE.L #59122,LENGTH
 MOVE.L #SOUNDBUFF,D6
 ADD.L LENGTH,D6
 MOVE.L D6,SBUFF
 MOVE.L #SOUNDBUFF,PLAYPOS
;
 MOVE.L #GRAFBUF,A0
 ADD.L #128,A0
 MOVE.L SCREEN,A1
 MOVE.L #199,D7
ROW: MOVE.L #159,D6
LINE: MOVE.W (A0)+,(A1)+
 DBRA D6,LINE
 DBRA D7,ROW
;
 MOVE.L #GRAFBUF,A4
 MOVE.W #0,D4
 MOVE.W #15,D5
COLORS:
 MOVE.W 4(A4),-(SP)
 MOVE.W D4,-(SP)
 MOVE.W #7,-(SP)
 TRAP #14
 ADDQ.L #6,SP
 ADD.L #2,A4
 ADD.W #1,D4
 DBRA D5,COLORS
;
 ADD.L #128,FONTPOINT
 MOVE.L #SCROLLTXT,BOKSTAV
 MOVE.B $FFFA07,REG1
 MOVE.B $FFFA09,REG2
 MOVE.B #0,$FFFA09
 MOVE.B #0,$FFFA07
;
 MOVE.L #$31415926,$426
 MOVE.L #RESVEC,$42A
 BSR RASTERON
 BSR TUNE111
 BRA MAIN

RESVEC:
 MOVE.B #2,$FF820A
 LEA $D50,A7
 MOVE.W #$000,$FF8240
 MOVE.L SCREEN,A0
 MOVE.L #32000/4,D7
RENSA: CLR.L (A0)+
 DBRA D7,RENSA
 MOVE.L #MESSAGE,-(SP)
 MOVE.W #9,-(SP)
 TRAP #1
 ADDQ.L #6,SP
 CLR.L D0
 MOVE.L #10,D0
SETREGS:
 MOVE.B D0,$FFF8800
 CLR.B $FFF8802
 DBF D0,SETREGS
 CLR.B $FFF8800
 CLR.B $FFF8802
 MOVE.B #7,$FFF8800
 MOVE.B #$F8,$FFF8802
 MOVE.L #CHANEL_A,A6
 MOVE.L PLAYPOS,A3
 MOVE.L #$FFFF8800,A5
ISR:             
 MOVE.B (A3)+,D0
 MOVE.L SBUFF,D6
 CMPA.L D6,A3           
 BLT.S OUTPUT
 MOVE.L #SOUNDBUFF,A3

OUTPUT:
 MOVE.W #45,D7
DELAY:	
 DBRA D7,DELAY
 AND.W #$FF,D0
 MOVE.B #8,(A5)
 MOVE.B 0(A6,D0.W),2(A5)
 MOVE.B #9,(A5)
 ADD.L #256,A6
 MOVE.B 0(A6,D0.W),2(A5)
 MOVE.B #10,(A5)
 ADD.L #256,A6
 MOVE.B 0(A6,D0.W),2(A5)
 SUB.L #512,A6
 MOVE.L A3,PLAYPOS
 BRA ISR

RASTERON:
 MOVE.W #37,-(SP)
 TRAP #14
 ADD.L #2,SP
 MOVE.W $FF8242,SCOLOR1
 MOVE.W $FF8240,SCOLOR0
 MOVE.W #0,LINE2
 MOVE.L #COLTAB,POINTER
 MOVE.L #COLTAB2,POINTER2
 MOVE.L #JMPTABLE,JMPPOINTER
 MOVE.L JMPPOINTER,A6
 MOVE.W (A6),JMPLINE
 MOVE.W (A6),JMPLINE2
 ADD.W #52,JMPLINE2
 MOVE.L #RASTER,-(SP)
 MOVE.W #1,-(SP)
 MOVE.W #8,-(SP)
 MOVE.W #1,-(SP)
 MOVE.W #31,-(SP)
 TRAP #14
 ADD.L #12,SP
 RTS

RASTER:  
 MOVE.W COLOR1,$FF8240
 MOVE.W COLOR,$FF8242
 ADD.W #1,LINE2
 MOVE.L POINTER,A6
 MOVE.W (A6),COLOR
 ADD.L #2,POINTER
 MOVE.W LINE2,A6
 CMPA.W JMPLINE,A6
 BLE NOT
 CMPA.W JMPLINE2,A6
 BGE NOT
 MOVE.L POINTER2,A6
 MOVE.W (A6),COLOR1
 ADD.L #2,POINTER2
 BRA SLUT
NOT: MOVE.W #0,COLOR1 
 CMPI.W #200,LINE2
 BNE SLUT
 MOVE.W #0,LINE2 
 MOVE.L #COLTAB,POINTER
 MOVE.L #COLTAB2,POINTER2
 MOVE.L JMPPOINTER,A6
 CMPI.W #255,(A6)
 BNE MORE
 MOVE.L #JMPTABLE,JMPPOINTER
MORE: MOVE.L JMPPOINTER,A6
 MOVE.W (A6),JMPLINE
 MOVE.W (A6),JMPLINE2
 ADD.W #52,JMPLINE2
 ADD.L #2,JMPPOINTER
SLUT: BCLR #0,$FFFA0F
 RTE

KEYREAD:
 MOVE.B TUNE,D0
 CMP.B #$1E,D0
 BEQ TUNE11
 CMP.B #$30,D0
 BEQ TUNE12
 CMP.B #$2E,D0
 BEQ TUNE21
 CMP.B #$20,D0
 BEQ TUNE31
 CMP.B #$12,D0
 BEQ TUNE41
 CMP.B #$21,D0
 BEQ TUNE42
 CMP.B #$22,D0
 BEQ TUNE43
 CMP.B #$23,D0
 BEQ TUNE51
 CMP.B #$17,D0
 BEQ TUNE52
 CMP.B #$24,D0
 BEQ TUNE53
 CMP.B #$25,D0
 BEQ TUNE61
 CMP.B #$26,D0
 BEQ TUNE62
 CMP.B #$32,D0
 BEQ TUNE63
 CMP.B #$31,D0
 BEQ TUNE71
 CMP.B #$18,D0
 BEQ TUNE72
 CMP.B #$19,D0
 BEQ TUNE91
 CMP.B #$10,D0
 BEQ TUNE92
 CMP.B #$13,D0
 BEQ TUNE101
 CMP.B #$1F,D0
 BEQ TUNE93
 CMP.B #$14,D0
 BEQ TUNE102
 CMP.B #$16,D0
 BEQ TUNE103
 CMP.B #$2F,D0
 BEQ TUNE121
 CMP.B #$11,D0
 BEQ TUNE122
 CMP.B #$2D,D0
 BEQ TUNE141
 CMP.B #$15,D0
 BEQ TUNE142
 CMP.B #$2C,D0
 BEQ TUNE143
 CMP.B #$3B,D0
 BEQ TUNE111
 CMP.B #$3C,D0
 BEQ TUNE112
 CMP.B #$3D,D0
 BEQ TUNE113
 CMP.B #$3E,D0
 BEQ TUNE151
 CMP.B #$3F,D0
 BEQ TUNE152
 CMP.B #$40,D0
 BEQ TUNE161
 CMP.B #$41,D0
 BEQ TUNE162
 CMP.B #$42,D0
 BEQ TUNE163
 CMP.B #$43,D0
 BEQ TUNE171
 CMP.B #$44,D0
 BEQ TUNE81
 RTS

TUNE11: MOVEQ #0,D0
 BRA START1
TUNE12: MOVEQ #1,D0
START1:
 CLR.L $4D2
 JSR MUSIC
 MOVE.L #MUSIC+262,$4D2
 RTS
TUNE21:
 BSR START2
 RTS
START2:
 CLR.L $4D2
 JSR MUSIC2+84
 MOVE.L #THRUST,$4D2
 RTS
THRUST:
 JSR MUSIC2+180
 MOVEQ #3,D1
 RTS
TUNE31:
 BSR START3
 RTS
START3:
 CLR.L $4D2
 JSR MUSIC3+84
 MOVE.L #WARHAWK,$4D2
 RTS
WARHAWK:
 JSR MUSIC3+180
 MOVEQ #3,D1
 RTS
TUNE41: MOVEQ #0,D0
 BRA START4
TUNE42: MOVEQ #1,D0
 BRA START4
TUNE43: MOVEQ #2,D0
START4:
 JSR MUSIC4
 MOVE.L #MUSIC4+294,$4D2
 RTS
TUNE51: MOVEQ #0,D0
 BRA START5
TUNE52: MOVEQ #1,D0
 BRA START5
TUNE53: MOVEQ #2,D0
START5:
 CLR.L $4D2
 JSR MUSIC5+16
 MOVE.L #MUSIC5+290,$4D2
 RTS
TUNE61: MOVEQ #0,D0
 BRA START6
TUNE62: MOVEQ #1,D0
 BRA START6
TUNE63: MOVEQ #2,D0
START6:
 CLR.L $4D2
 JSR MUSIC6
 MOVE.L #MUSIC6+278,$4D2
 RTS
TUNE71: MOVEQ #0,D0
 BRA START7
TUNE72: MOVEQ #1,D0
START7:
 CLR.L $4D2
 JSR MUSIC7
 MOVE.L #MUSIC7+274,$4D2
 RTS
TUNE81:
 CLR.L $4D2
 JSR MUSIC8
 MOVE.L #MUSIC8+100,$4D2
 RTS
TUNE91: MOVEQ #0,D0
 BRA START9
TUNE92: MOVEQ #1,D0
 BRA START9
TUNE93: MOVEQ #2,D0
START9:
 CLR.L $4D2
 JSR MUSIC9
 MOVE.L #MUSIC9+246,$4D2
 RTS
TUNE101: JSR MUSIC101 
 MOVEQ #0,D0
 BRA START10
TUNE102: JSR MUSIC101 
 MOVEQ #1,D0
 BRA START10
TUNE103: JSR MUSIC101 
 MOVEQ #2,D0
START10:
 CLR.L $4D2
 JSR MUSIC102+$4E0
 MOVE.L #MUSIC102+$26,$4D2
 RTS
TUNE111:
 MOVEQ #0,D0
 BRA START11
TUNE112:
 MOVEQ #2,D0
 BRA START11
TUNE113:
 MOVEQ #3,D0
START11:
 CLR.L $4D2
 JSR MUSIC11
 MOVE.L #MUSIC11+322,$4D2
 RTS
TUNE121: MOVEQ #0,D0
 BRA START12
TUNE122: MOVEQ #1,D0
START12:
 CLR.L $4D2
 JSR MUSIC12+1350
 MOVE.L #MUSIC12+40,$4D2
 RTS
TUNE141: MOVEQ #0,D0
 BRA START14
TUNE142: MOVEQ #1,D0
 BRA START14
TUNE143: MOVEQ #2,D0
START14:
 CLR.L $4D2
 JSR MUSIC14+$4C8
 JSR MUSIC14+$504
 MOVE.L #MUSIC14+$42,$4D2
 RTS
TUNE151: MOVEQ #0,D0
 BRA START15
TUNE152: MOVEQ #1,D0
START15:
 CLR.L $4D2
 JSR MUSIC15
 MOVE.L #MUSIC15+$154,$4D2
 RTS
TUNE161: MOVEQ #0,D0
 BRA START16
TUNE162: MOVEQ #1,D0
 BRA START16
TUNE163: MOVEQ #2,D0
START16:
 CLR.L $4D2
 JSR MUSIC16
 MOVE.L #MUSIC16+$116,$4D2
 RTS
TUNE171: MOVEQ #0,D0
 BRA START17
TUNE172: MOVEQ #1,D0
 BRA START17
TUNE173: MOVEQ #2,D0
START17:
 CLR.L $4D2
 JSR MUSIC17
 MOVE.L #MUSIC17+$14C,$4D2
 RTS
MAIN:
 MOVE.L #15,D7
GETBOK: MOVE.L BOKSTAV,A2
 ADD.L #1,BOKSTAV
 CLR.L D3
 MOVE.B (A2),D3
 CMP.B #0,D3
 BNE NEXT2
 MOVE.L #SCROLLTXT,BOKSTAV
 BRA GETBOK
NEXT2: CMP.B #32,D3
 BNE NEXT4
 MOVE.L #BOKADR,A2
 MOVE.L (A2),ADDSUM
 BRA SCROLL
NEXT4: SUB.L #32,D3
 MULU #4,D3
 MOVE.L #BOKADR,A2
 ADD.L D3,A2
 MOVE.L (A2),ADDSUM
SCROLL:
 MOVE.W #37,-(SP)
 TRAP #14
 ADD.L #2,SP
 MOVE.B $FFFC02,TUNE
 MOVE.L SCREEN,A1
 ADDA.L #160*184,A1
 MOVE.L FONTPOINT,A0
 ADDA.L ADDSUM,A0
 MOVE.L #15,D1
LINES16:
 MOVE.L A1,-(SP)
 MOVE.L #3,D2
BITPL:
 CLR.L D0
 ROXL.W #1,D0
 CLR.L D0
 MOVE.W (A0),D0
 ROL.W #1,D0
 MOVE.W D0,(A0)+
 ROXR.W #1,D0
 ROXL.W 152(A1)
 ROXL.W 144(A1)
 ROXL.W 136(A1)
 ROXL.W 128(A1)
 ROXL.W 120(A1)
 ROXL.W 112(A1)
 ROXL.W 104(A1)
 ROXL.W 96(A1)
 ROXL.W 88(A1)
 ROXL.W 80(A1)
 ROXL.W 72(A1)
 ROXL.W 64(A1)
 ROXL.W 56(A1)
 ROXL.W 48(A1)
 ROXL.W 40(A1)
 ROXL.W 32(A1)
 ROXL.W 24(A1)
 ROXL.W 16(A1)
 ROXL.W 8(A1)
 ROXL.W (A1)
 ADDQ.L #2,A1
 DBRA D2,BITPL
 MOVE.L (SP)+,A1
 ADDA.L #160,A1
 ADDA.L #152,A0
 DBRA D1,LINES16
 DBRA D7,SCROLL
 BSR KEYREAD
 CLR.B TUNE
 BRA MAIN 

FONTPOINT:		DC.L FONTBUF
SCREEN:                 DC.L 0
HANDLE:                 DC.W 0
BOKSTAV:                DC.L 0
ADDSUM:                 DC.L 0
SUPER: 			DC.L 0
BOKADR: DC.L 12800,5136,5144,5176,5168,12800,5184,12800
        DC.L 2704,2712,0,5352,2696,5360,2688,5368,2680,2608,2616
        DC.L 2624,2632,2640,2648,2656,2664,2672,5120,5128
        DC.L 2712,0,0,5160,0
        DC.L 0,8,16,24,32,40,48,56,64,72
        DC.L 80,88,96,104,112,120,128,136,144,152
        DC.L 2560,2568,2576,2584,2592,2600
SCROLLTXT: 
 DC.B 'YEEEAH!!!   FINALLY IT WORKS!!!  THE DISK BUSTER OF THE LIGHT TEAM PROUDLY PRESENTS:  THE T.L.T MUZAK DEMO.... CODEING AND MUZAK RIPPING BY TDB OF TLT, GRAPHIXX BY GANDALF OF TLT.....  '
 DC.B ' AHHH! WHAT A FEELING TO WRITE SCROLLINES.... ITS GREAT!!!! THIS WONDERFUL DEMO HAS FINALLY BEEN COMPLETED, AND READY FOR RELEASE!!! AND NOW WE ARE PROUD TO ANNOUNCE THAT OUR BBS WILL '
 DC.B 'OPEN IN THE SEVENTH OF MARCH 1989, THE EAGLES NEST BBS, IN UPPSALA, WHICH RUNS ON 300/300, 1200/1200 BPS 8 DATABITS, 1 STOPBIT.....THE PHONE NUMBER IS +46 18 262804, SO DONT WAIT!!! '
 DC.B 'RELEASE DATE FOR THIS DEMO IS 890222...... WE HOPE YOU WILL ENJOY IT, AND IF YOU WISH TO CONTACT US, CALL OUR BBS!!! ' 
 DC.B ' HERE COMES A FRIEND OF MINE, JOHAN SELEN, WHO IS GONNA HELP ME WITH THIS SCROLLWRITING STUFF.....HERE HE COMES: '
 DC.B 'HELLO, FANS!!!!!!! HOW ARE THE THINGS GOING ON?????  WELL I HOPE YOU LIKE THIS DEMO !!!  '
 DC.B ' TDB IS BACK TO STRIKE AGAIN (TDB=THE DISK BUSTER!!!) WELL, HERE I AM AGAIN.... (TCB, IF YOU ARE READING THIS, I WANT YOU TO CONTACT ME!! GET HOLD OF A MODEM, AND CALL OUR BBS, OR CALL MY'
 DC.B ' NORMAL PHONE NUMBER!!! SINCE YOU KNOW THE BBS NUMBER, IT WONT BE TOO HARD FOR YA TO FIND OUT THE OTHER ONE...) HMMM.... I HAS SUCH LACK OF IMAGINATION..... ITS QUITE HARD TO COME UP WITH THINGS TO WRITE IN SCROLLINES..... MAYBE I CAN WRITE '
 DC.B 'ABOUT A FRIEND OF MINE, WHO WANTED THE COMPLETE SOURCE LISTING FOR THIS DEMO..... (AT LEAST HE THOUGHT I WAS GOING TO GIVE IT TO HIM.... HEHEHE!!! POOR FELLOW, IT MUST HAVE BEEN A SHOCK TO HIM WHEN I SAID: NO, I AINT GONNA GIVE IT TO YA!) '
 DC.B 'ITS QUITE FUN TO BE THE SYSOP OF A BBS.... YOU CAN HAVE QUITE FUN WITH USERS YOU DONT LIKE.... ITS QUITE EASY TO PRESS THE ON/OFF SWITCH ON THE MODEM WHEN SOMEONE YOU DONT LIKE ARE DOWNLOADING A LONG PROGRAM... SADISTIC EHH??? '
 DC.B ' AND HERE COMES OMICRON OF MHC: HI THERE. I WANT TO MAKE CLEAR THAT YOU CANT REBOOT THIS DEMO NORMALLY, COZ IT FEATURES A RESET SAMPLING CONTAINING A BIT OF "MEGABLAST" FROM THE BEAT DIS CD AND ITS VERRRY GOOD (DONT GET ME WRONG, RESET WHEN '
 DC.B 'YOUVE LISTENED TO AAALLL THE MUZAK AND READ AAALLL THE SCROLL, OK?). THIS DEMO IS THE FIRST DONE BY US FOR A LONG WHILE, THE ONE BEFORE THIS WAS SOME SHIT CALLED ULTRAVOX DEMO (AARRGH) AND THE ONLY GOOD THING INCLUDED THERE WAS THE SAMPLING '
 DC.B ', WHICH WAS THE LONGEST SAMPLING YOU COULD GET ON A 520. THE WORSE THINGS WERE THAT 1) IT WAS WRITTEN IN GFA BASIC 2) YOU HAD TO CHOOSE MUZAK BEFORE THE MAIN MENU AND 3) THE MUZAK STINKED... WELL LETS NOT TALK ABOUT OLD TIMES, LETS GO BACK '
 DC.B 'TO THE DAYS WHEN WE PROGRAMMED OUR 8-BIT COMPUTERS (ATARI XE, ZX SPECTRUM, C64...). THOSE COMPUTERS KNEW WHAT MUSIC WAS (IN PARTICULAR ZX SPECTRUM HEHEHE), AND TO THOSE COMPUTERS THE GAMES WERENT AS GOOD AS GAMES USUALLY ARE NOW. BUT - '
 DC.B 'BACK TO THE PRESENT NOW AND TO TDB: HI AGAIN, FOLKS.... HERE I AM AGAIN, TDB OF TLT, THE WORST COMPUTER FREAK IN UPPSALA..... HMM.......  DID YA KNOW THAT THE OLD ATARI XE HAD FOUR SOUND CHANNELS, AND THE FACT THAT THE ST HAS ONLY THREE'
 DC.B ' OF THEM??? SADISTIC EHH??? HERE IS AN ADVICE TO SUCCESS OF MHC: DONT FALL ASLEEP!! HEHEHE!!! TAREK, IF YOYU ARE READING THIS SCROLL, PRESS RESET, YOU DONT WANT TO READ THE FUCKING GREETINGS.... HEHEHE!!! '
 
 DC.B '  AND NOW THE GREETINGS: THEY GOES TO THE FOLLOWING GROUPS & PEOPLE: AN COOL, '
 DC.B 'TCB, DELTA FORCE, THE REPLICANTS, LEVEL 16, TNT-CREW, TEX, FLEXIBLE FRONT, SYNC, OMEGA, ACC, DMA, MCA, 42 CREW, 1001 CREW, B.O.S.S, S.T.C.S, 007, PK, GROWTWIG, MR. MAGOO, DR.KRALL (THANXX FOR THE HELP WITH MY SCROLLING PROBLEMS!!), DR.WHY'
 DC.B ', WAS (NOT WAS), THE MASTER, CAKE (ARE YOU STILL WORKING WITH THE XE, OR HAVE YOU BOUGHT AN ST???), MOSK, 2001, LYTZEN, AKO, BLUE RONDO CREW, THE GIGABYTE CREW, ATOR, GARFIELD, C.S.S...........'

 DC.B 'FUCKING GREETINGS ARE SENT TO THE FOLLOWING PEOPLE: MARGARETHA PERSSON (SWEDISH FILM CENSOR), TAREK ALDEBE (A REAL PESTY ARABIAN HERE IN UPPSALA), ALL VIRUS MAKERS, ASC CODE CHANGERS, UNPROTECTED GAME CRACKERS, PEOPLE WHO SELL CRACKED '
 DC.B 'SOFTWARE, JOWI DATA (A REAL CROOKED COMPUTER STORE IN UPPSALA, THEY HAVE QUITE GOOD PRICES, BUT IF SOMETHING YOU BUY THERE DOESNT WORK, THEY CAN BE A REAL PAIN WHEN YOU WANT YOUR MONEY BACK. FOR EXAMPLE: WE BOUGHT AN ORIGINAL GAME THERE, '
 DC.B 'THAT DIDNT WORK, AND WE BROUGHT IT BACK THERE BEFORE CHRISTMAS 1988, AND WE HAVE STILL NOT RECIEVED A NEW ORIGINAL NOR EITHER OUR MONEY, AND TODAYS DATE IS 890222.... SO DONT BUY ANYTHING THERE!).........'
 
 DC.B 0   

MUSIC: INCBIN A:\MUSIX\SOUND.BIN
 EVEN
MUSIC3: INCBIN A:\MUSIX\WARS.OBJ
 EVEN
MUSIC4: INCBIN A:\MUSIX\L
 EVEN
MUSIC5: INCBIN A:\MUSIX\XENON.MUS
 EVEN
MUSIC2: INCBIN A:\MUSIX\MUSIC.OBJ
 EVEN
MUSIC6: INCBIN A:\MUSIX\ENDURO.MUS
 EVEN
MUSIC7: INCBIN A:\MUSIX\ICEPLC.MUS
 EVEN
MUSIC8: INCBIN A:\MUSIX\TDRC.MUS
 EVEN
MUSIC9: INCBIN A:\MUSIX\BMX.MUS
 EVEN
MUSIC101: INCBIN A:\MUSIX\SIDE0.MUS
 EVEN
MUSIC102: INCBIN A:\MUSIX\SIDE2.MUS
 EVEN
MUSIC11: INCBIN A:\MUSIX\STARRAY.MUS
 EVEN
MUSIC12: INCBIN A:\MUSIX\OUTRUN.PIN
 EVEN
MUSIC14: INCBIN A:\MUSIX\MODULE.BAK
 EVEN
MUSIC15: INCBIN A:\MUSIX\QUAD.MUS
 EVEN
MUSIC16: INCBIN A:\MUSIX\BRO.MUS
 EVEN
MUSIC17: INCBIN A:\MUSIX\GARFIELD.MUS
 EVEN
REG1: DC.B 0
REG2: DC.B 0
 EVEN
FONTBUF: INCBIN A:\16X16_02.NEO
 EVEN
GRAFBUF: INCBIN A:\PRESS.NEO
 EVEN
SOUNDBUFF: INCBIN A:\MEGA10.SPL
 EVEN
CHANEL_A: 
 DC.L    $00000000,$00000000,$00000000,$00000000
 DC.L    $00010000,$00000001,$00000000,$00000001
 DC.L    $02000000,$00010000,$01020001,$00010203
 DC.L    $00010000,$00000100,$01020000,$00010203
 DC.L    $00010204,$00000001,$02000100,$00010001
 DC.L    $02030001,$00010200,$01020403,$03000102
 DC.L    $06050300,$00010001,$02000000,$01020001
 DC.L    $02000100,$01020000,$01020203,$00010204
 DC.L    $05030001,$02060503,$00010200,$01020207
 DC.L    $03030504,$04050000,$00010200,$01020001
 DC.L    $00010203,$00010202,$04000102,$04000100
 DC.L    $01020305,$03040404,$00010206,$07030304
 DC.L    $04040505,$05060600,$00010207,$0B030309
 DC.L    $04080001,$02020603,$03000001,$02020303
 DC.L    $06080404,$05070706,$06060908,$07070707
 DC.L    $0B0B0000,$00000102,$00010200,$01000100

CHANEL_B: 
 DC.L    $00000001,$02000102,$00010001,$02030001
 DC.L    $02020400,$01020404,$03000102,$06050303
 DC.L    $03040001,$02020703,$03030404,$05050504
 DC.L    $06060001,$02070703,$03030408,$05050504
 DC.L    $06060608,$00010202,$02030308,$04040505
 DC.L    $05040606,$09090907,$07070607,$07080808
 DC.L    $0607080A,$0A0A0909,$09000102,$02020303
 DC.L    $03040405,$05050A06,$0606060A,$07070706
 DC.L    $0A070808,$08060708,$0B0B0B09,$09090907
 DC.L    $09090B09,$09090001,$02020203,$03030404
 DC.L    $05050504,$06060606,$05070707,$060B0B08
 DC.L    $08080B07,$080B0808,$0909090B,$07090909
 DC.L    $09090909,$0909090A,$0A0A0A09,$0B0A0A0B
 DC.L    $0A090C0C,$0C0C0A0C,$0C0B0B0B,$0B0B0B0B
 DC.L    $0C0A0B0B,$0B0C0C0B,$0B0B0A0C,$0B0B0B0B
 DC.L    $0B0B0000,$01020202,$03030304,$0405050C

CHANEL_C:
 DC.L    $00010202,$02030303,$04040505,$05040606
 DC.L    $06060507,$07070606,$07080808,$06070808
 DC.L    $08080909,$09090709,$09090909,$09090909
 DC.L    $09090A0A,$0A09090A,$0A0A0A09,$0A0A0A0A
 DC.L    $0A0A0A09,$0B0B0B0B,$0B0B0B0A,$0B0B0B0B
 DC.L    $0B0B0B0B,$0A0A0A0B,$0B0B0B0B,$0B0B0B0B
 DC.L    $0B0B0B0A,$0A0A0B0B,$0B0C0C0C,$0C0C0C0C
 DC.L    $0C0C0C0C,$0C0C0B0C,$0C0C0C0B,$0C0C0C0C
 DC.L    $0B0C0C0C,$0C0C0C0C,$0B0B0B0C,$0C0C0C0C
 DC.L    $0C0C0B0C,$0C0C0D0D,$0D0D0D0D,$0D0D0D0D
 DC.L    $0D0D0D0D,$0D0D0D0D,$0D0D0D0D,$0D0C0C0D
 DC.L    $0D0D0C0D,$0D0C0D0D,$0D0D0D0C,$0D0D0D0D
 DC.L    $0D0D0D0D,$0D0D0D0D,$0D0D0D0D,$0B0D0D0C
 DC.L    $0D0D0C0C,$0C0C0D0C,$0C0D0D0D,$0D0D0D0D
 DC.L    $0C0D0D0D,$0D0C0C0D,$0D0D0D0C,$0D0D0D0D
 DC.L    $0C0C0E0E,$0E0E0E0E,$0E0E0E0E,$0E0E0E0D


LENGTH: DS.L 1
SBUFF: DS.L 1
PLAYPOS: DS.L 1
TUNE: DC.B 0
LINE2		DS.W 1
COLOR		DS.W 1
COLOR1		DS.W 1
SCOLOR0		DS.W 1
SCOLOR1		DS.W 1
POINTER 	DC.L COLTAB
POINTER2	DC.L COLTAB2
JMPPOINTER	DC.L JMPTABLE
JMPLINE		DC.W 1
JMPLINE2	DC.W 1
COLTAB	dc.w $100,$110,$120,$130,$140,$150,$160,$170,$270,$370,$470,$570,$670
	dc.w $770,$671,$572,$473,$374,$275,$176,$077,$067,$057,$047,$037,$027
	dc.w $017,$007,$016,$025,$034,$043,$052,$061,$070,$170,$270,$360,$450
	dc.w $540,$630,$720,$710,$700,$700,$710,$720,$730,$740,$750,$760,$770
	dc.w $670,$570,$470,$370,$270,$170,$070,$071,$072,$073,$074,$075,$076
	dc.w $077,$167,$257,$347,$437,$527,$617,$707,$717,$727,$737,$747,$757
	dc.w $746,$735,$724,$713,$702,$701,$700,$710,$720,$730,$741,$752,$763
	dc.w $774,$674,$574,$474,$374,$275,$176,$077,$177,$277,$377,$477,$577
	dc.w $677,$777,$776,$775,$774,$773,$772,$771,$770,$761,$752,$743,$733
	dc.w $722,$711,$700,$711,$722,$733,$744,$755,$766,$777,$767,$757,$747
	dc.w $737,$727,$717,$707,$617,$527,$437,$347,$257,$167,$077,$067,$057
	dc.w $047,$037,$027,$017,$007,$016,$025,$034,$043,$052,$061,$070,$160
	dc.w $250,$340,$430,$520,$610,$700,$601,$502,$403,$304,$205,$106,$007
	dc.w $007,$006,$006,$005,$004,$004,$014,$024,$034,$043,$052,$061,$060
	dc.w $160,$170,$270,$370,$570,$770,$772,$774,$775,$777,$666,$555,$444
	dc.w $333,$222,$111
	

JMPTABLE: DC.W 0,0,0,1,1,2,4,5,7,8,11,13,15,18
          DC.W 21,23,26,30,33,36,40,44,47,51,55,59,63,67
          DC.W 71,75,79,83,87,90,94,98,102,105,108,112,115,118
          DC.W 120,123,126,128,130,132,134,135,136,137,138,139,139,139
          DC.W 139,139,139,138,137,136,134,133,131,129,127,125,122,119
          DC.W 116,113,110,107,103,100,96,93,89,85,81,77,73,69
          DC.W 65,61,57,53,50,46,42,38,35,32,28,25,22,19
          DC.W 17,14,12,10,8,6,4,3,2,1,0,0,0,255
COLTAB2: DC.W $100,$110,$120,$130,$140,$150,$160,$170,$270,$370,$470,$570,$670,$770,$671,$572,$473,$374,$275,$176,$077,$067,$057,$047,$037,$027,$017,$007,$016,$025,$034,$043,$052,$061,$070,$170,$270,$360,$450,$540,$630,$720,$710,$700,$700,$600
	 DC.W $500,$400,$300,$200,$100,$100
MESSAGE:
 DC.B 27,'Y',32+05,32+12,'   YOU HAVE BEEN'
 DC.B 27,'Y',32+06,32+12,'     WATCHING A  '
 DC.B 27,'Y',32+07,32+12,'   DEMO FROM THE '
 DC.B 27,'Y',32+08,32+12,'    LIGHT TEAM'
 DC.B 27,'Y',32+09,32+12,'    OF SWEDEN   '
 DC.B 27,'Y',32+10,32+12,'   FOR CONTACT  '
 DC.B 27,'Y',32+11,32+12,'CALL EAGLES NEST'
 DC.B 27,'Y',32+12,32+11,'BBS,TEL:018-262804'
 DC.B 27,'Y',32+16,32+0,0
 END
