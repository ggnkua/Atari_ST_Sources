/* resource set indicies for TUBE_GEM */

#define TUBE     0	/* form/dialog */
#define CADTUBE  0	/* BOX in tree TUBE */
#define TUBE1    4	/* BUTTON in tree TUBE */
#define TUBE2    5	/* BUTTON in tree TUBE */
#define TUBE3    6	/* BUTTON in tree TUBE */
#define TUBE4    7	/* BUTTON in tree TUBE */
#define TUBE5    8	/* BUTTON in tree TUBE */
#define ANNUTUBE 9	/* BUTTON in tree TUBE */
#define NEXTTUBE 10	/* BUTTON in tree TUBE */
