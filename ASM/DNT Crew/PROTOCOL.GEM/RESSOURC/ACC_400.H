* resource set indicies for ACC_400 *

MENU1    EQU	0	/* menu tree */
DESK400  EQU	3	/* TITLE in tree MENU1 */
FILES400 EQU	4	/* TITLE in tree MENU1 */
TESTS400 EQU	5	/* TITLE in tree MENU1 */
ABOUT400 EQU	8	/* STRING in tree MENU1 */
QUIT400  EQU	18	/* STRING in tree MENU1 */
HELLO400 EQU	20	/* STRING in tree MENU1 */
CHECK400 EQU	21	/* STRING in tree MENU1 */
