***********************************************************************
**                                                                   **
** NoisePakker v0.2 - (c) by Radical Systems Inc. 1992               **
**                                                                   **
** Written by Karl Morton and Steffen Fischer                        **
**                                                                   **
** Latest changes : 04.05.92                                         **
**                                                                   **
***********************************************************************

; SPECIAL TOS Version . 13.6.92



                OUTPUT 'NOISEPAK.PRG'

                TEXT

start:
                movea.l A7,A5
                movea.l 4(A5),A5
                move.l  12(A5),D0
                add.l   20(A5),D0
                add.l   28(A5),D0
                addi.l  #$0500,D0
                move.l  D0,D1
                a***********************************************************************
**                                                                   **
** NoisePakker v0.2 - (c) by Radical Systems Inc. 1992               **
**                                                                   **
** Written by Karl Morton and Steffen Fischer                        **
**                                                                   **
** Latest changes : 04.05.92                                         **
**                                                                   **
***********************************************************************

; SPECIAL TOS Version . 13.6.92



                OUTPUT 'NOISEPAK.PRG'

                TEXT

start:
                movea.l A7,A5
                movea.l 4(A5),A5
                move.l  12(A5),D0
                add.l   20(A5),D0
                add.l   28(A5),D0
                addi.l  #$0500,D0
                move.l  D0,D1
                a***********************************************************************
**                                                                   **
** NoisePakker v0.2 - (c) by Radical Systems Inc. 1992               **
**                                                                   **
** Written by Karl Morton and Steffen Fischer                        **
**                                                                   **
** Latest changes : 04.05.92                                         **
**                                                                   **
***********************************************************************

; SPECIAL TOS Version . 13.6.92



                OUTPUT 'NOISEPAK.PRG'

                TEXT

start:
                movea.l A7,A5
                movea.l 4(A5),A5
                move.l  12(A5),D0
                add.l   20(A5),D0
                add.l   28(A5),D0
                addi.l  #$0500,D0
                move.l  D0,D1
                a***********************************************************************
**                                                                   **
** NoisePakker v0.2 - (c) by Radical Systems Inc. 1992               **
**                                                                   **
** Written by Karl Morton and Steffen Fischer                        **
**                                                                   **
** Latest changes : 04.05.92                                         **
**                                                                   **
***********************************************************************

; SPECIAL TOS Version . 13.6.92



                OUTPUT 'NOISEPAK.PRG'

                TEXT

start:
                movea.l A7,A5
                movea.l 4(A5),A5
                move.l  12(A5),D0
                add.l   20(A5),D0
                add.l   28(A5),D0
                addi.l  #$0500,D0
                move.l  D0,D1
                a***********************************************************************
**                                                                   **
** NoisePakker v0.2 - (c) by Radical Systems Inc. 1992               **
**                                                                   **
** Written by Karl Morton and Steffen Fischer                        **
**                                                                   **
** Latest changes : 04.05.92                                         **
**                                                                   **
***********************************************************************

; SPECIAL TOS Version . 13.6.92



                OUTPUT 'NOISEPAK.PRG'

                TEXT

start:
                movea.l A7,A5
                movea.l 4(A5),A5
                move.l  12(A5),D0
                add.l   20(A5),D0
                add.l   28(A5),D0
                addi.l  #$0500,D0
                move.l  D0,D1
                a***********************************************************************
**                                                                   **
** NoisePakker v0.2 - (c) by Radical Systems Inc. 1992               **
**                                                                   **
** Written by Karl Morton and Steffen Fischer                        **
**                                                                   **
** Latest changes : 04.05.92                                         **
**                                                                   **
***********************************************************************

; SPECIAL TOS Version . 13.6.92



                OUTPUT 'NOISEPAK.PRG'

                TEXT

start:
                movea.l A7,A5
                movea.l 4(A5),A5
                move.l  12(A5),D0
                add.l   20(A5),D0
                add.l   28(A5),D0
                addi.l  #$0500,D0
                move.l  D0,D1
                a***********************************************************************
**                                                                   **
** NoisePakker v0.2 - (c) by Radical Systems Inc. 1992               **
**                                                                   **
** Written by Karl Morton and Steffen Fischer                        **
**                                                                   **
** Latest changes : 04.05.92                                         **
**                                                                   **
***********************************************************************

; SPECIAL TOS Version . 13.6.92



                OUTPUT 'NOISEPAK.PRG'

                TEXT

start:
                movea.l A7,A5
                movea.l 4(A5),A5
                move.l  12(A5),D0
                add.l   20(A5),D0
                add.l   28(A5),D0
                addi.l  #$0500,D0
                move.l  D0,D1
                a***********************************************************************
**                                                                   **
** NoisePakker v0.2 - (c) by Radical Systems Inc. 1992               **
**                                                                   **
** Written by Karl Morton and Steffen Fischer                        **
**                                                                   **
** Latest changes : 04.05.92                                         **
**                                                                   **
***********************************************************************

; SPECIAL TOS Version . 13.6.92



                OUTPUT 'NOISEPAK.PRG'

                TEXT

start:
                movea.l A7,A5
                movea.l 4(A5),A5
                move.l  12(A5),D0
                add.l   20(A5),D0
                add.l   28(A5),D0
                addi.l  #$0500,D0
                move.l  D0,D1
                a***********************************************************************
**                                                                   **
** NoisePakker v0.2 - (c) by Radical Systems Inc. 1992               **
**                                                                   **
** Written by Karl Morton and Steffen Fischer                        **
**                                                                   **
** Latest changes : 04.05.92                                         **
**                                                                   **
***********************************************************************

; SPECIAL TOS Version . 13.6.92



                OUTPUT 'NOISEPAK.PRG'

                TEXT

start:
                movea.l A7,A5
                movea.l 4(A5),A5
                move.l  12(A5),D0
                add.l   20(A5),D0
                add.l   28(A5),D0
                addi.l  #$0500,D0
                move.l  D0,D1
                a***********************************************************************
**                                                                   **
** NoisePakker v0.2 - (c) by Radical Systems Inc. 1992               **
**                                                                   **
** Written by Karl Morton and Steffen Fischer                        **
**                                                                   **
** Latest changes : 04.05.92                                         **
**                                                                   **
***********************************************************************

; SPECIAL TOS Version . 13.6.92



                OUTPUT 'NOISEPAK.PRG'

                TEXT

start:
                movea.l A7,A5
                movea.l 4(A5),A5
                move.l  12(A5),D0
                add.l   20(A5),D0
                add.l   28(A5),D0
                addi.l  #$0500,D0
                move.l  D0,D1
                a***********************************************************************
**                                                                   **
** NoisePakker v0.2 - (c) by Radical Systems Inc. 1992               **
**                                                                   **
** Written by Karl Morton and Steffen Fischer                        **
**                                                                   **
** Latest changes : 04.05.92                                         **
**                                                                   **
***********************************************************************

; SPECIAL TOS Version . 13.6.92



                OUTPUT 'NOISEPAK.PRG'

                TEXT

start:
                movea.l A7,A5
                movea.l 4(A5),A5
                move.l  12(A5),D0
                add.l   20(A5),D0
                add.l   28(A5),D0
                addi.l  #$0500,D0
                move.l  D0,D1
                a