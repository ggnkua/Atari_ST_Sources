TNT1		DC.W 0,0,0
		DC.W 24
		DC.L 0,0,$6000000
		dc.w -$15E*4,$226*4,-$64*4,-$96*4,$226*4,-$64*4,-$96*4,$64*4 
		dc.w -$64*4,-$32*4,$0*4,-$64*4,$96*4,$0*4,-$64*4,$96*4 
		dc.w $226*4,-$64*4,$15E*4,$226*4,-$64*4,$15E*4,-$C8*4,-$64*4 
		dc.w -$64*4,-$C8*4,-$64*4,-$C8*4,-$96*4,-$64*4,-$12C*4,-$32*4 
		dc.w -$64*4,-$15E*4,$32*4,-$64*4,-$15E*4,$226*4,$64*4,-$96*4 
		dc.w $226*4,$64*4,-$96*4,$64*4,$64*4,-$32*4,$0*4,$64*4 
		dc.w $96*4,$0*4,$64*4,$96*4,$226*4,$64*4,$15E*4,$226*4 
		dc.w $64*4,$15E*4,-$C8*4,$64*4,-$64*4,-$C8*4,$64*4,-$C8*4 
		dc.w -$96*4,$64*4,-$12C*4,-$32*4,$64*4,-$15E*4,$32*4,$64*4 
		dc.w 20
		dc.w 01*16,4,$02*6,$0E*6,$0D*6,$01*6
		dc.w 03*16,4,$03*6,$0F*6,$0E*6,$02*6
		dc.w 05*16,4,$04*6,$10*6,$0F*6,$03*6
		dc.w 03*16,4,$11*6,$10*6,$04*6,$05*6
		dc.w 04*16,4,$01*6,$0D*6,$0C*6,$00*6 
		dc.w 03*16,4,$0C*6,$17*6,$0B*6,$00*6
		dc.w 06*16,4,$17*6,$16*6,$0A*6,$0B*6
		dc.w 09*16,4,$16*6,$15*6,$09*6,$0A*6
		dc.w 08*16,4,$15*6,$14*6,$08*6,$09*6
		dc.w 12*16,4,$14*6,$13*6,$07*6,$08*6
		dc.w 11*16,4,$07*6,$13*6,$12*6,$06*6
		dc.w 10*16,4,$12*6,$11*6,$05*6,$06*6
		dc.w 13*16,4,$0B*6,$02*6,$01*6,$00*6 
		dc.w 14*16,6,$0B*6,$0A*6,$09*6,$08*6,$03*6,$02*6
		dc.w 15*16,4,$08*6,$07*6,$04*6,$03*6
		dc.w 09*16,4,$07*6,$06*6,$05*6,$04*6
		dc.w 07*16,4,$0E*6,$17*6,$0C*6,$0D*6
		dc.w 04*16,6,$14*6,$15*6,$16*6,$17*6,$0E*6,$0F*6
		dc.w 06*16,4,$0F*6,$10*6,$13*6,$14*6
		dc.w 10*16,4,$10*6,$11*6,$12*6,$13*6

TNT2		DC.W 0,0,0
		DC.W 44
		DC.L 0,0,$1000000
		dc.w	$FE2A,$0050,$FF6A,$FE66,$008C,$FF6A,$0208 
		dc.w	$008C,$FF6A,$01CC,$0050,$FF6A,$014A,$0050,$FF6A 
		dc.w	$006E,$FF74,$FF6A,$0014,$FF74,$FF6A,$00F0,$0050 
		dc.w	$FF6A,$FF2E,$0050,$FF6A,$FE52,$FF74,$FF6A,$FDF8 
		dc.w	$FF74,$FF6A,$FED4,$0050,$FF6A,$FEAC,$FF74,$FF6A 
		dc.w	$FF60,$0028,$FF6A,$FFBA,$0028,$FF6A,$FFBA,$FFCE 
		dc.w	$FF6A,$0014,$0028,$FF6A,$006E,$0028,$FF6A,$FFBA 
		dc.w	$FF74,$FF6A,$FF60,$FF74,$FF6A,$FF60,$FFCE,$FF6A 
		dc.w	$FF06,$FF74,$FF6A,$FE2A,$0050,$0096,$FE66,$008C 
		dc.w	$0096,$0208,$008C,$0096,$01CC,$0050,$0096,$014A 
		dc.w	$0050,$0096,$006E,$FF74,$0096,$0014,$FF74,$0096 
		dc.w	$00F0,$0050,$0096,$FF2E,$0050,$0096,$FE52,$FF74 
		dc.w	$0096,$FDF8,$FF74,$0096,$FED4,$0050,$0096,$FEAC 
		dc.w	$FF74,$0096,$FF60,$0028,$0096,$FFBA,$0028,$0096 
		dc.w	$FFBA,$FFCE,$0096,$0014,$0028,$0096,$006E,$0028 
		dc.w	$0096,$FFBA,$FF74,$0096,$FF60,$FF74,$0096,$FF60 
		dc.w	$FFCE,$0096,$FF06,$FF74,$0096
		dc.w 42
		dc.w 01*16,4,$16*6,$21*6,$0B*6,$00*6
		dc.w 02*16,4,$1E*6,$1D*6,$07*6,$08*6
		dc.w 03*16,4,$1A*6,$19*6,$03*6,$04*6
		dc.w 04*16,4,$09*6,$1f*6,$1e*6,$08*6
		dc.w 05*16,4,$2b*6,$2a*6,$14*6,$15*6
		dc.w 06*16,4,$25*6,$24*6,$0e*6,$0f*6
		dc.w 07*16,4,$28*6,$27*6,$11*6,$12*6
		dc.w 08*16,4,$1d*6,$1c*6,$06*6,$07*6
		dc.w 09*16,4,$26*6,$25*6,$0f*6,$10*6
		dc.w 10*16,4,$2a*6,$29*6,$13*6,$14*6
		dc.w 11*16,4,$23*6,$22*6,$0c*6,$0d*6
		dc.w 12*16,4,$0e*6,$24*6,$23*6,$0d*6
		dc.w 13*16,4,$27*6,$26*6,$10*6,$11*6
		dc.w 14*16,4,$1b*6,$1a*6,$04*6,$05*6
		dc.w 13*16,4,$21*6,$20*6,$0a*6,$0b*6
		dc.w 12*16,4,$17*6,$16*6,$00*6,$01*6
		dc.w 11*16,4,$19*6,$18*6,$02*6,$03*6
		dc.w 10*16,4,$20*6,$1f*6,$09*6,$0a*6
		dc.w 09*16,4,$1c*6,$1b*6,$05*6,$06*6
		dc.w 08*16,4,$22*6,$2b*6,$15*6,$0c*6
		dc.w 07*16,4,$29*6,$28*6,$12*6,$13*6
		dc.w 06*16,3,$0b*6,$01*6,$00*6
		dc.w 05*16,3,$0b*6,$08*6,$01*6
		dc.w 04*16,4,$08*6,$07*6,$02*6,$01*6
		dc.w 03*16,3,$07*6,$04*6,$02*6
		dc.w 02*16,3,$04*6,$03*6,$02*6
		dc.w 01*16,4,$0b*6,$0a*6,$09*6,$08*6
		dc.w 02*16,4,$07*6,$06*6,$05*6,$04*6
		dc.w 03*16,5,$15*6,$14*6,$0E*6,$0d*6,$0c*6
		dc.w 04*16,4,$14*6,$13*6,$0f*6,$0e*6
		dc.w 05*16,5,$13*6,$12*6,$11*6,$10*6,$0f*6
		dc.w 06*16,3,$21*6,$16*6,$17*6
		dc.w 07*16,3,$1e*6,$21*6,$17*6
		dc.w 08*16,4,$18*6,$1d*6,$1e*6,$17*6
		dc.w 09*16,3,$1a*6,$1D*6,$18*6
		dc.w 10*16,3,$19*6,$1A*6,$18*6
		dc.w 11*16,4,$1e*6,$1f*6,$20*6,$21*6
		dc.w 12*16,4,$1a*6,$1b*6,$1c*6,$1d*6
		dc.w 13*16,5,$2a*6,$2b*6,$22*6,$23*6,$24*6
		dc.w 14*16,4,$24*6,$25*6,$29*6,$2a*6
		dc.w 15*16,5,$25*6,$26*6,$27*6,$28*6,$29*6
		dc.w 14*16,4,$02*6,$18*6,$17*6,$01*6
