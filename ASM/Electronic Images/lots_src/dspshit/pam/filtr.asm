; Input multirate, interpolation and raised cosine filter
; Produced by MATLAB (19-Jul-94)
iftaps	equ	28
ifbnks	equ	8

; Input filter even part
icoeffs dc	1.329706e-05,3.924698e-05,8.760116e-04,1.477363e-03
	dc	1.140257e-03,-2.206576e-03,-9.605002e-03,-1.769563e-02
	dc	-1.734849e-02,2.796666e-03,4.858163e-02,1.132852e-01
	dc	1.772121e-01,2.159940e-01,2.133782e-01,1.704168e-01
	dc	1.048885e-01,4.133357e-02,-1.651849e-03,-1.891216e-02
	dc	-1.740436e-02,-8.717248e-03,-1.525536e-03,1.417046e-03
	dc	1.488979e-03,7.939218e-04,5.330688e-06,-1.670007e-06

	dc	-4.216658e-05,-1.044840e-04,7.506352e-04,1.451274e-03
	dc	1.677234e-03,-6.166012e-04,-7.264751e-03,-1.640500e-02
	dc	-2.017703e-02,-6.912373e-03,3.175383e-02,9.292505e-02
	dc	1.598427e-01,2.081126e-01,2.180767e-01,1.857147e-01
	dc	1.248583e-01,5.926047e-02,9.897174e-03,-1.434840e-02
	dc	-1.759613e-02,-1.067046e-02,-3.195389e-03,6.477284e-04
	dc	1.411814e-03,1.015851e-03,-3.052778e-05,5.324129e-06

	dc	-4.366212e-05,-9.739543e-05,6.545850e-04,1.342415e-03
	dc	1.804911e-03,1.722784e-04,-5.706474e-03,-1.492705e-02
	dc	-2.071642e-02,-1.162791e-02,2.205181e-02,7.999910e-02
	dc	1.478207e-01,2.016444e-01,2.198593e-01,1.949708e-01
	dc	1.377890e-01,7.116073e-02,1.753095e-02,-1.156738e-02
	dc	-1.810894e-02,-1.228414e-02,-4.421130e-03,1.873044e-04
	dc	1.415259e-03,1.116384e-03,-5.788162e-05,5.004941e-06

	dc	-2.151334e-20,-3.432007e-20,5.518829e-04,1.177438e-03
	dc	1.591011e-03,2.059060e-04,-5.022291e-03,-1.358596e-02
	dc	-1.945943e-02,-1.172191e-02,1.963765e-02,7.548632e-02
	dc	1.428459e-01,1.984866e-01,2.200963e-01,1.984866e-01
	dc	1.428459e-01,7.548632e-02,1.963765e-02,-1.172191e-02
	dc	-1.945943e-02,-1.358596e-02,-5.022291e-03,2.059060e-04
	dc	1.591011e-03,1.177438e-03,-1.724617e-20,-1.280673e-20

	dc	3.650439e-05,7.248276e-05,3.874720e-04,1.019568e-03
	dc	1.371597e-03,1.873044e-04,-4.421130e-03,-1.228414e-02
	dc	-1.810894e-02,-1.156738e-02,1.753095e-02,7.116073e-02
	dc	1.377890e-01,1.949708e-01,2.198593e-01,2.016444e-01
	dc	1.478207e-01,7.999910e-02,2.205181e-02,-1.162791e-02
	dc	-2.071642e-02,-1.492705e-02,-5.706474e-03,1.722784e-04
	dc	1.768407e-03,1.274937e-03,2.092314e-04,-5.794314e-07

	dc	2.938883e-05,5.636789e-05,1.634385e-04,9.080921e-04
	dc	1.369647e-03,6.477284e-04,-3.195389e-03,-1.067046e-02
	dc	-1.759613e-02,-1.434840e-02,9.897174e-03,5.926047e-02
	dc	1.248583e-01,1.857147e-01,2.180767e-01,2.081126e-01
	dc	1.598427e-01,9.292505e-02,3.175383e-02,-6.912373e-03
	dc	-2.017703e-02,-1.640500e-02,-7.264751e-03,-6.166012e-04
	dc	1.647845e-03,1.400230e-03,5.566689e-04,3.275081e-06

	dc	-7.678584e-06,-1.434860e-05,-3.101461e-05,8.358586e-04
	dc	1.502276e-03,1.417046e-03,-1.525536e-03,-8.717248e-03
	dc	-1.740436e-02,-1.891216e-02,-1.651849e-03,4.133357e-02
	dc	1.048885e-01,1.704168e-01,2.133782e-01,2.159940e-01
	dc	1.772121e-01,1.132852e-01,4.858163e-02,2.796666e-03
	dc	-1.734849e-02,-1.769563e-02,-9.605002e-03,-2.206576e-03
	dc	1.147936e-03,1.490041e-03,9.123569e-04,-2.689898e-06

	dc	-3.082973e-05,-5.645818e-05,-1.030231e-04,7.626422e-04
	dc	1.527134e-03,1.898530e-03,-2.408664e-04,-6.890268e-03
	dc	-1.654278e-02,-2.162454e-02,-1.031714e-02,2.650862e-02
	dc	8.706158e-02,1.553712e-01,2.068938e-01,2.207890e-01
	dc	1.914045e-01,1.314081e-01,6.449439e-02,1.262169e-02
	dc	-1.398550e-02,-1.853997e-02,-1.176993e-02,-3.812312e-03
	dc	5.727853e-04,1.525273e-03,1.128120e-03,-2.496413e-05

; Input filter odd part
	dc	2.617030e-07,6.021975e-04,1.210605e-03,1.548649e-03
	dc	-2.814891e-05,-5.470762e-03,-1.401329e-02,-1.931313e-02
	dc	-1.034717e-02,2.256103e-02,7.955385e-02,1.469056e-01
	dc	2.010979e-01,2.202489e-01,1.961392e-01,1.389412e-01
	dc	7.143374e-02,1.660525e-02,-1.327523e-02,-1.978515e-02
	dc	-1.328472e-02,-4.626652e-03,4.453181e-04,1.667277e-03
	dc	1.184831e-03,-3.979576e-05,-1.964820e-05,-1.181120e-05

	dc	-4.246166e-06,3.356215e-04,1.041578e-03,1.702810e-03
	dc	1.002999e-03,-3.384221e-03,-1.187186e-02,-1.966682e-02
	dc	-1.637892e-02,9.091898e-03,6.027803e-02,1.271418e-01
	dc	1.878047e-01,2.185807e-01,2.066900e-01,1.574505e-01
	dc	9.113187e-02,3.165527e-02,-5.362713e-03,-1.797691e-02
	dc	-1.469935e-02,-6.600362e-03,-7.768121e-04,1.271679e-03
	dc	1.159460e-03,2.225179e-04,7.759348e-05,4.520589e-05

	dc	-6.978141e-06,1.100335e-04,9.097953e-04,1.658568e-03
	dc	1.412173e-03,-2.176969e-03,-1.017182e-02,-1.890929e-02
	dc	-1.878177e-02,1.839512e-03,4.856973e-02,1.140611e-01
	dc	1.780460e-01,2.161034e-01,2.125305e-01,1.691363e-01
	dc	1.040909e-01,4.166832e-02,-2.453187e-04,-1.711629e-02
	dc	-1.601482e-02,-8.133986e-03,-1.608547e-03,1.095792e-03
	dc	1.247619e-03,5.628666e-04,1.004185e-04,5.615105e-05

	dc	-1.157848e-20,-2.326084e-20,8.489062e-04,1.477126e-03
	dc	1.267588e-03,-1.855970e-03,-9.116352e-03,-1.747117e-02
	dc	-1.803667e-02,6.485008e-04,4.498353e-02,1.090439e-01
	dc	1.737064e-01,2.145388e-01,2.145388e-01,1.737064e-01
	dc	1.090439e-01,4.498353e-02,6.485008e-04,-1.803667e-02
	dc	-1.747117e-02,-9.116352e-03,-1.855970e-03,1.267588e-03
	dc	1.477126e-03,8.489062e-04,-4.477418e-20,-3.309182e-20

	dc	8.773008e-06,-1.677986e-05,8.102853e-04,1.307802e-03
	dc	1.095792e-03,-1.608547e-03,-8.133986e-03,-1.601482e-02
	dc	-1.711629e-02,-2.453187e-04,4.166832e-02,1.040909e-01
	dc	1.691363e-01,2.125305e-01,2.161034e-01,1.780460e-01
	dc	1.140611e-01,4.856973e-02,1.839512e-03,-1.878177e-02
	dc	-1.890929e-02,-1.017182e-02,-2.176969e-03,1.412173e-03
	dc	1.705946e-03,1.026994e-03,-1.373851e-04,-6.716106e-05

	dc	7.904685e-06,-3.225802e-06,7.074337e-04,1.220075e-03
	dc	1.271679e-03,-7.768121e-04,-6.600362e-03,-1.469935e-02
	dc	-1.797691e-02,-5.362713e-03,3.165527e-02,9.113187e-02
	dc	1.574505e-01,2.066900e-01,2.185807e-01,1.878047e-01
	dc	1.271418e-01,6.027803e-02,9.091898e-03,-1.637892e-02
	dc	-1.966682e-02,-1.187186e-02,-3.384221e-03,1.002999e-03
	dc	1.740111e-03,1.122398e-03,-1.492942e-04,-6.486063e-05

	dc	-2.246644e-06,-8.489095e-07,5.053837e-04,1.164639e-03
	dc	1.667277e-03,4.453181e-04,-4.626652e-03,-1.328472e-02
	dc	-1.978515e-02,-1.327523e-02,1.660525e-02,7.143374e-02
	dc	1.389412e-01,1.961392e-01,2.202489e-01,2.010979e-01
	dc	1.469056e-01,7.955385e-02,2.256103e-02,-1.034717e-02
	dc	-1.931313e-02,-1.401329e-02,-5.470762e-03,-2.814891e-05
	dc	1.539084e-03,1.191805e-03,5.701804e-05,2.045353e-05

	dc	-9.631001e-06,-8.060780e-06,2.648173e-04,1.067928e-03
	dc	1.868732e-03,1.304420e-03,-2.969851e-03,-1.166577e-02
	dc	-2.035504e-02,-1.875820e-02,4.684636e-03,5.450542e-02
	dc	1.217058e-01,1.847805e-01,2.193447e-01,2.111043e-01
	dc	1.638676e-01,9.725282e-02,3.569798e-02,-3.911715e-03
	dc	-1.842444e-02,-1.584155e-02,-7.496354e-03,-1.113028e-03
	dc	1.298261e-03,1.279307e-03,3.974903e-04,1.001137e-04
