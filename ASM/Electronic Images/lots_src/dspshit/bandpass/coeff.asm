; SPW FDS generated coefficients
;
; sample_freq	=	8000       {sample frequency}
; tap_length	=	320       {filter length}
; center_freq	=	800       {center frequency}
; pass_bw	=	100       {passband bandwidth}
; stop_bw	=	200       {stopband bandwidth}
; weight1	=	10       {first stopband weight;passband weight = 1}
; weight2	=	10       {second stopband weight}

taps	equ	320

coeffs	dc	0.0017996576744581446
	dc	-3.4706815797811048e-05
	dc	-0.00032621005019612607
	dc	-0.0006800155401674138
	dc	-0.00093375759838703601
	dc	-0.00094873786343264467
	dc	-0.00067172215726001711
	dc	-0.00017095710474832851
	dc	0.00038170587382695196
	dc	0.00077191026630810014
	dc	0.00083222792690434999
	dc	0.00051479874443189451
	dc	-7.6688026970194627e-05
	dc	-0.00071901407208648242
	dc	-0.0011490714293175895
	dc	-0.0011728996885619156
	dc	-0.00076205334230794604
	dc	-4.802601343789994e-05
	dc	0.00069589521447677291
	dc	0.0011776348151302434
	dc	0.0012002562056323358
	dc	0.0007451733539490205
	dc	-1.398696106063072e-05
	dc	-0.00078061229819909039
	dc	-0.0012522929526443064
	dc	-0.0012454411423010201
	dc	-0.00076801568886045429
	dc	-1.7096791271077388e-05
	dc	0.00070677587627990365
	dc	0.001123969410341269
	dc	0.0010906074220241994
	dc	0.00064723397110594012
	dc	1.2683573860940416e-06
	dc	-0.00057867503505505745
	dc	-0.00087250527641806702
	dc	-0.00080240630341597949
	dc	-0.00045059987450060766
	dc	-8.7754467973132685e-06
	dc	0.00032243075647834488
	dc	0.00042679905019966675
	dc	0.00032117911983512359
	dc	0.00012951880935753424
	dc	4.7636222976930528e-06
	dc	3.4577108435382463e-05
	dc	0.00018865665970039017
	dc	0.00032963161842238767
	dc	0.00029316488063787453
	dc	-5.5439711634432814e-06
	dc	-0.00049938428654178841
	dc	-0.00097063446989502063
	dc	-0.0011405450901983193
	dc	-0.00081232747762052695
	dc	3.6804692844431657e-06
	dc	0.0010450809399885522
	dc	0.0018764270890977448
	dc	0.0020658529995952859
	dc	0.0013947402079791313
	dc	-3.2566960077979289e-06
	dc	-0.0016423561815143593
	dc	-0.002851328431726168
	dc	-0.0030458959141827185
	dc	-0.0020019300893205651
	dc	2.6578724225999675e-06
	dc	0.0022437815408723866
	dc	0.003816152486123753
	dc	0.0039983999110910062
	dc	0.002580406847405764
	dc	-2.255396052253545e-06
	dc	-0.0027938003044902819
	dc	-0.0046776643520767157
	dc	-0.0048272921603747911
	dc	-0.0030701155179088148
	dc	1.3371054296607877e-06
	dc	0.0032277262600952537
	dc	0.0053302358130787328
	dc	0.0054255445469057612
	dc	0.0034034400001745962
	dc	-1.2442664672459094e-06
	dc	-0.0034803272474487308
	dc	-0.0056671000690012002
	dc	-0.0056864025131494883
	dc	-0.0035153732158138256
	dc	9.721989568233641e-07
	dc	0.0034852071229489008
	dc	0.005583375275453514
	dc	0.0055071556926189775
	dc	0.0033432727040189807
	dc	-1.3779993711855211e-06
	dc	-0.0031855629609605241
	dc	-0.0049898525299422371
	dc	-0.0048023492354152472
	dc	-0.0028372031319763005
	dc	2.1447428011360688e-06
	dc	0.0025364042490918343
	dc	0.0038194547394352352
	dc	0.0035106930104271609
	dc	0.0019629515090879937
	dc	-2.8866586714968064e-06
	dc	-0.0015111241865102141
	dc	-0.0020358870230620238
	dc	-0.0016028831912264794
	dc	-0.0007071000713312031
	dc	3.5317895701191156e-06
	dc	0.00010504905706129825
	dc	-0.00036043617629423442
	dc	-0.00091279061069705208
	dc	-0.0009203940656845593
	dc	-4.1124855589800852e-06
	dc	0.0016615211214856978
	dc	0.0033286272632425057
	dc	0.0039872628308454004
	dc	0.0028841932939367492
	dc	5.1941263154194192e-06
	dc	-0.0037422314705840625
	dc	-0.0067855455556849733
	dc	-0.0075291074594349998
	dc	-0.0051225255405828478
	dc	-5.7064556811525498e-06
	dc	0.0060674743512730009
	dc	0.010610488147199976
	dc	0.011410207913072954
	dc	0.0075520027921826697
	dc	6.2644857647058778e-06
	dc	-0.0085445987258299487
	dc	-0.014647690152578415
	dc	-0.015469070807386331
	dc	-0.010069406544237641
	dc	-6.4537070647355515e-06
	dc	0.011064976991981973
	dc	0.018717098046788769
	dc	0.0195218298142266
	dc	0.012558941655314515
	dc	6.2594921035191708e-06
	dc	-0.013509864713319166
	dc	-0.022624574441191699
	dc	-0.0233729774823314
	dc	-0.014899243428626086
	dc	-5.5615661262733117e-06
	dc	0.01575793881086952
	dc	0.026174561175660211
	dc	0.026828267545684886
	dc	0.016971573785486548
	dc	5.1014808865245884e-06
	dc	-0.017692296963606746
	dc	-0.029181445622957977
	dc	-0.02970576095584819
	dc	-0.018665715628985908
	dc	-3.627067572197374e-06
	dc	0.019211228079840416
	dc	0.031485738949934394
	dc	0.031852187412654089
	dc	0.019891532620125454
	dc	2.4576684438033271e-06
	dc	-0.020231071510730357
	dc	-0.032960752669612188
	dc	-0.033149226099650202
	dc	-0.020580992970288224
	dc	-8.2387268651989282e-07
	dc	0.020696318272458082
	dc	0.033525745957109915
	dc	0.033525745957109915
	dc	0.020696318272458082
	dc	-8.2387268651989282e-07
	dc	-0.020580992970288224
	dc	-0.033149226099650202
	dc	-0.032960752669612188
	dc	-0.020231071510730357
	dc	2.4576684438033271e-06
	dc	0.019891532620125454
	dc	0.031852187412654089
	dc	0.031485738949934394
	dc	0.019211228079840416
	dc	-3.627067572197374e-06
	dc	-0.018665715628985908
	dc	-0.02970576095584819
	dc	-0.029181445622957977
	dc	-0.017692296963606746
	dc	5.1014808865245884e-06
	dc	0.016971573785486548
	dc	0.026828267545684886
	dc	0.026174561175660211
	dc	0.01575793881086952
	dc	-5.5615661262733117e-06
	dc	-0.014899243428626086
	dc	-0.0233729774823314
	dc	-0.022624574441191699
	dc	-0.013509864713319166
	dc	6.2594921035191708e-06
	dc	0.012558941655314515
	dc	0.0195218298142266
	dc	0.018717098046788769
	dc	0.011064976991981973
	dc	-6.4537070647355515e-06
	dc	-0.010069406544237641
	dc	-0.015469070807386331
	dc	-0.014647690152578415
	dc	-0.0085445987258299487
	dc	6.2644857647058778e-06
	dc	0.0075520027921826697
	dc	0.011410207913072954
	dc	0.010610488147199976
	dc	0.0060674743512730009
	dc	-5.7064556811525498e-06
	dc	-0.0051225255405828478
	dc	-0.0075291074594349998
	dc	-0.0067855455556849733
	dc	-0.0037422314705840625
	dc	5.1941263154194192e-06
	dc	0.0028841932939367492
	dc	0.0039872628308454004
	dc	0.0033286272632425057
	dc	0.0016615211214856978
	dc	-4.1124855589800852e-06
	dc	-0.0009203940656845593
	dc	-0.00091279061069705208
	dc	-0.00036043617629423442
	dc	0.00010504905706129825
	dc	3.5317895701191156e-06
	dc	-0.0007071000713312031
	dc	-0.0016028831912264794
	dc	-0.0020358870230620238
	dc	-0.0015111241865102141
	dc	-2.8866586714968064e-06
	dc	0.0019629515090879937
	dc	0.0035106930104271609
	dc	0.0038194547394352352
	dc	0.0025364042490918343
	dc	2.1447428011360688e-06
	dc	-0.0028372031319763005
	dc	-0.0048023492354152472
	dc	-0.0049898525299422371
	dc	-0.0031855629609605241
	dc	-1.3779993711855211e-06
	dc	0.0033432727040189807
	dc	0.0055071556926189775
	dc	0.005583375275453514
	dc	0.0034852071229489008
	dc	9.721989568233641e-07
	dc	-0.0035153732158138256
	dc	-0.0056864025131494883
	dc	-0.0056671000690012002
	dc	-0.0034803272474487308
	dc	-1.2442664672459094e-06
	dc	0.0034034400001745962
	dc	0.0054255445469057612
	dc	0.0053302358130787328
	dc	0.0032277262600952537
	dc	1.3371054296607877e-06
	dc	-0.0030701155179088148
	dc	-0.0048272921603747911
	dc	-0.0046776643520767157
	dc	-0.0027938003044902819
	dc	-2.255396052253545e-06
	dc	0.002580406847405764
	dc	0.0039983999110910062
	dc	0.003816152486123753
	dc	0.0022437815408723866
	dc	2.6578724225999675e-06
	dc	-0.0020019300893205651
	dc	-0.0030458959141827185
	dc	-0.002851328431726168
	dc	-0.0016423561815143593
	dc	-3.2566960077979289e-06
	dc	0.0013947402079791313
	dc	0.0020658529995952859
	dc	0.0018764270890977448
	dc	0.0010450809399885522
	dc	3.6804692844431657e-06
	dc	-0.00081232747762052695
	dc	-0.0011405450901983193
	dc	-0.00097063446989502063
	dc	-0.00049938428654178841
	dc	-5.5439711634432814e-06
	dc	0.00029316488063787453
	dc	0.00032963161842238767
	dc	0.00018865665970039017
	dc	3.4577108435382463e-05
	dc	4.7636222976930528e-06
	dc	0.00012951880935753424
	dc	0.00032117911983512359
	dc	0.00042679905019966675
	dc	0.00032243075647834488
	dc	-8.7754467973132685e-06
	dc	-0.00045059987450060766
	dc	-0.00080240630341597949
	dc	-0.00087250527641806702
	dc	-0.00057867503505505745
	dc	1.2683573860940416e-06
	dc	0.00064723397110594012
	dc	0.0010906074220241994
	dc	0.001123969410341269
	dc	0.00070677587627990365
	dc	-1.7096791271077388e-05
	dc	-0.00076801568886045429
	dc	-0.0012454411423010201
	dc	-0.0012522929526443064
	dc	-0.00078061229819909039
	dc	-1.398696106063072e-05
	dc	0.0007451733539490205
	dc	0.0012002562056323358
	dc	0.0011776348151302434
	dc	0.00069589521447677291
	dc	-4.802601343789994e-05
	dc	-0.00076205334230794604
	dc	-0.0011728996885619156
	dc	-0.0011490714293175895
	dc	-0.00071901407208648242
	dc	-7.6688026970194627e-05
	dc	0.00051479874443189451
	dc	0.00083222792690434999
	dc	0.00077191026630810014
	dc	0.00038170587382695196
	dc	-0.00017095710474832851
	dc	-0.00067172215726001711
	dc	-0.00094873786343264467
	dc	-0.00093375759838703601
	dc	-0.0006800155401674138
	dc	-0.00032621005019612607
	dc	-3.4706815797811048e-05
	dc	0.0017996576744581446
