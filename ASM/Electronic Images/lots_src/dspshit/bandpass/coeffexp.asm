; SPW FDS generated coefficients
;
; sample_freq	=	8000           {sample frequency}
; tap_length	=	320           {filter length}
; center_freq	=	800           {center frequency}
; pass_bw	=	50           {passband bandwidth}
; stop_bw	=	60           {stopband bandwidth}
; weight1	=	10           {first stopband weight;passband weight = 1}
; weight2	=	10           {second stopband weight}

taps	equ	320

coeffs	dc	0.033303883305370749
	dc	-0.0051989102022629921
	dc	-0.0063032211397226617
	dc	-0.0075818130545806453
	dc	-0.0082491973241016689
	dc	-0.0077885838610063235
	dc	-0.0060914427637923929
	dc	-0.0035894901351558386
	dc	-0.0010305336687942701
	dc	0.0007232889047186844
	dc	0.0011146237231682427
	dc	3.3909054300229613e-05
	dc	-0.0020153747252404444
	dc	-0.0042014280660151032
	dc	-0.0055451743009580709
	dc	-0.005458996986063884
	dc	-0.0037809704090775026
	dc	-0.001145783143507613
	dc	0.0015462230446124034
	dc	0.0034001946488187995
	dc	0.0035569977712384612
	dc	0.0020257598580080485
	dc	-0.0006588583418794397
	dc	-0.003425882127401414
	dc	-0.0052014504538017009
	dc	-0.0052135109237390967
	dc	-0.0033971329752396084
	dc	-0.0003614234867559199
	dc	0.0027545509904175758
	dc	0.0047748659225519269
	dc	0.0048791802240761642
	dc	0.00299571973404128
	dc	-0.0002120202952007183
	dc	-0.0035079298371627696
	dc	-0.0056413129544566065
	dc	-0.0056868321981214456
	dc	-0.0036031517180905026
	dc	-0.00012195294800251832
	dc	0.0034627225531899952
	dc	0.0057642829181349525
	dc	0.0058575320690616439
	dc	0.0036504950469942801
	dc	-6.0928436027354871e-05
	dc	-0.0038738287248799436
	dc	-0.0063120732314109612
	dc	-0.0063890882001746557
	dc	-0.0040144460053323991
	dc	-4.0525704840067844e-05
	dc	0.004031924687466687
	dc	0.0066333533582332363
	dc	0.0067173186023691753
	dc	0.0041947903843102818
	dc	-1.3989956490136068e-05
	dc	-0.0043395006728858196
	dc	-0.0070882105098501041
	dc	-0.0071683600917187076
	dc	-0.0044854325133383555
	dc	-1.6051227968535975e-05
	dc	0.0045554252082923782
	dc	0.0074620366733868793
	dc	0.0075464400059302508
	dc	0.0047145172058336918
	dc	1.5907831327557909e-06
	dc	-0.0048129977952454522
	dc	-0.0078678808526341515
	dc	-0.0079501820006254512
	dc	-0.0049641319408149365
	dc	-7.2217500881460728e-06
	dc	0.0050523464540768517
	dc	0.0082533625151111484
	dc	0.0083295816860208746
	dc	0.0051979994252067604
	dc	-4.6458135427585034e-07
	dc	-0.0052930960332141647
	dc	-0.0086406353637269451
	dc	-0.0087150339875350161
	dc	-0.0054322183511787137
	dc	1.8185852260002577e-06
	dc	0.005527438855325785
	dc	0.0090163771356101055
	dc	0.0090889542035497983
	dc	0.0056629660728474696
	dc	8.5733498912665684e-07
	dc	-0.0057492293475252601
	dc	-0.0093755376921447649
	dc	-0.0094452713156904337
	dc	-0.0058838161932476402
	dc	1.178381332248013e-06
	dc	0.0059691390010598172
	dc	0.0097255203681691944
	dc	0.0097925966659457402
	dc	0.0060933659772030371
	dc	-2.7057428826707253e-06
	dc	-0.0061807971860701055
	dc	-0.010065508375242747
	dc	-0.010130937416999664
	dc	-0.0063042067647359548
	dc	-5.2929420046726738e-06
	dc	0.0063717116893151141
	dc	0.010377106986187521
	dc	0.010439901588427652
	dc	0.0064913539176014237
	dc	6.8906881899727379e-07
	dc	-0.006563450558122387
	dc	-0.010677829839778351
	dc	-0.010738185407338244
	dc	-0.0066724385656988169
	dc	-9.3358261821219202e-07
	dc	0.0067400789999931196
	dc	0.010960451128848726
	dc	0.011014917044537914
	dc	0.0068406743766380104
	dc	4.8938535174292142e-07
	dc	-0.0069038190570859248
	dc	-0.011220568039861403
	dc	-0.011270979853128815
	dc	-0.006996441079910716
	dc	-2.8557327310177461e-06
	dc	0.0070501416832365674
	dc	0.011453422677332084
	dc	0.011499623158023185
	dc	0.0071329199274741129
	dc	-1.6550165822179497e-06
	dc	-0.0071865305483710812
	dc	-0.011667153471231154
	dc	-0.01170584036390741
	dc	-0.007256866750872476
	dc	2.721003478527162e-06
	dc	0.0073066731326454221
	dc	0.011854646709011409
	dc	0.011887796329288318
	dc	0.007365760061198677
	dc	-2.6984935143359312e-06
	dc	-0.007408762456171579
	dc	-0.012014699053419741
	dc	-0.012041382247762304
	dc	-0.0074573457729861167
	dc	3.1751169904253862e-06
	dc	0.0074925105683896903
	dc	0.012145973760596791
	dc	0.012166683843866141
	dc	0.0075301216207177349
	dc	-5.3277215020380853e-06
	dc	-0.0075635522439842437
	dc	-0.012252593067511953
	dc	-0.012267780545296994
	dc	-0.0075900600638302562
	dc	3.4189358480360421e-06
	dc	0.0076121340325587469
	dc	0.012327829252425468
	dc	0.012337956056605252
	dc	0.0076317803642066001
	dc	-1.8992870397249728e-07
	dc	-0.0076414656749005661
	dc	-0.01237148961822683
	dc	-0.012376326850286334
	dc	-0.0076501288568261994
	dc	2.379159462918834e-06
	dc	0.0076586990376616773
	dc	0.012392026772332591
	dc	0.012392026772332591
	dc	0.0076586990376616773
	dc	2.379159462918834e-06
	dc	-0.0076501288568261994
	dc	-0.012376326850286334
	dc	-0.01237148961822683
	dc	-0.0076414656749005661
	dc	-1.8992870397249728e-07
	dc	0.0076317803642066001
	dc	0.012337956056605252
	dc	0.012327829252425468
	dc	0.0076121340325587469
	dc	3.4189358480360421e-06
	dc	-0.0075900600638302562
	dc	-0.012267780545296994
	dc	-0.012252593067511953
	dc	-0.0075635522439842437
	dc	-5.3277215020380853e-06
	dc	0.0075301216207177349
	dc	0.012166683843866141
	dc	0.012145973760596791
	dc	0.0074925105683896903
	dc	3.1751169904253862e-06
	dc	-0.0074573457729861167
	dc	-0.012041382247762304
	dc	-0.012014699053419741
	dc	-0.007408762456171579
	dc	-2.6984935143359312e-06
	dc	0.007365760061198677
	dc	0.011887796329288318
	dc	0.011854646709011409
	dc	0.0073066731326454221
	dc	2.721003478527162e-06
	dc	-0.007256866750872476
	dc	-0.01170584036390741
	dc	-0.011667153471231154
	dc	-0.0071865305483710812
	dc	-1.6550165822179497e-06
	dc	0.0071329199274741129
	dc	0.011499623158023185
	dc	0.011453422677332084
	dc	0.0070501416832365674
	dc	-2.8557327310177461e-06
	dc	-0.006996441079910716
	dc	-0.011270979853128815
	dc	-0.011220568039861403
	dc	-0.0069038190570859248
	dc	4.8938535174292142e-07
	dc	0.0068406743766380104
	dc	0.011014917044537914
	dc	0.010960451128848726
	dc	0.0067400789999931196
	dc	-9.3358261821219202e-07
	dc	-0.0066724385656988169
	dc	-0.010738185407338244
	dc	-0.010677829839778351
	dc	-0.006563450558122387
	dc	6.8906881899727379e-07
	dc	0.0064913539176014237
	dc	0.010439901588427652
	dc	0.010377106986187521
	dc	0.0063717116893151141
	dc	-5.2929420046726738e-06
	dc	-0.0063042067647359548
	dc	-0.010130937416999664
	dc	-0.010065508375242747
	dc	-0.0061807971860701055
	dc	-2.7057428826707253e-06
	dc	0.0060933659772030371
	dc	0.0097925966659457402
	dc	0.0097255203681691944
	dc	0.0059691390010598172
	dc	1.178381332248013e-06
	dc	-0.0058838161932476402
	dc	-0.0094452713156904337
	dc	-0.0093755376921447649
	dc	-0.0057492293475252601
	dc	8.5733498912665684e-07
	dc	0.0056629660728474696
	dc	0.0090889542035497983
	dc	0.0090163771356101055
	dc	0.005527438855325785
	dc	1.8185852260002577e-06
	dc	-0.0054322183511787137
	dc	-0.0087150339875350161
	dc	-0.0086406353637269451
	dc	-0.0052930960332141647
	dc	-4.6458135427585034e-07
	dc	0.0051979994252067604
	dc	0.0083295816860208746
	dc	0.0082533625151111484
	dc	0.0050523464540768517
	dc	-7.2217500881460728e-06
	dc	-0.0049641319408149365
	dc	-0.0079501820006254512
	dc	-0.0078678808526341515
	dc	-0.0048129977952454522
	dc	1.5907831327557909e-06
	dc	0.0047145172058336918
	dc	0.0075464400059302508
	dc	0.0074620366733868793
	dc	0.0045554252082923782
	dc	-1.6051227968535975e-05
	dc	-0.0044854325133383555
	dc	-0.0071683600917187076
	dc	-0.0070882105098501041
	dc	-0.0043395006728858196
	dc	-1.3989956490136068e-05
	dc	0.0041947903843102818
	dc	0.0067173186023691753
	dc	0.0066333533582332363
	dc	0.004031924687466687
	dc	-4.0525704840067844e-05
	dc	-0.0040144460053323991
	dc	-0.0063890882001746557
	dc	-0.0063120732314109612
	dc	-0.0038738287248799436
	dc	-6.0928436027354871e-05
	dc	0.0036504950469942801
	dc	0.0058575320690616439
	dc	0.0057642829181349525
	dc	0.0034627225531899952
	dc	-0.00012195294800251832
	dc	-0.0036031517180905026
	dc	-0.0056868321981214456
	dc	-0.0056413129544566065
	dc	-0.0035079298371627696
	dc	-0.0002120202952007183
	dc	0.00299571973404128
	dc	0.0048791802240761642
	dc	0.0047748659225519269
	dc	0.0027545509904175758
	dc	-0.0003614234867559199
	dc	-0.0033971329752396084
	dc	-0.0052135109237390967
	dc	-0.0052014504538017009
	dc	-0.003425882127401414
	dc	-0.0006588583418794397
	dc	0.0020257598580080485
	dc	0.0035569977712384612
	dc	0.0034001946488187995
	dc	0.0015462230446124034
	dc	-0.001145783143507613
	dc	-0.0037809704090775026
	dc	-0.005458996986063884
	dc	-0.0055451743009580709
	dc	-0.0042014280660151032
	dc	-0.0020153747252404444
	dc	3.3909054300229613e-05
	dc	0.0011146237231682427
	dc	0.0007232889047186844
	dc	-0.0010305336687942701
	dc	-0.0035894901351558386
	dc	-0.0060914427637923929
	dc	-0.0077885838610063235
	dc	-0.0082491973241016689
	dc	-0.0075818130545806453
	dc	-0.0063032211397226617
	dc	-0.0051989102022629921
	dc	0.033303883305370749
