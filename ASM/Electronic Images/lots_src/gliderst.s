	CLR.L	-(SP)		;Enter Supervisor & Save sp
	MOVE.W	#$20,-(SP)
	TRAP	#1
	LEA	6(SP),SP
	MOVE.L	#1,D0
	JSR	R0_CHANGE
LOOP	MOVE.W	#37,-(SP)
	TRAP	#14
	ADD.L	#2,SP
	JSR	R0_PLAY
	MOVE.W	#2,-(SP)
	MOVE.W	#1,-(SP)
	TRAP	#13
	ADD.L	#4,SP
	TST.L	D0
	BEQ	LOOP
	CLR.W	-(SP)
	TRAP	#1
R0_PLAY	BRA	R0_49381
R0_CHANGE	;D0=0 TO 2
R0_49170	MULU	#12,D0
	MOVE.L	#R0_50381,A0
	ADD.L	D0,A0
	MOVE.L	#R0_49247,A1
	MOVE.L	#2,D0
R0_49195	MOVE.L	(A0)+,A2
	MOVE.W	#1,32(A1)
	MOVE.W	#0,(A1)
	MOVE.W	#0,58(A1)
	MOVE.L	A2,6(A1)
	MOVE.L	(A2),A2
	MOVE.L	#4,10(A1)
	MOVE.L	A2,2(A1)
	ADD.L	#62,A1
	DBRA	D0,R0_49195
	MOVE.W	#1,R0_49488
	MOVE.W	#1,R0_50379
	RTS
	;
	;
	;
R0_49247	DC.W	0
	DC.L	0 ;R0_50650
	DC.L	0 ;R0_50458
	DC.W	24,0,0,0
	DC.L	0 ;R0_50345
	DC.L	0 ;R0_50345+1
	DC.W	0,0,0,2,2,7,15,0,33,17,9,9,15,2,1,0,64,9
R0_49278	DC.W	0
	DC.L	0 ;R0_50929
	DC.L	0 ;R0_50522
	DC.W	24,0,0,0
	DC.L	R0_50346
	DC.L	R0_50346+2
	DC.W	1,48,0,32,32,55,11,0,17,1,1,1,11,2,1,0,64,18
R0_49309	DC.W	0
	DC.L	0 ;R0_51140
	DC.L	0 ;R0_50586
	DC.W	24,0,176,4
	DC.L	R0_50346+30
	DC.L	R0_50346+32
	DC.W	120,1,0,10,10,64,10,18,129,2,21,5,8,2,1,0,64,36
R0_49387	DC.W	1
	;
R0_49464	DC.W	1
R0_49423	DC.W	5
R0_49488	DC.W	1
R0_50094	DC.W	56
	;
	;
R0_49381	CLR.L	D0
	CLR.L	D1
	CLR.L	D2
	CLR.L	D3
	CLR.L	D4
	CLR.L	D5
	CLR.L	D6
	CLR.L	D7
	MOVE.W	R0_50379,D0
	AND.W	D0,D0
	BNE	R0_49386
	RTS
R0_49386	MOVE.W	R0_49387,R0_49464
	SUB.W	#1,R0_49488
	BNE	R0_49424
	MOVE.W	R0_49488,D0
	MOVE.L	#R0_49247,A0
	JSR	R0_49686
	MOVE.L	#R0_49278,A0
	JSR	R0_49686
	MOVE.L	#R0_49309,A0
	JSR	R0_49686
R0_49422	MOVE.W	R0_49423,R0_49488
R0_49424	MOVE.L	#R0_49247,A0
	JSR	R0_49848
	MOVE.W	D3,R0_50151
	MOVE.W	D1,R0_50152
	MOVE.W	D2,R0_50159
	MOVE.L	#R0_49278,A0
	JSR	R0_49848
	MOVE.W	D3,R0_50153
	MOVE.W	D1,R0_50154
	MOVE.W	D2,R0_50160
	MOVE.L	#R0_49309,A0
	JSR	R0_49848
	MOVE.W	D3,R0_50155
	MOVE.W	D1,R0_50156
	MOVE.W	D2,R0_50161
R0_49463	MOVE.W	R0_49464,R0_50157
	MOVE.B	#0,$FFFF8800.W
	MOVE.B	R0_50151+1,$FFFF8802.W
	MOVE.B	#1,$FFFF8800.W
	MOVE.B	R0_50152+1,$FFFF8802.W
	MOVE.B	#2,$FFFF8800.W
	MOVE.B	R0_50153+1,$FFFF8802.W
	MOVE.B	#3,$FFFF8800.W
	MOVE.B	R0_50154+1,$FFFF8802.W
	MOVE.B	#4,$FFFF8800.W
	MOVE.B	R0_50155+1,$FFFF8802.W
	MOVE.B	#5,$FFFF8800.W
	MOVE.B	R0_50156+1,$FFFF8802.W
	MOVE.B	#6,$FFFF8800.W
	MOVE.B	R0_50157+1,$FFFF8802.W
	MOVE.B	#7,$FFFF8800.W
	MOVE.B	R0_50158+1,D0
	OR.B	#%11000000,D0
	MOVE.B	D0,$FFFF8802.W
	MOVE.B	#8,$FFFF8800.W
	MOVE.B	R0_50159+1,$FFFF8802.W
	MOVE.B	#9,$FFFF8800.W
	MOVE.B	R0_50160+1,$FFFF8802.W
	MOVE.B	#10,$FFFF8800.W
	MOVE.B	R0_50161+1,$FFFF8802.W
	MOVE.B	#11,$FFFF8800.W
	MOVE.B	R0_50162+1,$FFFF8802.W
	MOVE.B	#12,$FFFF8800.W
	MOVE.B	R0_50163+1,$FFFF8802.W
	RTS
	;
	;
	;
R0_49489	DC.L 	R0_49677
	DC.L 	R0_49654
	DC.L 	R0_49659
	DC.L	R0_49665
	DC.L 	R0_49600
	DC.L 	R0_49648
	DC.L 	R0_49644
	DC.L 	R0_49512
	DC.L 	R0_49629
	DC.L 	R0_49622
	DC.L 	R0_49573
	DC.L 	R0_49557
	DC.L 	R0_49589
	DC.L 	R0_49671
	DC.L 	R0_49504
R0_49504	MOVE.W	#0,R0_50379
	ADD.L	#4,SP
	BRA	R0_50121
R0_49512	MOVE.L	10(A0),D4
	MOVE.L	6(A0),A1
	ADD.L	D4,A1
	ADD.L	#4,D4
	MOVE.L	(A1),A2
	CMP.L	#0,A2
	BNE	R0_49546
	MOVE.L	6(A0),A1
	MOVE.L	#4,D4
	MOVE.L	(A1),A2
R0_49546	MOVE.L	D4,10(A0)
	CLR.L	D0
	BRA	R0_49700
R0_49557	MOVE.W	60(A0),D2
	MOVE.W	D2,D5
	AND.W	#7,D2
	MOVE.W	R0_50094,D1
	EOR.W	D1,D2
	AND.W	D5,D2
	EOR.W	D1,D2
	MOVE.W	D2,R0_50094
	BRA	R0_49700
R0_49573	MOVE.W	60(A0),D2
	MOVE.W	D2,D5
	AND.W	#56,D2
	MOVE.W	R0_50094,D1
	EOR.W	D1,D2
	AND.W	D5,D2
	EOR.W	D1,D2
	MOVE.W	D2,R0_50094
	BRA	R0_49700
R0_49589	MOVE.W	60(A0),D2
	NOT.W	D2
	AND.W	R0_50094,D2
	MOVE.W	D2,R0_50094
	BRA	R0_49700
R0_49600	CLR.L	D2
	MOVE.B	(A2)+,D2
	MOVE.W	D0,14(A0)
	MOVE.W	D0,16(A0)
	MOVE.W	D2,26(A0)
	BSET	#2,1(A0)
	MOVE.B	(A2)+,D2
	MOVE.W	D2,28(A0)
	BRA	R0_49700
R0_49622	MOVE.B	(A2)+,D2
	MOVE.W	D2,R0_49387
	BRA	R0_49700
R0_49629	MOVE.B	(A2)+,D2
	MOVE.W	D2,54(A0)
	MOVE.B	(A2)+,D2
	MOVE.W	D2,52(A0)
	MOVE.W	D2,56(A0)
	BRA	R0_49700
R0_49644	BSET	#7,1(A0)
R0_49648	BSET	#3,1(A0)
	BRA	R0_49700
R0_49654	MOVE.W	D0,58(A0)
	BRA	R0_49700
R0_49659	MOVE.W	#64,58(A0)
	BRA	R0_49700
R0_49665	MOVE.W	#192,58(A0)
	BRA	R0_49700
R0_49671	BSET	#1,1(A0)
	BRA	R0_49700
R0_49677	MOVE.W	D0,38(A0)
	BCLR	#5,1(A0)
	BRA	R0_49735
R0_49686	SUB.W	#1,32(A0)
	BNE	R0_49748
	MOVE.W	D0,(A0)
	MOVE.L	2(A0),A2
R0_49700	CLR.L	D2
	MOVE.B	(A2)+,D2
	AND.B	D2,D2
	BMI	R0_49765
	MOVE.W	D2,36(A0)
	MOVE.W	50(A0),D2
	MOVE.W	D2,38(A0)
	BSET	#5,1(A0)
	BSET	#6,1(A0)
	MOVE.W	40(A0),D2
	MOVE.W	D2,44(A0)
	MOVE.W	46(A0),D2
	MOVE.W	D2,48(A0)
R0_49735	MOVE.W	34(A0),D2
	MOVE.W	D2,32(A0)
	MOVE.L	A2,2(A0)
	RTS
R0_49748	MOVE.W	(A0),D2
	BTST	#3,D2
	BEQ	EXIT
	LSL.B	#1,D2
	BCC	R0_49761
	ADD.W	#1,36(A0)
EXIT	RTS
R0_49761	SUB.W	#1,36(A0)
	RTS
R0_49765	CMP.B	#184,D2
	BLT	R0_49840
	ADD.B	#32,D2
	BCS	R0_49813
	ADD.B	#16,D2
	BCS	R0_49819
	ADD.B	#16,D2
	BCC	R0_49806
	MOVE.L	#R0_50333,A1
	ADD.L	D2,A1
	CLR.L	D2
	MOVE.B	(A1),D2
	ADD.L	D2,A1
	MOVE.L	A1,18(A0)
	MOVE.L	A1,22(A0)
	BSET	#4,1(A0)
	BRA	R0_49700
R0_49806	ADD.B	#9,D2
	MOVE.W	D2,R0_49423
	BRA	R0_49700
R0_49813	ADD.W	#1,D2
	MOVE.W	D2,34(A0)
	BRA	R0_49700
R0_49819	MOVE.W	D2,50(A0)
	MOVE.B	(A2)+,D2
	MOVE.W	D2,40(A0)
	MOVE.B	(A2)+,D2
	MOVE.W	D2,42(A0)
	MOVE.B	(A2)+,D2
	MOVE.W	D2,46(A0)
	BRA	R0_49700
R0_49840	MOVE.L	#R0_49489,A1
	AND.W	#127,D2
	ADD.L	D2,D2
	ADD.L	D2,D2
	ADD.L	D2,A1
	MOVE.L	(A1),A1
	JMP 	(A1)
R0_49848	MOVE.W	(A0),D5
	BTST	#5,D5
	BEQ	R0_49923
	MOVE.W	44(A0),D2
	SUB.W	#16,D2
	BCC	R0_49899
	BTST 	#6,D5
	BEQ	R0_49904
	ADD.B	39(A0),D2
	BCC	R0_49872
	SUBX.W	D2,D2
R0_49872	ADD.W	#16,D2
	MOVE.W	D2,38(A0)
	MOVE.W	48(A0),D2
	SUB.W	#16,D2
	BCC	R0_49894
	BCLR	#6,D5
	MOVE.W	42(A0),D2
	MOVE.W	D2,44(A0)
	BRA	R0_49923
R0_49894	MOVE.W	D2,48(A0)
	BRA	R0_49923
R0_49899	MOVE.W	D2,44(A0)
	BRA	R0_49923
R0_49904	NOT.W	D2
	SUB.W	#15,D2
	ADD.B	39(A0),D2
	BCS	R0_49913
	SUB.W	D2,D2
R0_49913	MOVE.W	D2,38(A0)
	SUB.W	#1,48(A0)
	BNE	R0_49923
	BCLR	#5,D5
R0_49923	MOVE.W	36(A0),D2
	BTST	#4,D5
	BEQ	R0_49957
	MOVE.W	D2,D0
	MOVE.L	22(A0),A1
	CLR.L	D2
	MOVE.B	(A1),D2
	CMP.W 	#84,D2
	BLT	R0_49949
	MOVE.L	18(A0),A1
	MOVE.B	(A1),D2
R0_49949	ADD.L	#1,A1
	MOVE.L	A1,22(A0)
	ADD.W	D0,D2
R0_49957	MOVE.L	#R0_50165,A1
	ADD.L	D2,D2
	ADD.L	D2,A1
	CLR.L	D6
	CLR.L	D7
	MOVE.B	(A1)+,D6
	MOVE.B	(A1),D7
	MOVE.W	58(A0),D3	
	BTST	#6,D3
	BEQ	R0_50047
	MOVE.L	D2,D1
	MOVE.W	52(A0),D0
	ADD.W	D0,D0
	MOVE.W	56(A0),D2
	BTST	#7,D3
	BEQ	R0_49992
	BTST	#0,D5
	BNE	R0_50022
R0_49992	BTST	#5,D3
	BNE	R0_50008
	SUB.W	54(A0),D2
	BCC	R0_50019
	BSET	#5,59(A0)
	SUB.W	D2,D2
	BRA	R0_50019
R0_50008	ADD.W	54(A0),D2
	CMP.W	D0,D2
	BLT	R0_50019
	BCLR	#5,59(A0)
	MOVE.W	D0,D2
R0_50019	MOVE.W	D2,56(A0)
R0_50022	EXG	D6,D3
	EXG	D7,D1
	DIVU.W	#2,D0
	SUB.W	D0,D2
	BCC	R0_50031
	MOVE.W	D2,D6
	MOVE.W	D7,D2
	MOVE.W	#255,D7
	BRA	R0_50033
R0_50031	MOVE.W	D2,D6
	MOVE.W	D7,D2
	MOVE.W	#0,D7
R0_50033	ADD.B	#160,D2
	BCS	R0_50045
R0_50037	ADD.B	D6,D6
	ADDX.B	D7,D7
	ADD.B	#24,D2
	BCC	R0_50037
R0_50045	ADD.B	D6,D3
	ADDX.B	D7,D1
	EXG	D1,D7
	EXG	D3,D6
R0_50047	MOVE.W	D5,D2
	EOR.W	#1,D2
	MOVE.W	D2,(A0)
	BTST	#2,D5
	BEQ	R0_50090
	MOVE.W	28(A0),D0
	SUB.W	#1,D0
	BNE	R0_50087
	MOVE.W	26(A0),D5
	BTST	#7,D5
	BEQ	R0_50070
	SUB.L	#1,D0
R0_50070	MOVE.L	14(A0),A1
	ADD.L	D5,A1
	MOVE.L	D0,-(SP)
	LSL.L	#8,D0
	ADD.L	D0,A1
	MOVE.L	(SP)+,D0
	MOVE.L	A1,14(A0)
	ADD.L	D6,A1
	MOVE.L	D7,-(SP)
	LSL.L	#8,D7
	ADD.L	D7,A1
	MOVE.L	(SP)+,D7
	MOVE.L	A1,D3
	MOVE.L	A1,D1
	AND.L	#$FF00,D1
	AND.L	#$FF,D3
	LSR.L	#8,D1
	EXG	D6,D3
	EXG	D7,D1
	BRA	R0_50090
R0_50087	MOVE.W	D0,28(A0)
R0_50090	NOT.B	D2
	AND.W	#03,D2
	BNE	R0_50105
	MOVE.W	R0_49387,D2
	EOR.W	#8,D2
	MOVE.W	D2,R0_49464
	MOVE.W	#7,D2
	BRA	R0_50107
R0_50105	MOVE.W	R0_50094,D2
R0_50107	MOVE.W	R0_50158,D1
R0_50138	EOR.W	D1,D2
	AND.W	60(A0),D2
	EOR.W	D1,D2
	MOVE.W	D2,R0_50158
	EXG	D6,D3
	EXG	D7,D1
	MOVE.W	38(A0),D2
	RTS
R0_50121	MOVE.B	#8,$FFFF8800.W
	MOVE.B	#0,$FFFF8802.W
	MOVE.B	#9,$FFFF8800.W
	MOVE.B	#0,$FFFF8802.W
	MOVE.B	#10,$FFFF8800.W
	MOVE.B	#0,$FFFF8802.W
	MOVE.B	#0,$FFFF8800.W
	MOVE.B	#0,$FFFF8802.W
	MOVE.B	#1,$FFFF8800.W
	MOVE.B	#0,$FFFF8802.W
	MOVE.B	#2,$FFFF8800.W
	MOVE.B	#0,$FFFF8802.W
	MOVE.B	#3,$FFFF8800.W
	MOVE.B	#0,$FFFF8802.W
	MOVE.B	#4,$FFFF8800.W
	MOVE.B	#0,$FFFF8802.W
	MOVE.B	#5,$FFFF8800.W
	MOVE.B	#0,$FFFF8802.W
	MOVE.B	#6,$FFFF8800.W
	MOVE.B	#0,$FFFF8802.W
	MOVE.B	#7,$FFFF8800.W
	MOVE.B	#255,$FFFF8802.W
	RTS


R0_50151	DC.W 	99
R0_50152	DC.W 	0
R0_50153	DC.W 	58
R0_50154	DC.W	0
R0_50155	DC.W 	51
R0_50156	DC.W 	56
R0_50157	DC.W 	15
R0_50158	DC.W 	15
R0_50159	DC.W 	15
R0_50160	DC.W 	0
R0_50161	DC.W 	0
R0_50162	DC.W 	0
R0_50163	DC.W 	0
R0_50164	DC.W 	0
R0_50165	DC.B 	248,14,16,14,96,13,128,12,216,11,40,11,136,10,0
	DC.B 	9,96,9,224,8,88,8
	DC.B 	224,7,124,7,8,7,176,6,64,6,236,5,148,5
	DC.B 	68,5,248,4,176,4,112,4,44,4,240,3,190,3,132
	DC.B 	3,88,3,32,3,246,2,202,2,162,2,124,2
	DC.B 	88,2,56,2,22,2,248,1,223,1,194,1,172,1
	DC.B 	144,1,123,1,101,1,81,1,62,1,44,1,28,1
	DC.B 	11,1,252,0,239,0,225,0,214,0,200,0,189,0
	DC.B 	178,0,168,0,159,0,150,0,142,0,133,0,126,0
	DC.B 	119,0,112,0,107,0,100,0,94,0,89,0,84,0
	DC.B 	79,0,75,0,71,0,66,0,63,0,59,0,56,0,53,0
	DC.B 	50,0,47,0,44,0,42,0,39,0,37,0,35,0,33,0,31,0
	;
	;UNKNOWN TABLE
	;
R0_50333	DC.B 9,12,15,19,23,26,29,32,35
	DC.B 0,3,7,135
R0_50346	DC.B 0,4,7,135
	DC.B 0,3,7,12,135
	DC.B 0,4,7,12,135
	DC.B 7,12,15,135
	DC.B 7,12,16,135
	DC.B 3,7,12,135
	DC.B 4,7,12,135
	DC.B 0,12,135
R0_50379	DC.W 	1
	EVEN
R0_50381	DC.L R0_50399 
	DC.L R0_50463 
	DC.L R0_50527 
R0_50387	DC.L R0_50591 
	DC.L R0_50655 
	DC.L R0_50719 
R0_50393	DC.L R0_50783 
	DC.L R0_50847 
	DC.L R0_50911 
R0_50399	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_51110 
	DC.L R0_51110 
	DC.L R0_51110 
	DC.L R0_51110 
	DC.L R0_51110 
	DC.L R0_51110 
	DC.L R0_51110 
	DC.L R0_51110 
	DC.L 0
R0_50463	DC.L R0_52584 
	DC.L R0_52558 
	DC.L R0_51348 
	DC.L R0_51348 
	DC.L R0_51219 
	DC.L R0_51262 
	DC.L R0_51305 
	DC.L R0_51348 
	DC.L R0_51219 
	DC.L R0_51262 
	DC.L R0_51305 
	DC.L R0_51348 
	DC.L R0_51348 
	DC.L R0_51219 
	DC.L R0_51262 
	DC.L R0_51305 
	DC.L R0_51348 
	DC.L R0_51219 
	DC.L R0_51262 
	DC.L R0_51305 
	DC.L R0_51348 
	DC.L R0_51348 
	DC.L R0_52558 
	DC.L R0_51391 
	DC.L R0_51434 
	DC.L R0_51391 
	DC.L R0_51434 
	DC.L R0_51477 
	DC.L R0_51477 
	DC.L R0_51477 
	DC.L R0_51477 
	DC.L 0
R0_50527	DC.L R0_52584 
	DC.L R0_52571 
	DC.L R0_52497 
	DC.L R0_52497 
	DC.L R0_51520 
	DC.L R0_51550 
	DC.L R0_51580 
	DC.L R0_51610 
	DC.L R0_51520 
	DC.L R0_51550 
	DC.L R0_51580 
	DC.L R0_51610 
	DC.L R0_52497 
	DC.L R0_51640 
	DC.L R0_51686 
	DC.L R0_51732 
	DC.L R0_51778 
	DC.L R0_51640 
	DC.L R0_51686 
	DC.L R0_51732 
	DC.L R0_51778 
	DC.L R0_52497 
	DC.L R0_52571 
	DC.L R0_51824 
	DC.L R0_51859 
	DC.L R0_51895 
	DC.L R0_51926 
	DC.L R0_51953 
	DC.L R0_51986 
	DC.L R0_51953 
	DC.L R0_51986 
	DC.L 0
R0_50591	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_50975 
	DC.L R0_51110 
	DC.L R0_51110 
	DC.L R0_51110 
	DC.L R0_51110 
	DC.L R0_51110 
	DC.L R0_51110 
	DC.L R0_51110 
	DC.L R0_51110 
	DC.L 0
R0_50655	DC.L R0_52584 
	DC.L R0_52558 
	DC.L R0_51348 
	DC.L R0_51348 
	DC.L R0_51219 
	DC.L R0_51262 
	DC.L R0_51305 
	DC.L R0_51348 
	DC.L R0_51219 
	DC.L R0_51262 
	DC.L R0_51305 
	DC.L R0_51348 
	DC.L R0_51348 
	DC.L R0_51219 
	DC.L R0_51262 
	DC.L R0_51305 
	DC.L R0_51348 
	DC.L R0_51219 
	DC.L R0_51262 
	DC.L R0_51305 
	DC.L R0_51348 
	DC.L R0_51348 
	DC.L R0_52558 
	DC.L R0_51391 
	DC.L R0_51434 
	DC.L R0_51391 
	DC.L R0_51434 
	DC.L R0_51477 
	DC.L R0_51477 
	DC.L R0_51477 
	DC.L R0_51477 
	DC.L 0
R0_50719	DC.L R0_52584 
	DC.L R0_52571 
	DC.L R0_52497 
	DC.L R0_52497 
	DC.L R0_52321 
	DC.L R0_52349 
	DC.L R0_52377 
	DC.L R0_52405 
	DC.L R0_52321 
	DC.L R0_52349 
	DC.L R0_52377 
	DC.L R0_52405 
	DC.L R0_52497 
	DC.L R0_52433 
	DC.L R0_52449 
	DC.L R0_52465 
	DC.L R0_52481 
	DC.L R0_52433 
	DC.L R0_52449 
	DC.L R0_52465 
	DC.L R0_52481 
	DC.L R0_52497 
	DC.L R0_52571 
	DC.L R0_52021 
	DC.L R0_52096 
	DC.L R0_52021 
	DC.L R0_52096 
	DC.L R0_52171 
	DC.L R0_52246 
	DC.L R0_52171 
	DC.L R0_52246 
	DC.L 0
R0_50783	DC.L R0_52592 
	DC.L R0_52627 
	DC.L R0_52592 
	DC.L R0_52627 
	DC.L R0_52662 
	DC.L R0_52697 
	DC.L R0_52592 
	DC.L R0_52627 
	DC.L R0_52662 
	DC.L R0_52697 
	DC.L R0_52592 
	DC.L R0_52627 
	DC.L R0_52592 
	DC.L R0_52627 
	DC.L R0_52662 
	DC.L R0_52697 
	DC.L R0_52592 
	DC.L R0_52627 
	DC.L R0_52662 
	DC.L R0_52697 
	DC.L R0_52592 
	DC.L R0_52627 
	DC.L R0_52592 
	DC.L R0_52627 
	DC.L R0_52662 
	DC.L R0_52697 
	DC.L R0_52592 
	DC.L R0_52627 
	DC.L R0_52662 
	DC.L R0_52697 
	DC.L R0_52592 
	DC.L 0
R0_50847	DC.L R0_52732 
	DC.L R0_52749 
	DC.L R0_52732 
	DC.L R0_52749 
	DC.L R0_52766 
	DC.L R0_52783 
	DC.L R0_52732 
	DC.L R0_52749 
	DC.L R0_52766 
	DC.L R0_52783 
	DC.L R0_52732 
	DC.L R0_52749 
	DC.L R0_52732 
	DC.L R0_52749 
	DC.L R0_52766 
	DC.L R0_52783 
	DC.L R0_52732 
	DC.L R0_52749 
	DC.L R0_52766 
	DC.L R0_52783 
	DC.L R0_52732 
	DC.L R0_52749 
	DC.L R0_52732 
	DC.L R0_52749 
	DC.L R0_52766 
	DC.L R0_52783 
	DC.L R0_52732 
	DC.L R0_52749 
	DC.L R0_52766 
	DC.L R0_52783 
	DC.L R0_52732 
	DC.L 0
R0_50911	DC.L R0_52800 
	DC.L R0_52823 
	DC.L R0_52800 
	DC.L R0_52823 
	DC.L R0_52846 
	DC.L R0_52869 
	DC.L R0_52800 
	DC.L R0_52823 
	DC.L R0_52846 
	DC.L R0_52869 
	DC.L R0_52800 
	DC.L R0_52823 
	DC.L R0_52800 
	DC.L R0_52823 
	DC.L R0_52846 
	DC.L R0_52869 
	DC.L R0_52800 
	DC.L R0_52823 
	DC.L R0_52846 
	DC.L R0_52869 
	DC.L R0_52800 
	DC.L R0_52823 
	DC.L R0_52800 
	DC.L R0_52823 
	DC.L R0_52846 
	DC.L R0_52869 
	DC.L R0_52800 
	DC.L R0_52823 
	DC.L R0_52846 
	DC.L R0_52869 
	DC.L R0_52800 
	DC.L 0
R0_50975	DC.B 188,139,136,1,2,130,223,0,2,9,224,137,31
	DC.B 141,0,223,0,3,5,137,1,0,0,0,223,0
	DC.B 1,9,225,137,7,141,0,224,137,21,141,0,223
	DC.B 0,3,5,137,1,0,223,0,2,9,137,7,141
	DC.B 0,223,0,3,5,137,1,0,0,0,223,0,1
	DC.B 9,225,137,7,141,0,223,0,3,5,224,137,1
	DC.B 0,0,139,223,0,17,9,225,137,31,141,0,223
	DC.B 0,3,5,224,137,1,0,0,223,0,1,9,225
	DC.B 137,7,141,0,137,21,141,0,137,7,141,0,223
	DC.B 0,3,5,224,137,1,0,0,223,0,1,9,227
	DC.B 137,7,141,0,135
R0_51110	DC.B 188,139,223,0,1,9,225,137,31,141,0,223,0
	DC.B 3,5,137,1,0,223,0,1,9,137,7,141,0
	DC.B 137,21,141,0,137,31,141,0,223,0,3,5,137
	DC.B 1,0,223,0,1,9,137,7,141,0,137,1,0
	DC.B 139,223,0,1,9,225,137,31,141,0,223,0,3
	DC.B 5,137,1,0,223,0,1,9,224,137,7,0,0
	DC.B 225,137,1,0,225,137,31,141,0,223,0,3,5
	DC.B 137,1,0,223,0,2,5,225,137,7,141,0,224
	DC.B 137,1,0,0,135
R0_51219	DC.B 138,136,1,2,130,223,0,17,8,224,14,14,14
	DC.B 26,14,14,26,14,14,14,14,26,14,14,26,14
	DC.B 14,14,14,26,14,14,26,14,14,14,26,26,14
	DC.B 26,38,50,135
R0_51262	DC.B 138,136,1,2,130,223,0,17,8,224,10,10,10
	DC.B 22,10,10,22,10,10,10,10,22,10,10,22,10
	DC.B 10,10,10,22,10,10,22,10,10,10,22,22,10
	DC.B 22,34,46,135
R0_51305	DC.B 138,136,1,2,130,223,0,17,8,224,5,5,5
	DC.B 17,5,5,17,5,5,5,5,17,5,5,17,5
	DC.B 5,5,5,17,5,5,17,5,5,5,17,17,5
	DC.B 17,29,41,135
R0_51348	DC.B 138,136,1,2,130,223,0,17,8,224,12,12,12
	DC.B 24,12,12,24,12,12,12,12,24,12,12,24,12
	DC.B 12,12,12,24,12,12,24,12,12,12,24,24,12
	DC.B 24,36,48,135
R0_51391	DC.B 138,136,1,2,130,223,0,17,8,224,11,11,11
	DC.B 23,11,11,23,11,11,11,23,23,11,23,35,47
	DC.B 14,14,14,26,14,14,26,14,14,14,26,26,14
	DC.B 26,38,50,135
R0_51434	DC.B 138,136,1,2,130,223,0,17,8,224,18,18,18
	DC.B 30,18,18,30,18,18,18,18,30,18,18,30,18
	DC.B 18,18,18,30,18,18,30,18,18,18,30,30,18
	DC.B 30,42,54,135
R0_51477	DC.B 138,136,1,2,130,223,0,17,8,224,9,9,9
	DC.B 21,9,9,33,21,9,9,21,21,9,21,33,45
	DC.B 18,18,18,30,18,18,30,18,18,18,30,30,18
	DC.B 30,42,54,135
R0_51520	DC.B 138,136,1,2,130,223,0,81,5,225,45,41,38
	DC.B 227,200,46,229,200,45,225,41,38,33,227,200,58
	DC.B 229,200,57,135
R0_51550	DC.B 138,136,1,2,130,223,0,81,5,225,41,38,34
	DC.B 227,200,45,229,200,46,225,38,34,29,227,200,57
	DC.B 229,200,58,135
R0_51580	DC.B 138,136,1,2,130,223,0,81,5,225,45,41,36
	DC.B 227,200,46,229,200,45,225,41,36,33,227,200,58
	DC.B 229,200,57,135
R0_51610	DC.B 138,136,1,2,130,223,0,81,5,225,43,40,36
	DC.B 227,200,46,229,200,45,225,48,46,45,227,200,57
	DC.B 229,200,58,135
R0_51640	DC.B 138,136,1,2,130,223,0,65,5,227,192,50,224
	DC.B 223,0,17,7,57,53,50,45,53,50,45,41,50
	DC.B 45,41,38,227,192,62,224,45,41,38,33,41,38
	DC.B 33,29,38,33,29,26,135
R0_51686	DC.B 138,136,1,2,130,223,0,65,5,227,193,46,224
	DC.B 223,0,17,7,58,53,50,46,53,50,46,41,50
	DC.B 46,41,38,227,193,58,224,46,41,38,34,41,38
	DC.B 34,29,38,34,29,26,135
R0_51732	DC.B 138,136,1,2,130,223,0,65,5,227,193,41,224
	DC.B 223,0,17,7,60,57,53,48,57,53,48,45,53
	DC.B 48,45,41,227,193,53,224,48,45,41,36,45,41
	DC.B 36,33,41,36,33,29,135
R0_51778	DC.B 138,136,1,2,130,223,0,65,5,227,193,36,224
	DC.B 223,0,17,7,60,55,52,48,55,52,48,43,52
	DC.B 48,43,40,227,193,48,224,48,43,40,36,43,40
	DC.B 36,31,40,36,31,28,135
R0_51824	DC.B 138,136,1,2,130,223,0,33,5,225,42,42,224
	DC.B 40,225,38,40,226,42,227,200,42,225,42,42,224
	DC.B 40,225,38,228,42,227,200,42,135
R0_51859	DC.B 138,136,1,2,130,223,0,49,5,225,128,47,224
	DC.B 47,225,47,232,200,45,225,128,194,47,224,194,47
	DC.B 225,194,47,232,132,8,10,195,45,135
R0_51895	DC.B 138,136,1,2,130,223,0,49,5,225,42,42,224
	DC.B 40,225,38,40,226,42,227,200,42,225,50,45,42
	DC.B 40,42,229,40,135
R0_51926	DC.B 138,136,1,2,130,223,0,49,5,235,132,8,16
	DC.B 42,225,200,42,229,200,37,225,200,37,233,200,30
	DC.B 135
R0_51953	DC.B 138,136,1,2,130,223,0,49,5,225,45,45,47
	DC.B 49,49,224,50,226,49,225,47,225,42,42,45,224
	DC.B 42,232,132,9,16,47,135
R0_51986	DC.B 138,136,1,2,130,223,0,65,5,225,33,33,35
	DC.B 37,37,224,38,226,37,225,35,225,30,30,33,30
	DC.B 42,224,35,225,42,226,200,47,135
R0_52021	DC.B 138,136,1,2,130,223,0,33,5,224,192,71,192
	DC.B 71,196,59,196,59,198,59,198,59,192,59,192,59
	DC.B 196,47,196,47,198,47,198,47,192,47,192,47,196
	DC.B 35,196,35,193,62,193,62,197,50,197,50,199,50
	DC.B 199,50,193,50,193,50,197,38,197,38,199,38,199
	DC.B 38,193,38,193,38,197,26,197,26,135
R0_52096	DC.B 138,136,1,2,130,223,0,33,5,224,192,78,192
	DC.B 78,196,66,196,66,198,66,198,66,192,66,192,66
	DC.B 196,54,196,54,198,54,198,54,192,54,192,54,196
	DC.B 42,196,42,192,30,192,30,198,30,198,30,196,30
	DC.B 196,30,192,42,192,42,198,42,198,42,196,42,196
	DC.B 42,192,54,192,54,198,54,198,54,135
R0_52171	DC.B 138,136,1,2,130,223,0,33,5,224,193,69,193
	DC.B 69,197,57,197,57,199,57,199,57,193,57,193,57
	DC.B 197,45,197,45,199,45,199,45,193,45,193,45,197
	DC.B 33,197,33,192,30,192,30,198,30,198,30,196,30
	DC.B 196,30,192,42,192,42,198,42,198,42,196,42,196
	DC.B 42,192,54,192,54,198,54,198,54,135
R0_52246	DC.B 138,136,1,2,130,223,0,33,5,224,193,69,193
	DC.B 69,197,57,197,57,199,57,199,57,193,57,193,57
	DC.B 197,45,197,45,199,45,199,45,193,45,193,45,197
	DC.B 33,197,33,192,30,192,30,198,54,198,54,196,42
	DC.B 196,42,192,66,192,66,198,42,198,42,196,54,196
	DC.B 54,192,66,192,66,198,78,198,78,135
R0_52321	DC.B 138,136,1,2,130,223,0,81,5,225,33,33,33
	DC.B 227,200,34,200,33,200,46,200,45,200,58,229,200
	DC.B 57,135
R0_52349	DC.B 138,136,1,2,130,223,0,81,5,225,33,33,33
	DC.B 227,200,31,200,33,200,43,200,45,200,55,229,200
	DC.B 57,135
R0_52377	DC.B 138,136,1,2,130,223,0,81,5,225,29,29,29
	DC.B 227,200,32,200,31,200,44,200,43,200,56,229,200
	DC.B 55,135
R0_52405	DC.B 138,136,1,2,130,223,0,81,5,225,29,29,29
	DC.B 227,200,27,200,24,200,39,200,36,200,51,229,200
	DC.B 48,135
R0_52433	DC.B 138,136,1,2,130,212,241,241,244,255,132,254,60
	DC.B 192,38,135
R0_52449	DC.B 138,136,1,2,130,212,241,241,244,255,132,254,60
	DC.B 192,34,135
R0_52465	DC.B 138,136,1,2,130,212,241,241,243,255,132,254,60
	DC.B 192,29,135
R0_52481	DC.B 138,136,1,2,130,212,241,241,243,255,132,254,60
	DC.B 192,36,135
R0_52497	DC.B 138,136,1,2,130,223,0,97,5,225,132,120,1
	DC.B 24,132,120,1,24,132,120,1,24,227,132,120,1
	DC.B 20,229,128,225,132,120,1,36,132,120,1,36,132
	DC.B 120,1,36,227,132,120,1,36,225,132,120,1,41
	DC.B 132,120,1,36,132,120,1,29,135
R0_52558	DC.B 138,136,1,2,130,223,0,241,1,255,134,0,135
R0_52571	DC.B 138,136,1,2,130,223,0,241,1,255,134,1,135
R0_52584	DC.B 138,223,0,241,1,255,128,135
R0_52592	DC.B 188,138,136,1,2,130,223,0,33,9,225,12,12
	DC.B 12,12,12,12,12,12,12,12,12,12,12,12,223
	DC.B 0,17,9,224,12,12,12,12,135
R0_52627	DC.B 188,138,136,1,2,130,223,0,33,9,225,7,7
	DC.B 7,7,7,7,7,7,7,7,7,7,7,7,223
	DC.B 0,17,9,224,7,7,7,7,135
R0_52662	DC.B 188,138,136,1,2,130,223,0,33,9,225,17,17
	DC.B 17,17,17,17,17,17,17,17,17,17,17,17,223
	DC.B 0,17,9,224,17,17,17,17,135
R0_52697	DC.B 188,138,136,1,2,130,223,0,33,9,225,19,19
	DC.B 19,19,19,19,19,19,19,19,19,19,19,19,223
	DC.B 0,17,9,224,19,31,43,55,135
R0_52732	DC.B 188,138,136,1,2,130,219,0,17,1,132,1,50
	DC.B 255,197,48,135
R0_52749	DC.B 188,138,136,1,2,130,219,0,17,1,132,1,50
	DC.B 255,193,55,135
R0_52766	DC.B 188,138,136,1,2,130,219,0,17,1,132,1,50
	DC.B 255,197,53,135
R0_52783	DC.B 188,138,136,1,2,130,219,0,17,1,132,1,50
	DC.B 255,197,55,135
R0_52800	DC.B 188,138,136,2,2,130,216,18,129,21,233,64,225
	DC.B 55,60,64,227,65,231,64,227,65,135
R0_52823	DC.B 188,138,136,1,2,130,216,18,129,21,233,64,225
	DC.B 55,59,62,227,65,231,64,227,67,135
R0_52846	DC.B 188,138,136,1,2,130,216,18,129,21,233,65,225
	DC.B 53,57,60,227,64,231,65,227,64,135
R0_52869	DC.B 188,138,136,1,2,130,216,18,129,21,233,67,225
	DC.B 55,59,62,227,64,231,65,227,64,135
	END
