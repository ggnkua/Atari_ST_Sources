	DC.W	56
	DC.W	15*1536
	DC.W	56
	DC.W	15*1536
	DC.W	56
	DC.W	14*1536
	DC.W	56
	DC.W	12*1536
	DC.W	56
	DC.W	11*1536
	DC.W	56
	DC.W	9*1536
	DC.W	56
	DC.W	7*1536
	DC.W	56
	DC.W	5*1536
	DC.W	56
	DC.W	2*1536
	DC.W	48
	DC.W	15*1536
	DC.W	48
	DC.W	12*1536
	DC.W	48
	DC.W	9*1536
	DC.W	48
	DC.W	5*1536
	DC.W	48
	DC.W	1*1536
	DC.W	40
	DC.W	14*1536
	DC.W	40
	DC.W	10*1536
	DC.W	40
	DC.W	5*1536
	DC.W	40
	DC.W	1*1536
	DC.W	32
	DC.W	13*1536
	DC.W	32
	DC.W	8*1536
	DC.W	32
	DC.W	4*1536
	DC.W	32
	DC.W	0*1536
	DC.W	24
	DC.W	11*1536
	DC.W	24
	DC.W	7*1536
	DC.W	24
	DC.W	2*1536
	DC.W	16
	DC.W	14*1536
	DC.W	16
	DC.W	10*1536
	DC.W	16
	DC.W	5*1536
	DC.W	16
	DC.W	1*1536
	DC.W	8
	DC.W	14*1536
	DC.W	8
	DC.W	10*1536
	DC.W	8
	DC.W	6*1536
	DC.W	8
	DC.W	3*1536
	DC.W	8
	DC.W	0*1536
	DC.W	0
	DC.W	13*1536
	DC.W	0
	DC.W	10*1536
	DC.W	0
	DC.W	8*1536
	DC.W	0
	DC.W	6*1536
	DC.W	0
	DC.W	4*1536
	DC.W	0
	DC.W	3*1536
	DC.W	0
	DC.W	1*1536
	DC.W	0
	DC.W	0*1536
	DC.W	0
	DC.W	0*1536
	DC.W	0
	DC.W	0*1536
	DC.W	0
	DC.W	0*1536
	DC.W	0
	DC.W	0*1536
	DC.W	0
	DC.W	0*1536
	DC.W	0
	DC.W	1*1536
	DC.W	0
	DC.W	3*1536
	DC.W	0
	DC.W	4*1536
	DC.W	0
	DC.W	6*1536
	DC.W	0
	DC.W	8*1536
	DC.W	0
	DC.W	10*1536
	DC.W	0
	DC.W	13*1536
	DC.W	8
	DC.W	0*1536
	DC.W	8
	DC.W	3*1536
	DC.W	8
	DC.W	6*1536
	DC.W	8
	DC.W	10*1536
	DC.W	8
	DC.W	14*1536
	DC.W	16
	DC.W	1*1536
	DC.W	16
	DC.W	5*1536
	DC.W	16
	DC.W	10*1536
	DC.W	16
	DC.W	14*1536
	DC.W	24
	DC.W	2*1536
	DC.W	24
	DC.W	7*1536
	DC.W	24
	DC.W	11*1536
