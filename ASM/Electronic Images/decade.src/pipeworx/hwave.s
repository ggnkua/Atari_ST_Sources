	DC.W	64
	DC.L	12*5888
	DC.W	72
	DC.L	2*5888
	DC.W	72
	DC.L	8*5888
	DC.W	72
	DC.L	13*5888
	DC.W	80
	DC.L	2*5888
	DC.W	80
	DC.L	7*5888
	DC.W	80
	DC.L	11*5888
	DC.W	80
	DC.L	14*5888
	DC.W	88
	DC.L	0*5888
	DC.W	88
	DC.L	1*5888
	DC.W	88
	DC.L	2*5888
	DC.W	88
	DC.L	1*5888
	DC.W	80
	DC.L	15*5888
	DC.W	80
	DC.L	11*5888
	DC.W	80
	DC.L	7*5888
	DC.W	80
	DC.L	2*5888
	DC.W	72
	DC.L	11*5888
	DC.W	72
	DC.L	4*5888
	DC.W	64
	DC.L	12*5888
	DC.W	64
	DC.L	3*5888
	DC.W	56
	DC.L	9*5888
	DC.W	48
	DC.L	15*5888
	DC.W	48
	DC.L	4*5888
	DC.W	40
	DC.L	10*5888
	DC.W	32
	DC.L	15*5888
	DC.W	32
	DC.L	4*5888
	DC.W	24
	DC.L	10*5888
	DC.W	24
	DC.L	0*5888
	DC.W	16
	DC.L	7*5888
	DC.W	8
	DC.L	14*5888
	DC.W	8
	DC.L	6*5888
	DC.W	8
	DC.L	0*5888
	DC.W	0
	DC.L	10*5888
	DC.W	0
	DC.L	5*5888
	DC.W	0
	DC.L	2*5888
	DC.W	0
	DC.L	0*5888
	DC.W	0
	DC.L	0*5888
	DC.W	0
	DC.L	0*5888
	DC.W	0
	DC.L	2*5888
	DC.W	0
	DC.L	5*5888
	DC.W	0
	DC.L	10*5888
	DC.W	8
	DC.L	0*5888
	DC.W	8
	DC.L	6*5888
	DC.W	8
	DC.L	14*5888
	DC.W	16
	DC.L	7*5888
	DC.W	24
	DC.L	0*5888
	DC.W	24
	DC.L	10*5888
	DC.W	32
	DC.L	4*5888
	DC.W	32
	DC.L	15*5888
	DC.W	40
	DC.L	10*5888
	DC.W	48
	DC.L	4*5888
	DC.W	48
	DC.L	15*5888
	DC.W	56
	DC.L	9*5888
	DC.W	64
	DC.L	3*5888
	DC.W	64
	DC.L	12*5888
	DC.W	72
	DC.L	4*5888
	DC.W	72
	DC.L	11*5888
	DC.W	80
	DC.L	2*5888
	DC.W	80
	DC.L	7*5888
	DC.W	80
	DC.L	11*5888
	DC.W	80
	DC.L	15*5888
	DC.W	88
	DC.L	1*5888
	DC.W	88
	DC.L	2*5888
	DC.W	88
	DC.L	1*5888
	DC.W	88
	DC.L	0*5888
	DC.W	80
	DC.L	14*5888
	DC.W	80
	DC.L	11*5888
	DC.W	80
	DC.L	7*5888
	DC.W	80
	DC.L	2*5888
	DC.W	72
	DC.L	13*5888
	DC.W	72
	DC.L	8*5888
	DC.W	72
	DC.L	2*5888
	DC.W	64
	DC.L	12*5888
	DC.W	64
	DC.L	5*5888
	DC.W	56
	DC.L	15*5888
	DC.W	56
	DC.L	10*5888
	DC.W	56
	DC.L	5*5888
	DC.W	56
	DC.L	0*5888
	DC.W	48
	DC.L	12*5888
	DC.W	48
	DC.L	9*5888
	DC.W	48
	DC.L	7*5888
	DC.W	48
	DC.L	6*5888
	DC.W	48
	DC.L	5*5888
	DC.W	48
	DC.L	6*5888
	DC.W	48
	DC.L	9*5888
	DC.W	48
	DC.L	12*5888
	DC.W	56
	DC.L	0*5888
	DC.W	56
	DC.L	5*5888
	DC.W	56
	DC.L	12*5888
	DC.W	64
	DC.L	3*5888
	DC.W	64
	DC.L	12*5888
	DC.W	72
	DC.L	4*5888
	DC.W	72
	DC.L	14*5888
	DC.W	80
	DC.L	8*5888
	DC.W	88
	DC.L	3*5888
	DC.W	88
	DC.L	13*5888
	DC.W	96
	DC.L	8*5888
	DC.W	104
	DC.L	3*5888
	DC.W	104
	DC.L	13*5888
	DC.W	112
	DC.L	7*5888
	DC.W	120
	DC.L	0*5888
	DC.W	120
	DC.L	9*5888
	DC.W	128
	DC.L	1*5888
	DC.W	128
	DC.L	7*5888
	DC.W	128
	DC.L	13*5888
	DC.W	136
	DC.L	2*5888
	DC.W	136
	DC.L	5*5888
	DC.W	136
	DC.L	7*5888
	DC.W	136
	DC.L	8*5888
	DC.W	136
	DC.L	7*5888
	DC.W	136
	DC.L	5*5888
	DC.W	136
	DC.L	2*5888
	DC.W	128
	DC.L	13*5888
	DC.W	128
	DC.L	7*5888
	DC.W	128
	DC.L	1*5888
	DC.W	120
	DC.L	9*5888
	DC.W	120
	DC.L	0*5888
	DC.W	112
	DC.L	7*5888
	DC.W	104
	DC.L	13*5888
	DC.W	104
	DC.L	3*5888
	DC.W	96
	DC.L	8*5888
	DC.W	88
	DC.L	13*5888
	DC.W	88
	DC.L	3*5888
	DC.W	80
	DC.L	8*5888
	DC.W	72
	DC.L	14*5888
	DC.W	72
	DC.L	4*5888
	DC.W	64
	DC.L	12*5888
	DC.W	64
	DC.L	3*5888
	DC.W	56
	DC.L	12*5888
	DC.W	56
	DC.L	5*5888
	DC.W	56
	DC.L	0*5888
	DC.W	48
	DC.L	12*5888
	DC.W	48
	DC.L	9*5888
	DC.W	48
	DC.L	6*5888
	DC.W	48
	DC.L	5*5888
	DC.W	48
	DC.L	6*5888
	DC.W	48
	DC.L	7*5888
	DC.W	48
	DC.L	9*5888
	DC.W	48
	DC.L	12*5888
	DC.W	56
	DC.L	0*5888
	DC.W	56
	DC.L	5*5888
	DC.W	56
	DC.L	10*5888
	DC.W	56
	DC.L	15*5888
	DC.W	64
	DC.L	5*5888
