	DC.W	11840
	DC.W	12480
	DC.W	13120
	DC.W	13760
	DC.W	14240
	dc.w	14880
	DC.W	15360
	DC.W	15840
	DC.W	16160
	dc.w	16480
	DC.W	16800
	DC.W	16960
	DC.W	17120
	DC.W	17120
	DC.W	16960
	DC.W	16800
	DC.W	16640
	DC.W	16480
	DC.W	16000
	DC.W	15680
	DC.W	15200
	DC.W	14720
	DC.W	14240
	DC.W	13760
	dc.w	13280
	DC.W	12640
	DC.W	12160
	DC.W	11680
	DC.W	11040
	DC.W	10560
	DC.W	10240
	DC.W	9760
	DC.W	9440
	DC.W	9120
	DC.W	8800
	DC.W	8640
	DC.W	8320
	DC.W	8320
	DC.W	8160
	DC.W	8160
	DC.W	8160
	DC.W	8160
	DC.W	8320
	DC.W	8320
	DC.W	8480
	DC.W	8640
	DC.W	8640
	DC.W	8800
	DC.W	8800
	DC.W	8960
	DC.W	8960
	DC.W	8960
	DC.W	8960
	DC.W	8800
	DC.W	8800
	DC.W	8640
	DC.W	8320
	DC.W	8000
	DC.W	7680
	DC.W	7360
	DC.W	7040
	DC.W	6560
	DC.W	6080
	DC.W	5440
	DC.W	4960
	DC.W	4480
	DC.W	3840
	DC.W	3360
	DC.W	2880
	DC.W	2400
	DC.W	1920
	DC.W	1440
	DC.W	1120
	DC.W	640
	DC.W	480
	DC.W	320
	DC.W	160
	DC.W	0
	DC.W	0
	DC.W	160
	DC.W	320
	DC.W	640
	DC.W	960
	DC.W	1280
	DC.W	1760
	DC.W	2240
	DC.W	2880
	DC.W	3360
	DC.W	4000
	DC.W	4640
	DC.W	5440
	DC.W	6080
	DC.W	6720
	DC.W	7360
	DC.W	8000
	DC.W	8640
	DC.W	9120
	DC.W	9600
	DC.W	10080
	DC.W	10400
	DC.W	10720
	DC.W	11040
	DC.W	11200
	DC.W	11360
	DC.W	11360
	DC.W	11360
	DC.W	11200
	DC.W	11040
	DC.W	10880
	DC.W	10720
	DC.W	10400
	DC.W	10080
	DC.W	9600
	DC.W	9280
	DC.W	8960
	DC.W	8640
	DC.W	8160
	DC.W	7840
	DC.W	7520
	DC.W	7200
	DC.W	7040
	DC.W	6720
	DC.W	6560
	DC.W	6400
	DC.W	6400
	DC.W	6400
	DC.W	6400
	DC.W	6560
	DC.W	6560
	DC.W	6880
	DC.W	7040
	DC.W	7360
	DC.W	7520
	DC.W	7840
	DC.W	8160
	DC.W	8640
	DC.W	8960
	DC.W	9280
	DC.W	9600
	DC.W	9760
	DC.W	10080
	DC.W	10240
	DC.W	10560
	DC.W	10560
	DC.W	10720
	DC.W	10720
	DC.W	10720
	DC.W	10720
	DC.W	10560
	DC.W	10400
	DC.W	10240
	DC.W	9920
	DC.W	9600
	DC.W	9280
	DC.W	8960
	DC.W	8640
	DC.W	8160
	DC.W	7840
	DC.W	7520
	DC.W	7040
	DC.W	6720
	DC.W	6400
	DC.W	6240
	DC.W	6080
	DC.W	5920
	DC.W	5760
	DC.W	5760
	DC.W	5760
	DC.W	5920
	DC.W	6080
	DC.W	6400
	DC.W	6720
	DC.W	7040
	DC.W	7520
	DC.W	8000
	DC.W	8640
	DC.W	9120
	DC.W	9760
	DC.W	10400
	DC.W	11040
