FontData
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00011000
	dc.b	%00011000
	dc.b	%00011000
	dc.b	%00000000
	dc.b	%00011000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%01100110
	dc.b	%01100110
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%01101100
	dc.b	%11111110
	dc.b	%01101100
	dc.b	%11111110
	dc.b	%01101100
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%01111110
	dc.b	%11010000
	dc.b	%01111100
	dc.b	%00010110
	dc.b	%11111100
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%01100110
	dc.b	%01101100
	dc.b	%00011000
	dc.b	%00110110
	dc.b	%01100110
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00110000
	dc.b	%01001000
	dc.b	%00111010
	dc.b	%01000100
	dc.b	%00111010
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00001100
	dc.b	%00001100
	dc.b	%00011000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00001100
	dc.b	%00011000
	dc.b	%00011000
	dc.b	%00011000
	dc.b	%00001100
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00011000
	dc.b	%00001100
	dc.b	%00001100
	dc.b	%00001100
	dc.b	%00011000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%01000100
	dc.b	%00111000
	dc.b	%01111100
	dc.b	%00111000
	dc.b	%01000100
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00010000
	dc.b	%00010000
	dc.b	%01111100
	dc.b	%00010000
	dc.b	%00010000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00001100
	dc.b	%00011000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00000000
	dc.b	%00000000
	dc.b	%01111100
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00011000
	dc.b	%00011000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00000110
	dc.b	%00001100
	dc.b	%00011000
	dc.b	%00110000
	dc.b	%01100000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00111100
	dc.b	%01101110
	dc.b	%01110110
	dc.b	%01100110
	dc.b	%00111100
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00011000
	dc.b	%00111000
	dc.b	%00011000
	dc.b	%00011000
	dc.b	%00111100
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%01111100
	dc.b	%00000110
	dc.b	%00111100
	dc.b	%01100000
	dc.b	%01111110
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%01111100
	dc.b	%00000110
	dc.b	%00011100
	dc.b	%00000110
	dc.b	%01111100
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00011100
	dc.b	%00111100
	dc.b	%01101100
	dc.b	%01111110
	dc.b	%00001100
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%01111110
	dc.b	%01100000
	dc.b	%01111100
	dc.b	%00000110
	dc.b	%01111100
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00111110
	dc.b	%01100000
	dc.b	%01111100
	dc.b	%01100110
	dc.b	%00111100
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%01111110
	dc.b	%00000110
	dc.b	%00001100
	dc.b	%00011000
	dc.b	%00011000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00111100
	dc.b	%01100110
	dc.b	%00111100
	dc.b	%01100110
	dc.b	%00111100
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00111100
	dc.b	%01100110
	dc.b	%00111110
	dc.b	%00000110
	dc.b	%01111100
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00011000
	dc.b	%00011000
	dc.b	%00000000
	dc.b	%00011000
	dc.b	%00011000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00011000
	dc.b	%00011000
	dc.b	%00000000
	dc.b	%00011000
	dc.b	%00110000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00001100
	dc.b	%00011000
	dc.b	%00110000
	dc.b	%00011000
	dc.b	%00001100
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00000000
	dc.b	%00111100
	dc.b	%00000000
	dc.b	%00111100
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00110000
	dc.b	%00011000
	dc.b	%00001100
	dc.b	%00011000
	dc.b	%00110000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%01111100
	dc.b	%00000110
	dc.b	%00011100
	dc.b	%00000000
	dc.b	%00011000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00111100
	dc.b	%01101110
	dc.b	%01101110
	dc.b	%01100000
	dc.b	%00111100
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00111100
	dc.b	%01100110
	dc.b	%01111110
	dc.b	%01100110
	dc.b	%01100110
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%01111100
	dc.b	%01100110
	dc.b	%01111100
	dc.b	%01100110
	dc.b	%01111100
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00111100
	dc.b	%01100110
	dc.b	%01100000
	dc.b	%01100110
	dc.b	%00111100
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%01111100
	dc.b	%01100110
	dc.b	%01100110
	dc.b	%01100110
	dc.b	%01111100
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%01111110
	dc.b	%01100000
	dc.b	%01111000
	dc.b	%01100000
	dc.b	%01111110
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%01111110
	dc.b	%01100000
	dc.b	%01111000
	dc.b	%01100000
	dc.b	%01100000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00111110
	dc.b	%01100000
	dc.b	%01101110
	dc.b	%01100110
	dc.b	%00111110
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%01100110
	dc.b	%01100110
	dc.b	%01111110
	dc.b	%01100110
	dc.b	%01100110
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00111100
	dc.b	%00011000
	dc.b	%00011000
	dc.b	%00011000
	dc.b	%00111100
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%01111110
	dc.b	%00000110
	dc.b	%00000110
	dc.b	%01100110
	dc.b	%00111100
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%01100110
	dc.b	%01101100
	dc.b	%01111000
	dc.b	%01101100
	dc.b	%01100110
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%01100000
	dc.b	%01100000
	dc.b	%01100000
	dc.b	%01100000
	dc.b	%01111110
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%01000010
	dc.b	%01100110
	dc.b	%01111110
	dc.b	%01100110
	dc.b	%01100110
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%01100110
	dc.b	%01110110
	dc.b	%01111110
	dc.b	%01101110
	dc.b	%01100110
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00111100
	dc.b	%01100110
	dc.b	%01100110
	dc.b	%01100110
	dc.b	%00111100
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%01111100
	dc.b	%01100110
	dc.b	%01111100
	dc.b	%01100000
	dc.b	%01100000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00111100
	dc.b	%01100110
	dc.b	%01100110
	dc.b	%01101100
	dc.b	%00110110
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%01111100
	dc.b	%01100110
	dc.b	%01111100
	dc.b	%01101100
	dc.b	%01100110
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00111110
	dc.b	%01100000
	dc.b	%00111100
	dc.b	%00000110
	dc.b	%01111100
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%01111110
	dc.b	%00011000
	dc.b	%00011000
	dc.b	%00011000
	dc.b	%00011000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%01100110
	dc.b	%01100110
	dc.b	%01100110
	dc.b	%01100110
	dc.b	%00111100
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%01100110
	dc.b	%01100110
	dc.b	%01100110
	dc.b	%00111100
	dc.b	%00011000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%01100110
	dc.b	%01100110
	dc.b	%01111110
	dc.b	%01100110
	dc.b	%01000010
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%01100110
	dc.b	%00111100
	dc.b	%00011000
	dc.b	%00111100
	dc.b	%01100110
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%01100110
	dc.b	%01100110
	dc.b	%00111100
	dc.b	%00011000
	dc.b	%00011000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%01111110
	dc.b	%00001100
	dc.b	%00011000
	dc.b	%00110000
	dc.b	%01111110
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00111100
	dc.b	%00110000
	dc.b	%00110000
	dc.b	%00110000
	dc.b	%00111100
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%01100000
	dc.b	%00110000
	dc.b	%00011000
	dc.b	%00001100
	dc.b	%00000110
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00111100
	dc.b	%00001100
	dc.b	%00001100
	dc.b	%00001100
	dc.b	%00111100
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00010000
	dc.b	%00111000
	dc.b	%01101100
	dc.b	%01000100
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%01111110
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%01100000
	dc.b	%01100000
	dc.b	%01111000
	dc.b	%01101100
	dc.b	%01111000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00011100
	dc.b	%00100000
	dc.b	%01100000
	dc.b	%00100000
	dc.b	%00011100
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00011000
	dc.b	%00011000
	dc.b	%00011000
	dc.b	%00011000
	dc.b	%00011000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00111000
	dc.b	%00000100
	dc.b	%00000110
	dc.b	%00000100
	dc.b	%00111000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00111011
	dc.b	%01101110
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00110000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000

	dc.b	%00000000
	dc.b	%00110000
	dc.b	%00000000
	dc.b	%00110000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
	dc.b	%00000000
