	dc.w	69,69,69,68,67,67,66,64
	dc.w	63,62,60,58,56,54,52,50
	dc.w	48,46,44,42,40,38,36,34
	dc.w	32,30,28,27,26,24,23,23
	dc.w	22,21,21,21,21,21,22,23
	dc.w	23,24,26,27,28,30,32,34
	dc.w	36,38,40,42,44,46,48,50
	dc.w	52,54,56,58,60,62,63,64
	dc.w	66,67,67,68,69,69
