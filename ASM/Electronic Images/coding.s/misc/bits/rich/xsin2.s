	dc.w	125,125,124,123,121,119,117,114
	dc.w	111,108,104,100,96,92,87,83
	dc.w	79,74,70,66,62,58,55,52
	dc.w	49,47,45,43,42,41,41,41
	dc.w	42,43,45,47,49,52,55,58
	dc.w	62,66,70,74,79,83,87,92
	dc.w	96,100,104,108,111,114,117,119
	dc.w	121,123,124,125
