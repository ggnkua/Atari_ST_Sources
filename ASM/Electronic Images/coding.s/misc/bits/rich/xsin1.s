	dc.w	149,149,148,147,145,143,141,138
	dc.w	135,132,128,124,120,115,110,105
	dc.w	101,96,90,85,81,76,71,66
	dc.w	62,58,54,51,48,45,43,41
	dc.w	39,38,37,37,37,38,39,41
	dc.w	43,45,48,51,54,58,62,66
	dc.w	71,76,81,85,90,96,101,105
	dc.w	110,115,120,124,128,132,135,138
	dc.w	141,143,145,147,148,149
