	dc.b	'........WELCOME TO THE             '
	DC.B	'GOLDEN PEANUT DEMO ...........     '
	DC.B    'THE ENTIRE THING IS DRAWN IN REAL-TIME '
	DC.B    'THE LIGHT-SOURCING ROTATES IN 3D TOO.. '
	DC.B	'THE BEZIER SURFACES ARE RECALCULATED AT 50 HERTZ '
	DC.B	'IN TIME TO THE MUSIC.. '
	DC.B	'THERE ARE OVER 60 SHADES OF COLOUR... '
	DC.B	'ETC ETC (BORING)...    '
	DC.B	'THE BEZIER BITS, GRID DRAWING, '
	DC.B	'LIGHTING ALGORITHM, FONT, ETC & '
	DC.B	'GENERAL CONCEPT BY  ME...  -YAMA-  '
	DC.B	'    THE POLYFILL, SCROLLER, AND STUFF '
	DC.B	'DONE BY MY MATE,  -THE PHANTOM-'
	DC.B	'      THANKS TO HIM (& KNIFEST) FOR '
	DC.B	'SAVING THE ENTIRE LOT FROM A CORRUPTED '
	DC.B	'DISK...'
	DC.B	'THE MUSIC IS (PROBABLY) BY COUNT ZERO.. CHEERS. '
	DC.B	'                      '
	DC.B	'MESSAGES ARE:          NAOMI,I LOVE YOU LOADS,'
	DC.B    'AND I WANT TO SPEND THE REST OF MY LIFE WITH YOU...'
	DC.B	'                                 '
	DC.B	'NOW GET READY TO SEE THAT PEANUT DANCE...          '
	DC.B    '      '
	
	