; Single Cube (joined with lines)

box		DC.L 0
		DC.W 8
		DC.W +400,+400,+400
		DC.W -400,+400,+400
		DC.W +400,-400,+400
		DC.W -400,-400,+400
		DC.W +400,+400,-400
		DC.W -400,+400,-400
		DC.W +400,-400,-400
		DC.W -400,-400,-400
		DC.W 8
		DC.W BALLOBJ,00*6,00*64
		DC.W BALLOBJ,01*6,00*64
		DC.W BALLOBJ,02*6,00*64
		DC.W BALLOBJ,03*6,00*64
		DC.W BALLOBJ,04*6,00*64
		DC.W BALLOBJ,05*6,00*64
		DC.W BALLOBJ,06*6,00*64
		DC.W BALLOBJ,07*6,00*64
		DC.W 12
		DC.W LINEOBJ,00*6,01*6
		DC.W LINEOBJ,01*6,03*6
		DC.W LINEOBJ,02*6,00*6
		DC.W LINEOBJ,02*6,03*6
		DC.W LINEOBJ,04*6,05*6
		DC.W LINEOBJ,05*6,07*6
		DC.W LINEOBJ,06*6,04*6
		DC.W LINEOBJ,06*6,07*6
		DC.W LINEOBJ,00*6,04*6
		DC.W LINEOBJ,01*6,05*6
		DC.W LINEOBJ,02*6,06*6
		DC.W LINEOBJ,03*6,07*6

box2		DC.L 0
		DC.W 16
		DC.W +250,+250,+250
		DC.W -250,+250,+250
		DC.W +250,-250,+250
		DC.W -250,-250,+250
		DC.W +250,+250,-250
		DC.W -250,+250,-250
		DC.W +250,-250,-250
		DC.W -250,-250,-250
		DC.W +500,+500,+500
		DC.W -500,+500,+500
		DC.W +500,-500,+500
		DC.W -500,-500,+500
		DC.W +500,+500,-500
		DC.W -500,+500,-500
		DC.W +500,-500,-500
		DC.W -500,-500,-500
		DC.W 16
		DC.W BALLOBJ,00*6,03*64
		DC.W BALLOBJ,01*6,03*64
		DC.W BALLOBJ,02*6,03*64
		DC.W BALLOBJ,03*6,03*64
		DC.W BALLOBJ,04*6,03*64
		DC.W BALLOBJ,05*6,03*64
		DC.W BALLOBJ,06*6,03*64
		DC.W BALLOBJ,07*6,03*64
		DC.W BALLOBJ,08*6,00*64
		DC.W BALLOBJ,09*6,00*64
		DC.W BALLOBJ,10*6,00*64
		DC.W BALLOBJ,11*6,00*64
		DC.W BALLOBJ,12*6,00*64
		DC.W BALLOBJ,13*6,00*64
		DC.W BALLOBJ,14*6,00*64
		DC.W BALLOBJ,15*6,00*64
		DC.W 24
		DC.W LINEOBJ,00*6,01*6
		DC.W LINEOBJ,01*6,03*6
		DC.W LINEOBJ,02*6,00*6
		DC.W LINEOBJ,02*6,03*6
		DC.W LINEOBJ,04*6,05*6
		DC.W LINEOBJ,05*6,07*6
		DC.W LINEOBJ,06*6,04*6
		DC.W LINEOBJ,06*6,07*6
		DC.W LINEOBJ,00*6,04*6
		DC.W LINEOBJ,01*6,05*6
		DC.W LINEOBJ,02*6,06*6
		DC.W LINEOBJ,03*6,07*6
		DC.W LINEOBJ,(00+8)*6,(01+8)*6
		DC.W LINEOBJ,(01+8)*6,(03+8)*6
		DC.W LINEOBJ,(02+8)*6,(00+8)*6
		DC.W LINEOBJ,(02+8)*6,(03+8)*6
		DC.W LINEOBJ,(04+8)*6,(05+8)*6
		DC.W LINEOBJ,(05+8)*6,(07+8)*6
		DC.W LINEOBJ,(06+8)*6,(04+8)*6
		DC.W LINEOBJ,(06+8)*6,(07+8)*6
		DC.W LINEOBJ,(00+8)*6,(04+8)*6
		DC.W LINEOBJ,(01+8)*6,(05+8)*6
		DC.W LINEOBJ,(02+8)*6,(06+8)*6
		DC.W LINEOBJ,(03+8)*6,(07+8)*6
