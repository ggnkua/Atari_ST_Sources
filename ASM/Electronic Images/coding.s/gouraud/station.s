	DC.W	12
	DC.W	0,-200,200
	DC.W	0,11585,-11585
	DC.W	200,0,200
	DC.W	-11585,0,-11585
	DC.W	200,-200,0
	DC.W	-11585,11585,0
	DC.W	0,200,200
	DC.W	0,-11585,-11585
	DC.W	200,0,-200
	DC.W	-11585,0,11585
	DC.W	-200,-200,0
	DC.W	11585,11585,0
	DC.W	0,-200,-200
	DC.W	0,11585,11585
	DC.W	-200,0,200
	DC.W	11585,0,-11585
	DC.W	200,200,0
	DC.W	-11585,-11585,0
	DC.W	0,200,-200
	DC.W	0,-11585,11585
	DC.W	-200,0,-200
	DC.W	11585,0,11585
	DC.W	-200,200,0
	DC.W	11585,-11585,0
