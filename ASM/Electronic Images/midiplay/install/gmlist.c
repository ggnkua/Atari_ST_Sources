/*
 *	General Midi Instrument lists.
 *	(c) Martin Griffiths August/September 1994.
 */

#include "types.h"
 
char gm_instrument[NO_INSTRUMENT][24] = 
{ "Acoustic Grand Piano",	/* 1-8 PIANO */
  "Bright Acoustic Piano",
  "Electric Grand Piano",
  "Honky-Tonk Piano",
  "Electric Piano 1",
  "Electric Piano 2",
  "Harpsichord",
  "Clav",
  "Celesta",				/* 9-16 CHROM PERCUSSION */
  "Glockenspiel",
  "Music Box",
  "Vibraphone",
  "Marimba",
  "Xylophone",
  "Tubular Bells",
  "Dulcimer",
  "Drawbar Organ",			/* 17 -24 ORGAN */
  "Percussive Organ",
  "Rock Organ",
  "Church Organ",
  "Reed Organ",
  "Accordian",
  "Harmonica",
  "Tango Accordian",
  "Acoustic Guitar(Nylon)", /* 25-32 GUITAR */
  "Acoustic Guitar(Steel)",
  "Electric Guitar(Jazz)",
  "Electric Guitar(Clean)",
  "Electric Guitar(Muted)",
  "Overdriver Guitar",
  "Distortion Guitar",
  "Guitar Harmonics", 
  "Acoustic Bass",			/* 33-40 BASS */
  "Electric Bass(finger)",
  "Electric Bass(pick)",
  "Fretless Bass",
  "Slap Bass 1", 
  "Slap Bass 2", 
  "Synth Bass 1", 
  "Synth Bass 2", 
  "Violin",					/* 41-48 STRINGS */
  "Viola",
  "Cello",
  "Contrabass",
  "Tremelo Strings",
  "Pizzicato Strings",
  "Orchestral Strings",
  "Timpani",
  "String Ensemble 1",		/* 49-56 ENSEMBLE */
  "String Ensemble 2",
  "Synth Strings 1",
  "Synth Strings 2",
  "Choir Aahs",
  "Voices Oohs",
  "Synth Voice",
  "Orchestra Hit",
  "Trumpet",				/* 57-64 BRASS */
  "Trombone",
  "Tuba",
  "Muted Trumpet",
  "French Horn",
  "Brass Section",
  "Synth Brass 1",
  "Synth Brass 2",
  "Soprano Sax",			/* 65-72 REED */
  "Alto Sax",
  "Tenor Sax",
  "Baritona Sax",
  "Oboe",
  "English Horn",
  "Bassoon",
  "Clarinet",
  "Piccolo",				/* 73-80 PIPE */
  "Flute",
  "Recorder",
  "Pan Flute",
  "Blown Bottle",
  "Skakubachi",
  "Whistle",
  "Ocarina",
  "Lead 1 (Square)",		/* 81-88 SYNTH LEAD */
  "Lead 2 (Sawtooth)",
  "Lead 3 (Calliope)",
  "Lead 4 (Chiff)",
  "Lead 5 (Charang)",
  "Lead 6 (Voice)",
  "Lead 7 (Fifths)",
  "Lead 8 (Bass+Lead)",
  "Pad 1 (new age)",		/* 89-96 SYNTH PAD */
  "Pad 2 (warm)",
  "Pad 3 (polysynth)",
  "Pad 4 (choir)",
  "Pad 5 (bowed)",
  "Pad 6 (metallic)",
  "Pad 7 (halo)",
  "Pad 8 (sweep)",
  "FX 1 (rain)",			/* 97-104 SYNTH EFFECTS */
  "FX 2 (soundtrack)",
  "FX 3 (crystal)",
  "FX 4 (atmosphere)",
  "FX 5 (brightness)",
  "FX 6 (goblins)",
  "FX 7 (echoes)",
  "FX 8 (sci-fi)",
  "Sitar",					/* 105-112 ETHNIC */
  "Banjo",
  "Shamisen",
  "Koto",
  "Kalimba",
  "Bagpipe",
  "Fiddle",
  "Shanai",
  "Tinkle Bell",			/* 113-120 Percussive */
  "Agogo",
  "Steel Drums",
  "WoodBlock",
  "Taiko Drum",
  "Melodic Tom",
  "Synth Drum",
  "Reverse Cymbal",
  "Guitar Fret Noise",		/* 121-128 SOUND EFFECTS */
  "Breath Noise",
  "Seashore",
  "Bird Tweet",
  "Telephone Ring",
  "Helicopter",
  "Applause",
  "Gunshot"
};


char gm_percussion[NO_PERCUSSION][24] = 
{	"Acoustic Bass Drum",
	"Bass Drum",
	"Side Stick",
	"Acoustic Snare",
	"Hand Clap",
	"Electric Snare",
	"Low Floor Tom",
	"Closed Hi-Hat",
	"High Floor Tom",
	"Pedal Hi-Hat",
	"Low Tom",
	"Open Hi-Hat",
	"Low-Mid Tom",
	"Hi-Mid Tom",
	"Crash Cymbal 1",
	"High Tom",
	"Ride Cynbal 1",
	"Chinese Cymbal",
	"Ride Bell",
	"Tambourine",
	"Splash Cymbal",
	"Cowbell",
	"Crash Cymbal 2",
	"Vibraslap",
	"Ride Cymbal 2",
	"Hi Bongo",
	"Low Bongo",
	"Mute Hi Conga",
	"Open Hi Conga",
	"Low Conga",
	"High Timbale",
	"Low Timbale",
	"High Agogo",
	"Low Agogo",
	"Cabasa",
	"Maracas",
	"Short Whistle",
	"Long Whistle",
	"Short Guiro",
	"Long Guiro",
	"Claves",
	"Hi Wood Block",
	"Low Wood Block",
	"Mute Cuica",
	"Open Cuica",
	"Mute Triangle",
	"Open Triangle"
};


char gm_instrument_fnames[NO_INSTRUMENT][FNAME_LEN] =
{	"acpiano.pat", 
	"britepno.pat",  
	"synpiano.pat",  
	"honky.pat",    
	"epiano1.pat",   
	"epiano2.pat",   
	"hrpschrd.pat",   
	"clavinet.pat",   
	"celeste.pat",   
	"glocken.pat",   
	"musicbox.pat",  
	"vibes.pat",     
	"marimba.pat",  
	"xylophon.pat",  
	"tubebell.pat",  
	"santur.pat",    
	"homeorg.pat",   
	"percorg.pat",   
	"rockorg.pat",   
	"church.pat",    
	"reedorg.pat",   
	"accordn.pat",   
	"harmonca.pat",  
	"concrtna.pat",  
	"nyguitar.pat",  
	"acguitar.pat",  
	"jazzgtr.pat",  
	"cleangtr.pat",  
	"mutegtr.pat",   
	"odguitar.pat",  
	"distgtr.pat",  
	"gtrharm.pat",   
	"acbass.pat",   
	"fngrbass.pat",  
	"pickbass.pat",  
	"fretless.pat",   
	"slapbas1.pat",  
	"slapbas2.pat",  
	"synbass1.pat",  
	"synbass2.pat",   
	"violin.pat",    
	"viola.pat",     
	"cello.pat", 
	"contraba.pat",   
	"tremstr.pat",  
	"pizzcato.pat",  
	"harp.pat",      
	"timpani.pat",   
	"marcato.pat",  
	"slowstr.pat",   
	"synstr1.pat",   
	"synstr2.pat",   
	"choir.pat",     
	"doo.pat",      
	"voices.pat",    
	"orchhit.pat",   
	"trumpet.pat",   
	"trombone.pat",  
	"tuba.pat",      
	"mutetrum.pat",  
	"frenchrn.pat",  
	"hitbrass.pat",  
	"synbras1.pat",  
	"synbras2.pat",  
	"sprnosax.pat",  
	"altosax.pat",   
	"tenorsax.pat",  
	"barisax.pat",   
	"oboe.pat",      
	"englhorn.pat",  
	"bassoon.pat",   
	"clarinet.pat",  
	"piccolo.pat",    
	"flute.pat",     
	"recorder.pat",   
	"woodflut.pat",   
	"bottle.pat",    
	"shakazul.pat",  
	"whistle.pat",   
	"ocarina.pat",   
	"sqrwave.pat",   
	"sawwave.pat",   
	"calliope.pat",  
	"chiflead.pat",  
	"charang.pat",   
	"voxlead.pat",   
	"lead5th.pat",   
	"basslead.pat",  
	"fantasia.pat",  
	"warmpad.pat",   
	"polysyn.pat",   
	"ghostie.pat",   
	"bowglass.pat",  
	"metalpad.pat",  
	"halopad.pat",   
	"sweeper.pat",   
	"aurora.pat",   
	"soundtrk.pat",  
	"crystal.pat",   
	"atmosphr.pat",  
	"freshair.pat",  
	"unicorn.pat",   
	"echovox.pat",   
	"startrak.pat",  
	"sitar.pat",     
	"banjo.pat",     
	"shamisen.pat",  
	"koto.pat",      
	"kalimba.pat",   
	"bagpipes.pat",  
	"fiddle.pat",    
	"shannai.pat",   
	"carillon.pat",  
	"agogo.pat",     
	"steeldrm.pat",  
	"woodblk.pat",   
	"taiko.pat",     
	"toms.pat",      
	"syntom.pat",    
	"revcym.pat",    
	"fx-fret.pat",   
	"fx-blow.pat",   
	"seashore.pat",  
	"jungle.pat",    
	"telephon.pat",  
	"helicptr.pat",  
	"applause.pat",  
	"ringwhsl.pat"  
};

char gm_percussion_fnames[NO_PERCUSSION][FNAME_LEN] = 
{	"kick1.pat",      
	"kick2.pat",     
	"stickrim.pat",   
	"snare1.pat",    
	"claps.pat",     
	"snare2.pat",     
	"tomlo2.pat",    
	"hihatcl.pat",    
	"tomlo1.pat",   
	"hihatpd.pat",   
	"tommid2.pat",   
	"hihatop.pat",   
	"tommid1.pat",   
	"tomhi2.pat",    
	"cymcrsh1.pat",
	"tomhi1.pat",    
	"cymride1.pat", 
	"cymchina.pat",  
	"cymbell.pat",  
	"tamborin.pat",               
	"cymsplsh.pat",  
	"cowbell.pat",   
	"cymcrsh2.pat",  
	"vibslap.pat",   
	"cymride2.pat",  
	"bongohi.pat",                 
	"bongolo.pat",                 
	"congahi1.pat",   
	"congahi2.pat",   
	"congalo.pat",   
	"timbaleh.pat",  
	"imbalel.pat",  
	"agogohi.pat",    
	"agogolo.pat",    
	"cabasa.pat",    
	"maracas.pat",    
	"whistle1.pat",   
	"whistle2.pat",   
	"guiro1.pat"
	"guiro2.pat",    
	"clave.pat",    
	"woodblk1.pat",  
	"woodblk2.pat",  
	"cuica1.pat",    
	"cuica2.pat",    
	"triangl1.pat",  
	"triangl2.pat"
};
