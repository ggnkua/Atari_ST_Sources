/*
 *	General Midi Instrument lists.
 *	(c) Martin Griffiths August/September 1994.
 */

#include "types.h"
 
char * gm_instrument[NO_INSTRUMENT] = 
{ "Acoustic Grand Piano",	/* 1-8 PIANO */
  "Bright Acoustic Piano",
  "Electric Grand Piano",
  "Honky-Tonk Piano",
  "Electric Piano 1",
  "Electric Piano 2",
  "Harpsichord",
  "Clav",
  "Celesta",				/* 9-16 CHROM PERCUSSION */
  "Glockenspiel",
  "Music Box",
  "Vibraphone",
  "Marimba",
  "Xylophone",
  "Tubular Bells",
  "Dulcimer",
  "Drawbar Organ",			/* 17 -24 ORGAN */
  "Percussive Organ",
  "Rock Organ",
  "Church Organ",
  "Reed Organ",
  "Accordian",
  "Harmonica",
  "Tango Accordian",
  "Acoustic Guitar(Nylon)", /* 25-32 GUITAR */
  "Acoustic Guitar(Steel)",
  "Electric Guitar(Jazz)",
  "Electric Guitar(Clean)",
  "Electric Guitar(Muted)",
  "Overdriver Guitar",
  "Distortion Guitar",
  "Guitar Harmonics", 
  "Acoustic Bass",			/* 33-40 BASS */
  "Electric Bass(finger)",
  "Electric Bass(pick)",
  "Fretless Bass",
  "Slap Bass 1", 
  "Slap Bass 2", 
  "Synth Bass 1", 
  "Synth Bass 2", 
  "Violin",					/* 41-48 STRINGS */
  "Viola",
  "Cello",
  "Contrabass",
  "Tremelo Strings",
  "Pizzicato Strings",
  "Orchestral Strings",
  "Timpani",
  "String Ensemble 1",		/* 49-56 ENSEMBLE */
  "String Ensemble 2",
  "Synth Strings 1",
  "Synth Strings 2",
  "Choir Aahs",
  "Voices Oohs",
  "Synth Voice",
  "Orchestra Hit",
  "Trumpet",				/* 57-64 BRASS */
  "Trombone",
  "Tuba",
  "Muted Trumpet",
  "French Horn",
  "Brass Section",
  "Synth Brass 1",
  "Synth Brass 2",
  "Soprano Sax",			/* 65-72 REED */
  "Alto Sax",
  "Tenor Sax",
  "Baritona Sax",
  "Oboe",
  "English Horn",
  "Bassoon",
  "Clarinet",
  "Piccolo",				/* 73-80 PIPE */
  "Flute",
  "Recorder",
  "Pan Flute",
  "Blown Bottle",
  "Skakubachi",
  "Whistle",
  "Ocarina",
  "Lead 1 (Square)",		/* 81-88 SYNTH LEAD */
  "Lead 2 (Sawtooth)",
  "Lead 3 (Calliope)",
  "Lead 4 (Chiff)",
  "Lead 5 (Charang)",
  "Lead 6 (Voice)",
  "Lead 7 (Fifths)",
  "Lead 8 (Bass+Lead)",
  "Pad 1 (new age)",		/* 89-96 SYNTH PAD */
  "Pad 2 (warm)",
  "Pad 3 (polysynth)",
  "Pad 4 (choir)",
  "Pad 5 (bowed)",
  "Pad 6 (metallic)",
  "Pad 7 (halo)",
  "Pad 8 (sweep)",
  "FX 1 (rain)",			/* 97-104 SYNTH EFFECTS */
  "FX 2 (soundtrack)",
  "FX 3 (crystal)",
  "FX 4 (atmosphere)",
  "FX 5 (brightness)",
  "FX 6 (goblins)",
  "FX 7 (echoes)",
  "FX 8 (sci-fi)",
  "Sitar",					/* 105-112 ETHNIC */
  "Banjo",
  "Shamisen",
  "Koto",
  "Kalimba",
  "Bagpipe",
  "Fiddle",
  "Shanai",
  "Tinkle Bell",			/* 113-120 Percussive */
  "Agogo",
  "Steel Drums",
  "WoodBlock",
  "Taiko Drum",
  "Melodic Tom",
  "Synth Drum",
  "Reverse Cymbal",
  "Guitar Fret Noise",		/* 121-128 SOUND EFFECTS */
  "Breath Noise",
  "Seashore",
  "Bird Tweet",
  "Telephone Ring",
  "Helicopter",
  "Applause",
  "Gunshot"
};


char * gm_percussion[NO_PERCUSSION] = 
{	"Acoustuc Bass Drum",
	"Bass Drum",
	"Side Stick",
	"Acoustic Snare",
	"Hand Clap",
	"Electric Snare",
	"Low Floor Tom",
	"Closed Hi-Hat",
	"High Floor Tom",
	"Pedal Hi-Hat",
	"Low Tom",
	"Open Hi-Hat",
	"Low-Mid Tom",
	"Hi-Mid Tom",
	"Crash Cymbal 1",
	"High Tom",
	"Ride Cynbal 1",
	"Chinese Cymbal",
	"Ride Bell",
	"Tambourine",
	"Splash Cymbal",
	"Cowbell",
	"Crash Cymbal 2",
	"Vibraslap",
	"Ride Cymbal 2",
	"Hi Bongo",
	"Low Bongo",
	"Mute Hi Conga",
	"Open Hi Conga",
	"Low Conga",
	"High Timbale",
	"Low Timbale",
	"High Agogo",
	"Low Agogo",
	"Cabasa",
	"Maracas",
	"Short Whistle",
	"Long Whistle",
	"Short Guiro",
	"Long Guiro",
	"Claves",
	"Hi Wood Block",
	"Low Wood Block",
	"Mute Cuica",
	"Open Cuica",
	"Mute Triangle",
	"Open Triangle"
};


char gm_instrument_fnames[NO_INSTRUMENT][FNAME_LEN] =
{	GMSOURCESET_PATH"acpiano.pat", 
	GMSOURCESET_PATH"britepno.pat",  
	GMSOURCESET_PATH"synpiano.pat",  
	GMSOURCESET_PATH"honky.pat",    
	GMSOURCESET_PATH"epiano1.pat",   
	GMSOURCESET_PATH"epiano2.pat",   
	GMSOURCESET_PATH"hrpschrd.pat",   
	GMSOURCESET_PATH"clavinet.pat",   
	GMSOURCESET_PATH"celeste.pat",   
	GMSOURCESET_PATH"glocken.pat",   
	GMSOURCESET_PATH"musicbox.pat",  
	GMSOURCESET_PATH"vibes.pat",     
	GMSOURCESET_PATH"marimba.pat",  
	GMSOURCESET_PATH"xylophon.pat",  
	GMSOURCESET_PATH"tubebell.pat",  
	GMSOURCESET_PATH"santur.pat",    
	GMSOURCESET_PATH"homeorg.pat",   
	GMSOURCESET_PATH"percorg.pat",   
	GMSOURCESET_PATH"rockorg.pat",   
	GMSOURCESET_PATH"church.pat",    
	GMSOURCESET_PATH"reedorg.pat",   
	GMSOURCESET_PATH"accordn.pat",   
	GMSOURCESET_PATH"harmonca.pat",  
	GMSOURCESET_PATH"concrtna.pat",  
	GMSOURCESET_PATH"nyguitar.pat",  
	GMSOURCESET_PATH"acguitar.pat",  
	GMSOURCESET_PATH"jazzgtr.pat",  
	GMSOURCESET_PATH"cleangtr.pat",  
	GMSOURCESET_PATH"mutegtr.pat",   
	GMSOURCESET_PATH"odguitar.pat",  
	GMSOURCESET_PATH"distgtr.pat",  
	GMSOURCESET_PATH"gtrharm.pat",   
	GMSOURCESET_PATH"acbass.pat",   
	GMSOURCESET_PATH"fngrbass.pat",  
	GMSOURCESET_PATH"pickbass.pat",  
	GMSOURCESET_PATH"fretless.pat",   
	GMSOURCESET_PATH"slapbas1.pat",  
	GMSOURCESET_PATH"slapbas2.pat",  
	GMSOURCESET_PATH"synbass1.pat",  
	GMSOURCESET_PATH"synbass2.pat",   
	GMSOURCESET_PATH"violin.pat",    
	GMSOURCESET_PATH"viola.pat",     
	GMSOURCESET_PATH"cello.pat", 
	GMSOURCESET_PATH"contraba.pat",   
	GMSOURCESET_PATH"tremstr.pat",  
	GMSOURCESET_PATH"pizzcato.pat",  
	GMSOURCESET_PATH"harp.pat",      
	GMSOURCESET_PATH"timpani.pat",   
	GMSOURCESET_PATH"marcato.pat",  
	GMSOURCESET_PATH"slowstr.pat",   
	GMSOURCESET_PATH"synstr1.pat",   
	GMSOURCESET_PATH"synstr2.pat",   
	GMSOURCESET_PATH"choir.pat",     
	GMSOURCESET_PATH"doo.pat",      
	GMSOURCESET_PATH"voices.pat",    
	GMSOURCESET_PATH"orchhit.pat",   
	GMSOURCESET_PATH"trumpet.pat",   
	GMSOURCESET_PATH"trombone.pat",  
	GMSOURCESET_PATH"tuba.pat",      
	GMSOURCESET_PATH"mutetrum.pat",  
	GMSOURCESET_PATH"frenchrn.pat",  
	GMSOURCESET_PATH"hitbrass.pat",  
	GMSOURCESET_PATH"synbras1.pat",  
	GMSOURCESET_PATH"synbras2.pat",  
	GMSOURCESET_PATH"sprnosax.pat",  
	GMSOURCESET_PATH"altosax.pat",   
	GMSOURCESET_PATH"tenorsax.pat",  
	GMSOURCESET_PATH"barisax.pat",   
	GMSOURCESET_PATH"oboe.pat",      
	GMSOURCESET_PATH"englhorn.pat",  
	GMSOURCESET_PATH"bassoon.pat",   
	GMSOURCESET_PATH"clarinet.pat",  
	GMSOURCESET_PATH"piccolo.pat",    
	GMSOURCESET_PATH"flute.pat",     
	GMSOURCESET_PATH"recorder.pat",   
	GMSOURCESET_PATH"woodflut.pat",   
	GMSOURCESET_PATH"bottle.pat",    
	GMSOURCESET_PATH"shakazul.pat",  
	GMSOURCESET_PATH"whistle.pat",   
	GMSOURCESET_PATH"ocarina.pat",   
	GMSOURCESET_PATH"sqrwave.pat",   
	GMSOURCESET_PATH"sawwave.pat",   
	GMSOURCESET_PATH"calliope.pat",  
	GMSOURCESET_PATH"chiflead.pat",  
	GMSOURCESET_PATH"charang.pat",   
	GMSOURCESET_PATH"voxlead.pat",   
	GMSOURCESET_PATH"lead5th.pat",   
	GMSOURCESET_PATH"basslead.pat",  
	GMSOURCESET_PATH"fantasia.pat",  
	GMSOURCESET_PATH"warmpad.pat",   
	GMSOURCESET_PATH"polysyn.pat",   
	GMSOURCESET_PATH"ghostie.pat",   
	GMSOURCESET_PATH"bowglass.pat",  
	GMSOURCESET_PATH"metalpad.pat",  
	GMSOURCESET_PATH"halopad.pat",   
	GMSOURCESET_PATH"sweeper.pat",   
	GMSOURCESET_PATH"aurora.pat",   
	GMSOURCESET_PATH"soundtrk.pat",  
	GMSOURCESET_PATH"crystal.pat",   
	GMSOURCESET_PATH"atmosphr.pat",  
	GMSOURCESET_PATH"freshair.pat",  
	GMSOURCESET_PATH"unicorn.pat",   
	GMSOURCESET_PATH"echovox.pat",   
	GMSOURCESET_PATH"startrak.pat",  
	GMSOURCESET_PATH"sitar.pat",     
	GMSOURCESET_PATH"banjo.pat",     
	GMSOURCESET_PATH"shamisen.pat",  
	GMSOURCESET_PATH"koto.pat",      
	GMSOURCESET_PATH"kalimba.pat",   
	GMSOURCESET_PATH"bagpipes.pat",  
	GMSOURCESET_PATH"fiddle.pat",    
	GMSOURCESET_PATH"shannai.pat",   
	GMSOURCESET_PATH"carillon.pat",  
	GMSOURCESET_PATH"agogo.pat",     
	GMSOURCESET_PATH"steeldrm.pat",  
	GMSOURCESET_PATH"woodblk.pat",   
	GMSOURCESET_PATH"taiko.pat",     
	GMSOURCESET_PATH"toms.pat",      
	GMSOURCESET_PATH"syntom.pat",    
	GMSOURCESET_PATH"revcym.pat",    
	GMSOURCESET_PATH"fx-fret.pat",   
	GMSOURCESET_PATH"fx-blow.pat",   
	GMSOURCESET_PATH"seashore.pat",  
	GMSOURCESET_PATH"jungle.pat",    
	GMSOURCESET_PATH"telephon.pat",  
	GMSOURCESET_PATH"helicptr.pat",  
	GMSOURCESET_PATH"applause.pat",  
	GMSOURCESET_PATH"ringwhsl.pat"  
};


char gm_percussion_fnames[NO_PERCUSSION][FNAME_LEN] = 
{	GMSOURCESET_PATH"kick1.pat",      
	GMSOURCESET_PATH"kick2.pat",     
	GMSOURCESET_PATH"stickrim.pat",   
	GMSOURCESET_PATH"snare1.pat",    
	GMSOURCESET_PATH"claps.pat",     
	GMSOURCESET_PATH"snare2.pat",     
	GMSOURCESET_PATH"tomlo2.pat",    
	GMSOURCESET_PATH"hihatcl.pat",    
	GMSOURCESET_PATH"tomlo1.pat",   
	GMSOURCESET_PATH"hihatpd.pat",   
	GMSOURCESET_PATH"tommid2.pat",   
	GMSOURCESET_PATH"hihatop.pat",   
	GMSOURCESET_PATH"tommid1.pat",   
	GMSOURCESET_PATH"tomhi2.pat",    
	GMSOURCESET_PATH"cymcrsh1.pat",
	GMSOURCESET_PATH"tomhi1.pat",    
	GMSOURCESET_PATH"cymride1.pat", 
	GMSOURCESET_PATH"cymchina.pat",  
	GMSOURCESET_PATH"cymbell.pat",  
	GMSOURCESET_PATH"tamborin.pat",               
	GMSOURCESET_PATH"cymsplsh.pat",  
	GMSOURCESET_PATH"cowbell.pat",   
	GMSOURCESET_PATH"cymcrsh2.pat",  
	GMSOURCESET_PATH"vibslap.pat",   
	GMSOURCESET_PATH"cymride2.pat",  
	GMSOURCESET_PATH"bongohi.pat",                 
	GMSOURCESET_PATH"bongolo.pat",                 
	GMSOURCESET_PATH"congahi1.pat",   
	GMSOURCESET_PATH"congahi2.pat",   
	GMSOURCESET_PATH"congalo.pat",   
	GMSOURCESET_PATH"timbaleh.pat",  
	GMSOURCESET_PATH"imbalel.pat",  
	GMSOURCESET_PATH"agogohi.pat",    
	GMSOURCESET_PATH"agogolo.pat",    
	GMSOURCESET_PATH"cabasa.pat",    
	GMSOURCESET_PATH"maracas.pat",    
	GMSOURCESET_PATH"whistle1.pat",   
	GMSOURCESET_PATH"whistle2.pat",   
	GMSOURCESET_PATH"guiro1.pat"
	GMSOURCESET_PATH"guiro2.pat",    
	GMSOURCESET_PATH"clave.pat",    
	GMSOURCESET_PATH"woodblk1.pat",  
	GMSOURCESET_PATH"woodblk2.pat",  
	GMSOURCESET_PATH"cuica1.pat",    
	GMSOURCESET_PATH"cuica2.pat",    
	GMSOURCESET_PATH"triangl1.pat",  
	GMSOURCESET_PATH"triangl2.pat"
};

	