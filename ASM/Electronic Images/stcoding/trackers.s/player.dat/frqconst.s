	dc.l	$00AEC854,$00B49BCE,$00BA6F49,$00C042C3,$00C6163D 
	dc.l	$00CBE9B8,$00D1BD32,$00D790AC,$00DD6427,$00E337A1 
	dc.l	$00E90B1B,$00EEDE95,$00F4B210,$00FA858A,$01005904 
	dc.l	$01062C7F,$010BFFF9,$0111D373,$0117A6ED,$011D7A68 
	dc.l	$01234DE2,$0129215C,$012EF4D7,$0134C851,$013A9BCB 
	dc.l	$01406F45,$014642C0,$014C163A,$0151E9B4,$0157BD2F 
	dc.l	$015D90A9,$01636423,$0169379D,$016F0B18,$0174DE92 
	dc.l	$017AB20C,$01808587,$01865901,$018C2C7B,$0191FFF6 
	dc.l	$0197D370,$019DA6EA,$01A37A64,$01A94DDF,$01AF2159 
	dc.l	$01B4F4D3,$01BAC84E,$01C09BC8,$01C66F42,$01CC42BC 
	dc.l	$01D21637,$01D7E9B1,$01DDBD2B,$01E390A6,$01E96420 
	dc.l	$01EF379A,$01F50B14,$01FADE8F,$0200B209,$02068583 
	dc.l	$020C58FE,$02122C78,$0217FFF2,$021DD36C,$0223A6E7 
	dc.l	$02297A61,$022F4DDB,$02352156,$023AF4D0,$0240C84A 
	dc.l	$02469BC5,$024C6F3F,$025242B9,$02581633,$025DE9AE 
	dc.l	$0263BD28,$026990A2,$026F641D,$02753797,$027B0B11 
	dc.l	$0280DE8B,$0286B206,$028C8580,$029258FA,$02982C75 
	dc.l	$029DFFEF,$02A3D369,$02A9A6E3,$02AF7A5E,$02B54DD8 
	dc.l	$02BB2152,$02C0F4CD,$02C6C847,$02CC9BC1,$02D26F3B 
	dc.l	$02D842B6,$02DE1630,$02E3E9AA,$02E9BD25,$02EF909F 
