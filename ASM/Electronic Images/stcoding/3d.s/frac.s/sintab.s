sintab: 	DC.W $00,$C9,$0192,$025B,$0324,$03ED,$04B6,$057E
		DC.W $0647,$0710,$07D9,$08A1,$096A,$0A32,$0AFB,$0BC3
		DC.W $0C8B,$0D53,$0E1B,$0EE3,$0FAB,$1072,$1139,$1200
		DC.W $12C7,$138E,$1455,$151B,$15E1,$16A7,$176D,$1833
		DC.W $18F8,$19BD,$1A82,$1B46,$1C0B,$1CCF,$1D93,$1E56
		DC.W $1F19,$1FDC,$209F,$2161,$2223,$22E4,$23A6,$2467
		DC.W $2527,$25E7,$26A7,$2767,$2826,$28E5,$29A3,$2A61
		DC.W $2B1E,$2BDB,$2C98,$2D54,$2E10,$2ECC,$2F86,$3041
		DC.W $30FB,$31B4,$326D,$3326,$33DE,$3496,$354D,$3603
		DC.W $36B9,$376F,$3824,$38D8,$398C,$3A3F,$3AF2,$3BA4
		DC.W $3C56,$3D07,$3DB7,$3E67,$3F16,$3FC5,$4073,$4120
		DC.W $41CD,$4279,$4325,$43D0,$447A,$4523,$45CC,$4674
		DC.W $471C,$47C3,$4869,$490E,$49B3,$4A57,$4AFA,$4B9D
		DC.W $4C3F,$4CE0,$4D80,$4E20,$4EBF,$4F5D,$4FFA,$5097
		DC.W $5133,$51CE,$5268,$5301,$539A,$5432,$54C9,$555F
		DC.W $55F4,$5689,$571D,$57B0,$5842,$58D3,$5963,$59F3
		DC.W $5A81,$5B0F,$5B9C,$5C28,$5CB3,$5D3D,$5DC6,$5E4F
		DC.W $5ED6,$5F5D,$5FE2,$6067,$60EB,$616E,$61F0,$6271
		DC.W $62F1,$6370,$63EE,$646B,$64E7,$6562,$65DD,$6656
		DC.W $66CE,$6745,$67BC,$6831,$68A5,$6919,$698B,$69FC
		DC.W $6A6C,$6ADB,$6B4A,$6BB7,$6C23,$6C8E,$6CF8,$6D61
		DC.W $6DC9,$6E30,$6E95,$6EFA,$6F5E,$6FC0,$7022,$7082
		DC.W $70E1,$7140,$719D,$71F9,$7254,$72AE,$7306,$735E
		DC.W $73B5,$740A,$745E,$74B1,$7503,$7554,$75A4,$75F3
		DC.W $7640,$768D,$76D8,$7722,$776B,$77B3,$77F9,$783F
		DC.W $7883,$78C6,$7908,$7949,$7989,$79C7,$7A04,$7A41
		DC.W $7A7C,$7AB5,$7AEE,$7B25,$7B5C,$7B91,$7BC4,$7BF7
		DC.W $7C29,$7C59,$7C88,$7CB6,$7CE2,$7D0E,$7D38,$7D61
		DC.W $7D89,$7DB0,$7DD5,$7DF9,$7E1C,$7E3E,$7E5E,$7E7E
		DC.W $7E9C,$7EB9,$7ED4,$7EEF,$7F08,$7F20,$7F37,$7F4C
		DC.W $7F61,$7F74,$7F86,$7F96,$7FA6,$7FB4,$7FC1,$7FCD
		DC.W $7FD7,$7FE0,$7FE8,$7FEF,$7FF5,$7FF9,$7FFC,$7FFE
		DC.W $7FFF,$7FFE,$7FFC,$7FF9,$7FF5,$7FEF,$7FE8,$7FE0
		DC.W $7FD7,$7FCD,$7FC1,$7FB4,$7FA6,$7F96,$7F86,$7F74
		DC.W $7F61,$7F4C,$7F37,$7F20,$7F08,$7EEF,$7ED4,$7EB9
		DC.W $7E9C,$7E7E,$7E5E,$7E3E,$7E1C,$7DF9,$7DD5,$7DB0
		DC.W $7D89,$7D61,$7D38,$7D0E,$7CE2,$7CB6,$7C88,$7C59
		DC.W $7C29,$7BF7,$7BC4,$7B91,$7B5C,$7B25,$7AEE,$7AB5
		DC.W $7A7C,$7A41,$7A04,$79C7,$7989,$7949,$7908,$78C6
		DC.W $7883,$783F,$77F9,$77B3,$776B,$7722,$76D8,$768D
		DC.W $7640,$75F3,$75A4,$7554,$7503,$74B1,$745E,$740A
		DC.W $73B5,$735E,$7306,$72AE,$7254,$71F9,$719D,$7140
		DC.W $70E1,$7082,$7022,$6FC0,$6F5E,$6EFA,$6E95,$6E30
		DC.W $6DC9,$6D61,$6CF8,$6C8E,$6C23,$6BB7,$6B4A,$6ADB
		DC.W $6A6C,$69FC,$698B,$6919,$68A5,$6831,$67BC,$6745
		DC.W $66CE,$6656,$65DD,$6562,$64E7,$646B,$63EE,$6370
		DC.W $62F1,$6271,$61F0,$616E,$60EB,$6067,$5FE2,$5F5D
		DC.W $5ED6,$5E4F,$5DC6,$5D3D,$5CB3,$5C28,$5B9C,$5B0F
		DC.W $5A81,$59F3,$5963,$58D3,$5842,$57B0,$571D,$5689
		DC.W $55F4,$555F,$54C9,$5432,$539A,$5301,$5268,$51CE
		DC.W $5133,$5097,$4FFA,$4F5D,$4EBF,$4E20,$4D80,$4CE0
		DC.W $4C3F,$4B9D,$4AFA,$4A57,$49B3,$490E,$4869,$47C3
		DC.W $471C,$4674,$45CC,$4523,$447A,$43D0,$4325,$4279
		DC.W $41CD,$4120,$4073,$3FC5,$3F16,$3E67,$3DB7,$3D07
		DC.W $3C56,$3BA4,$3AF2,$3A3F,$398C,$38D8,$3824,$376F
		DC.W $36B9,$3603,$354D,$3496,$33DE,$3326,$326D,$31B4
		DC.W $30FB,$3041,$2F86,$2ECC,$2E10,$2D54,$2C98,$2BDB
		DC.W $2B1E,$2A61,$29A3,$28E5,$2826,$2767,$26A7,$25E7
		DC.W $2527,$2467,$23A6,$22E4,$2223,$2161,$209F,$1FDC
		DC.W $1F19,$1E56,$1D93,$1CCF,$1C0B,$1B46,$1A82,$19BD
		DC.W $18F8,$1833,$176D,$16A7,$15E1,$151B,$1455,$138E
		DC.W $12C7,$1200,$1139,$1072,$0FAB,$0EE3,$0E1B,$0D53
		DC.W $0C8B,$0BC3,$0AFB,$0A32,$096A,$08A1,$07D9,$0710
		DC.W $0647,$057E,$04B6,$03ED,$0324,$025B,$0192,$C9
		DC.W $00,$FF37,$FE6E,$FDA5,$FCDC,$FC13,$FB4A,$FA82
		DC.W $F9B9,$F8F0,$F827,$F75F,$F696,$F5CE,$F505,$F43D
		DC.W $F375,$F2AD,$F1E5,$F11D,$F055,$EF8E,$EEC7,$EE00
		DC.W $ED39,$EC72,$EBAB,$EAE5,$EA1F,$E959,$E893,$E7CD
		DC.W $E708,$E643,$E57E,$E4BA,$E3F5,$E331,$E26D,$E1AA
		DC.W $E0E7,$E024,$DF61,$DE9F,$DDDD,$DD1C,$DC5A,$DB99
		DC.W $DAD9,$DA19,$D959,$D899,$D7DA,$D71B,$D65D,$D59F
		DC.W $D4E2,$D425,$D368,$D2AC,$D1F0,$D134,$D07A,$CFBF
		DC.W $CF05,$CE4C,$CD93,$CCDA,$CC22,$CB6A,$CAB3,$C9FD
		DC.W $C947,$C891,$C7DC,$C728,$C674,$C5C1,$C50E,$C45C
		DC.W $C3AA,$C2F9,$C249,$C199,$C0EA,$C03B,$BF8D,$BEE0
		DC.W $BE33,$BD87,$BCDB,$BC30,$BB86,$BADD,$BA34,$B98C
		DC.W $B8E4,$B83D,$B797,$B6F2,$B64D,$B5A9,$B506,$B463
		DC.W $B3C1,$B320,$B280,$B1E0,$B141,$B0A3,$B006,$AF69
		DC.W $AECD,$AE32,$AD98,$ACFF,$AC66,$ABCE,$AB37,$AAA1
		DC.W $AA0C,$A977,$A8E3,$A850,$A7BE,$A72D,$A69D,$A60D
		DC.W $A57F,$A4F1,$A464,$A3D8,$A34D,$A2C3,$A23A,$A1B1
		DC.W $A12A,$A0A3,$A01E,$9F99,$9F15,$9E92,$9E10,$9D8F
		DC.W $9D0F,$9C90,$9C12,$9B95,$9B19,$9A9E,$9A23,$99AA
		DC.W $9932,$98BB,$9844,$97CF,$975B,$96E7,$9675,$9604
		DC.W $9594,$9525,$94B6,$9449,$93DD,$9372,$9308,$929F
		DC.W $9237,$91D0,$916B,$9106,$90A2,$9040,$8FDE,$8F7E
		DC.W $8F1F,$8EC0,$8E63,$8E07,$8DAC,$8D52,$8CFA,$8CA2
		DC.W $8C4B,$8BF6,$8BA2,$8B4F,$8AFD,$8AAC,$8A5C,$8A0D
		DC.W $89C0,$8973,$8928,$88DE,$8895,$884D,$8807,$87C1
		DC.W $877D,$873A,$86F8,$86B7,$8677,$8639,$85FC,$85BF
		DC.W $8584,$854B,$8512,$84DB,$84A4,$846F,$843C,$8409
		DC.W $83D7,$83A7,$8378,$834A,$831E,$82F2,$82C8,$829F
		DC.W $8277,$8250,$822B,$8207,$81E4,$81C2,$81A2,$8182
		DC.W $8164,$8147,$812C,$8111,$80F8,$80E0,$80C9,$80B4
		DC.W $809F,$808C,$807A,$806A,$805A,$804C,$803F,$8033
		DC.W $8029,$8020,$8018,$8011,$800B,$8007,$8004,$8002
		DC.W $8001,$8002,$8004,$8007,$800B,$8011,$8018,$8020
		DC.W $8029,$8033,$803F,$804C,$805A,$806A,$807A,$808C
		DC.W $809F,$80B4,$80C9,$80E0,$80F8,$8111,$812C,$8147
		DC.W $8164,$8182,$81A2,$81C2,$81E4,$8207,$822B,$8250
		DC.W $8277,$829F,$82C8,$82F2,$831E,$834A,$8378,$83A7
		DC.W $83D7,$8409,$843C,$846F,$84A4,$84DB,$8512,$854B
		DC.W $8584,$85BF,$85FC,$8639,$8677,$86B7,$86F8,$873A
		DC.W $877D,$87C1,$8807,$884D,$8895,$88DE,$8928,$8973
		DC.W $89C0,$8A0D,$8A5C,$8AAC,$8AFD,$8B4F,$8BA2,$8BF6
		DC.W $8C4B,$8CA2,$8CFA,$8D52,$8DAC,$8E07,$8E63,$8EC0
		DC.W $8F1F,$8F7E,$8FDE,$9040,$90A2,$9106,$916B,$91D0
		DC.W $9237,$929F,$9308,$9372,$93DD,$9449,$94B6,$9525
		DC.W $9594,$9604,$9675,$96E7,$975B,$97CF,$9844,$98BB
		DC.W $9932,$99AA,$9A23,$9A9E,$9B19,$9B95,$9C12,$9C90
		DC.W $9D0F,$9D8F,$9E10,$9E92,$9F15,$9F99,$A01E,$A0A3
		DC.W $A12A,$A1B1,$A23A,$A2C3,$A34D,$A3D8,$A464,$A4F1
		DC.W $A57F,$A60D,$A69D,$A72D,$A7BE,$A850,$A8E3,$A977
		DC.W $AA0C,$AAA1,$AB37,$ABCE,$AC66,$ACFF,$AD98,$AE32
		DC.W $AECD,$AF69,$B006,$B0A3,$B141,$B1E0,$B280,$B320
		DC.W $B3C1,$B463,$B506,$B5A9,$B64D,$B6F2,$B797,$B83D
		DC.W $B8E4,$B98C,$BA34,$BADD,$BB86,$BC30,$BCDB,$BD87
		DC.W $BE33,$BEE0,$BF8D,$C03B,$C0EA,$C199,$C249,$C2F9
		DC.W $C3AA,$C45C,$C50E,$C5C1,$C674,$C728,$C7DC,$C891
		DC.W $C947,$C9FD,$CAB3,$CB6A,$CC22,$CCDA,$CD93,$CE4C
		DC.W $CF05,$CFBF,$D07A,$D134,$D1F0,$D2AC,$D368,$D425
		DC.W $D4E2,$D59F,$D65D,$D71B,$D7DA,$D899,$D959,$DA19
		DC.W $DAD9,$DB99,$DC5A,$DD1C,$DDDD,$DE9F,$DF61,$E024
		DC.W $E0E7,$E1AA,$E26D,$E331,$E3F5,$E4BA,$E57E,$E643
		DC.W $E708,$E7CD,$E893,$E959,$EA1F,$EAE5,$EBAB,$EC72
		DC.W $ED39,$EE00,$EEC7,$EF8E,$F055,$F11D,$F1E5,$F2AD
		DC.W $F375,$F43D,$F505,$F5CE,$F696,$F75F,$F827,$F8F0
		DC.W $F9B9,$FA82,$FB4A,$FC13,$FCDC,$FDA5,$FE6E,$FF37
		DC.W $00,$C9,$0192,$025B,$0324,$03ED,$04B6,$057E
		DC.W $0647,$0710,$07D9,$08A1,$096A,$0A32,$0AFB,$0BC3
		DC.W $0C8B,$0D53,$0E1B,$0EE3,$0FAB,$1072,$1139,$1200
		DC.W $12C7,$138E,$1455,$151B,$15E1,$16A7,$176D,$1833
		DC.W $18F8,$19BD,$1A82,$1B46,$1C0B,$1CCF,$1D93,$1E56
		DC.W $1F19,$1FDC,$209F,$2161,$2223,$22E4,$23A6,$2467
		DC.W $2527,$25E7,$26A7,$2767,$2826,$28E5,$29A3,$2A61
		DC.W $2B1E,$2BDB,$2C98,$2D54,$2E10,$2ECC,$2F86,$3041
		DC.W $30FB,$31B4,$326D,$3326,$33DE,$3496,$354D,$3603
		DC.W $36B9,$376F,$3824,$38D8,$398C,$3A3F,$3AF2,$3BA4
		DC.W $3C56,$3D07,$3DB7,$3E67,$3F16,$3FC5,$4073,$4120
		DC.W $41CD,$4279,$4325,$43D0,$447A,$4523,$45CC,$4674
		DC.W $471C,$47C3,$4869,$490E,$49B3,$4A57,$4AFA,$4B9D
		DC.W $4C3F,$4CE0,$4D80,$4E20,$4EBF,$4F5D,$4FFA,$5097
		DC.W $5133,$51CE,$5268,$5301,$539A,$5432,$54C9,$555F
		DC.W $55F4,$5689,$571D,$57B0,$5842,$58D3,$5963,$59F3
		DC.W $5A81,$5B0F,$5B9C,$5C28,$5CB3,$5D3D,$5DC6,$5E4F
		DC.W $5ED6,$5F5D,$5FE2,$6067,$60EB,$616E,$61F0,$6271
		DC.W $62F1,$6370,$63EE,$646B,$64E7,$6562,$65DD,$6656
		DC.W $66CE,$6745,$67BC,$6831,$68A5,$6919,$698B,$69FC
		DC.W $6A6C,$6ADB,$6B4A,$6BB7,$6C23,$6C8E,$6CF8,$6D61
		DC.W $6DC9,$6E30,$6E95,$6EFA,$6F5E,$6FC0,$7022,$7082
		DC.W $70E1,$7140,$719D,$71F9,$7254,$72AE,$7306,$735E
		DC.W $73B5,$740A,$745E,$74B1,$7503,$7554,$75A4,$75F3
		DC.W $7640,$768D,$76D8,$7722,$776B,$77B3,$77F9,$783F
		DC.W $7883,$78C6,$7908,$7949,$7989,$79C7,$7A04,$7A41
		DC.W $7A7C,$7AB5,$7AEE,$7B25,$7B5C,$7B91,$7BC4,$7BF7
		DC.W $7C29,$7C59,$7C88,$7CB6,$7CE2,$7D0E,$7D38,$7D61
		DC.W $7D89,$7DB0,$7DD5,$7DF9,$7E1C,$7E3E,$7E5E,$7E7E
		DC.W $7E9C,$7EB9,$7ED4,$7EEF,$7F08,$7F20,$7F37,$7F4C
		DC.W $7F61,$7F74,$7F86,$7F96,$7FA6,$7FB4,$7FC1,$7FCD
		DC.W $7FD7,$7FE0,$7FE8,$7FEF,$7FF5,$7FF9,$7FFC,$7FFE