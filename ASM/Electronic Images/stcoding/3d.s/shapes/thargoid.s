thargoid	DC.W 0,0,0	
		DC.W 16
		DC.L 0,0,$b000000
		DC.W 0*4,200*4,0*4
		DC.W 140*4,140*4,0*4
		DC.W 200*4,0*4,0*4
		DC.W 140*4,-140*4,0*4
		DC.W 0*4,-200*4,0*4
		DC.W -140*4,-140*4,0*4
		DC.W -200*4,0*4,0*4
		DC.W -140*4,140*4,0*4
		DC.W 0*4,360*4,-100*4
		DC.W 252*4,252*4,-100*4
		DC.W 360*4,0*4,-100*4
		DC.W 252*4,-252*4,-100*4
		DC.W 0*4,-360*4,-100*4
		DC.W -252*4,-252*4,-100*4
		DC.W -360*4,0*4,-100*4
		DC.W -252*4,252*4,-100*4
		DC.W 10
		DC.W 0*2,8,00*4,01*4,02*4,03*4,04*4,05*4,06*4,07*4
		DC.W 1*2,8,15*4,14*4,13*4,12*4,11*4,10*4,09*4,08*4
		DC.W 2*2,4,06*4,14*4,15*4,07*4
		DC.W 3*2,4,05*4,13*4,14*4,06*4
		DC.W 1*2,4,04*4,12*4,13*4,05*4
		DC.W 2*2,4,03*4,11*4,12*4,04*4
		DC.W 3*2,4,02*4,10*4,11*4,03*4
		DC.W 1*2,4,01*4,09*4,10*4,02*4
		DC.W 2*2,4,00*4,08*4,09*4,01*4
		DC.W 3*2,4,07*4,15*4,08*4,00*4
