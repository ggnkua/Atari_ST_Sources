cube		DC.W 0,0,0
		DC.W 8
		DC.W 0,0,$e00
		DC.W -800,-800,-800
		DC.W 800,-800,-800
		DC.W 800,-800,800
		DC.W -800,-800,800
		DC.W -800,800,-800
		DC.W 800,800,-800
		DC.W 800,800,800
		DC.W -800,800,800
		DC.W 6
		DC.W 04*2,4,03*4,02*4,01*4,00*4
		DC.W 01*2,4,02*4,06*4,05*4,01*4
		DC.W 05*2,4,03*4,07*4,06*4,02*4
		DC.W 02*2,4,06*4,07*4,04*4,05*4
		DC.W 06*2,4,01*4,05*4,04*4,00*4
		DC.W 03*2,4,04*4,07*4,03*4,00*4
