Grid1		DC.W 0,0,0
		DC.W 49
		DC.W 192,600,0
		DC.W 96,600,166
		DC.W -96,600,166
		DC.W -192,600,0
		DC.W -96,600,-166
		DC.W 96,600,-166
		DC.W 192,600,0
		DC.W 192,400,0
		DC.W 96,400,166
		DC.W -96,400,166
		DC.W -192,400,0
		DC.W -96,400,-166
		DC.W 96,400,-166
		DC.W 192,400,0
		DC.W 192,200,0
		DC.W 96,200,166
		DC.W -96,200,166
		DC.W -192,200,0
		DC.W -96,200,-166
		DC.W 96,200,-166
		DC.W 192,200,0
		DC.W 192,0,0
		DC.W 96,0,166
		DC.W -96,0,166
		DC.W -192,0,0
		DC.W -96,0,-166
		DC.W 96,0,-166
		DC.W 192,0,0
		DC.W 192,-200,0
		DC.W 96,-200,166
		DC.W -96,-200,166
		DC.W -192,-200,0
		DC.W -96,-200,-166
		DC.W 96,-200,-166
		DC.W 192,-200,0
		DC.W 192,-400,0
		DC.W 96,-400,166
		DC.W -96,-400,166
		DC.W -192,-400,0
		DC.W -96,-400,-166
		DC.W 96,-400,-166
		DC.W 192,-400,0
		DC.W 192,-600,0
		DC.W 96,-600,166
		DC.W -96,-600,166
		DC.W -192,-600,0
		DC.W -96,-600,-166
		DC.W 96,-600,-166
		DC.W 192,-600,0
		DC.W 72
		DC.W 1*16,4,00*6,01*6,08*6,07*6
		DC.W 3*16,4,01*6,02*6,09*6,08*6
		DC.W 1*16,4,02*6,03*6,10*6,09*6
		DC.W 3*16,4,03*6,04*6,11*6,10*6
		DC.W 1*16,4,04*6,05*6,12*6,11*6
		DC.W 3*16,4,05*6,06*6,13*6,12*6
		DC.W 3*16,4,07*6,08*6,15*6,14*6
		DC.W 1*16,4,08*6,09*6,16*6,15*6
		DC.W 3*16,4,09*6,10*6,17*6,16*6
		DC.W 1*16,4,10*6,11*6,18*6,17*6
		DC.W 3*16,4,11*6,12*6,19*6,18*6
		DC.W 1*16,4,12*6,13*6,20*6,19*6
		DC.W 1*16,4,14*6,15*6,22*6,21*6
		DC.W 3*16,4,15*6,16*6,23*6,22*6
		DC.W 1*16,4,16*6,17*6,24*6,23*6
		DC.W 3*16,4,17*6,18*6,25*6,24*6
		DC.W 1*16,4,18*6,19*6,26*6,25*6
		DC.W 3*16,4,19*6,20*6,27*6,26*6
		DC.W 3*16,4,21*6,22*6,29*6,28*6
		DC.W 1*16,4,22*6,23*6,30*6,29*6
		DC.W 3*16,4,23*6,24*6,31*6,30*6
		DC.W 1*16,4,24*6,25*6,32*6,31*6
		DC.W 3*16,4,25*6,26*6,33*6,32*6
		DC.W 1*16,4,26*6,27*6,34*6,33*6
		DC.W 1*16,4,28*6,29*6,36*6,35*6
		DC.W 3*16,4,29*6,30*6,37*6,36*6
		DC.W 1*16,4,30*6,31*6,38*6,37*6
		DC.W 3*16,4,31*6,32*6,39*6,38*6
		DC.W 1*16,4,32*6,33*6,40*6,39*6
		DC.W 3*16,4,33*6,34*6,41*6,40*6
		DC.W 3*16,4,35*6,36*6,43*6,42*6
		DC.W 1*16,4,36*6,37*6,44*6,43*6
		DC.W 3*16,4,37*6,38*6,45*6,44*6
		DC.W 1*16,4,38*6,39*6,46*6,45*6
		DC.W 3*16,4,39*6,40*6,47*6,46*6
		DC.W 1*16,4,40*6,41*6,48*6,47*6

		DC.W 5*16,4,07*6,08*6,01*6,00*6
		DC.W 7*16,4,08*6,09*6,02*6,01*6
		DC.W 5*16,4,09*6,10*6,03*6,02*6
		DC.W 7*16,4,10*6,11*6,04*6,03*6
		DC.W 5*16,4,11*6,12*6,05*6,04*6
		DC.W 7*16,4,12*6,13*6,06*6,05*6
		DC.W 7*16,4,14*6,15*6,08*6,07*6
		DC.W 5*16,4,15*6,16*6,09*6,08*6
		DC.W 7*16,4,16*6,17*6,10*6,09*6
		DC.W 5*16,4,17*6,18*6,11*6,10*6
		DC.W 7*16,4,18*6,19*6,12*6,11*6
		DC.W 5*16,4,19*6,20*6,13*6,12*6
		DC.W 5*16,4,21*6,22*6,15*6,14*6
		DC.W 7*16,4,22*6,23*6,16*6,15*6
		DC.W 5*16,4,23*6,24*6,17*6,16*6
		DC.W 7*16,4,24*6,25*6,18*6,17*6
		DC.W 5*16,4,25*6,26*6,19*6,18*6
		DC.W 7*16,4,26*6,27*6,20*6,19*6
		DC.W 7*16,4,28*6,29*6,22*6,21*6
		DC.W 5*16,4,29*6,30*6,23*6,22*6
		DC.W 7*16,4,30*6,31*6,24*6,23*6
		DC.W 5*16,4,31*6,32*6,25*6,24*6
		DC.W 7*16,4,32*6,33*6,26*6,25*6
		DC.W 5*16,4,33*6,34*6,27*6,26*6
		DC.W 5*16,4,35*6,36*6,29*6,28*6
		DC.W 7*16,4,36*6,37*6,30*6,29*6
		DC.W 5*16,4,37*6,38*6,31*6,30*6
		DC.W 7*16,4,38*6,39*6,32*6,31*6
		DC.W 5*16,4,39*6,40*6,33*6,32*6
		DC.W 7*16,4,40*6,41*6,34*6,33*6
		DC.W 7*16,4,42*6,43*6,36*6,35*6
		DC.W 5*16,4,43*6,44*6,37*6,36*6
		DC.W 7*16,4,44*6,45*6,38*6,37*6
		DC.W 5*16,4,45*6,46*6,39*6,38*6
		DC.W 7*16,4,46*6,47*6,40*6,39*6
		DC.W 5*16,4,47*6,48*6,41*6,40*6
