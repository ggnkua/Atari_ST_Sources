station	DC.W 0,0,0
		DC.W 12
		DC.L 0,0,$3000000
		DC.W 0,-200,200
		DC.W 200,0,200
		DC.W 200,-200,0
		DC.W 0,200,200
		DC.W 200,0,-200
		DC.W -200,-200,0
		DC.W 0,-200,-200
		DC.W -200,0,200
		DC.W 200,200,0
		DC.W 0,200,-200
		DC.W -200,0,-200
		DC.W -200,200,0
		DC.W 14
		DC.W 13*2,3,00*4,01*4,02*4
		DC.W 14*2,3,09*4,11*4,10*4
		DC.W 13*2,3,04*4,08*4,09*4
		DC.W 14*2,3,01*4,03*4,08*4
		DC.W 13*2,3,03*4,07*4,11*4
		DC.W 14*2,3,00*4,05*4,07*4
		DC.W 13*2,3,05*4,06*4,10*4
		DC.W 14*2,3,02*4,04*4,06*4
		DC.W 15*2,4,00*4,02*4,06*4,05*4
		DC.W 09*2,4,04*4,02*4,01*4,08*4
		DC.W 11*2,4,00*4,07*4,03*4,01*4
		DC.W 09*2,4,07*4,05*4,10*4,11*4
		DC.W 15*2,4,08*4,03*4,11*4,09*4
		DC.W 11*2,4,06*4,04*4,09*4,10*4

