PLANE		DC.W	0,0,0
		DC.W	59
		DC.L 0,0,$B00000
		DC.W	-80,170,-15
		DC.W	-40,160,-15
		DC.W	40,80,-15		
		DC.W	100,50,-15	
		DC.W	-20,50,-15
		DC.W	-20,-50,-15
		DC.W	100,-50,-15	
		DC.W	40,-80,-15	
		DC.W	-40,-160,-15
		DC.W	-80,-170,-15 
		DC.W	-140,50,0	
		DC.W	-160,90,0
		DC.W	-140,90,0
		DC.W	-100,50,0
		DC.W	-140,-50,0
		DC.W	-160,-90,0
		DC.W	-140,-90,0
		DC.W	-100,-50,0
		DC.W	-160,40,-15
		DC.W	-170,40,-55
		DC.W	-150,40,-55	
		DC.W	-100,40,-15
		DC.W	-160,-40,-15
		DC.W	-170,-40,-55
		DC.W	-150,-40,-55
		DC.W	-100,-40,-15
		DC.W	100,20,-20
		DC.W	170,15,-17
		DC.W	170,-15,-17
		DC.W	100,-20,-20
		DC.W	100,20,10	
		DC.W	170,15,7
		DC.W	170,-15,7
		DC.W	100,-20,10
		DC.W	230,0,-5
		DC.W	150,-10,-18
		DC.W	150,10,-18
		DC.W	130,10,-23
		DC.W	100,10,-20
		DC.W	100,-10,-20
		DC.W	130,-10,-23	
		DC.W	-160,50,-15
		DC.W	-160,20,-15
		DC.W	-160,-20,-15
		DC.W	-160,-50,-15
		DC.W	100,-50,-15
		DC.W	100,50,-15
		DC.W	-160,50,15
		DC.W	-160,20,15
		DC.W	-160,-20,15
		DC.W	-160,-50,15	
		DC.W	60,-50,18
		DC.W	60,50,18
		DC.W	-160,20,0
		DC.W	-160,-20,0
		DC.W	100,20,-15
		DC.W	100,-20,-15
		DC.W	60,-20,18
		DC.W	60,20,18

		DC.W 44
	
		DC.W	1*2,4,04*6,02*6,01*6,00*6
		DC.W	1*2,4,02*6,04*6,00*6,01*6
		DC.W	1*2,4,10*6,13*6,12*6,11*6
		DC.W	1*2,4,11*6,12*6,13*6,10*6
		DC.W	1*2,3,04*6,03*6,02*6
		DC.W	1*2,3,02*6,03*6,04*6
		DC.W	1*2,4,09*6,08*6,07*6,05*6
		DC.W	1*2,4,05*6,07*6,08*6,09*6
		DC.W	1*2,4,15*6,16*6,17*6,14*6
		DC.W	1*2,4,14*6,17*6,16*6,15*6
		DC.W	1*2,4,43*6,56*6,45*6,44*6
		DC.W	1*2,4,44*6,45*6,51*6,50*6
		DC.W	1*2,4,49*6,57*6,56*6,43*6
		DC.W	1*2,4,57*6,49*6,50*6,51*6
		DC.W	1*2,4,50*6,49*6,43*6,44*6
		DC.W	1*2,4,56*6,57*6,51*6,45*6	
		DC.W	1*2,4,26*6,29*6,54*6,53*6
		DC.W	1*2,4,53*6,54*6,33*6,30*6
		DC.W	1*2,3,54*6,29*6,33*6
		DC.W	1*2,3,53*6,30*6,26*6
		DC.W	1*2,4,42*6,41*6,46*6,55*6
		DC.W	1*2,4,42*6,55*6,58*6,48*6
		DC.W	1*2,4,52*6,46*6,41*6,47*6
		DC.W	1*2,4,52*6,47*6,48*6,58*6
		DC.W	1*2,4,47*6,41*6,42*6,48*6
		DC.W	1*2,4,46*6,52*6,58*6,55*6
		DC.W	1*2,4,38*6,37*6,40*6,39*6
		DC.W	1*2,4,37*6,36*6,35*6,40*6
		DC.W	1*2,3,40*6,35*6,39*6
		DC.W	1*2,3,36*6,37*6,38*6
		DC.W	1*2,4,26*6,27*6,28*6,29*6
		DC.W	1*2,4,29*6,28*6,32*6,33*6
		DC.W	1*2,4,30*6,31*6,27*6,26*6
		DC.W	1*2,4,31*6,30*6,33*6,32*6
		DC.W	1*2,3,27*6,34*6,28*6
		DC.W	1*2,3,31*6,34*6,27*6
		DC.W	1*2,3,32*6,28*6,34*6
		DC.W	1*2,3,31*6,32*6,34*6
		DC.W	1*2,3,05*6,07*6,06*6
		DC.W	1*2,3,06*6,07*6,05*6
		DC.W	1*2,4,19*6,20*6,21*6,18*6
		DC.W	1*2,4,18*6,21*6,20*6,19*6
		DC.W	1*2,4,23*6,24*6,25*6,22*6
		DC.W	1*2,4,22*6,25*6,24*6,23*6
