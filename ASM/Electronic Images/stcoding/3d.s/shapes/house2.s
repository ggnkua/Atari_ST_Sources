House2		DC.W 0,0,0
		DC.W 10
		DC.w 0,0,$300
		DC.W -100,50,75
		DC.W 100,50,75
		DC.W 100,-80,75
		DC.W -100,-80,75
		DC.W -100,50,-75
		DC.W 100,50,-75
		DC.W 100,-80,-75
		DC.W -100,-80,-75
		DC.W -100,125,0
		DC.W 100,125,0
		DC.W 7
		DC.W 01*2,4,0*4,1*4,2*4,3*4
		DC.W 04*2,4,7*4,6*4,5*4,4*4
		DC.W 2*2,5,0*4,3*4,7*4,4*4,8*4
		DC.W 3*2,5,1*4,9*4,5*4,6*4,2*4
		DC.W 04*2,4,8*4,9*4,1*4,0*4
		DC.W 05*2,4,4*4,5*4,9*4,8*4
		DC.W 06*2,4,6*4,7*4,3*4,2*4
