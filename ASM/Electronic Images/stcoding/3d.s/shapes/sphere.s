facelist	DC.W 00*2,10,40*6,41*6,42*6,43*6,44*6,45*6,46*6,47*6,48*6,49*6
		DC.W 00*2,10,09*6,08*6,07*6,06*6,05*6,04*6,03*6,02*6,01*6,00*6
		DC.W 01*2,4,01*6,11*6,10*6,00*6
		DC.W 00*2,4,02*6,12*6,11*6,01*6
		DC.W 01*2,4,03*6,13*6,12*6,02*6
		DC.W 00*2,4,04*6,14*6,13*6,03*6
		DC.W 01*2,4,05*6,15*6,14*6,04*6
		DC.W 00*2,4,06*6,16*6,15*6,05*6
		DC.W 01*2,4,07*6,17*6,16*6,06*6
		DC.W 00*2,4,08*6,18*6,17*6,07*6
		DC.W 01*2,4,09*6,19*6,18*6,08*6
		DC.W 00*2,4,00*6,10*6,19*6,09*6

		DC.W 00*2,4,11*6,21*6,20*6,10*6
		DC.W 01*2,4,12*6,22*6,21*6,11*6
		DC.W 00*2,4,13*6,23*6,22*6,12*6
		DC.W 01*2,4,14*6,24*6,23*6,13*6
		DC.W 00*2,4,15*6,25*6,24*6,14*6
		DC.W 01*2,4,16*6,26*6,25*6,15*6
		DC.W 00*2,4,17*6,27*6,26*6,16*6
		DC.W 01*2,4,18*6,28*6,27*6,17*6
		DC.W 00*2,4,19*6,29*6,28*6,18*6
		DC.W 01*2,4,10*6,20*6,29*6,19*6

		DC.W 01*2,4,21*6,31*6,30*6,20*6
		DC.W 00*2,4,22*6,32*6,31*6,21*6
		DC.W 01*2,4,23*6,33*6,32*6,22*6
		DC.W 00*2,4,24*6,34*6,33*6,23*6
		DC.W 01*2,4,25*6,35*6,34*6,24*6
		DC.W 00*2,4,26*6,36*6,35*6,25*6
		DC.W 01*2,4,27*6,37*6,36*6,26*6
		DC.W 00*2,4,28*6,38*6,37*6,27*6
		DC.W 01*2,4,29*6,39*6,38*6,28*6
		DC.W 00*2,4,20*6,30*6,39*6,29*6

		DC.W 00*2,4,31*6,41*6,40*6,30*6
		DC.W 01*2,4,32*6,42*6,41*6,31*6
		DC.W 00*2,4,33*6,43*6,42*6,32*6
		DC.W 01*2,4,34*6,44*6,43*6,33*6
		DC.W 00*2,4,35*6,45*6,44*6,34*6
		DC.W 01*2,4,36*6,46*6,45*6,35*6
		DC.W 00*2,4,37*6,47*6,46*6,36*6
		DC.W 01*2,4,38*6,48*6,47*6,37*6
		DC.W 00*2,4,39*6,49*6,48*6,38*6
		DC.W 01*2,4,30*6,40*6,49*6,39*6
