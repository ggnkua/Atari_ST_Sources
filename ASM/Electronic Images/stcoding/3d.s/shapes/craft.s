craft_np	dc.l	26
craft_nf	dc.l	23
craft_point	dc.w	-20,0,-10,20,0,-10,20,0,-55,-20,0,-55
	dc.w	-20,5,-50,20,5,-50,-10,10,-15,10,10,-15
	dc.w	-20,0,55,20,0,55,-10,10,50,-10,10,10
	dc.w	10,10,50,10,10,10,-10,15,10,10,15,10
	dc.w	-15,-10,15,-15,-10,-45,15,-10,-45,15,-10,15
	dc.w	-20,0,25,-40,0,35,-40,0,45
	dc.w	20,0,25,40,0,35,40,0,45
craft_facet	dc.b	7,6,4,5,15	Cockpit
	dc.b	7,5,1,1,14
	dc.b	4,6,0,0,14
	dc.b	1,5,2,2,2
	dc.b	4,0,3,3,2
	dc.b	4,3,2,5,3
	dc.b	12,7,1,9,2	Back
	dc.b	10,8,0,6,2
	dc.b	10,12,9,8,12
	dc.b	13,11,6,7,3
	dc.b	12,15,13,13,2
	dc.b	14,10,11,11,2
	dc.b	12,10,14,15,3
	dc.b	14,11,13,15,12
	dc.b	2,18,19,9,3	Bottom 
	dc.b	16,17,3,8,3
	dc.b	2,3,17,18,2
	dc.b	8,9,19,16,2
	dc.b	18,17,16,19,1
	dc.b	8,22,21,20,3 Right wing
	dc.b	20,21,22,8,1
	dc.b	9,23,24,25,3 Left wing
	dc.b	25,24,23,9,1
	even
