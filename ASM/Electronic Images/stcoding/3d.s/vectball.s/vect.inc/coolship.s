; Cool SHIP

coolship	DC.L 0
		DC.W 50
		DC.W 0*8,0*8,-90*8
		DC.W -15*8,0*8,-48*8
		DC.W 15*8,0*8,-48*8
		DC.W -30*8,0*8,-20*8
		DC.W 30*8,0*8,-20*8
		DC.W 90*8,0*8,20*8
		DC.W 90*8,0*8,50*8
		DC.W 30*8,0*8,50*8
		DC.W 20*8,0*8,80*8
		DC.W 20*8,0*8,70*8
		DC.W -20*8,0*8,70*8
		DC.W -20*8,0*8,80*8
		DC.W -30*8,0*8,50*8
		DC.W -90*8,0*8,50*8
		DC.W -90*8,0*8,20*8
		DC.W -90*8,20*8,20*8
		DC.W -90*8,20*8,50*8
		DC.W 90*8,20*8,50*8
		DC.W 90*8,20*8,20*8
		DC.W -10*8,20*8,0*8
		DC.W 10*8,20*8,0*8
		DC.W -5*8,20*8,-20*8
		DC.W 5*8,20*8,-20*8
		DC.W 0*8,20*8,-40*8
		DC.W 0*8,10*8,-50*8
		DC.W -20*8,10*8,0*8
		DC.W 20*8,10*8,0*8
		DC.W 0*8,10*8,10*8
		DC.W -30*8,10*8,50*8
		DC.W 30*8,10*8,50*8
		DC.W -20*8,20*8,40*8
		DC.W 20*8,20*8,40*8
		DC.W 20*8,20*8,70*8
		DC.W -20*8,20*8,70*8
		DC.W -65*8,-10*8,0*8
		DC.W -50*8,-10*8,-10*8
		DC.W 50*8,-10*8,-10*8
		DC.W 65*8,-10*8,0*8
		DC.W -65*8,-10*8,60*8
		DC.W -50*8,-10*8,60*8
		DC.W 50*8,-10*8,60*8
		DC.W 65*8,-10*8,60*8
		DC.W -65*8,0*8,0*8
		DC.W -50*8,0*8,-10*8
		DC.W -50*8,0*8,60*8
		DC.W -65*8,0*8,60*8
		DC.W 50*8,0*8,60*8
		DC.W 65*8,0*8,60*8
		DC.W 65*8,0*8,0*8
		DC.W 50*8,0*8,-10*8
		DC.W 0
;		DC.W BALLOBJ,00*6,03*64
;		DC.W BALLOBJ,01*6,03*64
;		DC.W BALLOBJ,02*6,03*64
;		DC.W BALLOBJ,03*6,03*64
;		DC.W BALLOBJ,04*6,03*64
;		DC.W BALLOBJ,05*6,03*64
;		DC.W BALLOBJ,06*6,03*64
;		DC.W BALLOBJ,07*6,03*64
;		DC.W BALLOBJ,08*6,03*64
;		DC.W BALLOBJ,09*6,03*64
;		DC.W BALLOBJ,10*6,03*64
;		DC.W BALLOBJ,11*6,03*64
;		DC.W BALLOBJ,12*6,03*64
;		DC.W BALLOBJ,13*6,03*64
;		DC.W BALLOBJ,14*6,03*64
;		DC.W BALLOBJ,15*6,03*64
;		DC.W BALLOBJ,16*6,03*64
;		DC.W BALLOBJ,17*6,03*64
;		DC.W BALLOBJ,18*6,03*64
;		DC.W BALLOBJ,19*6,03*64
;		DC.W BALLOBJ,20*6,03*64
;		DC.W BALLOBJ,21*6,03*64
;		DC.W BALLOBJ,22*6,03*64
;		DC.W BALLOBJ,23*6,03*64
;		DC.W BALLOBJ,24*6,03*64
;		DC.W BALLOBJ,25*6,03*64
;		DC.W BALLOBJ,26*6,03*64
;		DC.W BALLOBJ,27*6,03*64
;		DC.W BALLOBJ,28*6,03*64
;		DC.W BALLOBJ,29*6,03*64
;		DC.W BALLOBJ,30*6,03*64
;		DC.W BALLOBJ,31*6,03*64
;		DC.W BALLOBJ,32*6,03*64
;		DC.W BALLOBJ,33*6,03*64
;		DC.W BALLOBJ,34*6,03*64
;		DC.W BALLOBJ,35*6,03*64
;		DC.W BALLOBJ,36*6,03*64
;		DC.W BALLOBJ,37*6,03*64
;		DC.W BALLOBJ,38*6,03*64
;		DC.W BALLOBJ,39*6,03*64
;		DC.W BALLOBJ,40*6,03*64
;		DC.W BALLOBJ,41*6,03*64
;		DC.W BALLOBJ,42*6,03*64
;		DC.W BALLOBJ,43*6,03*64
;		DC.W BALLOBJ,44*6,03*64
;		DC.W BALLOBJ,45*6,03*64
;		DC.W BALLOBJ,46*6,03*64
;		DC.W BALLOBJ,47*6,03*64
;		DC.W BALLOBJ,48*6,03*64
;		DC.W BALLOBJ,49*6,03*64
;		DC.W BALLOBJ,50*6,03*64
;		DC.W BALLOBJ,51*6,03*64
;		DC.W BALLOBJ,52*6,03*64
;		DC.W BALLOBJ,53*6,03*64
;		DC.W BALLOBJ,54*6,03*64
;		DC.W BALLOBJ,55*6,03*64
;		DC.W BALLOBJ,56*6,03*64
;		DC.W BALLOBJ,57*6,03*64
;		DC.W BALLOBJ,58*6,03*64
;		DC.W BALLOBJ,59*6,03*64
;		DC.W BALLOBJ,60*6,03*64
;		DC.W BALLOBJ,61*6,03*64
;		DC.W BALLOBJ,62*6,03*64
;		DC.W BALLOBJ,63*6,03*64
;		DC.W BALLOBJ,64*6,03*64
;		DC.W BALLOBJ,65*6,03*64
;		DC.W BALLOBJ,66*6,03*64
;		DC.W BALLOBJ,67*6,03*64

		DC.W 68
		DC.W LINEOBJ,00*6,01*6
		DC.W LINEOBJ,01*6,03*6
		DC.W LINEOBJ,03*6,14*6
		DC.W LINEOBJ,14*6,13*6
		DC.W LINEOBJ,13*6,12*6
		DC.W LINEOBJ,12*6,11*6
		DC.W LINEOBJ,11*6,10*6
		DC.W LINEOBJ,10*6,09*6
		DC.W LINEOBJ,09*6,08*6
		DC.W LINEOBJ,08*6,07*6
		DC.W LINEOBJ,07*6,06*6
		DC.W LINEOBJ,06*6,05*6
		DC.W LINEOBJ,05*6,04*6
		DC.W LINEOBJ,04*6,02*6
		DC.W LINEOBJ,02*6,00*6
		DC.W LINEOBJ,24*6,26*6
		DC.W LINEOBJ,26*6,27*6
		DC.W LINEOBJ,27*6,25*6
		DC.W LINEOBJ,25*6,24*6
		DC.W LINEOBJ,23*6,22*6
		DC.W LINEOBJ,22*6,20*6
		DC.W LINEOBJ,20*6,19*6
		DC.W LINEOBJ,19*6,21*6
		DC.W LINEOBJ,21*6,23*6
		DC.W LINEOBJ,19*6,25*6
		DC.W LINEOBJ,26*6,20*6
		DC.W LINEOBJ,23*6,24*6
		DC.W LINEOBJ,24*6,00*6
		DC.W LINEOBJ,04*6,26*6
		DC.W LINEOBJ,26*6,25*6
		DC.W LINEOBJ,25*6,03*6
		DC.W LINEOBJ,14*6,25*6
		DC.W LINEOBJ,26*6,05*6
		DC.W LINEOBJ,13*6,30*6
		DC.W LINEOBJ,31*6,06*6
		DC.W LINEOBJ,27*6,30*6
		DC.W LINEOBJ,30*6,31*6
		DC.W LINEOBJ,31*6,27*6
		DC.W LINEOBJ,30*6,12*6
		DC.W LINEOBJ,10*6,30*6
		DC.W LINEOBJ,31*6,09*6
		DC.W LINEOBJ,07*6,31*6
		DC.W LINEOBJ,34*6,38*6 
		DC.W LINEOBJ,38*6,39*6
		DC.W LINEOBJ,39*6,35*6  
		DC.W LINEOBJ,35*6,34*6  
		DC.W LINEOBJ,36*6,37*6  
		DC.W LINEOBJ,37*6,41*6  
		DC.W LINEOBJ,41*6,40*6  
		DC.W LINEOBJ,40*6,36*6  
		DC.W LINEOBJ,43*6,42*6 
		DC.W LINEOBJ,42*6,45*6 
		DC.W LINEOBJ,45*6,44*6 
		DC.W LINEOBJ,44*6,43*6
		DC.W LINEOBJ,49*6,48*6
		DC.W LINEOBJ,48*6,47*6
		DC.W LINEOBJ,47*6,46*6 
		DC.W LINEOBJ,46*6,49*6
		DC.W LINEOBJ,49*6,36*6
		DC.W LINEOBJ,37*6,48*6
		DC.W LINEOBJ,47*6,41*6
		DC.W LINEOBJ,40*6,46*6 
		DC.W LINEOBJ,44*6,39*6
		DC.W LINEOBJ,38*6,45*6 
		DC.W LINEOBJ,42*6,34*6 
		DC.W LINEOBJ,35*6,43*6 
		DC.W LINEOBJ,30*6,25*6
		DC.W LINEOBJ,26*6,31*6
