; 7*7 Grid of balls (joined with lines).

grid7by7	DC.L 0
		DC.W 49
i		SET -600
		REPT 7
		DC.W +400,i,0
		DC.W -600,i,0
		DC.W -400,i,0
		DC.W +200,i,0
		DC.W -200,i,0
		DC.W  000,i,0
		DC.W +600,i,0
i		SET i+200 
		ENDR
		DC.W 49
i		SET 0
		REPT 49
		DC.W BALLOBJ,i,03*64
i		SET i+6
		ENDR		
		DC.W 84
		DC.W LINEOBJ,00*6,07*6
		DC.W LINEOBJ,01*6,08*6
		DC.W LINEOBJ,02*6,09*6
		DC.W LINEOBJ,03*6,10*6
		DC.W LINEOBJ,04*6,11*6
		DC.W LINEOBJ,05*6,12*6
		DC.W LINEOBJ,06*6,13*6
		DC.W LINEOBJ,07*6,14*6
		DC.W LINEOBJ,08*6,15*6
		DC.W LINEOBJ,09*6,16*6
		DC.W LINEOBJ,10*6,17*6
		DC.W LINEOBJ,11*6,18*6
		DC.W LINEOBJ,12*6,19*6
		DC.W LINEOBJ,13*6,20*6
		DC.W LINEOBJ,14*6,21*6
		DC.W LINEOBJ,15*6,22*6
		DC.W LINEOBJ,16*6,23*6
		DC.W LINEOBJ,17*6,24*6
		DC.W LINEOBJ,18*6,25*6
		DC.W LINEOBJ,19*6,26*6
		DC.W LINEOBJ,20*6,27*6
		DC.W LINEOBJ,21*6,28*6
		DC.W LINEOBJ,22*6,29*6
		DC.W LINEOBJ,23*6,30*6
		DC.W LINEOBJ,24*6,31*6
		DC.W LINEOBJ,25*6,32*6
		DC.W LINEOBJ,26*6,33*6
		DC.W LINEOBJ,27*6,34*6
		DC.W LINEOBJ,28*6,35*6
		DC.W LINEOBJ,29*6,36*6
		DC.W LINEOBJ,30*6,37*6
		DC.W LINEOBJ,31*6,38*6
		DC.W LINEOBJ,32*6,39*6
		DC.W LINEOBJ,33*6,40*6
		DC.W LINEOBJ,34*6,41*6
		DC.W LINEOBJ,35*6,42*6
		DC.W LINEOBJ,36*6,43*6
		DC.W LINEOBJ,37*6,44*6
		DC.W LINEOBJ,38*6,45*6
		DC.W LINEOBJ,39*6,46*6
		DC.W LINEOBJ,40*6,47*6
		DC.W LINEOBJ,41*6,48*6
		DC.W LINEOBJ,(00+00)*6,(00+06)*6
		DC.W LINEOBJ,(00+01)*6,(00+02)*6
		DC.W LINEOBJ,(00+02)*6,(00+04)*6
		DC.W LINEOBJ,(00+03)*6,(00+00)*6
		DC.W LINEOBJ,(00+04)*6,(00+05)*6
		DC.W LINEOBJ,(00+05)*6,(00+03)*6
		DC.W LINEOBJ,(07+00)*6,(07+06)*6
		DC.W LINEOBJ,(07+01)*6,(07+02)*6
		DC.W LINEOBJ,(07+02)*6,(07+04)*6
		DC.W LINEOBJ,(07+03)*6,(07+00)*6
		DC.W LINEOBJ,(07+04)*6,(07+05)*6
		DC.W LINEOBJ,(07+05)*6,(07+03)*6
		DC.W LINEOBJ,(14+00)*6,(14+06)*6
		DC.W LINEOBJ,(14+01)*6,(14+02)*6
		DC.W LINEOBJ,(14+02)*6,(14+04)*6
		DC.W LINEOBJ,(14+03)*6,(14+00)*6
		DC.W LINEOBJ,(14+04)*6,(14+05)*6
		DC.W LINEOBJ,(14+05)*6,(14+03)*6
		DC.W LINEOBJ,(21+00)*6,(21+06)*6
		DC.W LINEOBJ,(21+01)*6,(21+02)*6
		DC.W LINEOBJ,(21+02)*6,(21+04)*6
		DC.W LINEOBJ,(21+03)*6,(21+00)*6
		DC.W LINEOBJ,(21+04)*6,(21+05)*6
		DC.W LINEOBJ,(21+05)*6,(21+03)*6
		DC.W LINEOBJ,(28+00)*6,(28+06)*6
		DC.W LINEOBJ,(28+01)*6,(28+02)*6
		DC.W LINEOBJ,(28+02)*6,(28+04)*6
		DC.W LINEOBJ,(28+03)*6,(28+00)*6
		DC.W LINEOBJ,(28+04)*6,(28+05)*6
		DC.W LINEOBJ,(28+05)*6,(28+03)*6
		DC.W LINEOBJ,(35+00)*6,(35+06)*6
		DC.W LINEOBJ,(35+01)*6,(35+02)*6
		DC.W LINEOBJ,(35+02)*6,(35+04)*6
		DC.W LINEOBJ,(35+03)*6,(35+00)*6
		DC.W LINEOBJ,(35+04)*6,(35+05)*6
		DC.W LINEOBJ,(35+05)*6,(35+03)*6
		DC.W LINEOBJ,(42+00)*6,(42+06)*6
		DC.W LINEOBJ,(42+01)*6,(42+02)*6
		DC.W LINEOBJ,(42+02)*6,(42+04)*6
		DC.W LINEOBJ,(42+03)*6,(42+00)*6
		DC.W LINEOBJ,(42+04)*6,(42+05)*6
		DC.W LINEOBJ,(42+05)*6,(42+03)*6

