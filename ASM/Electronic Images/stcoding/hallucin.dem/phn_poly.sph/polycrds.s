obj		DC.W 50
		dc.w $3C,$13,$06,$3C,$0B,$10,$3C,$00 
		dc.w $13,$3C,$F4,$10,$3C,$EC,$06,$3C
		dc.w $EC,$F9,$3C,$F4,$EF,$3C,$00,$EC
		dc.w $3C,$0B,$EF,$3C,$13,$F9,$25,$31
		dc.w $10,$25,$1E,$2A,$25,$00,$33,$25 
		dc.w $E1,$2A,$25,$CE,$10,$25,$CE,$EF 
		dc.w $25,$E1,$D5,$25,$00,$CC,$25,$1E 
		dc.w $D5,$25,$31,$EF,$00,$3C,$13,$00 
		dc.w $25,$33,$00,$00,$3F,$00,$DA,$33 
		dc.w $00,$C3,$13,$00,$C3,$EC,$00,$DA
		dc.w $CC,$00,$00,$C0,$00,$25,$CC,$00
		dc.w $3C,$EC,$DA,$31,$10,$DA,$1E,$2A
		dc.w $DA,$00,$33,$DA,$E1,$2A,$DA,$CE
		dc.w $10,$DA,$CE,$EF,$DA,$E1,$D5,$DA
		dc.w $00,$CC,$DA,$1E,$D5,$DA,$31,$EF
		dc.w $C3,$13,$06,$C3,$0B,$10,$C3,$00
		dc.w $13,$C3,$F4,$10,$C3,$EC,$06,$C3 
		dc.w $EC,$F9,$C3,$F4,$EF,$C3,$00,$EC
		dc.w $C3,$0B,$EF,$C3,$13,$F9 
		DC.W 10,40*6,41*6,42*6,43*6,44*6,45*6,46*6,47*6,48*6,49*6
		DC.W 10,09*6,08*6,07*6,06*6,05*6,04*6,03*6,02*6,01*6,00*6
		DC.W 4,01*6,11*6,10*6,00*6
		DC.W 4,02*6,12*6,11*6,01*6
		DC.W 4,03*6,13*6,12*6,02*6
		DC.W 4,04*6,14*6,13*6,03*6
		DC.W 4,05*6,15*6,14*6,04*6
		DC.W 4,06*6,16*6,15*6,05*6
		DC.W 4,07*6,17*6,16*6,06*6
		DC.W 4,08*6,18*6,17*6,07*6
		DC.W 4,09*6,19*6,18*6,08*6
		DC.W 4,00*6,10*6,19*6,09*6
		DC.W 4,11*6,21*6,20*6,10*6
		DC.W 4,12*6,22*6,21*6,11*6
		DC.W 4,13*6,23*6,22*6,12*6
		DC.W 4,14*6,24*6,23*6,13*6
		DC.W 4,15*6,25*6,24*6,14*6
		DC.W 4,16*6,26*6,25*6,15*6
		DC.W 4,17*6,27*6,26*6,16*6
		DC.W 4,18*6,28*6,27*6,17*6
		DC.W 4,19*6,29*6,28*6,18*6
		DC.W 4,10*6,20*6,29*6,19*6
		DC.W 4,21*6,31*6,30*6,20*6
		DC.W 4,22*6,32*6,31*6,21*6
		DC.W 4,23*6,33*6,32*6,22*6
		DC.W 4,24*6,34*6,33*6,23*6
		DC.W 4,25*6,35*6,34*6,24*6
		DC.W 4,26*6,36*6,35*6,25*6
		DC.W 4,27*6,37*6,36*6,26*6
		DC.W 4,28*6,38*6,37*6,27*6
		DC.W 4,29*6,39*6,38*6,28*6
		DC.W 4,20*6,30*6,39*6,29*6
		DC.W 4,31*6,41*6,40*6,30*6
		DC.W 4,32*6,42*6,41*6,31*6
		DC.W 4,33*6,43*6,42*6,32*6
		DC.W 4,34*6,44*6,43*6,33*6
		DC.W 4,35*6,45*6,44*6,34*6
		DC.W 4,36*6,46*6,45*6,35*6
		DC.W 4,37*6,47*6,46*6,36*6
		DC.W 4,38*6,48*6,47*6,37*6
		DC.W 4,39*6,49*6,48*6,38*6
		DC.W 4,30*6,40*6,49*6,39*6
