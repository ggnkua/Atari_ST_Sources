
	lea	$11D16E,a1
	move.w	$16(a6),d0
	move.w	$12(a6),d1
	move.w	$14(a6),d2
	and.w	#$1FFC,d0
	and.w	#$1FFC,d1
	and.w	#$1FFC,d2
	bsr.s	l9B44E
	rts
l9B44E	move.w	d0,d3
	move.w	d0,d4
	add.w	d2,d3
	sub.w	d2,d4
	move.l	0(a1,d3.w),d5
	move.l	0(a1,d4.w),d6
	add.w	d5,d6
	move.w	d6,(a0)+
	swap	d5
	swap	d6
	add.w	d5,d6
	move.w	d6,(a0)+
	move.w	0(a1,d2.w),d5
	add.w	d5,d5
	neg.w	d5
	move.w	d5,(a0)+
	move.w	d1,d3
	move.w	d1,d4
	add.w	d2,d3
	sub.w	d2,d4
	move.l	0(a1,d3.w),d5
	move.l	0(a1,d4.w),d6
	add.w	d5,d6
	move.w	d6,$A(a0)
	swap	d5
	swap	d6
	add.w	d5,d6
	move.w	d6,4(a0)
	move.w	d0,d3
	add.w	d1,d0
	sub.w	d1,d3
	move.w	d2,d4
	move.w	d2,d1
	neg.w	d1
	move.w	d1,d5
	add.w	d0,d1
	add.w	d0,d2
	add.w	d3,d4
	add.w	d3,d5
	move.l	0(a1,d0.w),d0
	move.l	0(a1,d1.w),d1
	move.l	0(a1,d2.w),d2
	move.l	0(a1,d3.w),d3
	move.l	0(a1,d4.w),d4
	move.l	0(a1,d5.w),d5
	swap	d0
	swap	d3
	sub.w	d2,d1
	sub.w	d5,d4
	asr.w	#1,d1
	asr.w	#1,d4
	sub.w	d0,d1
	sub.w	d3,d4
	move.w	d1,d6
	add.w	d4,d6
	move.w	d6,(a0)+
	sub.w	d4,d1
	move.w	d1,6(a0)
	swap	d0
	swap	d3
	swap	d1
	swap	d2
	swap	d4
	swap	d5
	sub.w	d2,d1
	sub.w	d5,d4
	asr.w	#1,d1
	asr.w	#1,d4
	add.w	d3,d4
	add.w	d0,d1
	move.w	d1,d6
	add.w	d4,d6
	move.w	d6,(a0)
	sub.w	d1,d4
	move.w	d4,4(a0)
	rts
	lea	$12410E,a3
	movea.l	a3,a4
	lea	$C(a3),a3
	addq.l	#8,a0
	movea.l	(a0)+,a2
	lea	0(a6),a1
	movem.w	(a1)+,d1-d3
	move.w	(a2)+,d0
	bra.s	l9B53C
l9B520	move.w	(a2)+,d4
	move.w	d4,d5
	move.w	d4,d6
	muls.w	d1,d4
	muls.w	d2,d5
	muls.w	d3,d6
	move.l	d4,(a3)+
	move.l	d5,(a3)+
	move.l	d6,(a3)+
	neg.l	d4
	neg.l	d5
	neg.l	d6
	movem.l	d4-d6,-(a4)
l9B53C	dbf	d0,l9B520
	lea	$12604E,a3
	movea.l	a3,a4
	lea	$C(a3),a3
	movea.l	(a0)+,a2
	movem.w	(a1)+,d1-d3
	move.w	(a2)+,d0
	bra.s	l9B572
l9B556	move.w	(a2)+,d4
	move.w	d4,d5
	move.w	d4,d6
	muls.w	d1,d4
	muls.w	d2,d5
	muls.w	d3,d6
	move.l	d4,(a3)+
	move.l	d5,(a3)+
	move.l	d6,(a3)+
	neg.l	d4
	neg.l	d5
	neg.l	d6
	movem.l	d4-d6,-(a4)
l9B572	dbf	d0,l9B556
	lea	$127F8E,a3
	movea.l	a3,a4
	lea	$C(a3),a3
	movea.l	(a0)+,a2
	movem.w	(a1)+,d1-d3
	move.w	(a2)+,d0
	bra.s	l9B5A8
l9B58C	move.w	(a2)+,d4
	move.w	d4,d5
	move.w	d4,d6
	muls.w	d1,d4
	muls.w	d2,d5
	muls.w	d3,d6
	move.l	d4,(a3)+
	move.l	d5,(a3)+
	move.l	d6,(a3)+
	neg.l	d4
	neg.l	d5
	neg.l	d6
	movem.l	d4-d6,-(a4)
l9B5A8	dbf	d0,l9B58C
	movea.l	(a0)+,a0
	move.w	(a0)+,d0
	subq.w	#1,d0
	lea	$C89AE,a4
	lea	$1E(a6),a5
	moveq	#0,d4
	move.w	$1C(a6),d4
	swap	d4
	moveq	#0,d5
	move.w	$18(a6),d5
	swap	d5
	asr.l	#4,d5
	moveq	#0,d6
	move.w	$1A(a6),d6
	swap	d6
	asr.l	#4,d6
l9B5D8	movem.l	(a4),a1-a3
	movem.w	(a0)+,d1-d3
	adda.w	d1,a1
	adda.w	d2,a2
	adda.w	d3,a3
	movem.l	(a1)+,d1-d3
	add.l	(a2)+,d1
	add.l	(a3)+,d1
	add.l	(a2)+,d2
	add.l	(a3)+,d2
	add.l	(a2)+,d3
	add.l	(a3)+,d3
	add.l	d4,d3
	add.l	d5,d1
	add.l	d6,d2
	swap	d3
	rol.l	#4,d3
	asr.l	#3,d1
	asr.l	#3,d2
	divs.w	d3,d1
	divs.w	d3,d2
	move.w	d1,(a5)+
	move.w	d2,(a5)+
	dbf	d0,l9B5D8
	rts
