	DC.W	$0,$965,$0,$9F4,$0,$A8C,$0,$B2C
	DC.W	$0,$BD6,$0,$C8B,$0,$D4A,$0,$E14
	DC.W	$0,$EEA,$0,$FCD,$0,$10BE,$0,$11BD
	DC.W	$0,$12CB,$0,$13E9,$0,$1518,$0,$1659
	DC.W	$0,$17AD,$0,$1916,$0,$1A94,$0,$1C28
	DC.W	$0,$1DD5,$0,$1F9B,$0,$217C,$0,$237A
	DC.W	$0,$2596,$0,$27D3,$0,$2A31,$0,$2CB3
	DC.W	$0,$2F5B,$0,$322C,$0,$3528,$0,$3851
	DC.W	$0,$3BAB,$0,$3F37,$0,$42F9,$0,$46F5
	DC.W	$0,$4B2D,$0,$4FA6,$0,$5462,$0,$5967
	DC.W	$0,$5EB7,$0,$6459,$0,$6A51,$0,$70A3
	DC.W	$0,$7756,$0,$7E6F,$0,$85F3,$0,$8DEA
	DC.W	$0,$965B,$0,$9F4C,$0,$A8C4,$0,$B2CE
	DC.W	$0,$BD6F,$0,$C8B3,$0,$D4A2,$0,$E147
	DC.W	$0,$EEAD,$0,$FCDE,$1,$BE7,$1,$1BD5
	DC.W	$1,$2CB6,$1,$3E98,$1,$5189,$1,$659C
