
int Cube[] = { 
		8,
		-100,100,100,
		-100,100,-100,
		 100,100,-100,
		 100,100,100,
		 -100,-100,100,
		 -100,-100,-100,
		 100,-100,-100,
		 100,-100,100,
		8,
		-2300,2300,2300,
		-2300,2300,-2300,
		 2300,2300,-2300,
		 2300,2300,2300,
		 -2300,-2300,2300,
		 -2300,-2300,-2300,
		 2300,-2300,-2300,
		 2300,-2300,2300,
		6,
		4,0*3,1*3,2*3,3*3,
		4,7*3,6*3,5*3,4*3,
		4,2*3,6*3,7*3,3*3,
		4,0*3,3*3,7*3,4*3,
		4,1*3,0*3,4*3,5*3,
		4,1*3,5*3,6*3,2*3,
		};
		
int Pyramid[]= 	{5,
		-100,-100,-100,
		100,-100,-100,
		100,-100,100,
		-100,-100,100,
		0,210,0,
		5,
		-1900,-1600,-1900,
		1900,-1600,-1900,
		1900,-1600,1900,
		-1900,-1600,1900,
		0,2900,0,
		5,
		4,3*3,2*3,1*3,00*3,
		3,0*3,1*3,4*3,
		3,2*3,3*3,4*3,
		3,1*3,2*3,4*3,
		3,3*3,0*3,4*3,
		};

int Station[]=	{12,
		0,-120,120,
		120,0,120,
		120,-120,0,
		0,120,120,
		120,0,-120,
		-120,-120,0,
		0,-120,-120,
		-120,0,120,
		120,120,0,
		0,120,-120,
		-120,0,-120,
		-120,120,0,
		12,
		0,-4000,4000,
		4000,0,4000,
		4000,-4000,0,
		0,4000,4000,
		4000,0,-4000,
		-4000,-4000,0,
		0,-4000,-4000,
		-4000,0,4000,
		4000,4000,0,
		0,4000,-4000,
		-4000,0,-4000,
		-4000,4000,0,
		14,	
		3,0*3,01*3, 2*3,
		3,9*3,11*3,10*3,
		3,4*3, 8*3, 9*3,
		3,1*3, 3*3, 8*3,
		3,3*3, 7*3,11*3,
		3,0*3, 5*3, 7*3,
		3,5*3, 6*3,10*3,
		3,2*3, 4*3, 6*3,
		4,0*3, 2*3, 6*3, 5*3,
		4,4*3, 2*3, 1*3, 8*3,
		4,0*3, 7*3, 3*3, 1*3,
		4,7*3, 5*3,10*3,11*3,
		4,8*3, 3*3,11*3, 9*3,
		4,6*3, 4*3, 9*3,10*3,
		};

/*
gasteriod	DC.W 12-1
		DC.W 0,-75,150
		DC.W 0,14755,-24414

		DC.W 150,0,75
		DC.W -24414,-1,-14755		

		DC.W 75,-150,0
		DC.W -14755,24414,0

		DC.W 0,75,150
		DC.W 0,-14755,-24414

		DC.W 150,0,-75
		DC.W -24414,-1,14755

		DC.W -75,-150,0
		DC.W 14755,24414,0		

		DC.W 0,-75,-150
		DC.W 0,14755,24414

		DC.W -150,0,75
		DC.W 24414,-1,-14755

		DC.W 75,150,0
		DC.W -14755,-24414,0		

		DC.W 0,75,-150
		DC.W 0,-14755,24414

		DC.W -150,0,-75
		DC.W 24414,0,14755

		DC.W -75,150,0
		DC.W 14755,-24414,-1

		DC.W 3,01*6,02*6,04*6
		DC.W 3,01*6,00*6,02*6
		DC.W 3,02*6,00*6,05*6
		DC.W 3,02*6,05*6,06*6
		DC.W 3,02*6,06*6,04*6
		DC.W 3,04*6,06*6,09*6
		DC.W 3,04*6,09*6,08*6
		DC.W 3,01*6,04*6,08*6
		DC.W 3,03*6,01*6,08*6
		DC.W 3,00*6,01*6,03*6
		DC.W 3,07*6,11*6,10*6
		DC.W 3,00*6,07*6,05*6
		DC.W 3,10*6,05*6,07*6
		DC.W 3,06*6,05*6,10*6
		DC.W 3,06*6,10*6,09*6
		DC.W 3,09*6,10*6,11*6
		DC.W 3,08*6,09*6,11*6
		DC.W 3,03*6,08*6,11*6
		DC.W 3,03*6,11*6,07*6
		DC.W 3,00*6,03*6,07*6
		DC.W -1

gthargoid	DC.W 16-1
		DC.W 0,200,0
		DC.W 0,11026,28307

		DC.W 140,140,0
		DC.W 7875,7875,28307

		DC.W 200,0,0
		DC.W 11026,0,28307

		DC.W 140,-140,0
		DC.W 7875,-7875,28307

		DC.W 0,-200,0
		DC.W 0,-11026,28307

		DC.W -140,-140,0
		DC.W -7875,-7875,28307

		DC.W -200,0,0
		DC.W -11026,0,28307		

		DC.W -140,140,0
		DC.W -7875,7875,28307

		DC.W 0,360,-100
		DC.W 0,11026,-16974

		DC.W 252,252,-100
		DC.W 7875,7875,-16974

		DC.W 360,0,-100
		DC.W 11026,0,-16974

		DC.W 252,-252,-100
		DC.W 7875,-7875,-16974

		DC.W 0,-360,-100		
		DC.W 0,-11026,-6974

		DC.W -252,-252,-100
		DC.W -7875,-7875,-16974

		DC.W -360,0,-100
		DC.W -11026,0,-16974

		DC.W -252,252,-100
		DC.W -7875,7875,-16974

		DC.W 8,00*6,01*6,02*6,03*6,04*6,05*6,06*6,07*6
		DC.W 8,15*6,14*6,13*6,12*6,11*6,10*6,09*6,08*6
		DC.W 4,06*6,14*6,15*6,07*6
		DC.W 4,05*6,13*6,14*6,06*6
		DC.W 4,04*6,12*6,13*6,05*6
		DC.W 4,03*6,11*6,12*6,04*6
		DC.W 4,02*6,10*6,11*6,03*6
		DC.W 4,01*6,09*6,10*6,02*6
		DC.W 4,00*6,08*6,09*6,01*6
		DC.W 4,07*6,15*6,08*6,00*6
		DC.W -1
*/
	
int Cube2[] = { 
		11,
		0,0,0,
		-100,100,-100,
		100,100,-100,
		-100,-100,-100,
		100,-100,-100,
		-100,100,100,
		100,100,100,
		-100,-100,100,
		100,-100,100,
		0,200,0,
		0,-200,0,
		11,
		0,0,0,
		-100,100,-100,
		100,100,-100,
		-100,-100,-100,
		100,-100,-100,
		-100,100,100,
		100,100,100,
		-100,-100,100,
		100,-100,100,
		0,200,0,
		0,-200,0,
		12,
		4,1*3,2*3,4*3,3*3,
		4,1*3,3*3,7*3,5*3,
		4,2*3,6*3,8*3,4*3,
		4,5*3,7*3,8*3,6*3,
		3,1*3,9*3,2*3,
		3,1*3,5*3,9*3,
		3,5*3,6*3,9*3,
		3,2*3,9*3,6*3,
		3,3*3,4*3,10*3,
		3,3*3,10*3,7*3,
		3,7*3,10*3,8*3,
		3,4*3,8*3,10*3,
	};
