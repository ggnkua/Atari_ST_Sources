
int Cube[] = { 
		8,
		-100,100,100,
		-100,100,-100,
		 100,100,-100,
		 100,100,100,
		 -100,-100,100,
		 -100,-100,-100,
		 100,-100,-100,
		 100,-100,100,
		8,
		-2300,2300,2300,
		-2300,2300,-2300,
		 2300,2300,-2300,
		 2300,2300,2300,
		 -2300,-2300,2300,
		 -2300,-2300,-2300,
		 2300,-2300,-2300,
		 2300,-2300,2300,
		6,
		4,0*3,1*3,2*3,3*3,
		4,7*3,6*3,5*3,4*3,
		4,2*3,6*3,7*3,3*3,
		4,0*3,3*3,7*3,4*3,
		4,1*3,0*3,4*3,5*3,
		4,1*3,5*3,6*3,2*3,
		};
		
int Pyramid[]=  {5,
		-100,-100,-100,
		100,-100,-100,
		100,-100,100,
		-100,-100,100,
		0,210,0,
		5,
		-1900,-1600,-1900,
		1900,-1600,-1900,
		1900,-1600,1900,
		-1900,-1600,1900,
		0,2900,0,
		5,
		4,3*3,2*3,1*3,00*3,
		3,0*3,1*3,4*3,
		3,2*3,3*3,4*3,
		3,1*3,2*3,4*3,
		3,3*3,0*3,4*3,
		};

int Station[]=  {12,
		0,-120,120,
		120,0,120,
		120,-120,0,
		0,120,120,
		120,0,-120,
		-120,-120,0,
		0,-120,-120,
		-120,0,120,
		120,120,0,
		0,120,-120,
		-120,0,-120,
		-120,120,0,
		12,
		0,-4000,4000,
		4000,0,4000,
		4000,-4000,0,
		0,4000,4000,
		4000,0,-4000,
		-4000,-4000,0,
		0,-4000,-4000,
		-4000,0,4000,
		4000,4000,0,
		0,4000,-4000,
		-4000,0,-4000,
		-4000,4000,0,
		14,     
		3,0*3,01*3, 2*3,
		3,9*3,11*3,10*3,
		3,4*3, 8*3, 9*3,
		3,1*3, 3*3, 8*3,
		3,3*3, 7*3,11*3,
		3,0*3, 5*3, 7*3,
		3,5*3, 6*3,10*3,
		3,2*3, 4*3, 6*3,
		4,0*3, 2*3, 6*3, 5*3,
		4,4*3, 2*3, 1*3, 8*3,
		4,0*3, 7*3, 3*3, 1*3,
		4,7*3, 5*3,10*3,11*3,
		4,8*3, 3*3,11*3, 9*3,
		4,6*3, 4*3, 9*3,10*3,
		};

int Asteriod[]= {12,
		0,-75,150,
		150,0,75,
		75,-150,0,
		0,75,150,
		150,0,-75,
		-75,-150,0,
		0,-75,-150,
		-150,0,75,
		75,150,0,
		0,75,-150,
		-150,0,-75,
		-75,150,0,
		12,
		0,14755/8,-24414/8,
		-24414/8,-1,-14755/8,
		-14755/8,24414/8,0,
		0,-14755/8,-24414/8,
		-24414/8,-1,14755/8,
		14755/8,24414/8,0,
		0,14755/8,24414/8,
		24414/8,-1,-14755/8,
		-14755/8,-24414/8,0,
		0,-14755/8,24414/8,
		24414/8,0,14755/8,
		14755/8,-24414/8,-1,
		20,
		3,01*3,02*3,04*3,
		3,01*3,00*3,02*3,
		3,02*3, 0*3,05*3,
		3,02*3, 5*3,06*3,
		3,02*3, 6*3,04*3,
		3,04*3, 6*3, 9*3,
		3,04*3, 9*3, 8*3,
		3,01*3,04*3, 8*3,
		3,03*3,01*3, 8*3,
		3,00*3,01*3, 3*3,
		3,07*3,11*3,10*3,
		3,00*3,07*3, 5*3,
		3,10*3,05*3, 7*3,
		3,06*3,05*3,10*3,
		3,06*3,10*3, 9*3,
		3, 9*3,10*3,11*3,
		3, 8*3, 9*3,11*3,
		3,03*3, 8*3,11*3,
		3,03*3,11*3, 7*3,
		3,00*3,03*3, 7*3
		};

/*
gthargoid       DC.W 16-1
		DC.W 0,200,0
		DC.W 0,11026,28307

		DC.W 140,140,0
		DC.W 7875,7875,28307

		DC.W 200,0,0
		DC.W 11026,0,28307

		DC.W 140,-140,0
		DC.W 7875,-7875,28307

		DC.W 0,-200,0
		DC.W 0,-11026,28307

		DC.W -140,-140,0
		DC.W -7875,-7875,28307

		DC.W -200,0,0
		DC.W -11026,0,28307             

		DC.W -140,140,0
		DC.W -7875,7875,28307

		DC.W 0,360,-100
		DC.W 0,11026,-16974

		DC.W 252,252,-100
		DC.W 7875,7875,-16974

		DC.W 360,0,-100
		DC.W 11026,0,-16974

		DC.W 252,-252,-100
		DC.W 7875,-7875,-16974

		DC.W 0,-360,-100                
		DC.W 0,-11026,-6974

		DC.W -252,-252,-100
		DC.W -7875,-7875,-16974

		DC.W -360,0,-100
		DC.W -11026,0,-16974

		DC.W -252,252,-100
		DC.W -7875,7875,-16974

		DC.W 8,00*3,01*3,02*3,03*3,04*3,05*3,06*3,07*3
		DC.W 8,15*3,14*3,13*3,12*3,11*3,10*3,09*3,08*3
		DC.W 4,06*3,14*3,15*3,07*3
		DC.W 4,05*3,13*3,14*3,06*3
		DC.W 4,04*3,12*3,13*3,05*3
		DC.W 4,03*3,11*3,12*3,04*3
		DC.W 4,02*3,10*3,11*3,03*3
		DC.W 4,01*3,09*3,10*3,02*3
		DC.W 4,00*3,08*3,09*3,01*3
		DC.W 4,07*3,15*3,08*3,00*3
		DC.W -1
*/
	
int Cube2[] = { 
		11,
		0,0,0,
		-100,100,-100,
		100,100,-100,
		-100,-100,-100,
		100,-100,-100,
		-100,100,100,
		100,100,100,
		-100,-100,100,
		100,-100,100,
		0,200,0,
		0,-200,0,
		11,
		0,0,0,
		-1000,1000,-1000,
		1000,1000,-1000,
		-1000,-1000,-1000,
		1000,-1000,-1000,
		-1000,1000,1000,
		1000,1000,1000,
		-1000,-1000,1000,
		1000,-1000,1000,
		0,2000,0,
		0,-2000,0,
		12,
		4,1*3,2*3,4*3,3*3,
		4,1*3,3*3,7*3,5*3,
		4,2*3,6*3,8*3,4*3,
		4,5*3,7*3,8*3,6*3,
		3,1*3,9*3,2*3,
		3,1*3,5*3,9*3,
		3,5*3,6*3,9*3,
		3,2*3,9*3,6*3,
		3,3*3,4*3,10*3,
		3,3*3,10*3,7*3,
		3,7*3,10*3,8*3,
		3,4*3,8*3,10*3,
	};
