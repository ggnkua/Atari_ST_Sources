
LABEL trig_tab WORD
	dw    00000h,000C9h,00192h,0025Bh,00324h,003EDh,004B6h,0057Eh
	dw    00647h,00710h,007D9h,008A1h,0096Ah,00A32h,00AFBh,00BC3h
	dw    00C8Bh,00D53h,00E1Bh,00EE3h,00FABh,01072h,01139h,01200h
	dw    012C7h,0138Eh,01455h,0151Bh,015E1h,016A7h,0176Dh,01833h
	dw    018F8h,019BDh,01A82h,01B46h,01C0Bh,01CCFh,01D93h,01E56h
	dw    01F19h,01FDCh,0209Fh,02161h,02223h,022E4h,023A6h,02467h
	dw    02527h,025E7h,026A7h,02767h,02826h,028E5h,029A3h,02A61h
	dw    02B1Eh,02BDBh,02C98h,02D54h,02E10h,02ECCh,02F86h,03041h
	dw    030FBh,031B4h,0326Dh,03326h,033DEh,03496h,0354Dh,03603h
	dw    036B9h,0376Fh,03824h,038D8h,0398Ch,03A3Fh,03AF2h,03BA4h
	dw    03C56h,03D07h,03DB7h,03E67h,03F16h,03FC5h,04073h,04120h
	dw    041CDh,04279h,04325h,043D0h,0447Ah,04523h,045CCh,04674h
	dw    0471Ch,047C3h,04869h,0490Eh,049B3h,04A57h,04AFAh,04B9Dh
	dw    04C3Fh,04CE0h,04D80h,04E20h,04EBFh,04F5Dh,04FFAh,05097h
	dw    05133h,051CEh,05268h,05301h,0539Ah,05432h,054C9h,0555Fh
	dw    055F4h,05689h,0571Dh,057B0h,05842h,058D3h,05963h,059F3h
	dw    05A81h,05B0Fh,05B9Ch,05C28h,05CB3h,05D3Dh,05DC6h,05E4Fh
	dw    05ED6h,05F5Dh,05FE2h,06067h,060EBh,0616Eh,061F0h,06271h
	dw    062F1h,06370h,063EEh,0646Bh,064E7h,06562h,065DDh,06656h
	dw    066CEh,06745h,067BCh,06831h,068A5h,06919h,0698Bh,069FCh
	dw    06A6Ch,06ADBh,06B4Ah,06BB7h,06C23h,06C8Eh,06CF8h,06D61h
	dw    06DC9h,06E30h,06E95h,06EFAh,06F5Eh,06FC0h,07022h,07082h
	dw    070E1h,07140h,0719Dh,071F9h,07254h,072AEh,07306h,0735Eh
	dw    073B5h,0740Ah,0745Eh,074B1h,07503h,07554h,075A4h,075F3h
	dw    07640h,0768Dh,076D8h,07722h,0776Bh,077B3h,077F9h,0783Fh
	dw    07883h,078C6h,07908h,07949h,07989h,079C7h,07A04h,07A41h
	dw    07A7Ch,07AB5h,07AEEh,07B25h,07B5Ch,07B91h,07BC4h,07BF7h
	dw    07C29h,07C59h,07C88h,07CB6h,07CE2h,07D0Eh,07D38h,07D61h
	dw    07D89h,07DB0h,07DD5h,07DF9h,07E1Ch,07E3Eh,07E5Eh,07E7Eh
	dw    07E9Ch,07EB9h,07ED4h,07EEFh,07F08h,07F20h,07F37h,07F4Ch
	dw    07F61h,07F74h,07F86h,07F96h,07FA6h,07FB4h,07FC1h,07FCDh
	dw    07FD7h,07FE0h,07FE8h,07FEFh,07FF5h,07FF9h,07FFCh,07FFEh
	dw    07FFFh,07FFEh,07FFCh,07FF9h,07FF5h,07FEFh,07FE8h,07FE0h
	dw    07FD7h,07FCDh,07FC1h,07FB4h,07FA6h,07F96h,07F86h,07F74h
	dw    07F61h,07F4Ch,07F37h,07F20h,07F08h,07EEFh,07ED4h,07EB9h
	dw    07E9Ch,07E7Eh,07E5Eh,07E3Eh,07E1Ch,07DF9h,07DD5h,07DB0h
	dw    07D89h,07D61h,07D38h,07D0Eh,07CE2h,07CB6h,07C88h,07C59h
	dw    07C29h,07BF7h,07BC4h,07B91h,07B5Ch,07B25h,07AEEh,07AB5h
	dw    07A7Ch,07A41h,07A04h,079C7h,07989h,07949h,07908h,078C6h
	dw    07883h,0783Fh,077F9h,077B3h,0776Bh,07722h,076D8h,0768Dh
	dw    07640h,075F3h,075A4h,07554h,07503h,074B1h,0745Eh,0740Ah
	dw    073B5h,0735Eh,07306h,072AEh,07254h,071F9h,0719Dh,07140h
	dw    070E1h,07082h,07022h,06FC0h,06F5Eh,06EFAh,06E95h,06E30h
	dw    06DC9h,06D61h,06CF8h,06C8Eh,06C23h,06BB7h,06B4Ah,06ADBh
	dw    06A6Ch,069FCh,0698Bh,06919h,068A5h,06831h,067BCh,06745h
	dw    066CEh,06656h,065DDh,06562h,064E7h,0646Bh,063EEh,06370h
	dw    062F1h,06271h,061F0h,0616Eh,060EBh,06067h,05FE2h,05F5Dh
	dw    05ED6h,05E4Fh,05DC6h,05D3Dh,05CB3h,05C28h,05B9Ch,05B0Fh
	dw    05A81h,059F3h,05963h,058D3h,05842h,057B0h,0571Dh,05689h
	dw    055F4h,0555Fh,054C9h,05432h,0539Ah,05301h,05268h,051CEh
	dw    05133h,05097h,04FFAh,04F5Dh,04EBFh,04E20h,04D80h,04CE0h
	dw    04C3Fh,04B9Dh,04AFAh,04A57h,049B3h,0490Eh,04869h,047C3h
	dw    0471Ch,04674h,045CCh,04523h,0447Ah,043D0h,04325h,04279h
	dw    041CDh,04120h,04073h,03FC5h,03F16h,03E67h,03DB7h,03D07h
	dw    03C56h,03BA4h,03AF2h,03A3Fh,0398Ch,038D8h,03824h,0376Fh
	dw    036B9h,03603h,0354Dh,03496h,033DEh,03326h,0326Dh,031B4h
	dw    030FBh,03041h,02F86h,02ECCh,02E10h,02D54h,02C98h,02BDBh
	dw    02B1Eh,02A61h,029A3h,028E5h,02826h,02767h,026A7h,025E7h
	dw    02527h,02467h,023A6h,022E4h,02223h,02161h,0209Fh,01FDCh
	dw    01F19h,01E56h,01D93h,01CCFh,01C0Bh,01B46h,01A82h,019BDh
	dw    018F8h,01833h,0176Dh,016A7h,015E1h,0151Bh,01455h,0138Eh
	dw    012C7h,01200h,01139h,01072h,00FABh,00EE3h,00E1Bh,00D53h
	dw    00C8Bh,00BC3h,00AFBh,00A32h,0096Ah,008A1h,007D9h,00710h
	dw    00647h,0057Eh,004B6h,003EDh,00324h,0025Bh,00192h,000C9h
	dw    00000h,0FF37h,0FE6Eh,0FDA5h,0FCDCh,0FC13h,0FB4Ah,0FA82h
	dw    0F9B9h,0F8F0h,0F827h,0F75Fh,0F696h,0F5CEh,0F505h,0F43Dh
	dw    0F375h,0F2ADh,0F1E5h,0F11Dh,0F055h,0EF8Eh,0EEC7h,0EE00h
	dw    0ED39h,0EC72h,0EBABh,0EAE5h,0EA1Fh,0E959h,0E893h,0E7CDh
	dw    0E708h,0E643h,0E57Eh,0E4BAh,0E3F5h,0E331h,0E26Dh,0E1AAh
	dw    0E0E7h,0E024h,0DF61h,0DE9Fh,0DDDDh,0DD1Ch,0DC5Ah,0DB99h
	dw    0DAD9h,0DA19h,0D959h,0D899h,0D7DAh,0D71Bh,0D65Dh,0D59Fh
	dw    0D4E2h,0D425h,0D368h,0D2ACh,0D1F0h,0D134h,0D07Ah,0CFBFh
	dw    0CF05h,0CE4Ch,0CD93h,0CCDAh,0CC22h,0CB6Ah,0CAB3h,0C9FDh
	dw    0C947h,0C891h,0C7DCh,0C728h,0C674h,0C5C1h,0C50Eh,0C45Ch
	dw    0C3AAh,0C2F9h,0C249h,0C199h,0C0EAh,0C03Bh,0BF8Dh,0BEE0h
	dw    0BE33h,0BD87h,0BCDBh,0BC30h,0BB86h,0BADDh,0BA34h,0B98Ch
	dw    0B8E4h,0B83Dh,0B797h,0B6F2h,0B64Dh,0B5A9h,0B506h,0B463h
	dw    0B3C1h,0B320h,0B280h,0B1E0h,0B141h,0B0A3h,0B006h,0AF69h
	dw    0AECDh,0AE32h,0AD98h,0ACFFh,0AC66h,0ABCEh,0AB37h,0AAA1h
	dw    0AA0Ch,0A977h,0A8E3h,0A850h,0A7BEh,0A72Dh,0A69Dh,0A60Dh
	dw    0A57Fh,0A4F1h,0A464h,0A3D8h,0A34Dh,0A2C3h,0A23Ah,0A1B1h
	dw    0A12Ah,0A0A3h,0A01Eh,09F99h,09F15h,09E92h,09E10h,09D8Fh
	dw    09D0Fh,09C90h,09C12h,09B95h,09B19h,09A9Eh,09A23h,099AAh
	dw    09932h,098BBh,09844h,097CFh,0975Bh,096E7h,09675h,09604h
	dw    09594h,09525h,094B6h,09449h,093DDh,09372h,09308h,0929Fh
	dw    09237h,091D0h,0916Bh,09106h,090A2h,09040h,08FDEh,08F7Eh
	dw    08F1Fh,08EC0h,08E63h,08E07h,08DACh,08D52h,08CFAh,08CA2h
	dw    08C4Bh,08BF6h,08BA2h,08B4Fh,08AFDh,08AACh,08A5Ch,08A0Dh
	dw    089C0h,08973h,08928h,088DEh,08895h,0884Dh,08807h,087C1h
	dw    0877Dh,0873Ah,086F8h,086B7h,08677h,08639h,085FCh,085BFh
	dw    08584h,0854Bh,08512h,084DBh,084A4h,0846Fh,0843Ch,08409h
	dw    083D7h,083A7h,08378h,0834Ah,0831Eh,082F2h,082C8h,0829Fh
	dw    08277h,08250h,0822Bh,08207h,081E4h,081C2h,081A2h,08182h
	dw    08164h,08147h,0812Ch,08111h,080F8h,080E0h,080C9h,080B4h
	dw    0809Fh,0808Ch,0807Ah,0806Ah,0805Ah,0804Ch,0803Fh,08033h
	dw    08029h,08020h,08018h,08011h,0800Bh,08007h,08004h,08002h
	dw    08001h,08002h,08004h,08007h,0800Bh,08011h,08018h,08020h
	dw    08029h,08033h,0803Fh,0804Ch,0805Ah,0806Ah,0807Ah,0808Ch
	dw    0809Fh,080B4h,080C9h,080E0h,080F8h,08111h,0812Ch,08147h
	dw    08164h,08182h,081A2h,081C2h,081E4h,08207h,0822Bh,08250h
	dw    08277h,0829Fh,082C8h,082F2h,0831Eh,0834Ah,08378h,083A7h
	dw    083D7h,08409h,0843Ch,0846Fh,084A4h,084DBh,08512h,0854Bh
	dw    08584h,085BFh,085FCh,08639h,08677h,086B7h,086F8h,0873Ah
	dw    0877Dh,087C1h,08807h,0884Dh,08895h,088DEh,08928h,08973h
	dw    089C0h,08A0Dh,08A5Ch,08AACh,08AFDh,08B4Fh,08BA2h,08BF6h
	dw    08C4Bh,08CA2h,08CFAh,08D52h,08DACh,08E07h,08E63h,08EC0h
	dw    08F1Fh,08F7Eh,08FDEh,09040h,090A2h,09106h,0916Bh,091D0h
	dw    09237h,0929Fh,09308h,09372h,093DDh,09449h,094B6h,09525h
	dw    09594h,09604h,09675h,096E7h,0975Bh,097CFh,09844h,098BBh
	dw    09932h,099AAh,09A23h,09A9Eh,09B19h,09B95h,09C12h,09C90h
	dw    09D0Fh,09D8Fh,09E10h,09E92h,09F15h,09F99h,0A01Eh,0A0A3h
	dw    0A12Ah,0A1B1h,0A23Ah,0A2C3h,0A34Dh,0A3D8h,0A464h,0A4F1h
	dw    0A57Fh,0A60Dh,0A69Dh,0A72Dh,0A7BEh,0A850h,0A8E3h,0A977h
	dw    0AA0Ch,0AAA1h,0AB37h,0ABCEh,0AC66h,0ACFFh,0AD98h,0AE32h
	dw    0AECDh,0AF69h,0B006h,0B0A3h,0B141h,0B1E0h,0B280h,0B320h
	dw    0B3C1h,0B463h,0B506h,0B5A9h,0B64Dh,0B6F2h,0B797h,0B83Dh
	dw    0B8E4h,0B98Ch,0BA34h,0BADDh,0BB86h,0BC30h,0BCDBh,0BD87h
	dw    0BE33h,0BEE0h,0BF8Dh,0C03Bh,0C0EAh,0C199h,0C249h,0C2F9h
	dw    0C3AAh,0C45Ch,0C50Eh,0C5C1h,0C674h,0C728h,0C7DCh,0C891h
	dw    0C947h,0C9FDh,0CAB3h,0CB6Ah,0CC22h,0CCDAh,0CD93h,0CE4Ch
	dw    0CF05h,0CFBFh,0D07Ah,0D134h,0D1F0h,0D2ACh,0D368h,0D425h
	dw    0D4E2h,0D59Fh,0D65Dh,0D71Bh,0D7DAh,0D899h,0D959h,0DA19h
	dw    0DAD9h,0DB99h,0DC5Ah,0DD1Ch,0DDDDh,0DE9Fh,0DF61h,0E024h
	dw    0E0E7h,0E1AAh,0E26Dh,0E331h,0E3F5h,0E4BAh,0E57Eh,0E643h
	dw    0E708h,0E7CDh,0E893h,0E959h,0EA1Fh,0EAE5h,0EBABh,0EC72h
	dw    0ED39h,0EE00h,0EEC7h,0EF8Eh,0F055h,0F11Dh,0F1E5h,0F2ADh
	dw    0F375h,0F43Dh,0F505h,0F5CEh,0F696h,0F75Fh,0F827h,0F8F0h
	dw    0F9B9h,0FA82h,0FB4Ah,0FC13h,0FCDCh,0FDA5h,0FE6Eh,0FF37h
	dw    00000h,000C9h,00192h,0025Bh,00324h,003EDh,004B6h,0057Eh
	dw    00647h,00710h,007D9h,008A1h,0096Ah,00A32h,00AFBh,00BC3h
	dw    00C8Bh,00D53h,00E1Bh,00EE3h,00FABh,01072h,01139h,01200h
	dw    012C7h,0138Eh,01455h,0151Bh,015E1h,016A7h,0176Dh,01833h
	dw    018F8h,019BDh,01A82h,01B46h,01C0Bh,01CCFh,01D93h,01E56h
	dw    01F19h,01FDCh,0209Fh,02161h,02223h,022E4h,023A6h,02467h
	dw    02527h,025E7h,026A7h,02767h,02826h,028E5h,029A3h,02A61h
	dw    02B1Eh,02BDBh,02C98h,02D54h,02E10h,02ECCh,02F86h,03041h
	dw    030FBh,031B4h,0326Dh,03326h,033DEh,03496h,0354Dh,03603h
	dw    036B9h,0376Fh,03824h,038D8h,0398Ch,03A3Fh,03AF2h,03BA4h
	dw    03C56h,03D07h,03DB7h,03E67h,03F16h,03FC5h,04073h,04120h
	dw    041CDh,04279h,04325h,043D0h,0447Ah,04523h,045CCh,04674h
	dw    0471Ch,047C3h,04869h,0490Eh,049B3h,04A57h,04AFAh,04B9Dh
	dw    04C3Fh,04CE0h,04D80h,04E20h,04EBFh,04F5Dh,04FFAh,05097h
	dw    05133h,051CEh,05268h,05301h,0539Ah,05432h,054C9h,0555Fh
	dw    055F4h,05689h,0571Dh,057B0h,05842h,058D3h,05963h,059F3h
	dw    05A81h,05B0Fh,05B9Ch,05C28h,05CB3h,05D3Dh,05DC6h,05E4Fh
	dw    05ED6h,05F5Dh,05FE2h,06067h,060EBh,0616Eh,061F0h,06271h
	dw    062F1h,06370h,063EEh,0646Bh,064E7h,06562h,065DDh,06656h
	dw    066CEh,06745h,067BCh,06831h,068A5h,06919h,0698Bh,069FCh
	dw    06A6Ch,06ADBh,06B4Ah,06BB7h,06C23h,06C8Eh,06CF8h,06D61h
	dw    06DC9h,06E30h,06E95h,06EFAh,06F5Eh,06FC0h,07022h,07082h
	dw    070E1h,07140h,0719Dh,071F9h,07254h,072AEh,07306h,0735Eh
	dw    073B5h,0740Ah,0745Eh,074B1h,07503h,07554h,075A4h,075F3h
	dw    07640h,0768Dh,076D8h,07722h,0776Bh,077B3h,077F9h,0783Fh
	dw    07883h,078C6h,07908h,07949h,07989h,079C7h,07A04h,07A41h
	dw    07A7Ch,07AB5h,07AEEh,07B25h,07B5Ch,07B91h,07BC4h,07BF7h
	dw    07C29h,07C59h,07C88h,07CB6h,07CE2h,07D0Eh,07D38h,07D61h
	dw    07D89h,07DB0h,07DD5h,07DF9h,07E1Ch,07E3Eh,07E5Eh,07E7Eh
	dw    07E9Ch,07EB9h,07ED4h,07EEFh,07F08h,07F20h,07F37h,07F4Ch
	dw    07F61h,07F74h,07F86h,07F96h,07FA6h,07FB4h,07FC1h,07FCDh
	dw    07FD7h,07FE0h,07FE8h,07FEFh,07FF5h,07FF9h,07FFCh,07FFEh

