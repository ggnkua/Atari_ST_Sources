short playgray[] = {
		0x0,0x0,0x0,0x0,0x20a,0xf080,0x1,0xd00,
		0x0,0x0,0x2600,0x2,0xbf0,0x8000,0x40,0x0,
		0x0,0x28,0x0,0x20b,0xf080,0x1,0x6d00,0x0,
		0x0,0x4000,0x230,0xf0,0xb805,0xbb,0x60f4,0x0,
		0x40,0xaa9,0x8000,0x44,0x84e,0x2b06,0xba0,0x2000,
		0x3256,0x7000,0x1,0xc006,0x480,0x0,0xfb60,0x7000,
		0x1,0xc122,0x1213,0x640,0xa056,0x5a00,0xaa9,0x8000,
		0x52,0x844,0x2b46,0xf400,0x0,0x8045,0xf4d0,0x400,
		0x21,0x400,0x62f4,0xa000,0xa0,0x5660,0xa,0xa980,
		0x0,0x5d08,0x442b,0x61f4,0xd000,0x0,0xaf0,0xaa00,
		0x7c,0xaa9,0x8000,0x64,0x844,0x2b48,0x59d0,0xe20,
		0x6422,0x3c00,0x61f4,0x0,0x0,0x62f4,0x0,0xa0,
		0x63f4,0x0,0x60,0x6dc,0x0,0x7b,0x73e1,0x4c,
		0xd900,0x7aeb,0x47,0xf000,0x1,0xc04d,0xea00,0x2358,
		0xf021,0x500,0x2000,0xa056,0x6800,0x64f4,0x0,0x40,
		0x51f,0xa438,0x800,0x507,0xa061,0xf400,0x0,0x62,
		0xf400,0x0,0x739,0x500,0x3a0b,0xf0,0x9800,0x608,
		0x8000,0xb2,0xf098,0xd0f0,0x98d8,0xf098,0xd2f0,0x98da,
		0xf098,0xd2f0,0x98da,0xf098,0xd2f5,0x98da,0xf098,0x1851,
		0x5916,0x5052,0xf0f0,0x98d8,0xf098,0xd2f0,0x98da,0xf098,
		0xd2f0,0x98da,0xf098,0xd2f5,0x98da,0xf098,0x1851,0x5916,
		0x5052,0xf0f0,0x98d8,0xf098,0xd2f0,0x98da,0xf098,0xd2f0,
		0x98da,0xf098,0xd2f5,0x98da,0xf098,0x1851,0x5916,0x5052,
		0xf0f0,0x98d8,0xf098,0xd2f0,0x98da,0xf098,0xd2f0,0x98da,
		0xf098,0xd220,0x48da,0xf098,0x1851,0x4916,0x504a,0x61,
		0xf000,0x1,0xc160,0xf400,0x0,0x22,0x3200,0x3a38,
		0x5,0x3fa0,0x204a,0x5,0x1fa1,0x51f,0xa264,0xf400,
		0x0,0x4039,0x800,0x72f4,0xff,0xfff8,0xf088,0x6,
		0x880,0x0,0xeff0,0x88d0,0xf088,0xd8f0,0x88d2,0xf088,
		0xdaf0,0x88d2,0xf088,0xdaf0,0x88d2,0xf588,0xdaf0,0x8818,
		0x5749,0x1656,0x4af0,0xf088,0xd8f0,0x88d2,0xf088,0xdaf0,
		0x88d2,0xf088,0xdaf0,0x88d2,0xf588,0xdaf0,0x8818,0x5749,
		0x1656,0x4af0,0xf088,0xd8f0,0x88d2,0xf088,0xdaf0,0x88d2,
		0xf088,0xdaf0,0x88d2,0xf588,0xdaf0,0x8818,0x5749,0x1656,
		0x4af0,0xf088,0xd8f0,0x88d2,0xf088,0xdaf0,0x88d2,0xf088,
		0xdaf0,0x88d2,0x2058,0xdaf0,0x8818,0x5749,0x1656,0x4a00,
		0x2059,0x20,0x5a00,0x60f0,0x0,0x1c1,0x3840,0x5,
		0xf424,0xffff,0xff20,0x4800,0x5f4,0x20ff,0xffff,0x5f4,
		0x21ff,0xffff,0x5f4,0x22ff,0xffff,0x61f4,0x0,0x40,
		0x65f4,0x0,0x2001,0x3d02,0x64,0xf400,0x17,0x79,
		0xcd00,0x600,0x8100,0x10a,0x74e9,0x79,0xcd00,0xaa9,
		0x8100,0x108,0x8ec,0xeb00,0x0,0xc00,0x4208,0xf4bf,
		0xc,0x8,0xf4a0,0x0,0x108,0xf4be,0x0,0x0,
		0xf0b8,0xaa8,0x2205,0xf420,0xffff,0xff05,0xf421,0xffff,
		0xff05,0xf422,0xffff,0xff05,0xf423,0xffff,0xff05,0xf424,
		0xffff,0xff05,0xf425,0xffff,0xff05,0xf426,0xffff,0xff05,
		0xf427,0xffff,0xff64,0xf400,0x10,0x65,0xf400,0x12,
		0x66,0xf400,0x14,0x67,0xf400,0x16,0x46,0xf400,
		0x0,0x6,0x8080,0x1,0x344e,0x5c00,0x4e5d,0x4e,
		0x5e00,0x4e5f,0x30,0x0,0x70f4,0x0,0x100,0x45f4,
		0x0,0xf800,0x600,0x8100,0x146,0x220f,0x44,0xf46e,
		0x400,0x21,0xe600,0x5f5c,0x44,0xf4d0,0x10,0x5e,
		0x5d18,0x2048,0xd05e,0x5e18,0x5f5f,0x46,0xf400,0xf8,
		0x47,0xf400,0x7,0xc044,0xf400,0x0,0x1f45,0xf400,
		0xff,0xdf06,0x8080,0x1,0x544e,0x5c00,0x4f5d,0x4c,
		0x5e00,0x4d5f,0x64,0xf400,0x18,0x46,0xf400,0x0,
		0x6,0x8081,0x1,0x5c4e,0x5c00,0x4e5c,0x30,0x0,
		0x3801,0x6,0x81,0x1,0x6422,0xe00,0x2048,0x5e,
		0x5c00,0x5e5c,0x46,0xf400,0x0,0xff06,0x8081,0x1,
		0x6a4e,0x5c00,0x4e5c,0x0,0x0,0xc01,0x6b00,0xf0b8,
		0x0,0xa,0xa980,0x1,0x6f08,0x70eb,0x0,0xa00a,
		0xa980,0x1,0x7308,0x70eb,0x0,0xa10a,0xa980,0x1,
		0x7708,0x70eb,0x0,0xa20a,0xa980,0x1,0x7b08,0x70eb,
		0x0,0xa30a,0xa980,0x1,0x7f08,0x70eb,0x0,0xa40a,
		0xa980,0x1,0x8308,0x70eb,0x0,0xa50a,0xa980,0x1,
		0x8708,0x70eb,0x0,0xa60a,0xa980,0x1,0x8b08,0x70eb,
		0x0,0xa70a,0xa980,0x1,0x8f08,0x70eb,0x0,0xa80a,
		0xa980,0x1,0x9308,0x70eb,0x0,0xa90a,0xa980,0x1,
		0x9708,0x70eb,0x0,0xaa0a,0xa980,0x1,0x9b08,0x70eb,
		0x0,0xab0a,0xa980,0x1,0x9f08,0x70eb,0x0,0xac0a,
		0xa980,0x1,0xa308,0x70eb,0x0,0xad0a,0xa980,0x1,
		0xa708,0x70eb,0x0,0xae0a,0xa980,0x1,0xab08,0x70eb,
		0x0,0xaf0a,0xa980,0x1,0xaf08,0x70eb,0x0,0xb00a,
		0xa980,0x1,0xb308,0x70eb,0x0,0xb10a,0xa980,0x1,
		0xb708,0x70eb,0x0,0xb20a,0xa980,0x1,0xbb08,0x70eb,
		0x0,0xb30a,0xa980,0x1,0xbf08,0x70eb,0x0,0xb40a,
		0xa980,0x1,0xc308,0x70eb,0x0,0xb50a,0xa980,0x1,
		0xc708,0x70eb,0x0,0xb60a,0xa980,0x1,0xcb08,0x70eb,
		0x0,0xb70a,0xa980,0x1,0xcf08,0x70eb,0x0,0xb80a,
		0xa980,0x1,0xd308,0x70eb,0x0,0xb90a,0xa980,0x1,
		0xd708,0x70eb,0x0,0xba0a,0xa980,0x1,0xdb08,0x70eb,
		0x0,0xbb0a,0xa980,0x1,0xdf08,0x70eb,0x0,0xbc0a,
		0xa980,0x1,0xe308,0x70eb,0x0,0xbd0a,0xa980,0x1,
		0xe708,0x70eb,0x0,0xbe0a,0xa980,0x1,0xeb08,0x70eb,
		0x0,0xbf0a,0xa980,0x1,0xef08,0x70eb,0x0,0xc00a,
		0xa980,0x1,0xf308,0x70eb,0x0,0xc10a,0xa980,0x1,
		0xf708,0x70eb,0x0,0xc20a,0xa980,0x1,0xfb08,0x70eb,
		0x0,0xc30a,0xa980,0x1,0xff08,0x70eb,0x0,0xc40a,
		0xa980,0x2,0x308,0x70eb,0x0,0xc50a,0xa980,0x2,
		0x708,0x70eb,0x0,0xc60a,0xa980,0x2,0xb08,0x70eb,
		0x0,0xc70a,0xa980,0x2,0xf08,0x70eb,0x0,0xc80a,
		0xa980,0x2,0x1308,0x70eb,0x0,0xc90a,0xa980,0x2,
		0x1708,0x70eb,0x0,0xca0a,0xa980,0x2,0x1b08,0x70eb,
		0x0,0xcb0a,0xa980,0x2,0x1f08,0x70eb,0x0,0xcc0a,
		0xa980,0x2,0x2308,0x70eb,0x0,0xcd0a,0xa980,0x2,
		0x2708,0x70eb,0x0,0xce0a,0xa980,0x2,0x2b08,0x70eb,
		0x0,0xcf0a,0xa980,0x2,0x2f08,0x70eb,0x0,0xd00a,
		0xa980,0x2,0x3308,0x70eb,0x0,0xd10a,0xa980,0x2,
		0x3708,0x70eb,0x0,0xd20a,0xa980,0x2,0x3b08,0x70eb,
		0x0,0xd30a,0xa980,0x2,0x3f08,0x70eb,0x0,0xd40a,
		0xa980,0x2,0x4308,0x70eb,0x0,0xd50a,0xa980,0x2,
		0x4708,0x70eb,0x0,0xd60a,0xa980,0x2,0x4b08,0x70eb,
		0x0,0xd70a,0xa980,0x2,0x4f08,0x70eb,0x0,0xd80a,
		0xa980,0x2,0x5308,0x70eb,0x0,0xd90a,0xa980,0x2,
		0x5708,0x70eb,0x0,0xda0a,0xa980,0x2,0x5b08,0x70eb,
		0x0,0xdb0a,0xa980,0x2,0x5f08,0x70eb,0x0,0xdc0a,
		0xa980,0x2,0x6308,0x70eb,0x0,0xdd0a,0xa980,0x2,
		0x6708,0x70eb,0x0,0xde0a,0xa980,0x2,0x6b08,0x70eb,
		0x0,0xdf00,0x4,0x0,0x200,0x40,0x0,0x6000,
		0x2aa,0x3,0xb200,0x37b,0x3,0x2200,0x2aa,0x2,
		0x1800,0x171,0x0,0xbc00,0x2aa,0x3,0x2200,0x171,
		0xffff,0x43ff,0xfd56,0xfffc,0x4dff,0xfc84,0xfffd,0xe700,
		0x2aa,0x2,0x18ff,0xfe8f,0xfffc,0x4dff,0xfd56,0x0,
		0xbc00,0x37c,0x3,0x2200,0x2aa,0x0,0xbcff,0xfc85,
		0xfffd,0xe700,0x2aa,0x3,0x22ff,0xfe8f,0xfffc,0x4c00,
		0x0,0x0,0x100,0x8,0x0,0x1000,0x9,0x0,
		0x200,0x3,0x0,0xa00,0x11,0x0,0x1800,0x20,
		0x0,0x1900,0x12,0x0,0xb00,0x4,0x0,0x500,
		0xc,0x0,0x1300,0x1a,0x0,0x2100,0x28,0x0,
		0x3000,0x29,0x0,0x2200,0x1b,0x0,0x1400,0xd,
		0x0,0x600,0x7,0x0,0xe00,0x15,0x0,0x1c00,
		0x23,0x0,0x2a00,0x31,0x0,0x3800,0x39,0x0,
		0x3200,0x2b,0x0,0x2400,0x1d,0x0,0x1600,0xf,
		0x0,0x1700,0x1e,0x0,0x2500,0x2c,0x0,0x3300,
		0x3a,0x0,0x3b00,0x34,0x0,0x2d00,0x26,0x0,
		0x1f00,0x27,0x0,0x2e00,0x35,0x0,0x3c00,0x3d,
		0x0,0x3600,0x2f,0x0,0x3700,0x3e,0x0,0x3f00,
		0x2,0x0,0xe000,0x5,0x2000,0x33,0x12a0,0xc89,
		0x601a,0x3e0,0x408d,0x2000,0x2,0x20,0x0,0x200,
		0x0,0x0,0x0,0x0,0x0,0x1,0x0,0x100,
		0x2,0x0,0x100,0x3,0x0,0x200,0x4,0x0,
		0x200,0x5,0x0,0x300,0x6,0x0,0x300,0x7,
		0x0,0x0,0x40,0x0,0x0,0x41,0x0,0x100,
		0x42,0x0,0x100,0x43,0x0,0x200,0x44,0x0,
		0x200,0x45,0x0,0x300,0x46,0x0,0x300,0x47,
		0x0,0x0,0x8,0x0,0x0,0x9,0x0,0x100,
		0xa,0x0,0x100,0xb,0x0,0x200,0xc,0x0,
		0x200,0xd,0x0,0x300,0xe,0x0,0x300,0xf,
		0x0,0x0,0x48,0x0,0x0,0x49,0x0,0x100,
		0x4a,0x0,0x100,0x4b,0x0,0x200,0x4c,0x0,
		0x200,0x4d,0x0,0x300,0x4e,0x0,0x300,0x4f,
		0x0,0x800,0x10,0x0,0x800,0x11,0x0,0x900,
		0x12,0x0,0x900,0x13,0x0,0xa00,0x14,0x0,
		0xa00,0x15,0x0,0xb00,0x16,0x0,0xb00,0x17,
		0x0,0x800,0x50,0x0,0x800,0x51,0x0,0x900,
		0x52,0x0,0x900,0x53,0x0,0xa00,0x54,0x0,
		0xa00,0x55,0x0,0xb00,0x56,0x0,0xb00,0x57,
		0x0,0x800,0x18,0x0,0x800,0x19,0x0,0x900,
		0x1a,0x0,0x900,0x1b,0x0,0xa00,0x1c,0x0,
		0xa00,0x1d,0x0,0xb00,0x1e,0x0,0xb00,0x1f,
		0x0,0x800,0x58,0x0,0x800,0x59,0x0,0x900,
		0x5a,0x0,0x900,0x5b,0x0,0xa00,0x5c,0x0,
		0xa00,0x5d,0x0,0xb00,0x5e,0x0,0xb00,0x5f,
		0x0,0x1000,0x20,0x0,0x1000,0x21,0x0,0x1100,
		0x22,0x0,0x1100,0x23,0x0,0x1200,0x24,0x0,
		0x1200,0x25,0x0,0x1300,0x26,0x0,0x1300,0x27,
		0x0,0x1000,0x60,0x0,0x1000,0x61,0x0,0x1100,
		0x62,0x0,0x1100,0x63,0x0,0x1200,0x64,0x0,
		0x1200,0x65,0x0,0x1300,0x66,0x0,0x1300,0x67,
		0x0,0x1000,0x28,0x0,0x1000,0x29,0x0,0x1100,
		0x2a,0x0,0x1100,0x2b,0x0,0x1200,0x2c,0x0,
		0x1200,0x2d,0x0,0x1300,0x2e,0x0,0x1300,0x2f,
		0x0,0x1000,0x68,0x0,0x1000,0x69,0x0,0x1100,
		0x6a,0x0,0x1100,0x6b,0x0,0x1200,0x6c,0x0,
		0x1200,0x6d,0x0,0x1300,0x6e,0x0,0x1300,0x6f,
		0x0,0x1800,0x30,0x0,0x1800,0x31,0x0,0x1900,
		0x32,0x0,0x1900,0x33,0x0,0x1a00,0x34,0x0,
		0x1a00,0x35,0x0,0x1b00,0x36,0x0,0x1b00,0x37,
		0x0,0x1800,0x70,0x0,0x1800,0x71,0x0,0x1900,
		0x72,0x0,0x1900,0x73,0x0,0x1a00,0x74,0x0,
		0x1a00,0x75,0x0,0x1b00,0x76,0x0,0x1b00,0x77,
		0x0,0x1800,0x38,0x0,0x1800,0x39,0x0,0x1900,
		0x3a,0x0,0x1900,0x3b,0x0,0x1a00,0x3c,0x0,
		0x1a00,0x3d,0x0,0x1b00,0x3e,0x0,0x1b00,0x3f,
		0x0,0x1800,0x78,0x0,0x1800,0x79,0x0,0x1900,
		0x7a,0x0,0x1900,0x7b,0x0,0x1a00,0x7c,0x0,
		0x1a00,0x7d,0x0,0x1b00,0x7e,0x0,0x1b00,0x7f,
		0x0,0x2000,0x80,0x0,0x2000,0x81,0x0,0x2100,
		0x82,0x0,0x2100,0x83,0x0,0x2200,0x84,0x0,
		0x2200,0x85,0x0,0x2300,0x86,0x0,0x2300,0x87,
		0x0,0x2000,0xc0,0x0,0x2000,0xc1,0x0,0x2100,
		0xc2,0x0,0x2100,0xc3,0x0,0x2200,0xc4,0x0,
		0x2200,0xc5,0x0,0x2300,0xc6,0x0,0x2300,0xc7,
		0x0,0x2000,0x88,0x0,0x2000,0x89,0x0,0x2100,
		0x8a,0x0,0x2100,0x8b,0x0,0x2200,0x8c,0x0,
		0x2200,0x8d,0x0,0x2300,0x8e,0x0,0x2300,0x8f,
		0x0,0x2000,0xc8,0x0,0x2000,0xc9,0x0,0x2100,
		0xca,0x0,0x2100,0xcb,0x0,0x2200,0xcc,0x0,
		0x2200,0xcd,0x0,0x2300,0xce,0x0,0x2300,0xcf,
		0x0,0x2800,0x90,0x0,0x2800,0x91,0x0,0x2900,
		0x92,0x0,0x2900,0x93,0x0,0x2a00,0x94,0x0,
		0x2a00,0x95,0x0,0x2b00,0x96,0x0,0x2b00,0x97,
		0x0,0x2800,0xd0,0x0,0x2800,0xd1,0x0,0x2900,
		0xd2,0x0,0x2900,0xd3,0x0,0x2a00,0xd4,0x0,
		0x2a00,0xd5,0x0,0x2b00,0xd6,0x0,0x2b00,0xd7,
		0x0,0x2800,0x98,0x0,0x2800,0x99,0x0,0x2900,
		0x9a,0x0,0x2900,0x9b,0x0,0x2a00,0x9c,0x0,
		0x2a00,0x9d,0x0,0x2b00,0x9e,0x0,0x2b00,0x9f,
		0x0,0x2800,0xd8,0x0,0x2800,0xd9,0x0,0x2900,
		0xda,0x0,0x2900,0xdb,0x0,0x2a00,0xdc,0x0,
		0x2a00,0xdd,0x0,0x2b00,0xde,0x0,0x2b00,0xdf,
		0x0,0x3000,0xa0,0x0,0x3000,0xa1,0x0,0x3100,
		0xa2,0x0,0x3100,0xa3,0x0,0x3200,0xa4,0x0,
		0x3200,0xa5,0x0,0x3300,0xa6,0x0,0x3300,0xa7,
		0x0,0x3000,0xe0,0x0,0x3000,0xe1,0x0,0x3100,
		0xe2,0x0,0x3100,0xe3,0x0,0x3200,0xe4,0x0,
		0x3200,0xe5,0x0,0x3300,0xe6,0x0,0x3300,0xe7,
		0x0,0x3000,0xa8,0x0,0x3000,0xa9,0x0,0x3100,
		0xaa,0x0,0x3100,0xab,0x0,0x3200,0xac,0x0,
		0x3200,0xad,0x0,0x3300,0xae,0x0,0x3300,0xaf,
		0x0,0x3000,0xe8,0x0,0x3000,0xe9,0x0,0x3100,
		0xea,0x0,0x3100,0xeb,0x0,0x3200,0xec,0x0,
		0x3200,0xed,0x0,0x3300,0xee,0x0,0x3300,0xef,
		0x0,0x3800,0xb0,0x0,0x3800,0xb1,0x0,0x3900,
		0xb2,0x0,0x3900,0xb3,0x0,0x3a00,0xb4,0x0,
		0x3a00,0xb5,0x0,0x3b00,0xb6,0x0,0x3b00,0xb7,
		0x0,0x3800,0xf0,0x0,0x3800,0xf1,0x0,0x3900,
		0xf2,0x0,0x3900,0xf3,0x0,0x3a00,0xf4,0x0,
		0x3a00,0xf5,0x0,0x3b00,0xf6,0x0,0x3b00,0xf7,
		0x0,0x3800,0xb8,0x0,0x3800,0xb9,0x0,0x3900,
		0xba,0x0,0x3900,0xbb,0x0,0x3a00,0xbc,0x0,
		0x3a00,0xbd,0x0,0x3b00,0xbe,0x0,0x3b00,0xbf,
		0x0,0x3800,0xf8,0x0,0x3800,0xf9,0x0,0x3900,
		0xfa,0x0,0x3900,0xfb,0x0,0x3a00,0xfc,0x0,
		0x3a00,0xfd,0x0,0x3b00,0xfe,0x0,0x3b00,0xff,
		0x0
	   };

long playgray_size = sizeof(playgray);
