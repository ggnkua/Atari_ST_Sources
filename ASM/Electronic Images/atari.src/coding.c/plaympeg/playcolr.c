short playcolr[] = {
		0x0,0x0,0x0,0x0,0x20a,0xf080,0x1,0x1c00,
		0x0,0x0,0x2600,0x2,0xbf0,0x8000,0x40,0x0,
		0x0,0x28,0x0,0x20b,0xf080,0x1,0x7900,0x0,
		0x0,0x4000,0x23c,0xf0,0xb805,0xbb,0x60f4,0x0,
		0x40,0xaa9,0x8000,0x44,0x84e,0x2b06,0xba0,0x2000,
		0x3256,0x7000,0x1,0xc006,0x680,0x0,0xef60,0x7000,
		0x1,0xc122,0x1213,0x640,0xa056,0x5a00,0xaa9,0x8000,
		0x52,0x844,0x2b46,0xf400,0x0,0x8045,0xf4d0,0x400,
		0x21,0x400,0x62f4,0xa000,0xa0,0x63f4,0x0,0x60,
		0xaa9,0x8000,0x5e,0x844,0x2b56,0x60d0,0xaf0,0xaa00,
		0x72,0x219b,0x21,0x400,0x7aeb,0x47,0xf000,0x1,
		0xc04d,0xea00,0x2358,0xf021,0x500,0x2000,0xa00a,0xa980,
		0x0,0x6d08,0x442b,0x5668,0xd00e,0x2064,0x64f4,0x0,
		0x40,0x51f,0xa438,0x800,0x507,0xa061,0xf400,0x0,
		0x62,0xf400,0x0,0x739,0x500,0x3a0b,0xf0,0x9800,
		0x608,0x8000,0xa8,0xf098,0xd0f0,0x98d8,0xf098,0xd2f0,
		0x98da,0xf098,0xd2f0,0x98da,0xf098,0xd2f5,0x98da,0xf098,
		0x1851,0x5916,0x5052,0xf0f0,0x98d8,0xf098,0xd2f0,0x98da,
		0xf098,0xd2f0,0x98da,0xf098,0xd2f5,0x98da,0xf098,0x1851,
		0x5916,0x5052,0xf0f0,0x98d8,0xf098,0xd2f0,0x98da,0xf098,
		0xd2f0,0x98da,0xf098,0xd2f5,0x98da,0xf098,0x1851,0x5916,
		0x5052,0xf0f0,0x98d8,0xf098,0xd2f0,0x98da,0xf098,0xd2f0,
		0x98da,0xf098,0xd220,0x48da,0xf098,0x1851,0x4916,0x504a,
		0x61,0xf000,0x1,0xc160,0xf400,0x0,0x22,0x3200,
		0x3a38,0x5,0x3fa0,0x204a,0x5,0x1fa1,0x51f,0xa239,
		0x800,0x72f4,0xff,0xfff8,0x44c8,0x6,0x880,0x0,
		0xe3f0,0x88d0,0xf088,0xd8f0,0x88d2,0xf088,0xdaf0,0x88d2,
		0xf088,0xdaf0,0x88d2,0xf588,0xdaf0,0x8818,0x5749,0x1656,
		0x4af0,0xf088,0xd8f0,0x88d2,0xf088,0xdaf0,0x88d2,0xf088,
		0xdaf0,0x88d2,0xf588,0xdaf0,0x8818,0x5749,0x1656,0x4af0,
		0xf088,0xd8f0,0x88d2,0xf088,0xdaf0,0x88d2,0xf088,0xdaf0,
		0x88d2,0xf588,0xdaf0,0x8818,0x5749,0x1656,0x4af0,0xf088,
		0xd8f0,0x88d2,0xf088,0xdaf0,0x88d2,0xf088,0xdaf0,0x88d2,
		0x2058,0xdaf0,0x8818,0x5749,0x1656,0x4a00,0x2059,0x20,
		0x5a00,0x60f0,0x0,0x1c1,0x3840,0x5,0xf424,0xffff,
		0xff20,0x4800,0x5f4,0x20ff,0xffff,0x5f4,0x21ff,0xffff,
		0x5f4,0x22ff,0xffff,0x60f4,0x0,0x40,0x61f4,0x0,
		0x140,0x62f4,0x0,0x180,0x63f4,0x0,0x2400,0x64f4,
		0x0,0x1200,0x65f4,0x0,0x1600,0x66f4,0x0,0x1a00,
		0x67f4,0x0,0xe0,0x504,0xa779,0xdb00,0x78db,0x6,
		0x81,0x1,0x1823,0x3a00,0x45e8,0x47,0xe900,0x46ea,
		0x4c,0xdf00,0x79db,0xa84c,0xdf01,0x4cdf,0xd221,0x9c01,
		0x4cdf,0xc64c,0xdfd6,0x219d,0xca21,0xbe00,0x5eec,0x4e,
		0xed00,0x4eee,0x5278,0xdb52,0xaa9,0x8100,0x116,0x8ce,
		0x2b05,0xf427,0xffff,0xff0c,0x42,0x8f4,0xbf00,0xc00,
		0x8f4,0xa000,0x1,0x8f4,0xbe00,0x0,0xf0,0xb80a,
		0xa822,0x5f4,0x20ff,0xffff,0x5f4,0x21ff,0xffff,0x5f4,
		0x22ff,0xffff,0x5f4,0x23ff,0xffff,0x5f4,0x24ff,0xffff,
		0x5f4,0x25ff,0xffff,0x5f4,0x26ff,0xffff,0x5f4,0x27ff,
		0xffff,0x64f4,0x0,0x1000,0x65f4,0x0,0x1400,0x66f4,
		0x0,0x1800,0x67f4,0x0,0x1c00,0x46f4,0x0,0x0,
		0x680,0x8100,0x143,0x4e5c,0x4e,0x5d00,0x4e5e,0x4e,
		0x5f00,0x3000,0x70,0xf400,0x1,0x45,0xf400,0xf8,
		0x6,0x81,0x1,0x5522,0xf00,0x44f4,0x6e04,0x0,
		0x21e6,0x5f,0x5c00,0x44f4,0xd000,0x1000,0x5e5d,0x1820,
		0x48d0,0x5e5e,0x185f,0x5f00,0x46f4,0x0,0xf800,0x47f4,
		0x0,0x7c0,0x44f4,0x0,0x1f,0x45f4,0x0,0xffdf,
		0x680,0x8100,0x163,0x4e5c,0x4f,0x5d00,0x4c5e,0x4d,
		0x5f00,0x64f4,0x0,0x2000,0x46f4,0x0,0x0,0x680,
		0x8100,0x16a,0x4e5c,0x30,0x0,0x3801,0x6,0x81,
		0x1,0x7122,0xe00,0x2048,0x5e,0x5c00,0x46f4,0x0,
		0xff,0x680,0x8100,0x176,0x4e5c,0x0,0x0,0xc01,
		0x7700,0xf0b8,0x0,0xa,0xa980,0x1,0x7b08,0x70eb,
		0x0,0xa00a,0xa980,0x1,0x7f08,0x70eb,0x0,0xa10a,
		0xa980,0x1,0x8308,0x70eb,0x0,0xa20a,0xa980,0x1,
		0x8708,0x70eb,0x0,0xa30a,0xa980,0x1,0x8b08,0x70eb,
		0x0,0xa40a,0xa980,0x1,0x8f08,0x70eb,0x0,0xa50a,
		0xa980,0x1,0x9308,0x70eb,0x0,0xa60a,0xa980,0x1,
		0x9708,0x70eb,0x0,0xa70a,0xa980,0x1,0x9b08,0x70eb,
		0x0,0xa80a,0xa980,0x1,0x9f08,0x70eb,0x0,0xa90a,
		0xa980,0x1,0xa308,0x70eb,0x0,0xaa0a,0xa980,0x1,
		0xa708,0x70eb,0x0,0xab0a,0xa980,0x1,0xab08,0x70eb,
		0x0,0xac0a,0xa980,0x1,0xaf08,0x70eb,0x0,0xad0a,
		0xa980,0x1,0xb308,0x70eb,0x0,0xae0a,0xa980,0x1,
		0xb708,0x70eb,0x0,0xaf0a,0xa980,0x1,0xbb08,0x70eb,
		0x0,0xb00a,0xa980,0x1,0xbf08,0x70eb,0x0,0xb10a,
		0xa980,0x1,0xc308,0x70eb,0x0,0xb20a,0xa980,0x1,
		0xc708,0x70eb,0x0,0xb30a,0xa980,0x1,0xcb08,0x70eb,
		0x0,0xb40a,0xa980,0x1,0xcf08,0x70eb,0x0,0xb50a,
		0xa980,0x1,0xd308,0x70eb,0x0,0xb60a,0xa980,0x1,
		0xd708,0x70eb,0x0,0xb70a,0xa980,0x1,0xdb08,0x70eb,
		0x0,0xb80a,0xa980,0x1,0xdf08,0x70eb,0x0,0xb90a,
		0xa980,0x1,0xe308,0x70eb,0x0,0xba0a,0xa980,0x1,
		0xe708,0x70eb,0x0,0xbb0a,0xa980,0x1,0xeb08,0x70eb,
		0x0,0xbc0a,0xa980,0x1,0xef08,0x70eb,0x0,0xbd0a,
		0xa980,0x1,0xf308,0x70eb,0x0,0xbe0a,0xa980,0x1,
		0xf708,0x70eb,0x0,0xbf0a,0xa980,0x1,0xfb08,0x70eb,
		0x0,0xc00a,0xa980,0x1,0xff08,0x70eb,0x0,0xc10a,
		0xa980,0x2,0x308,0x70eb,0x0,0xc20a,0xa980,0x2,
		0x708,0x70eb,0x0,0xc30a,0xa980,0x2,0xb08,0x70eb,
		0x0,0xc40a,0xa980,0x2,0xf08,0x70eb,0x0,0xc50a,
		0xa980,0x2,0x1308,0x70eb,0x0,0xc60a,0xa980,0x2,
		0x1708,0x70eb,0x0,0xc70a,0xa980,0x2,0x1b08,0x70eb,
		0x0,0xc80a,0xa980,0x2,0x1f08,0x70eb,0x0,0xc90a,
		0xa980,0x2,0x2308,0x70eb,0x0,0xca0a,0xa980,0x2,
		0x2708,0x70eb,0x0,0xcb0a,0xa980,0x2,0x2b08,0x70eb,
		0x0,0xcc0a,0xa980,0x2,0x2f08,0x70eb,0x0,0xcd0a,
		0xa980,0x2,0x3308,0x70eb,0x0,0xce0a,0xa980,0x2,
		0x3708,0x70eb,0x0,0xcf0a,0xa980,0x2,0x3b08,0x70eb,
		0x0,0xd00a,0xa980,0x2,0x3f08,0x70eb,0x0,0xd10a,
		0xa980,0x2,0x4308,0x70eb,0x0,0xd20a,0xa980,0x2,
		0x4708,0x70eb,0x0,0xd30a,0xa980,0x2,0x4b08,0x70eb,
		0x0,0xd40a,0xa980,0x2,0x4f08,0x70eb,0x0,0xd50a,
		0xa980,0x2,0x5308,0x70eb,0x0,0xd60a,0xa980,0x2,
		0x5708,0x70eb,0x0,0xd70a,0xa980,0x2,0x5b08,0x70eb,
		0x0,0xd80a,0xa980,0x2,0x5f08,0x70eb,0x0,0xd90a,
		0xa980,0x2,0x6308,0x70eb,0x0,0xda0a,0xa980,0x2,
		0x6708,0x70eb,0x0,0xdb0a,0xa980,0x2,0x6b08,0x70eb,
		0x0,0xdc0a,0xa980,0x2,0x6f08,0x70eb,0x0,0xdd0a,
		0xa980,0x2,0x7308,0x70eb,0x0,0xde0a,0xa980,0x2,
		0x7708,0x70eb,0x0,0xdf00,0x4,0x0,0x200,0x40,
		0x0,0x6000,0x400,0x5,0x8d00,0x539,0x4,0xb400,
		0x400,0x3,0x2500,0x22a,0x1,0x1b00,0x400,0x4,
		0xb400,0x22a,0xfffe,0xe6ff,0xfc00,0xfffa,0x74ff,0xfac6,
		0xfffc,0xdc00,0x400,0x3,0x25ff,0xfdd6,0xfffa,0x74ff,
		0xfc00,0x1,0x1b00,0x53a,0x4,0xb400,0x400,0x1,
		0x1bff,0xfac7,0xfffc,0xdc00,0x400,0x4,0xb4ff,0xfdd6,
		0xfffa,0x7400,0x0,0x0,0x100,0x8,0x0,0x1000,
		0x9,0x0,0x200,0x3,0x0,0xa00,0x11,0x0,
		0x1800,0x20,0x0,0x1900,0x12,0x0,0xb00,0x4,
		0x0,0x500,0xc,0x0,0x1300,0x1a,0x0,0x2100,
		0x28,0x0,0x3000,0x29,0x0,0x2200,0x1b,0x0,
		0x1400,0xd,0x0,0x600,0x7,0x0,0xe00,0x15,
		0x0,0x1c00,0x23,0x0,0x2a00,0x31,0x0,0x3800,
		0x39,0x0,0x3200,0x2b,0x0,0x2400,0x1d,0x0,
		0x1600,0xf,0x0,0x1700,0x1e,0x0,0x2500,0x2c,
		0x0,0x3300,0x3a,0x0,0x3b00,0x34,0x0,0x2d00,
		0x26,0x0,0x1f00,0x27,0x0,0x2e00,0x35,0x0,
		0x3c00,0x3d,0x0,0x3600,0x2f,0x0,0x3700,0x3e,
		0x0,0x3f00,0x2,0x0,0xe000,0x5,0x3f00,0x64,
		0x8cab,0x18ae,0x7533,0x37a1,0x7f15,0xd700,0x2,0x24,
		0x0,0x200,0x0,0x0,0x0,0x0,0x0,0x1,
		0x0,0x100,0x2,0x0,0x100,0x3,0x0,0x200,
		0x4,0x0,0x200,0x5,0x0,0x300,0x6,0x0,
		0x300,0x7,0x0,0x400,0x40,0x0,0x400,0x41,
		0x0,0x500,0x42,0x0,0x500,0x43,0x0,0x600,
		0x44,0x0,0x600,0x45,0x0,0x700,0x46,0x0,
		0x700,0x47,0x0,0x0,0x8,0x0,0x0,0x9,
		0x0,0x100,0xa,0x0,0x100,0xb,0x0,0x200,
		0xc,0x0,0x200,0xd,0x0,0x300,0xe,0x0,
		0x300,0xf,0x0,0x400,0x48,0x0,0x400,0x49,
		0x0,0x500,0x4a,0x0,0x500,0x4b,0x0,0x600,
		0x4c,0x0,0x600,0x4d,0x0,0x700,0x4e,0x0,
		0x700,0x4f,0x0,0x800,0x10,0x0,0x800,0x11,
		0x0,0x900,0x12,0x0,0x900,0x13,0x0,0xa00,
		0x14,0x0,0xa00,0x15,0x0,0xb00,0x16,0x0,
		0xb00,0x17,0x0,0xc00,0x50,0x0,0xc00,0x51,
		0x0,0xd00,0x52,0x0,0xd00,0x53,0x0,0xe00,
		0x54,0x0,0xe00,0x55,0x0,0xf00,0x56,0x0,
		0xf00,0x57,0x0,0x800,0x18,0x0,0x800,0x19,
		0x0,0x900,0x1a,0x0,0x900,0x1b,0x0,0xa00,
		0x1c,0x0,0xa00,0x1d,0x0,0xb00,0x1e,0x0,
		0xb00,0x1f,0x0,0xc00,0x58,0x0,0xc00,0x59,
		0x0,0xd00,0x5a,0x0,0xd00,0x5b,0x0,0xe00,
		0x5c,0x0,0xe00,0x5d,0x0,0xf00,0x5e,0x0,
		0xf00,0x5f,0x0,0x1000,0x20,0x0,0x1000,0x21,
		0x0,0x1100,0x22,0x0,0x1100,0x23,0x0,0x1200,
		0x24,0x0,0x1200,0x25,0x0,0x1300,0x26,0x0,
		0x1300,0x27,0x0,0x1400,0x60,0x0,0x1400,0x61,
		0x0,0x1500,0x62,0x0,0x1500,0x63,0x0,0x1600,
		0x64,0x0,0x1600,0x65,0x0,0x1700,0x66,0x0,
		0x1700,0x67,0x0,0x1000,0x28,0x0,0x1000,0x29,
		0x0,0x1100,0x2a,0x0,0x1100,0x2b,0x0,0x1200,
		0x2c,0x0,0x1200,0x2d,0x0,0x1300,0x2e,0x0,
		0x1300,0x2f,0x0,0x1400,0x68,0x0,0x1400,0x69,
		0x0,0x1500,0x6a,0x0,0x1500,0x6b,0x0,0x1600,
		0x6c,0x0,0x1600,0x6d,0x0,0x1700,0x6e,0x0,
		0x1700,0x6f,0x0,0x1800,0x30,0x0,0x1800,0x31,
		0x0,0x1900,0x32,0x0,0x1900,0x33,0x0,0x1a00,
		0x34,0x0,0x1a00,0x35,0x0,0x1b00,0x36,0x0,
		0x1b00,0x37,0x0,0x1c00,0x70,0x0,0x1c00,0x71,
		0x0,0x1d00,0x72,0x0,0x1d00,0x73,0x0,0x1e00,
		0x74,0x0,0x1e00,0x75,0x0,0x1f00,0x76,0x0,
		0x1f00,0x77,0x0,0x1800,0x38,0x0,0x1800,0x39,
		0x0,0x1900,0x3a,0x0,0x1900,0x3b,0x0,0x1a00,
		0x3c,0x0,0x1a00,0x3d,0x0,0x1b00,0x3e,0x0,
		0x1b00,0x3f,0x0,0x1c00,0x78,0x0,0x1c00,0x79,
		0x0,0x1d00,0x7a,0x0,0x1d00,0x7b,0x0,0x1e00,
		0x7c,0x0,0x1e00,0x7d,0x0,0x1f00,0x7e,0x0,
		0x1f00,0x7f,0x0,0x2000,0x80,0x0,0x2000,0x81,
		0x0,0x2100,0x82,0x0,0x2100,0x83,0x0,0x2200,
		0x84,0x0,0x2200,0x85,0x0,0x2300,0x86,0x0,
		0x2300,0x87,0x0,0x2400,0xc0,0x0,0x2400,0xc1,
		0x0,0x2500,0xc2,0x0,0x2500,0xc3,0x0,0x2600,
		0xc4,0x0,0x2600,0xc5,0x0,0x2700,0xc6,0x0,
		0x2700,0xc7,0x0,0x2000,0x88,0x0,0x2000,0x89,
		0x0,0x2100,0x8a,0x0,0x2100,0x8b,0x0,0x2200,
		0x8c,0x0,0x2200,0x8d,0x0,0x2300,0x8e,0x0,
		0x2300,0x8f,0x0,0x2400,0xc8,0x0,0x2400,0xc9,
		0x0,0x2500,0xca,0x0,0x2500,0xcb,0x0,0x2600,
		0xcc,0x0,0x2600,0xcd,0x0,0x2700,0xce,0x0,
		0x2700,0xcf,0x0,0x2800,0x90,0x0,0x2800,0x91,
		0x0,0x2900,0x92,0x0,0x2900,0x93,0x0,0x2a00,
		0x94,0x0,0x2a00,0x95,0x0,0x2b00,0x96,0x0,
		0x2b00,0x97,0x0,0x2c00,0xd0,0x0,0x2c00,0xd1,
		0x0,0x2d00,0xd2,0x0,0x2d00,0xd3,0x0,0x2e00,
		0xd4,0x0,0x2e00,0xd5,0x0,0x2f00,0xd6,0x0,
		0x2f00,0xd7,0x0,0x2800,0x98,0x0,0x2800,0x99,
		0x0,0x2900,0x9a,0x0,0x2900,0x9b,0x0,0x2a00,
		0x9c,0x0,0x2a00,0x9d,0x0,0x2b00,0x9e,0x0,
		0x2b00,0x9f,0x0,0x2c00,0xd8,0x0,0x2c00,0xd9,
		0x0,0x2d00,0xda,0x0,0x2d00,0xdb,0x0,0x2e00,
		0xdc,0x0,0x2e00,0xdd,0x0,0x2f00,0xde,0x0,
		0x2f00,0xdf,0x0,0x3000,0xa0,0x0,0x3000,0xa1,
		0x0,0x3100,0xa2,0x0,0x3100,0xa3,0x0,0x3200,
		0xa4,0x0,0x3200,0xa5,0x0,0x3300,0xa6,0x0,
		0x3300,0xa7,0x0,0x3400,0xe0,0x0,0x3400,0xe1,
		0x0,0x3500,0xe2,0x0,0x3500,0xe3,0x0,0x3600,
		0xe4,0x0,0x3600,0xe5,0x0,0x3700,0xe6,0x0,
		0x3700,0xe7,0x0,0x3000,0xa8,0x0,0x3000,0xa9,
		0x0,0x3100,0xaa,0x0,0x3100,0xab,0x0,0x3200,
		0xac,0x0,0x3200,0xad,0x0,0x3300,0xae,0x0,
		0x3300,0xaf,0x0,0x3400,0xe8,0x0,0x3400,0xe9,
		0x0,0x3500,0xea,0x0,0x3500,0xeb,0x0,0x3600,
		0xec,0x0,0x3600,0xed,0x0,0x3700,0xee,0x0,
		0x3700,0xef,0x0,0x3800,0xb0,0x0,0x3800,0xb1,
		0x0,0x3900,0xb2,0x0,0x3900,0xb3,0x0,0x3a00,
		0xb4,0x0,0x3a00,0xb5,0x0,0x3b00,0xb6,0x0,
		0x3b00,0xb7,0x0,0x3c00,0xf0,0x0,0x3c00,0xf1,
		0x0,0x3d00,0xf2,0x0,0x3d00,0xf3,0x0,0x3e00,
		0xf4,0x0,0x3e00,0xf5,0x0,0x3f00,0xf6,0x0,
		0x3f00,0xf7,0x0,0x3800,0xb8,0x0,0x3800,0xb9,
		0x0,0x3900,0xba,0x0,0x3900,0xbb,0x0,0x3a00,
		0xbc,0x0,0x3a00,0xbd,0x0,0x3b00,0xbe,0x0,
		0x3b00,0xbf,0x0,0x3c00,0xf8,0x0,0x3c00,0xf9,
		0x0,0x3d00,0xfa,0x0,0x3d00,0xfb,0x0,0x3e00,
		0xfc,0x0,0x3e00,0xfd,0x0,0x3f00,0xfe,0x0,
		0x3f00,0xff,0x0
	   };

long playcolr_size = sizeof(playcolr);
