unsigned int resource_data[] 
	 = {
		0x0,0x2c,0x2cc,0x374,0x462,0x462,0x462,0x50a,
		0x50a,0x24,0x1c,0x2,0x6,0x7,0x0,0x0,
		0x0,0x88a,0x0,0x2c,0x0,0x284,0xffff,0x1,
		0x18,0x1b,0x0,0x0,0xff,0x1100,0x0,0x0,
		0x724,0xf,0xc,0x2,0xb,0x1b,0x0,0xb0,
		0xff,0x1101,0x403,0x401,0x1e,0x5,0x3,0xffff,
		0xffff,0x1c,0x0,0x0,0x0,0x462,0x5,0x2,
		0xb,0x1,0x4,0xffff,0xffff,0x1c,0x0,0x0,
		0x0,0x468,0x14,0x400,0x9,0x1,0x5,0xffff,
		0xffff,0x1c,0x0,0x0,0x0,0x46f,0x14,0x403,
		0x9,0x1,0x6,0xffff,0xffff,0x1c,0x0,0x0,
		0x0,0x475,0x5,0x403,0xb,0x1,0x7,0xffff,
		0xffff,0x14,0x4,0x1,0x1,0x1171,0x410,0x403,
		0x2,0x1,0x8,0xffff,0xffff,0x14,0x4,0x1,
		0x1,0x1171,0x401,0x400,0x2,0x1,0x9,0xffff,
		0xffff,0x14,0x4,0x1,0x1,0x1171,0x401,0x2,
		0x2,0x1,0xa,0xffff,0xffff,0x14,0x4,0x1,
		0x1,0x1171,0x401,0x403,0x2,0x1,0xb,0xffff,
		0xffff,0x1c,0x0,0x0,0x0,0x480,0x5,0x400,
		0xc,0x1,0x1,0xffff,0xffff,0x14,0x4,0x1,
		0x1,0x1171,0x210,0x400,0x2,0x1,0x17,0xd,
		0x16,0x1b,0x0,0xb0,0xff,0x1100,0x403,0x408,
		0x1e,0x405,0xe,0xffff,0xffff,0x1516,0x5,0xb0,
		0x0,0x2cc,0x18,0x4,0x404,0x1,0xf,0xffff,
		0xffff,0x116,0x5,0xb0,0x0,0x2e8,0x11,0x4,
		0x5,0x1,0x10,0xffff,0xffff,0x116,0x5,0xb0,
		0x0,0x304,0x401,0x4,0x208,0x1,0x11,0xffff,
		0xffff,0x1f,0x5,0x0,0x0,0x374,0x5,0x400,
		0x4,0x3,0x12,0xffff,0xffff,0x1f,0x5,0x0,
		0x0,0x396,0x9,0x400,0x4,0x3,0x13,0xffff,
		0xffff,0x1f,0x5,0x0,0x0,0x3b8,0xd,0x400,
		0x4,0x3,0x14,0xffff,0xffff,0x1f,0x5,0x0,
		0x0,0x3da,0x11,0x400,0x4,0x3,0x15,0xffff,
		0xffff,0x1f,0x5,0x0,0x0,0x3fc,0x15,0x400,
		0x4,0x3,0x16,0xffff,0xffff,0x1f,0x5,0x0,
		0x0,0x41e,0x19,0x400,0x4,0x3,0xc,0xffff,
		0xffff,0x1f,0x5,0x0,0x0,0x440,0x1,0x400,
		0x4,0x3,0x18,0xffff,0xffff,0x15,0x0,0x0,
		0x0,0x320,0x105,0x507,0x10,0x1,0x0,0xffff,
		0xffff,0x15,0x20,0x0,0x0,0x33c,0x404,0x400,
		0xf,0x1,0xffff,0x1,0x1,0x14,0x0,0x10,
		0x2,0x1100,0x0,0x0,0x425,0x410,0x0,0x2,
		0x2,0x1b,0x0,0xb0,0xff,0x1101,0x403,0x1,
		0x51e,0x301,0x1,0xffff,0xffff,0x15,0x20,0x0,
		0x0,0x358,0x603,0x100,0x17,0x1,0x0,0x48a,
		0x0,0x491,0x0,0x492,0x5,0x6,0x0,0x1180,
		0x0,0xffff,0x7,0x1,0x0,0x493,0x0,0x49a,
		0x0,0x49b,0x5,0x6,0x0,0x1180,0x0,0xffff,
		0x7,0x1,0x0,0x49c,0x0,0x4a8,0x0,0x4a9,
		0x5,0x6,0x0,0x1180,0x0,0xffff,0xc,0x1,
		0x0,0x4aa,0x0,0x4bb,0x0,0x4bc,0x3,0x6,
		0x0,0x1180,0x0,0xffff,0x11,0x1,0x0,0x4bd,
		0x0,0x4cd,0x0,0x4ce,0x3,0x6,0x0,0x1180,
		0x0,0xffff,0x10,0x1,0x0,0x4cf,0x0,0x4e7,
		0x0,0x4e8,0x3,0x6,0x0,0x1180,0x0,0xffff,
		0x18,0x1,0x0,0x50a,0x0,0x54a,0x0,0x4e9,
		0x102d,0x18,0x1,0x0,0x0,0x20,0x10,0x6,
		0x10,0x12,0x8,0x0,0x58a,0x0,0x5ca,0x0,
		0x4ed,0x102b,0x18,0x1,0x0,0x0,0x20,0x10,
		0x9,0x10,0xc,0x8,0x0,0x60a,0x0,0x64a,
		0x0,0x4f0,0x1053,0x18,0x1,0x0,0x0,0x20,
		0x10,0x3,0x10,0x18,0x8,0x0,0x68a,0x0,
		0x6ca,0x0,0x4f5,0x104f,0x18,0x1,0x0,0x0,
		0x20,0x10,0x0,0x10,0x1e,0x8,0x0,0x70a,
		0x0,0x74a,0x0,0x4fb,0x104c,0x18,0x1,0x0,
		0x0,0x20,0x10,0x3,0x10,0x18,0x8,0x0,
		0x78a,0x0,0x7ca,0x0,0x500,0x1058,0x18,0x1,
		0x0,0x0,0x20,0x10,0x3,0x10,0x18,0x8,
		0x0,0x80a,0x0,0x84a,0x0,0x505,0x1050,0x18,
		0x1,0x0,0x0,0x20,0x10,0x3,0x10,0x18,
		0x8,0x426f,0x6f73,0x7400,0x4669,0x6c74,0x6572,0x54,
		0x656d,0x706f,0x50,0x726f,0x7472,0x6163,0x6b65,0x7200,
		0x416e,0x7469,0x416c,0x6961,0x7300,0x2048,0x454c,0x5020,
		0x0,0x20,0x494e,0x464f,0x2000,0x0,0x2043,0x4f4e,
		0x4649,0x4755,0x5245,0x2000,0x0,0x2050,0x6c61,0x7965,
		0x7220,0x436f,0x6e74,0x726f,0x6c20,0x0,0x20,0x536f,
		0x756e,0x6420,0x436f,0x6e74,0x726f,0x6c20,0x0,0x50,
		0x726f,0x7472,0x6163,0x6b65,0x7220,0x5265,0x706c,0x6179,
		0x2053,0x6574,0x7570,0x0,0x52,0x4557,0x46,0x4600,
		0x5354,0x4f50,0x50,0x4155,0x5345,0x4c,0x4f41,0x4400,
		0x5341,0x5645,0x50,0x4c41,0x5900,0xffff,0xffff,0xffff,
		0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
		0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
		0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
		0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0x8000,
		0x1,0x8000,0x1,0x8000,0x1,0x8003,0x8e01,0x800f,
		0x3e01,0x803c,0xfe01,0x80f3,0xfe01,0x803c,0xfe01,0x800f,
		0x3e01,0x8003,0x8e01,0x8000,0x1,0x8000,0x1,0x8000,
		0x1,0x8000,0x1,0xffff,0xffff,0xffff,0xffff,0xffff,
		0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
		0xffff,0xffff,0xffff,0xffff,0xffff,0xff7f,0xffff,0xffff,
		0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
		0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0x8000,
		0x1,0x8000,0x1,0x8000,0x1,0x80e3,0x8001,0x80f9,
		0xe001,0x80fe,0x7801,0x80ff,0x9e01,0x807e,0x7801,0x80f9,
		0xe001,0x80e3,0x8001,0x8000,0x1,0x8000,0x1,0x8000,
		0x1,0x8000,0x1,0xffff,0xffff,0xffff,0xffff,0xffff,
		0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
		0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
		0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
		0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0x8000,
		0x1,0x8000,0x1,0x8000,0x1,0x8000,0x1,0x801f,
		0xf001,0x801f,0xf001,0x801f,0xf001,0x801f,0xf001,0x801f,
		0xf001,0x801f,0xf001,0x8000,0x1,0x8000,0x1,0x8000,
		0x1,0x8000,0x1,0xffff,0xffff,0xffff,0xffff,0xffff,
		0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
		0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
		0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
		0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0x8000,
		0x1,0x8000,0x1,0x8000,0x1,0x8000,0x1,0x801e,
		0xf001,0x801e,0xf001,0x801e,0xf001,0x801e,0xf001,0x801e,
		0xf001,0x801e,0xf001,0x8000,0x1,0x8000,0x1,0x8000,
		0x1,0x8000,0x1,0xffff,0xffff,0xffff,0xffff,0xffff,
		0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
		0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
		0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
		0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0x8000,
		0x1,0x8000,0x1,0x8000,0x1,0x8000,0x1,0x8001,
		0x8001,0x8007,0xe001,0x801f,0xf801,0x807f,0xfe01,0x8000,
		0x1,0x807f,0xfe01,0x8000,0x1,0x8000,0x1,0x8000,
		0x1,0x8000,0x1,0xffff,0xffff,0xffff,0xffff,0xffff,
		0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
		0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
		0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
		0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0x8000,
		0x1,0x8000,0x1,0x8000,0x1,0x8000,0x1,0x8003,
		0x8001,0x800f,0xe001,0x801f,0xf001,0x801f,0xf001,0x800f,
		0xe001,0x8003,0x8001,0x8000,0x1,0x8000,0x1,0x8000,
		0x1,0x8000,0x1,0xffff,0xffff,0xffff,0xffff,0xffff,
		0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
		0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
		0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
		0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0x8000,
		0x1,0x8000,0x1,0x8000,0x1,0x801c,0x1,0x801f,
		0x1,0x801f,0xc001,0x801f,0xf001,0x801f,0xc001,0x801f,
		0x1,0x801c,0x1,0x8000,0x1,0x8000,0x1,0x8000,
		0x1,0x8000,0x1,0xffff,0xffff,0x0
	   };
