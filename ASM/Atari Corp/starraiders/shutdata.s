*
*	SHUTDATA.S	ST Star-Raiders SHUTTLE CRAFT Image Data
*

*
*	PUBLIC SYMBOLS
*
	.globl	shut00
	.globl	shut01
	.globl	shut02
	.globl	shut03
	.globl	shut04
	.globl	shut05
	.globl	shut06
	.globl	shut07
	.globl	shut08
	.globl	shut09
	.globl	shut10
	.globl	shut11
	.globl	shut12
	.globl	shut13
	.globl	shut14
	.globl	shut15

*
*	SHUTTLECRAFT Image data
*		Xoffset,Yoffset (pixels)
*		Height (lines), Width (words)
*		Image_Data
*
*	        Total of SIXTEEN Perspective Depths
*

	.data
	.even

shut00:		* ShuttleCraft (Perspective:0)
	.dc.w	20,22
	.dc.w	47,3
	.dc.w	$0000,$0000,$0000,$0000,$0800,$1C00,$1C00,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0800,$1C00,$1C00,$0000,$8000,$8000,$8000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0800,$1C00,$1C00,$0000
	.dc.w	$0000,$C000,$8000,$4000,$0000,$0000,$0000,$0000
	.dc.w	$0802,$1C02,$1C02,$0000,$6000,$6000,$4000,$2000
	.dc.w	$0000,$0000,$0000,$0000,$0800,$1C03,$1C02,$0001
	.dc.w	$C000,$C000,$8000,$4000,$0000,$0000,$0000,$0000
	.dc.w	$0800,$7F01,$7F01,$0000,$0000,$E000,$4000,$A000
	.dc.w	$0000,$0000,$0000,$0000,$6B00,$EB80,$EB80,$1400
	.dc.w	$1000,$A000,$A000,$1000,$0000,$0001,$0001,$0000
	.dc.w	$BC80,$80C0,$80C0,$7F00,$0000,$1000,$1000,$0800
	.dc.w	$0001,$0003,$0003,$0000,$5D40,$2260,$2260,$FF80
	.dc.w	$0400,$0C00,$0C00,$0000,$0002,$0006,$0006,$0001
	.dc.w	$80A0,$7730,$2230,$FFC0,$0380,$0680,$0680,$0100
	.dc.w	$0005,$000C,$000C,$0003,$1450,$F798,$0018,$FFE0
	.dc.w	$0100,$0180,$0000,$0380,$0000,$0001,$0001,$0000
	.dc.w	$3E00,$FFE0,$FFE0,$0000,$0280,$0280,$0280,$0100
	.dc.w	$0001,$01FF,$01FF,$0000,$C9C0,$BEFF,$88FF,$7700
	.dc.w	$0400,$C780,$C780,$0000,$0183,$0380,$0380,$007F
	.dc.w	$4162,$E382,$2202,$DDFD,$C000,$E400,$E400,$0800
	.dc.w	$00E6,$01E1,$01E0,$001F,$88B3,$F7C3,$4103,$BEFC
	.dc.w	$9000,$C800,$C800,$1000,$003C,$01F3,$01F0,$000F
	.dc.w	$C19E,$FFE7,$5507,$AAF8,$0000,$B000,$9000,$2000
	.dc.w	$010E,$033F,$023F,$0100,$5D38,$C9FE,$C1FE,$3E00
	.dc.w	$4000,$6000,$2000,$4000,$0044,$06CB,$04C8,$0237
	.dc.w	$AA97,$E3EF,$630F,$94F0,$0000,$C000,$C000,$0000
	.dc.w	$04A2,$099D,$0984,$047B,$A2A2,$EBDC,$6310,$9CEF
	.dc.w	$8000,$C000,$C000,$0000,$00D1,$11CE,$11C2,$083D
	.dc.w	$AAC5,$6339,$6321,$9CDE,$8000,$C000,$C000,$0000
	.dc.w	$11A8,$F3A7,$F3A1,$005E,$220A,$6372,$6342,$9CBD
	.dc.w	$4000,$6000,$6000,$8000,$A143,$A33F,$A30B,$40FC
	.dc.w	$5561,$F7FE,$F7E8,$081F,$4000,$6000,$6000,$8000
	.dc.w	$41C0,$C3BF,$038D,$E07E,$AA81,$FFFE,$FFD8,$003F
	.dc.w	$4000,$6000,$6000,$8000,$E09C,$B180,$B180,$407F
	.dc.w	$361C,$BE80,$BE80,$417F,$8000,$C000,$C000,$0000
	.dc.w	$1041,$18C1,$18C1,$003E,$3641,$BEC1,$BEC1,$413E
	.dc.w	$0000,$8000,$8000,$0000,$004E,$04CF,$04CF,$0830
	.dc.w	$AAB9,$3E79,$3E79,$C186,$0000,$8000,$8000,$0000
	.dc.w	$0471,$02FE,$02FE,$0401,$554D,$773D,$773D,$88C2
	.dc.w	$0000,$8000,$8000,$0000,$002A,$03E4,$0160,$029F
	.dc.w	$AAA6,$E397,$E387,$1C78,$0000,$0000,$0000,$0000
	.dc.w	$0195,$01F1,$00B1,$014E,$555C,$C9CE,$C1CE,$3E30
	.dc.w	$0000,$0000,$0000,$0000,$0320,$033F,$013F,$0200
	.dc.w	$AA80,$9CFC,$80FC,$7F00,$0000,$0000,$0000,$0000
	.dc.w	$0001,$0183,$0083,$0100,$AAC0,$9CE0,$80E0,$7F00
	.dc.w	$0000,$0000,$0000,$0000,$0080,$0081,$0081,$0000
	.dc.w	$D580,$C9C0,$C1C0,$3E00,$0000,$0000,$0000,$0000
	.dc.w	$0003,$0007,$0007,$0000,$A2E0,$9CF0,$80F0,$7F00
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0001,$0001,$0000
	.dc.w	$D580,$C9C0,$C1C0,$3E00,$0000,$0000,$0000,$0000
	.dc.w	$0003,$0007,$0007,$0000,$AAE0,$9CF0,$80F0,$7F00
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0003,$0003,$0000
	.dc.w	$0000,$FFE0,$FFE0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$2200,$6300,$6300,$1C00
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$1400,$3600,$3600,$0800,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$1400,$3600,$3600,$0800
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$1400,$3600,$3600,$0800,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$1400,$3600,$3600,$0800
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0800,$1C00,$1C00,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0800,$1C00,$1C00,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0800,$1C00,$1C00,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0800,$1C00,$1C00,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$1C00,$1C00,$0800,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$1C00,$1C00,$0800
	.dc.w	$0000,$0000,$0000,$0000
shut01:		* ShuttleCraft (Perspective:1)
	.dc.w	18,22
	.dc.w	46,3
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$4000,$4000,$4000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$2000,$7000,$7000,$0000,$0000,$6000,$4000,$2000
	.dc.w	$0080,$0080,$0080,$0000,$2001,$7001,$7001,$0000
	.dc.w	$3000,$3000,$2000,$1000,$0000,$0180,$0080,$0100
	.dc.w	$2000,$7001,$7001,$0000,$6000,$E000,$4000,$A000
	.dc.w	$0320,$0320,$0120,$0200,$2000,$7000,$7000,$0000
	.dc.w	$1000,$F000,$A000,$5000,$0180,$01E0,$00A0,$0140
	.dc.w	$2000,$7000,$7000,$0000,$0000,$7000,$6000,$1000
	.dc.w	$0000,$03C3,$0143,$0280,$2000,$FE00,$FE00,$0000
	.dc.w	$1000,$2000,$2000,$1000,$0403,$0287,$0287,$0400
	.dc.w	$2600,$2700,$2700,$D800,$0000,$2000,$2000,$1000
	.dc.w	$0005,$040C,$040C,$0803,$FD00,$0180,$8980,$FE00
	.dc.w	$1000,$3000,$3000,$0000,$100A,$1819,$1818,$0007
	.dc.w	$8A80,$54C0,$88C0,$FF00,$0000,$3000,$3000,$0000
	.dc.w	$E016,$B031,$B030,$400F,$0340,$DC60,$0060,$FF80
	.dc.w	$3800,$2800,$2800,$1000,$4000,$C007,$0007,$E000
	.dc.w	$F800,$FF00,$FF00,$0000,$1000,$1800,$0000,$3800
	.dc.w	$A007,$A3FE,$A3FE,$4001,$2700,$FBFE,$23FE,$DC00
	.dc.w	$2800,$2800,$2800,$1000,$130D,$F703,$F700,$00FF
	.dc.w	$0586,$8E07,$8807,$77F8,$4000,$7800,$7800,$0000
	.dc.w	$019A,$1387,$1381,$087E,$22CC,$DF0E,$040E,$FBF0
	.dc.w	$0000,$4000,$4000,$8000,$04F3,$09CF,$09C1,$043E
	.dc.w	$0679,$FF9C,$541C,$ABE1,$0000,$8000,$8000,$0000
	.dc.w	$0039,$06FF,$04FF,$0200,$74E0,$27FB,$07F9,$F802
	.dc.w	$0000,$0000,$0000,$0000,$0010,$032F,$0321,$00DE
	.dc.w	$A840,$8FA6,$8C26,$53D8,$0000,$0000,$0000,$0000
	.dc.w	$0188,$0377,$0311,$00EE,$888C,$AF76,$8C46,$73B8
	.dc.w	$0000,$0000,$0000,$0000,$0146,$0339,$0309,$00F6
	.dc.w	$AB14,$8CE6,$8C86,$7378,$0000,$0000,$0000,$0000
	.dc.w	$03A0,$079D,$0785,$007A,$882E,$8DCF,$8D0F,$72F0
	.dc.w	$0000,$0000,$0000,$0000,$020D,$06FF,$062F,$01F0
	.dc.w	$5582,$DFFB,$DFA3,$207C,$0000,$0000,$0000,$0000
	.dc.w	$0302,$07FF,$0737,$00F8,$AA06,$FFFF,$FF67,$00F8
	.dc.w	$0000,$0000,$0000,$0000,$0170,$0302,$0302,$00FD
	.dc.w	$D874,$FA06,$FA06,$05F8,$0000,$0000,$0000,$0000
	.dc.w	$0004,$0106,$0106,$00F9,$D900,$FB04,$FB04,$04F8
	.dc.w	$0000,$0000,$0000,$0000,$003A,$013C,$013C,$00C3
	.dc.w	$AAE0,$F9E4,$F9E4,$0618,$0000,$0000,$0000,$0000
	.dc.w	$00E5,$01F9,$01F9,$0006,$5538,$DCFC,$DCFC,$2300
	.dc.w	$0000,$0000,$0000,$0000,$00AA,$0193,$0183,$007C
	.dc.w	$AAA8,$8E4C,$8E0C,$71F0,$0000,$0000,$0000,$0000
	.dc.w	$0055,$00C7,$00C7,$0038,$5550,$2718,$0718,$F8E0
	.dc.w	$0000,$0000,$0000,$0000,$0002,$007E,$007E,$0001
	.dc.w	$AA00,$73F0,$03F0,$FC00,$0000,$0000,$0000,$0000
	.dc.w	$0006,$000E,$000E,$0001,$AB00,$7380,$0380,$FC00
	.dc.w	$0000,$0000,$0000,$0000,$0003,$0007,$0007,$0000
	.dc.w	$5600,$2700,$0700,$F800,$0000,$0000,$0000,$0000
	.dc.w	$000E,$001E,$001E,$0001,$8B80,$73C0,$03C0,$FC00
	.dc.w	$0000,$0000,$0000,$0000,$0003,$0007,$0007,$0000
	.dc.w	$5600,$2700,$0700,$F800,$0000,$0000,$0000,$0000
	.dc.w	$000E,$001E,$001E,$0001,$AB80,$73C0,$03C0,$FC00
	.dc.w	$0000,$0000,$0000,$0000,$0000,$000F,$000F,$0000
	.dc.w	$0000,$FF80,$FF80,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0001,$0001,$0000,$8800,$8C00,$8C00,$7000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$5000,$D800,$D800,$2000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$5000,$D800,$D800,$2000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$5000,$D800,$D800,$2000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$2000,$7000,$7000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$2000,$7000,$7000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$2000,$7000,$7000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$2000,$7000,$7000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$2000,$7000,$7000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$2000,$7000,$7000,$0000,$0000,$0000,$0000,$0000
shut02:		* ShuttleCraft (Perspective:2)
	.dc.w	18,20
	.dc.w	43,3
	.dc.w	$0000,$0000,$0000,$0000,$2000,$7000,$7000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$2000,$7000,$7000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$2000,$7000,$7000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$2000,$7000,$7000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$2000,$7000,$7000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0001,$0001,$0000
	.dc.w	$2000,$FC00,$FC00,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0001,$0003,$0003,$0000,$AC00,$AE00,$AE00,$5000
	.dc.w	$0000,$0000,$0000,$0000,$0002,$0006,$0006,$0001
	.dc.w	$2200,$8B00,$8B00,$FC00,$0000,$0000,$0000,$0000
	.dc.w	$0004,$000D,$000C,$0003,$0100,$DD80,$8980,$FE00
	.dc.w	$0000,$0000,$0000,$0000,$000C,$001D,$001C,$0003
	.dc.w	$0380,$DDC0,$01C0,$FE00,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0003,$0003,$0000,$F800,$FE00,$FE00,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0003,$01FE,$01FE,$0001
	.dc.w	$2600,$FBFE,$23FE,$DC00,$0000,$0000,$0000,$0000
	.dc.w	$0107,$0301,$0300,$00FF,$0516,$8E17,$8817,$77E8
	.dc.w	$0000,$0000,$0000,$0000,$00CC,$01C3,$01C1,$003E
	.dc.w	$239C,$DE1E,$041E,$FBE0,$0000,$0000,$0000,$0000
	.dc.w	$0079,$01E7,$01E1,$001E,$06F0,$FF3C,$543C,$ABC0
	.dc.w	$0000,$0000,$0000,$0000,$003D,$037F,$027F,$0100
	.dc.w	$75E0,$27F2,$07F0,$F802,$0000,$0000,$0000,$0000
	.dc.w	$0298,$0597,$0591,$026E,$A8B9,$8F3E,$8C3E,$53C1
	.dc.w	$0000,$0000,$0000,$0000,$01A6,$0B9D,$0B85,$047A
	.dc.w	$AA2C,$8CCF,$8C0F,$73F0,$0000,$0000,$0000,$8000
	.dc.w	$0952,$1B4F,$1B43,$00BC,$8852,$8D93,$8C13,$73EC
	.dc.w	$4000,$C000,$C000,$0000,$1087,$F27F,$F217,$01F8
	.dc.w	$570A,$DFF3,$DF43,$20FC,$2000,$6000,$6000,$0000
	.dc.w	$A180,$A37F,$A31B,$40FC,$AA0A,$FFF3,$FEC3,$01FC
	.dc.w	$1400,$3400,$3400,$0800,$4138,$0300,$0300,$E0FF
	.dc.w	$D8E4,$FA06,$FA06,$05F8,$0400,$2800,$2000,$1C00
	.dc.w	$E082,$A182,$A182,$407D,$D808,$FA0C,$FA0C,$05F0
	.dc.w	$1C00,$3400,$3400,$0800,$009C,$419E,$419E,$0061
	.dc.w	$ABC8,$F9CC,$F9CC,$0630,$0800,$1800,$1800,$0000
	.dc.w	$4093,$619D,$619D,$0062,$5448,$DDCC,$DDCC,$2230
	.dc.w	$0000,$1000,$1000,$0800,$0054,$10C9,$10C1,$203E
	.dc.w	$AB10,$8E98,$8E18,$71E0,$0800,$1000,$1000,$0800
	.dc.w	$102B,$0A63,$0A63,$101C,$54A0,$2630,$0630,$F9C0
	.dc.w	$0000,$3800,$3000,$0800,$0002,$0F3E,$053E,$0A01
	.dc.w	$AA00,$73E0,$03E0,$FC00,$0000,$7000,$5000,$2000
	.dc.w	$0601,$0783,$0283,$0500,$5400,$2600,$0600,$F800
	.dc.w	$3000,$F000,$A000,$5000,$0C86,$0C8E,$048E,$0801
	.dc.w	$8B00,$7380,$0380,$FC00,$8000,$E000,$C000,$2000
	.dc.w	$0001,$0603,$0203,$0400,$5400,$2600,$0600,$F800
	.dc.w	$4000,$4000,$4000,$0000,$0206,$020E,$020E,$0001
	.dc.w	$AB00,$7380,$0380,$FC00,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0007,$0007,$0000,$0000,$FF00,$FF00,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0001,$0001,$0000
	.dc.w	$8800,$8C00,$8C00,$7000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$5000,$D800,$D800,$2000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$5000,$D800,$D800,$2000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$5000,$D800,$D800,$2000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$2000,$7000,$7000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$2000,$7000,$7000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$2000,$7000,$7000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$2000,$7000,$7000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$7000,$7000,$2000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$7000,$7000,$2000
	.dc.w	$0000,$0000,$0000,$0000
shut03:		* ShuttleCraft (Perspective:3)
	.dc.w	15,19
	.dc.w	41,2
	.dc.w	$0001,$0003,$0003,$0000,$0000,$8000,$8000,$0000
	.dc.w	$0001,$0003,$0003,$0000,$0000,$8000,$8000,$0000
	.dc.w	$0001,$0003,$0003,$0000,$0000,$8000,$8000,$0000
	.dc.w	$0001,$0003,$0003,$0000,$0000,$8000,$8000,$0000
	.dc.w	$0001,$0003,$0003,$0000,$0000,$8000,$8000,$0000
	.dc.w	$0001,$0007,$0007,$0000,$0000,$C000,$C000,$0000
	.dc.w	$0006,$000E,$000E,$0001,$C000,$E000,$E000,$0000
	.dc.w	$000B,$0018,$0018,$0007,$A000,$3000,$3000,$C000
	.dc.w	$0016,$0030,$0034,$000F,$E000,$0800,$4800,$F000
	.dc.w	$0028,$0066,$0060,$001F,$1800,$EC00,$0C00,$F000
	.dc.w	$0000,$000F,$000F,$0000,$0000,$F000,$F000,$0000
	.dc.w	$000D,$03FB,$03F9,$0006,$3000,$DFC0,$1FC0,$E000
	.dc.w	$0334,$070E,$0702,$00FD,$28C0,$70E0,$40E0,$BF00
	.dc.w	$00CC,$03BF,$0384,$007B,$3700,$F9C0,$A1C0,$5E00
	.dc.w	$0065,$07FD,$05FC,$0203,$4C40,$7F00,$7F00,$8040
	.dc.w	$0503,$0BBF,$0B06,$04F9,$8100,$FBC0,$C1C0,$3E20
	.dc.w	$0322,$16DF,$1606,$09F9,$8990,$F6F0,$C0F0,$3F00
	.dc.w	$129B,$3646,$3606,$01F9,$B288,$C4D8,$C0D8,$3F00
	.dc.w	$821C,$A7DE,$A65E,$41E1,$7081,$F7C5,$F4C5,$0F02
	.dc.w	$820B,$47EF,$066F,$E1F0,$A081,$EFCA,$ECC8,$1F07
	.dc.w	$C2C3,$A60B,$A60B,$41F4,$8683,$A0C5,$A0C5,$5F02
	.dc.w	$0312,$471B,$471B,$00E4,$9182,$B1C6,$B1C6,$4E00
	.dc.w	$41AB,$63B3,$63B3,$004C,$AB00,$9B84,$9B84,$6402
	.dc.w	$0094,$2186,$2186,$4079,$5202,$C30C,$C30C,$3C02
	.dc.w	$4074,$20FD,$20FC,$4003,$5C08,$7E14,$7E14,$8008
	.dc.w	$001B,$3079,$1078,$2007,$B014,$3C38,$3C38,$C004
	.dc.w	$2004,$780D,$280C,$5003,$4008,$6018,$6018,$8000
	.dc.w	$0818,$383B,$1838,$2007,$3000,$B800,$3800,$C000
	.dc.w	$1004,$100D,$100C,$0003,$4000,$6000,$6000,$8000
	.dc.w	$0018,$003B,$0038,$0007,$3000,$B800,$3800,$C000
	.dc.w	$0000,$000F,$000F,$0000,$0000,$E000,$E000,$0000
	.dc.w	$0004,$000C,$000C,$0003,$4000,$6000,$6000,$8000
	.dc.w	$0002,$0006,$0006,$0001,$8000,$C000,$C000,$0000
	.dc.w	$0002,$0006,$0006,$0001,$8000,$C000,$C000,$0000
	.dc.w	$0002,$0006,$0006,$0001,$8000,$C000,$C000,$0000
	.dc.w	$0002,$0006,$0006,$0001,$8000,$C000,$C000,$0000
	.dc.w	$0001,$0003,$0003,$0000,$0000,$8000,$8000,$0000
	.dc.w	$0001,$0003,$0003,$0000,$0000,$8000,$8000,$0000
	.dc.w	$0001,$0003,$0003,$0000,$0000,$8000,$8000,$0000
	.dc.w	$0001,$0003,$0003,$0000,$0000,$8000,$8000,$0000
	.dc.w	$0001,$0003,$0003,$0000,$0000,$8000,$8000,$0000
shut04:		* ShuttleCraft (Perspective:4)
	.dc.w	15,16
	.dc.w	36,3
	.dc.w	$0001,$0003,$0003,$0000,$0000,$8000,$8000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0001,$0003,$0003,$0000
	.dc.w	$0000,$8000,$8000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0001,$0003,$0003,$0000,$0000,$8000,$8000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0001,$0007,$0007,$0000
	.dc.w	$0000,$C000,$C000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0007,$000F,$000F,$0000,$C000,$E000,$E000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$000D,$001C,$001C,$0003
	.dc.w	$6000,$7000,$7000,$8000,$0000,$0000,$0000,$0000
	.dc.w	$0010,$0036,$0034,$000F,$1000,$D800,$5800,$E000
	.dc.w	$0000,$0000,$0000,$0000,$0038,$0076,$0070,$000F
	.dc.w	$3800,$DC00,$1C00,$E000,$0000,$0000,$0000,$0000
	.dc.w	$0003,$000F,$000F,$0000,$8000,$E000,$E000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$000D,$01FB,$01F9,$0006
	.dc.w	$6000,$BF00,$3F00,$C000,$4000,$4000,$4000,$0000
	.dc.w	$01BC,$038F,$0386,$0079,$7B00,$E380,$C380,$3C00
	.dc.w	$A000,$6000,$6000,$8000,$00E9,$01DE,$01C4,$003B
	.dc.w	$2E00,$F700,$4700,$B800,$4000,$8000,$8000,$4000
	.dc.w	$1477,$13FD,$11FC,$0E03,$DC80,$7F00,$7F00,$8080
	.dc.w	$8000,$4000,$4000,$8000,$4130,$E36D,$E324,$00DB
	.dc.w	$1100,$6580,$4180,$BE41,$0000,$8000,$8000,$0000
	.dc.w	$A159,$E334,$A314,$40EB,$2522,$49E3,$41E3,$BE00
	.dc.w	$0000,$0000,$0000,$0000,$42A0,$E6D4,$E6C4,$017B
	.dc.w	$0A88,$56FE,$46FE,$BD00,$0000,$0000,$0000,$0000
	.dc.w	$0309,$06FF,$066F,$01F0,$2194,$FEDC,$ECD4,$1F08
	.dc.w	$0000,$0000,$0000,$0000,$4262,$660B,$660B,$01F4
	.dc.w	$8C88,$A0DC,$A0DC,$5F00,$0000,$0000,$0000,$0000
	.dc.w	$0102,$230B,$230B,$40F4,$8100,$A180,$A180,$5E00
	.dc.w	$0000,$0000,$0000,$0000,$4129,$2333,$2333,$40CC
	.dc.w	$2900,$9980,$9980,$6600,$0000,$0000,$0000,$0000
	.dc.w	$2099,$118C,$118C,$2073,$3600,$6700,$6700,$9800
	.dc.w	$0000,$0000,$0000,$0000,$7006,$38FD,$38FC,$4003
	.dc.w	$C000,$7E00,$7E00,$8000,$0000,$0000,$0000,$0000
	.dc.w	$2004,$301D,$301C,$0003,$4000,$7000,$7000,$8000
	.dc.w	$0000,$0000,$0000,$0000,$0018,$003B,$0038,$0007
	.dc.w	$3000,$B800,$3800,$C000,$0000,$0000,$0000,$0000
	.dc.w	$0004,$001D,$001C,$0003,$4000,$7000,$7000,$8000
	.dc.w	$0000,$0000,$0000,$0000,$0018,$003B,$0038,$0007
	.dc.w	$3000,$B800,$3800,$C000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$001F,$001F,$0000,$0000,$F000,$F000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0004,$0004,$0003
	.dc.w	$0000,$4000,$4000,$8000,$0000,$0000,$0000,$0000
	.dc.w	$0002,$0006,$0006,$0001,$8000,$C000,$C000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0002,$0006,$0006,$0001
	.dc.w	$8000,$C000,$C000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0002,$0006,$0006,$0001,$8000,$C000,$C000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0001,$0003,$0003,$0000
	.dc.w	$0000,$8000,$8000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0001,$0003,$0003,$0000,$0000,$8000,$8000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0001,$0003,$0003,$0000
	.dc.w	$0000,$8000,$8000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0003,$0003,$0001,$0000,$8000,$8000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0003,$0003,$0001
	.dc.w	$0000,$8000,$8000,$0000,$0000,$0000,$0000,$0000
shut05:		* ShuttleCraft (Perspective:5)
	.dc.w	14,15
	.dc.w	32,2
	.dc.w	$0002,$0007,$0007,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0002,$0007,$0007,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0002,$0007,$0007,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0002,$000F,$000F,$0000,$0000,$8000,$8000,$0000
	.dc.w	$000F,$001F,$001F,$0000,$8000,$C000,$C000,$0000
	.dc.w	$001F,$0038,$0038,$0007,$C000,$E000,$E000,$0000
	.dc.w	$0028,$0065,$0068,$001F,$A000,$3000,$B000,$C000
	.dc.w	$0070,$00ED,$00E0,$001F,$7000,$B800,$3800,$C000
	.dc.w	$000A,$03FA,$03FA,$0005,$8000,$FE00,$FE00,$0000
	.dc.w	$0228,$0618,$0600,$01FF,$A600,$C700,$0700,$F800
	.dc.w	$01D8,$03BF,$038D,$0072,$DC00,$EE00,$8E00,$7000
	.dc.w	$04EF,$03FA,$03F8,$0407,$B900,$FE00,$FE00,$0100
	.dc.w	$0360,$06DA,$0648,$09B7,$2600,$CB00,$8300,$7C80
	.dc.w	$12B2,$1E68,$1E28,$01D7,$4A40,$93C0,$83C0,$7C00
	.dc.w	$463D,$EDFD,$ECBD,$03C2,$E310,$FDF8,$E9F8,$1E00
	.dc.w	$E612,$ADFF,$ACDF,$43E0,$4338,$FDA8,$D9A8,$3E10
	.dc.w	$4605,$EE17,$EE17,$01E8,$0310,$43B8,$43B8,$BC00
	.dc.w	$2262,$2677,$2677,$0188,$3220,$7320,$7320,$8C00
	.dc.w	$03CD,$27ED,$27ED,$1012,$9A00,$BB20,$BB20,$4440
	.dc.w	$08CD,$139A,$1398,$0867,$9880,$CE40,$CE40,$3080
	.dc.w	$0008,$09FA,$09F8,$0207,$8000,$F880,$F880,$0200
	.dc.w	$0130,$0377,$0370,$040F,$6400,$7600,$7600,$8100
	.dc.w	$0208,$033A,$0338,$0007,$8200,$E600,$E600,$0000
	.dc.w	$0030,$0077,$0070,$000F,$6000,$7000,$7000,$8000
	.dc.w	$0000,$003F,$003F,$0000,$0000,$E000,$E000,$0000
	.dc.w	$0005,$000D,$000D,$0002,$0000,$8000,$8000,$0000
	.dc.w	$0005,$000D,$000D,$0002,$0000,$8000,$8000,$0000
	.dc.w	$0005,$000D,$000D,$0002,$0000,$8000,$8000,$0000
	.dc.w	$0002,$0007,$0007,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0002,$0007,$0007,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0002,$0007,$0007,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0002,$0007,$0007,$0000,$0000,$0000,$0000,$0000
shut06:		* ShuttleCraft (Perspective:6)
	.dc.w	13,15
	.dc.w	31,2
	.dc.w	$0000,$0000,$0000,$0000,$0400,$0C00,$0C00,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0800,$0C00,$0C00,$0200
	.dc.w	$0004,$000E,$000E,$0000,$0000,$0800,$0800,$0400
	.dc.w	$0004,$000E,$000E,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0004,$000E,$000E,$0000,$0000,$0200,$0200,$0100
	.dc.w	$0004,$000E,$000E,$0000,$0080,$0180,$0180,$0000
	.dc.w	$0015,$0015,$0015,$000A,$0040,$00E0,$00E0,$0000
	.dc.w	$0024,$002A,$002A,$001F,$80A0,$80A0,$80A0,$0040
	.dc.w	$005B,$0040,$0040,$003F,$4040,$40E0,$40E0,$8000
	.dc.w	$000E,$03FF,$03FF,$0000,$0100,$F900,$F900,$0000
	.dc.w	$0324,$071B,$0700,$00FF,$B800,$3D00,$3D00,$C200
	.dc.w	$01B1,$039B,$038A,$0075,$B400,$3A00,$3A00,$C400
	.dc.w	$0464,$03F5,$01F1,$060E,$C000,$F400,$F400,$0000
	.dc.w	$11CA,$137F,$134A,$08B5,$7000,$D800,$5800,$A000
	.dc.w	$433F,$E76A,$E72A,$00D5,$5800,$1C00,$1C00,$E000
	.dc.w	$A251,$A69B,$A61B,$41E4,$4800,$2C00,$0C00,$F000
	.dc.w	$424A,$E69F,$E69F,$01E0,$4800,$2C00,$2C00,$F000
	.dc.w	$030A,$271F,$271F,$00E0,$1800,$1C00,$1C00,$E000
	.dc.w	$0140,$0B6A,$0B6A,$1095,$5000,$D800,$D800,$2000
	.dc.w	$08C0,$19D5,$19D1,$202E,$6000,$7000,$7000,$8000
	.dc.w	$101F,$18F5,$18F1,$000E,$0000,$E000,$E000,$0000
	.dc.w	$0011,$0035,$0031,$000E,$0000,$8000,$8000,$0000
	.dc.w	$003F,$0075,$0071,$000E,$8000,$C000,$C000,$0000
	.dc.w	$0000,$003F,$003F,$0000,$0000,$8000,$8000,$0000
	.dc.w	$000A,$001B,$001B,$0004,$0000,$0000,$0000,$0000
	.dc.w	$000A,$001B,$001B,$0004,$0000,$0000,$0000,$0000
	.dc.w	$0000,$000A,$000A,$0004,$0000,$0000,$0000,$0000
	.dc.w	$0004,$000E,$000E,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0004,$000E,$000E,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0004,$000E,$000E,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$000E,$000E,$0004,$0000,$0000,$0000,$0000
shut07:		* ShuttleCraft (Perspective:7)
	.dc.w	11,11
	.dc.w	25,2
	.dc.w	$0010,$0038,$0038,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0010,$0038,$0038,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0010,$0038,$0038,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0038,$007C,$007C,$0000,$0000,$0000,$0000,$0000
	.dc.w	$007C,$00C6,$00EE,$0038,$0000,$0000,$0000,$0000
	.dc.w	$00EE,$0183,$0183,$007C,$0000,$0000,$0000,$0000
	.dc.w	$007C,$07FF,$07FF,$0000,$0000,$C000,$C000,$0000
	.dc.w	$06D6,$0E6C,$0E00,$01FF,$C000,$E000,$E000,$0000
	.dc.w	$0555,$0339,$0301,$04FE,$4000,$8000,$8000,$4000
	.dc.w	$02AA,$06FE,$06AA,$0955,$8000,$C000,$C000,$2000
	.dc.w	$1529,$1CAA,$1C28,$03D7,$5000,$7000,$7000,$8000
	.dc.w	$0555,$6ED6,$6D55,$02AA,$4000,$EC00,$6C00,$8000
	.dc.w	$2428,$AC7C,$AC7C,$4383,$4800,$6800,$6800,$8400
	.dc.w	$41FF,$E5BB,$E5BB,$0244,$0400,$4C00,$4C00,$8000
	.dc.w	$03FE,$466C,$466C,$0193,$8800,$CC00,$CC00,$0000
	.dc.w	$007C,$83D7,$83C7,$4038,$0000,$8800,$8800,$1000
	.dc.w	$2044,$60D6,$60C6,$8038,$2000,$1000,$1000,$2000
	.dc.w	$40C6,$C1D7,$C1C7,$0038,$0000,$8000,$8000,$4000
	.dc.w	$0000,$00FE,$00FE,$0000,$8000,$C000,$C000,$2000
	.dc.w	$0028,$006C,$006C,$0010,$4000,$C000,$C000,$0000
	.dc.w	$0000,$0028,$0028,$0010,$0000,$0000,$0000,$0000
	.dc.w	$0010,$0038,$0038,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0010,$0038,$0038,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0010,$0038,$0038,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0010,$0038,$0038,$0000,$0000,$0000,$0000,$0000
shut08:		* ShuttleCraft (Perspective:8)
	.dc.w	9,11
	.dc.w	24,2
	.dc.w	$0040,$0040,$0040,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0040,$00E0,$00E0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0040,$00E0,$00E0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0040,$01F0,$01F0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0150,$03B8,$03B8,$00E0,$0000,$0000,$0000,$0000
	.dc.w	$0318,$06AC,$060C,$01F0,$0000,$0000,$0000,$0000
	.dc.w	$0150,$0F5E,$0F5E,$00A0,$0000,$0000,$0000,$0000
	.dc.w	$0D56,$1CE7,$1C07,$03F8,$0000,$0000,$0000,$0000
	.dc.w	$035A,$175D,$171D,$08E2,$0000,$0000,$0000,$0000
	.dc.w	$15B4,$3CE6,$3CA6,$0359,$0000,$8000,$8000,$0000
	.dc.w	$2AAA,$B8A3,$B8A3,$475C,$8000,$C000,$C000,$0000
	.dc.w	$49F0,$FDF5,$FBF9,$0406,$4000,$C000,$C000,$2000
	.dc.w	$08A2,$59F3,$59F3,$260C,$2000,$6000,$6000,$0000
	.dc.w	$13F8,$3AEA,$3AEA,$4514,$0000,$4000,$4000,$8000
	.dc.w	$27F5,$2DB7,$2DB7,$0248,$0000,$8000,$8000,$4000
	.dc.w	$01F0,$075C,$071C,$00E0,$8000,$8000,$8000,$0000
	.dc.w	$0110,$0358,$0318,$00E0,$0000,$0000,$0000,$0000
	.dc.w	$0318,$075C,$071C,$00E0,$0000,$0000,$0000,$0000
	.dc.w	$0000,$03F8,$03F8,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$00A0,$00A0,$0040,$0000,$0000,$0000,$0000
	.dc.w	$0000,$00A0,$00A0,$0040,$0000,$0000,$0000,$0000
	.dc.w	$0040,$00E0,$00E0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0040,$0040,$0040,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0040,$0040,$0040,$0000,$0000,$0000,$0000
shut09:		* ShuttleCraft (Perspective:9)
	.dc.w	9,10
	.dc.w	21,2
	.dc.w	$0040,$0040,$0040,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0040,$00E0,$00E0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0040,$00E0,$00E0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$00E0,$03B8,$03B8,$0040,$0000,$0000,$0000,$0000
	.dc.w	$02A8,$06AC,$060C,$01F0,$0000,$0000,$0000,$0000
	.dc.w	$00E0,$0FFE,$0FFE,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0D4A,$1CF3,$1C03,$03FC,$0000,$0000,$0000,$0000
	.dc.w	$0358,$075E,$071E,$00E0,$0000,$0000,$0000,$0000
	.dc.w	$05B4,$0CE6,$0CA6,$1359,$0000,$8000,$8000,$0000
	.dc.w	$2CA6,$3AAB,$38A3,$075C,$8000,$C000,$C000,$0000
	.dc.w	$4FBE,$7BFB,$79F3,$8404,$4000,$5000,$5000,$2000
	.dc.w	$8BBA,$DAEB,$DAEB,$0514,$2000,$3000,$3000,$0000
	.dc.w	$07FC,$0DB6,$0DB6,$C248,$0000,$2000,$2000,$4000
	.dc.w	$61F0,$E75C,$E71C,$00E0,$8000,$C000,$C000,$2000
	.dc.w	$0110,$4358,$4318,$00E0,$4000,$4000,$4000,$0000
	.dc.w	$03F8,$075C,$071C,$00E0,$0000,$0000,$0000,$0000
	.dc.w	$0000,$03F8,$03F8,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$00A0,$00A0,$0040,$0000,$0000,$0000,$0000
	.dc.w	$0000,$00A0,$00A0,$0040,$0000,$0000,$0000,$0000
	.dc.w	$0040,$0040,$0040,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0040,$0040,$0040,$0000,$0000,$0000,$0000,$0000
shut10:		* ShuttleCraft (Perspective:10)
	.dc.w	7,7
	.dc.w	17,2
	.dc.w	$0100,$0100,$0100,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0100,$0100,$0100,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0380,$06C0,$06C0,$0100,$0000,$0000,$0000,$0000
	.dc.w	$0440,$0EE0,$0C60,$0380,$0000,$0000,$0000,$0000
	.dc.w	$0380,$1FF0,$1FF0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$1550,$3398,$3018,$0FE0,$0000,$0000,$0000,$0000
	.dc.w	$0AA0,$1BB0,$1AB0,$2548,$8000,$8000,$8000,$0000
	.dc.w	$5294,$7EFC,$729C,$0920,$4000,$4000,$4000,$8000
	.dc.w	$9452,$3119,$3119,$8EE2,$0000,$0000,$0000,$0000
	.dc.w	$0BA0,$9BB0,$9BB0,$0440,$0000,$0000,$0000,$0000
	.dc.w	$2100,$2C60,$2C60,$4380,$0000,$0000,$0000,$0000
	.dc.w	$4440,$4D60,$4C60,$0380,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0380,$0380,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0280,$0280,$0100,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0280,$0280,$0100,$0000,$0000,$0000,$0000
	.dc.w	$0100,$0100,$0100,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0100,$0100,$0100,$0000,$0000,$0000,$0000
shut11:		* ShuttleCraft (Perspective:11)
	.dc.w	7,6
	.dc.w	13,1
	.dc.w	$0100,$0100,$0100,$0000,$0100,$0100,$0100,$0000
	.dc.w	$0280,$06C0,$06C0,$0100,$0000,$0EE0,$0C60,$0380
	.dc.w	$1550,$3398,$3018,$0FE0,$0BE0,$1AB0,$1AB0,$0540
	.dc.w	$5114,$755C,$711C,$0EE0,$8C64,$9EF4,$9EF4,$0100
	.dc.w	$0000,$0D60,$0C60,$4388,$0540,$0C60,$0C60,$0380
	.dc.w	$0000,$0380,$0380,$0000,$0000,$0000,$0000,$0100
	.dc.w	$0100,$0100,$0100,$0000
shut12:		* ShuttleCraft (Perspective:12)
	.dc.w	5,5
	.dc.w	12,1
	.dc.w	$0400,$0400,$0400,$0000,$0400,$0400,$0400,$0000
	.dc.w	$0A00,$1B00,$1B00,$0400,$2A80,$64C0,$60C0,$1F00
	.dc.w	$1F40,$31C0,$31C0,$0E00,$3F80,$64C0,$64C0,$1B20
	.dc.w	$AA80,$AE80,$AE80,$1100,$0A00,$1F00,$1B00,$8400
	.dc.w	$0E00,$1B00,$1B00,$0400,$0400,$0A00,$0A00,$0400
	.dc.w	$0400,$0400,$0400,$0000,$0000,$0400,$0400,$0400
shut13:		* ShuttleCraft (Perspective:13)
	.dc.w	5,4
	.dc.w	11,1
	.dc.w	$0400,$0400,$0400,$0000,$0400,$0400,$0400,$0000
	.dc.w	$0A00,$1B00,$1B00,$0400,$2A80,$64C0,$60C0,$1F20
	.dc.w	$1540,$31C0,$31C0,$0E00,$B580,$E4C0,$E4C0,$1B00
	.dc.w	$5A00,$7E80,$7E80,$0100,$0A00,$1B00,$1B00,$0400
	.dc.w	$0A00,$1B00,$1B00,$0400,$0400,$0400,$0400,$0000
	.dc.w	$0400,$0400,$0400,$0000
shut14:		* ShuttleCraft (Perspective:14)
	.dc.w	3,3
	.dc.w	9,1
	.dc.w	$1000,$1000,$1000,$0000,$1000,$3800,$3800,$0000
	.dc.w	$5400,$4400,$4400,$3800,$BA00,$EE00,$EE00,$1000
	.dc.w	$6C00,$4400,$4400,$3800,$6C00,$7C00,$7C00,$0000
	.dc.w	$2800,$2800,$2800,$1000,$1000,$1000,$1000,$0000
	.dc.w	$0000,$1000,$1000,$1000
shut15:		* ShuttleCraft (Perspective:15)
	.dc.w	2,2
	.dc.w	7,1
	.dc.w	$2000,$2000,$2000,$0000,$0000,$0000,$0000,$7000
	.dc.w	$A800,$D800,$D800,$2000,$0000,$2000,$2000,$5000
	.dc.w	$7000,$7000,$7000,$0000,$0000,$0000,$0000,$2000
	.dc.w	$2000,$2000,$2000,$0000

	.end
