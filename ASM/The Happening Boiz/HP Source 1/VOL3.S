**********************************************
* THE HAPPENING BOIZ PRESENT THE VOLUME      *
* EXTENSION 2 !! - BIG VOLUME BARS!          *
*ENTER WITH A5 POINTING TO MEMORY WHERE YOU  *
*WANT THE 3 VOLUMES RETURNED TO (3 BYTES!)   *
*AREG(0) - DEST SCREEN FOR BARS		     *
**********************************************


CHANGE	MOVEQ.W #0,D0
	MOVEQ.W #0,D1
	MOVEQ.W #0,D2
	MOVE.W	#65535,D6
	MOVE.B #8,$FFFF8800.W  	
	MOVE.B $FFFF8800.W,D0
	MOVE.B #9,$FFFF8800.W   
	MOVE.B $FFFF8800.W,D1
	MOVE.B #10,$FFFF8800.W  
	MOVE.B $FFFF8800.W,D2
	BTST #4,D0              
	BEQ .L1
	MOVE.B #10,D0           
.L1	BTST #4,D1    		
       	BEQ .L2
	MOVE.B #10,D1
.L2	BTST #4,D2		
	BEQ .L3
	MOVE.B #10,D2
.L3 	
	MULU	#15,D0
	MULU	#15,D1
	MULU	#15,D2
	JSR	CH_1
	JSR	CH_2
	JSR	CH_3
STOP_NOW
	RTS
	
*ROUTINES TO DRAW VOLUME BARS

CH_1
	MOVE.L	#VOL,A1
	ADD.W	D0,A1
	MOVE.L	A0,A2
	ADD.L	#16008,A2
	MOVE.W	#14,D4
CH_1_L
	MOVE.B	(A1)+,D5
	CMP.B	#1,D5
	BEQ	CH_1_DRAW
	MOVE.W	#0,(A2)
	MOVE.W	#0,8(A2)
	MOVE.W	#0,16(A2)
	MOVE.W	#0,24(A2)
	MOVE.W	#0,160(A2)
	MOVE.W	#0,168(A2)
	MOVE.W	#0,176(A2)
	MOVE.W	#0,184(A2)
CH_1_LL
	SUB.L	#640,A2
	DBF	D4,CH_1_L
	RTS
CH_1_DRAW
	MOVE.W	D6,(A2)
	MOVE.W	D6,8(A2)
	MOVE.W	D6,16(A2)
	MOVE.W	D6,24(A2)
	MOVE.W	D6,160(A2)
	MOVE.W	D6,168(A2)
	MOVE.W	D6,176(A2)
	MOVE.W	D6,184(A2)
	BRA	CH_1_LL
***************************
CH_2
	MOVE.L	#VOL,A1
	ADD.W	D1,A1
	MOVE.L	A0,A2
	ADD.L	#16056,A2
	MOVE.W	#14,D4
CH_2_L
	MOVE.B	(A1)+,D5
	CMP.B	#1,D5
	BEQ	CH_2_DRAW
	MOVE.W	#0,(A2)
	MOVE.W	#0,8(A2)
	MOVE.W	#0,16(A2)
	MOVE.W	#0,24(A2)
	MOVE.W	#0,160(A2)
	MOVE.W	#0,168(A2)
	MOVE.W	#0,176(A2)
	MOVE.W	#0,184(A2)
CH_2_LL
	SUB.L	#640,A2
	DBF	D4,CH_2_L
	RTS
CH_2_DRAW
	MOVE.W	D6,(A2)
	MOVE.W	D6,8(A2)
	MOVE.W	D6,16(A2)
	MOVE.W	D6,24(A2)
	MOVE.W	D6,160(A2)
	MOVE.W	D6,168(A2)
	MOVE.W	D6,176(A2)
	MOVE.W	D6,184(A2)
	BRA	CH_2_LL

****************************
CH_3
	MOVE.L	#VOL,A1
	ADD.W	D2,A1
	MOVE.L	A0,A2
	ADD.L	#16104,A2
	MOVE.W	#14,D4
CH_3_L
	MOVE.B	(A1)+,D5
	CMP.B	#1,D5
	BEQ	CH_3_DRAW
	MOVE.W	#0,(A2)
	MOVE.W	#0,8(A2)
	MOVE.W	#0,16(A2)
	MOVE.W	#0,24(A2)
	MOVE.W	#0,160(A2)
	MOVE.W	#0,168(A2)
	MOVE.W	#0,176(A2)
	MOVE.W	#0,184(A2)
CH_3_LL
	SUB.L	#640,A2
	DBF	D4,CH_3_L
	RTS
CH_3_DRAW
	MOVE.W	D6,(A2)
	MOVE.W	D6,8(A2)
	MOVE.W	D6,16(A2)
	MOVE.W	D6,24(A2)
	MOVE.W	D6,160(A2)
	MOVE.W	D6,168(A2)
	MOVE.W	D6,176(A2)
	MOVE.W	D6,184(A2)
	BRA	CH_3_LL


VOL	DC.B	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	DC.B	1,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	DC.B	1,1,0,0,0,0,0,0,0,0,0,0,0,0,0
	DC.B	1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	DC.B	1,1,1,1,0,0,0,0,0,0,0,0,0,0,0
	DC.B	1,1,1,1,1,0,0,0,0,0,0,0,0,0,0
	DC.B    1,1,1,1,1,1,0,0,0,0,0,0,0,0,0
	DC.B    1,1,1,1,1,1,1,0,0,0,0,0,0,0,0
	DC.B    1,1,1,1,1,1,1,1,0,0,0,0,0,0,0
	DC.B    1,1,1,1,1,1,1,1,1,0,0,0,0,0,0
	DC.B    1,1,1,1,1,1,1,1,1,1,0,0,0,0,0
	DC.B    1,1,1,1,1,1,1,1,1,1,1,0,0,0,0
	DC.B    1,1,1,1,1,1,1,1,1,1,1,1,0,0,0
	DC.B    1,1,1,1,1,1,1,1,1,1,1,1,1,0,0
	DC.B    1,1,1,1,1,1,1,1,1,1,1,1,1,1,0
	DC.B    1,1,1,1,1,1,1,1,1,1,1,1,1,1,1
	EVEN