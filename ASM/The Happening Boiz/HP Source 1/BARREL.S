**************************************************************
*ROUTINES BY EDDIE BRYAN OF THE HAPPENING BOIZ		     *
**************************************************************

*EDDIES BARREL SCROLLL ROUTINE - BASED ON MANIKINS TWIST SCROLL
*ADAPTED FOR USE WITH STOS !!!!!!!!!
*A1-DESTINATION
*A0 SOURCE
*D0-SOURCE POS (160'S)
*D1-DEST POS   (160'S)

BARREL_SCROLL	ADD.L 	D1,A1			
		ADD.L	D0,A0
		MOVE.L #ADDTAB,A2	
		MOVE.W #67,D0		
CONLOOP		MOVE.W (A0),(A1)	
		MOVE.W 8(A0),8(A1)
		MOVE.W 16(A0),16(A1)
		MOVE.W 24(A0),24(A1)
		MOVE.W 32(A0),32(A1)
		MOVE.W 40(A0),40(A1)
		MOVE.W 48(A0),48(A1)
		MOVE.W 56(A0),56(A1)
		MOVE.W 64(A0),64(A1)
		MOVE.W 72(A0),72(A1)
		MOVE.W 80(A0),80(A1)
		MOVE.W 88(A0),88(A1)
		MOVE.W 96(A0),96(A1)
		MOVE.W 104(A0),104(A1)
		MOVE.W 112(A0),112(A1)
		MOVE.W 120(A0),120(A1)
		MOVE.W 128(A0),128(A1)
		MOVE.W 136(A0),136(A1)
		MOVE.W 144(A0),144(A1)
		MOVE.W 152(A0),152(A1)


		ADD.L #160,A1		
		MOVE.W (A2)+,D1		
		ADD.W D1,A0		
		DBF D0,CONLOOP
		RTS

ADDTAB		DC.W 800,640,480,320,320,320,320,160,320,160,320,160,160,160,0,160,160,0
		DC.W	160,160,0,160,160,0,160,0,160,0,160,0,160,0,160,0
		DC.W 0,160,0,160,0,160,0,160,0,160,0,160,160,0,160,160
		DC.W	0,160,160,0,160,160,160,320,160,320,160,320,320,320,480,320,640,800

GOING_UP	DC.B	0	



