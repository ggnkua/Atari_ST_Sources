 TEXT
gloky_start:
      JMP       L000E 
L0000:DC.B      $4C,$98,$00,$0F,$4C,$99,$00,$F0 
      DC.B      $28,$32,$40,$00,$2A,$32,$50,$00 
      DC.B      $2C,$32,$60,$00,$2E,$32,$70,$00 
      DC.B      $D0,$44,$D2,$45,$D4,$46,$D6,$47 
      DC.B      $48,$A3,$F0,$00,$48,$44,$48,$45 
      DC.B      $48,$46,$48,$47 
L0001:DC.B      $89,$74,$00,$00,$8B,$74,$10,$00 
      DC.B      $8D,$74,$20,$00,$8F,$74,$30,$00 
L0002:DC.B      $89,$74,$00,$02,$8B,$74,$10,$02 
      DC.B      $8D,$74,$20,$02,$8F,$74,$30,$02 
L0003:DC.B      $89,$74,$00,$04,$8B,$74,$10,$04 
      DC.B      $8D,$74,$20,$04,$8F,$74,$30,$04 
L0004:DC.B      $89,$74,$00,$06,$8B,$74,$10,$06 
      DC.B      $8D,$74,$20,$06,$8F,$74,$30,$06 
      DC.B      $4C,$9B,$00,$0F 
L0005:DC.B      $31,$84,$00,$00,$31,$84,$10,$00 
      DC.B      $31,$84,$20,$00,$31,$84,$30,$00 
L0006:DC.B      $31,$84,$00,$02,$31,$84,$10,$02 
      DC.B      $31,$84,$20,$02,$31,$84,$30,$02 
L0007:DC.B      $31,$84,$00,$04,$31,$84,$10,$04 
      DC.B      $31,$84,$20,$04,$31,$84,$30,$04 
L0008:DC.B      $31,$84,$00,$06,$31,$84,$10,$06 
      DC.B      $31,$84,$20,$06,$31,$84,$30,$06 
L0009:DC.B      $21,$84,$00,$00,$21,$84,$10,$00 
      DC.B      $21,$84,$20,$00,$21,$84,$30,$00 
L000A:DC.B      $21,$84,$00,$02,$21,$84,$10,$02 
      DC.B      $21,$84,$20,$02,$21,$84,$30,$02 
L000B:DC.B      $21,$84,$00,$04,$21,$84,$10,$04 
      DC.B      $21,$84,$20,$04,$21,$84,$30,$04 
L000C:DCB.W     4,0 
      DC.L      L0005 
      DCB.W     2,0 
      DC.L      L0006 
      DCB.W     2,0 
      DC.L      L0009 
      DCB.W     2,0 
      DC.L      L0007 
      DCB.W     2,0 
      DC.L      L0007 
      DC.L      L0005 
      DC.L      L000A 
      DCB.W     2,0 
      DC.L      L000A 
      DC.L      L0005 
      DC.L      L0008 
      DCB.W     2,0 
      DC.L      L0008 
      DC.L      L0005 
      DC.L      L0008 
      DC.L      L0006 
      DC.L      L0008 
      DC.L      L0009 
      DC.L      L000B 
      DCB.W     2,0 
      DC.L      L000B 
      DC.L      L0005 
      DC.L      L000B 
      DC.L      L0006
      DC.L      L000B 
      DC.L      L0009 
L000D:DCB.W     8,0 
      DC.L      L0001 
      DCB.W     6,0 
      DC.L      L0002 
      DCB.W     6,0 
      DC.L      L0002 
      DC.L      L0001 
      DCB.W     4,0 
      DC.L      L0003 
      DCB.W     6,0 
      DC.L      L0003 
      DC.L      L0001 
      DCB.W     4,0 
      DC.L      L0003 
      DC.L      L0002 
      DCB.W     4,0 
      DC.L      L0003 
      DC.L      L0002 
      DC.L      L0001 
      DCB.W     2,0 
      DC.L      L0004 
      DCB.W     6,0 
      DC.L      L0004 
      DC.L      L0001 
      DCB.W     4,0 
      DC.L      L0004 
      DC.L      L0002 
      DCB.W     4,0 
      DC.L      L0004 
      DC.L      L0002 
      DC.L      L0001 
      DCB.W     2,0 
      DC.L      L0004 
      DC.L      L0003 
      DCB.W     4,0 
      DC.L      L0004 
      DC.L      L0003 
      DC.L      L0001 
      DCB.W     2,0 
      DC.L      L0004 
      DC.L      L0003 
      DC.L      L0002 
      DCB.W     2,0 
      DC.L      L0004 
      DC.L      L0003 
      DC.L      L0002 
      DC.L      L0001 
      DC.B      $38,$3C,$FF,$F6,$3A,$04,$E5,$44 
      DC.B      $D8,$45,$EB,$44,$4E,$71,$06,$44 
      DC.B      $06,$40,$09,$E8,$12,$34,$30,$28 
      DC.B      $00,$12,$49,$F1,$00,$00,$30,$2C 
      DC.B      $00,$34,$D0,$6A,$00,$56,$36,$C0 
      DC.B      $4E,$71,$30,$28,$00,$0C,$49,$F1 
      DC.B      $00,$00,$30,$2C,$00,$22,$D0,$6A 
      DC.B      $00,$38,$20,$35,$00,$00,$D1,$5B 
      DC.B      $48,$40,$3C,$C0,$00,$10,$00,$20 
      DC.B      $00,$C8,$00,$0A,$00,$0E,$00,$96 
      DC.B      $00,$14,$00,$20,$01,$5E,$00,$18 
      DC.B      $00,$37,$00,$0A,$00,$02 
L000E:
;      PEA       0.W
;      MOVE.W    #$20,-(A7) 	;SUPER
;      TRAP      #1
;      ADDQ.L    #6,A7
      LEA       L003E,A0
      MOVE.W    #$13,D0
      MOVEQ     #0,D1
      MOVE.W    #$8000,D2
      MOVE.W    D2,D3
L000F:MOVE.W    D2,(A0)+
      MOVE.W    D1,(A0)+
      LSR.W     #1,D2
      BNE.S     L000F
      ADDQ.L    #8,D1
      MOVE.W    D3,D2
      DBF       D0,L000F
      LEA       L0034,A0
      LEA       L0042,A1
      MOVE.W    #$28,D1
      MOVE.W    #$28,D2
      MOVEA.L   #L001C,A2
      JSR       L0018
      LEA       L0034,A0
      LEA       L0043,A1
      MOVE.W    #$3B,D1
      MOVE.W    #$3C,D2
      MOVEA.L   #L001C,A2
      JSR       L0018
      JSR       L001A
      LEA       L0034,A0
      LEA       L0044,A1
      MOVE.W    #$190,D1
      MOVE.W    #$200,D2
      MOVEA.L   #L001D,A2
      JSR       L0018
      LEA       L0034,A0
      LEA       L0045,A1
      MOVE.W    #$5A,D1 	;#'Z'
      MOVE.W    #$5A,D2 	;#'Z'
      MOVEA.L   #L001E,A2
      JSR       L0018
      LEA       L0034,A0
      LEA       L0046,A1
      MOVE.W    #$46,D1
      MOVE.W    #$46,D2
      MOVEA.L   #L001E,A2
      JSR       L0018
      JSR       L001A
      LEA       L0034,A0
      LEA       L0047,A1
      MOVE.W    #$B4,D1
      MOVE.W    #$B5,D2
      MOVEA.L   #L001D,A2
      JSR       L0018

      LEA       L0039,A0
      MOVE.L    $44E.W,(A0)
      MOVE.L    #scr_top,D0			; *** screens ***
      ANDI.L    #$FFFFFF00,D0
      MOVE.L    #$7D00,D1
      MOVEA.L   D0,A0
      LEA       L003C,A1
      MOVE.L    D0,(A1)+
      ADD.L     D1,D0
      MOVE.L    D0,(A1)+
      ADD.L     D1,D0
      MOVE.L    D0,(A1)+
      ADD.L     D1,D0
      MOVE.L    D0,(A1)+
      MOVE.W    #$1F3F,D0
      MOVEQ     #0,D1
L0010:MOVE.L    D1,(A0)+
      MOVE.L    D1,(A0)+
      MOVE.L    D1,(A0)+
      MOVE.L    D1,(A0)+
      DBF       D0,L0010
      LEA       L0048,A0
      MOVE.L    #L004B,D0
      MOVE.L    D0,(A0)+
      ADDI.L    #$400,D0
      MOVE.L    D0,(A0)+
      ADDI.L    #$400,D0
      MOVE.L    D0,(A0)+
      ADDI.L    #$400,D0
      MOVE.L    D0,(A0)+
      LEA       L0037,A0
      MOVE.W    #8,(A0)+
      MOVE.W    #7,(A0)+
      MOVE.W    #$C,(A0)+
      MOVE.W    #6,(A0)+
      MOVE.W    #$B,(A0)+
      MOVE.W    #$A,(A0)+
      LEA       L0041,A0
      MOVE.W    #$10,D0
      MOVE.W    #$20,D1
      MOVE.W    #$19,D2
      MOVE.W    #$32,D3
      MOVE.W    #$3A,D4
      MOVE.W    #$7FF,D5
      JSR       L001F
      MOVE.W    #$15,D2
      MOVE.W    #$26,D3
      MOVE.W    #$7D1,D4
      JSR       L001F
      MOVE.W    #$A,D2
      MOVE.W    #$7BD,D3
      MOVE.W    #$3A,D4
      JSR       L001F
      LEA       L0041,A0
      LEA       L004F,A1
      LEA       L004D,A2
      MOVE.W    #$200,D2
      JSR       L0022
      LEA       L0041,A0
      MOVE.W    #3,D2
      MOVE.W    #$86,D3
      MOVE.W    #$7D9,D4
      JSR       L001F
      MOVE.W    #$66,D2
      MOVE.W    #$7C7,D3
      MOVE.W    #$3F,D4
      JSR       L001F
      MOVE.W    #$201,D2
      MOVE.W    #$16,D3
      MOVE.W    #$32,D4
      JSR       L001F
      LEA       L0041,A0
      MOVE.W    #$200,D2
      JSR       L0022
      LEA       L0050,A0
      LEA       L003F,A1
      LEA       L0033,A4
      LEA       L000D,A5
      MOVE.W    #$7F,D0
      MOVE.L    A0,(A1)+
L0011:LEA       L0000,A2
      MOVE.W    #$15,D1
L0012:MOVE.W    (A2)+,(A0)+
      DBF       D1,L0012
      MOVE.B    (A4)+,D1
      EXT.W     D1
      LSL.W     #4,D1
      MOVE.W    #3,D2
L0013:MOVE.L    0(A5,D1.W),D3
      BEQ.S     L0014
      MOVEA.L   D3,A6
      MOVE.L    (A6)+,(A0)+
      MOVE.L    (A6)+,(A0)+
      MOVE.L    (A6)+,(A0)+
      MOVE.L    (A6)+,(A0)+
      ADDQ.L    #4,D1
      DBF       D2,L0013
L0014:DBF       D0,L0011
      MOVE.W    #$4E75,(A0)+
      LEA       L000C,A5
      MOVE.W    #$7F,D0
      MOVE.L    A0,(A1)+
L0015:MOVE.L    #$4C9B000F,(A0)+
      MOVE.B    -(A4),D1
      EXT.W     D1
      LSL.W     #3,D1
      MOVE.W    #1,D2
L0016:MOVE.L    0(A5,D1.W),D3
      BEQ.S     L0017
      MOVEA.L   D3,A6
      MOVE.L    (A6)+,(A0)+
      MOVE.L    (A6)+,(A0)+
      MOVE.L    (A6)+,(A0)+
      MOVE.L    (A6)+,(A0)+
      ADDQ.L    #4,D1
      DBF       D2,L0016
L0017:DBF       D0,L0015
      MOVE.W    #$4E75,(A0)+
      MOVE.W    #0,L0038
      JSR       L002A
      MOVE.W    #1,L0038
      JSR       L002A
      MOVE.W    #2,L0038
      JSR       L002A
      MOVE.W    #3,L0038
      JSR       L002A
      MOVE.W    #0,L003B
      JSR       L0029
      JSR       L0027
      MOVE.W    #3,L0038
      MOVE.B    $FFFF8260.W,L004C
      MOVE.B    #0,$FFFF8260.W
      JMP       L0024
L0018:MOVE.W    #$7FF,D0
L0019:MOVE.W    (A0)+,D4
      MULS      D1,D4
      DIVS      #$4000,D4
      ADD.W     D2,D4
      JSR       (A2)
      MOVE.W    D4,(A1)+
      MOVE.W    D4,4094(A1)
      DBF       D0,L0019
      RTS
L001A:MOVE.W    #$7FF,D0
      LEA       4096(A1),A2
L001B:MOVE.W    (A1)+,(A2)+
      DBF       D0,L001B
      RTS
L001C:MOVE.W    D4,D5
      ASL.W     #2,D4
      ADD.W     D5,D4
      ASL.W     #5,D4
      RTS
L001D:ADD.W     D4,D4
      RTS
L001E:ASL.W     #2,D4
      RTS
L001F:MOVEM.W   D5/D0-D1,-(A7)
      SUBQ.W    #2,D0
      SUBQ.W    #1,D1
L0020:MOVE.W    D0,-(A7)
      MOVE.W    D2,-(A7)
      MOVE.W    D2,(A0)+
L0021:ADD.W     D3,D2
      AND.W     D5,D2
      MOVE.W    D2,(A0)+
      DBF       D0,L0021
      MOVE.W    (A7)+,D2
      MOVE.W    (A7)+,D0
      ADD.W     D4,D2
      AND.W     D5,D2
      DBF       D1,L0020
      MOVEM.W   (A7)+,D5/D0-D1
      RTS
L0022:MOVE.L    A1,(A2)+
      MOVE.W    D2,D7
      ADD.W     D7,D7
      LEA       0(A0,D7.W),A3
      LEA       0(A3,D7.W),A4
      SUBQ.W    #1,D2
L0023:MOVE.W    #$3028,(A1)+
      MOVE.W    (A0)+,D3
      ADD.W     D3,D3
      MOVE.W    D3,(A1)+
      MOVE.L    #$49F10000,(A1)+
      MOVE.W    #$302C,(A1)+
      MOVE.W    (A3)+,D3
      ADD.W     D3,D3
      MOVE.W    D3,(A1)+
      MOVE.W    #$D06A,(A1)+
      MOVE.W    (A4)+,D3
      ADD.W     D3,D3
      MOVE.W    D3,(A1)+
      MOVE.W    #$36C0,(A1)+
      DBF       D2,L0023
      MOVE.W    #$4E75,(A1)+
      RTS
L0024:
      MOVEA.W   #$8240,A1
      LEA       L003A,A2
      MOVEM.L   (A1),D0-D7
      MOVEM.L   D0-D7,(A2)
      MOVE.W    #3,L0038			; *** MAIN ***
      MOVE.W    #2,L003B

	LEA			L002D,			A0
	lea			split_pal,		a1
	lea			ste_colors,		a2
	moveq		#15,			d0
	moveq		#15,			d3
gloky_init_0:
	move.w		(a0)+,			d1
	move.w		d1,				d2
	lsr.w		#8,				d2
	and.w		d3,				d2
	add.w		d2,				d2
	move.w		0(a2,d2.w),		(a1)+
	move.w		d1,				d2
	lsr.w		#4,				d2
	and.w		d3,				d2
	add.w		d2,				d2
	move.w		0(a2,d2.w),		(a1)+
	move.w		d1,				d2
	and.w		d3,				d2
	add.w		d2,				d2
	move.w		0(a2,d2.w),		(a1)+
	dbra		d0,gloky_init_0
	lea			gloky_fade,		a0
	moveq		#0,				d0
	move.w		d0,				(a0)+
	move.w		d0,				(a0)+
	move.w		d0,				(a0)

	move.w		#0,gloky_step
gloky_fadein:
	move.w		gloky_step,		d0
	lea			gloky_fade,		a0
	bsr			pal_blend
	bsr			gloky_render
	tst.w		d0
	bne			gloky_rts
	move.w		gloky_step,		d0			; step
	addq.w		#8,				d0
	move.w		d0,gloky_step
	cmpi.w		#256,			d0
	bne.s		gloky_fadein

	move.w		#1475,gloky_step
gloky_loop:
	bsr			pal_draw
	bsr			gloky_render
	tst.w		d0
	bne			gloky_rts
	move.w		gloky_step,		d0
	subq.w		#1,				d0
	move.w		d0,gloky_step
	tst.w		d0
	bne.s		gloky_loop

	move.w		#256,gloky_step
gloky_fadeout:
	move.w		gloky_step,		d0
	lea			gloky_fade,		a0
	bsr			pal_blend
	bsr			gloky_render
	tst.w		d0
	bne			gloky_rts
	move.w		gloky_step,		d0			; step
	subq.w		#8,				d0
	move.w		d0,gloky_step
	tst.w		d0
	bne.s		gloky_fadeout
	moveq		#1,				d0

gloky_rts:
	rts


gloky_render:
      JSR       L0029				; *** MAIN 2 ***
      JSR       L0027
      MOVE.W    L003B,D0
      ADDQ.L    #1,D0
      ANDI.W    #3,D0
      MOVE.W    D0,L003B
      MOVE.W    L0038,D0
      ADDQ.L    #1,D0
      ANDI.W    #3,D0
      MOVE.W    D0,L0038
      JSR       L0026
      JSR       L002A

      cmpi.b    #129,$FFFFFC02.W
      beq.s     gloky_quit
      CMPI.B    #57,$FFFFFC02.W			; *** END ***
      BEQ.S     gloky_end
      moveq		#0,d0
      RTS
gloky_end:
      bsr		demo_space
      moveq     #1,d0					; exit
      RTS
gloky_quit:
      moveq     #2,d0
      RTS

L0026:LEA       L0048,A3
      MOVE.W    L0038,D0
      LSL.W     #2,D0
      MOVEA.L   0(A3,D0.W),A3
      LEA       L003C,A0
      MOVEA.L   0(A0,D0.W),A0
      MOVEQ     #0,D4
      MOVEA.L   L0040,A5
      JSR       (A5)
      RTS
L0027:
;      MOVE.W    $468.W,D0
;L0028:
;      MOVE.W    $468.W,D1
;      CMP.W     D0,D1
;      BEQ.S     L0028
      bsr       sys_vsync
      RTS 
L0029:LEA       L003C,A0
      MOVE.W    L003B,D0
      LSL.W     #2,D0 
      MOVE.L    0(A0,D0.W),D0 
      LSR.W     #8,D0 
      MOVE.L    D0,$FFFF8200.W
      RTS 
L002A:LEA       L0035,A0
      LEA       L0037,A1
      MOVE.W    #$FFE,D0
      MOVEQ     #5,D1 
L002B:MOVE.W    (A1)+,D2
      MOVE.W    (A0),D3 
      ADD.W     D2,D3 
      AND.W     D0,D3 
      MOVE.W    D3,(A0)+
      DBF       D1,L002B
      LEA       L004A,A3
      LEA       L0035,A4
      LEA       L0044,A0
      LEA       L0043,A1
      LEA       L0042,A2
      ADDA.W    (A4)+,A0
      ADDA.W    (A4)+,A1
      ADDA.W    (A4)+,A2
      MOVEA.L   L004D,A5
      JSR       (A5)
      LEA       L0049,A3
      LEA       L0036,A4
      LEA       L0047,A0
      LEA       L0046,A1
      LEA       L0045,A2
      ADDA.W    (A4)+,A0
      ADDA.W    (A4)+,A1
      ADDA.W    (A4)+,A2
      MOVEA.L   L004E,A5
      JSR       (A5)
      LEA       L004A,A0
      LEA       L0049,A1
      LEA       L003E,A2
      MOVE.W    L0038,D0
      LSL.W     #2,D0 
      LEA       L0048,A4
      MOVEA.L   0(A4,D0.W),A3 
      LEA       1024(A3),A3 
      LEA       L003C,A4
      MOVEA.L   0(A4,D0.W),A4 
      MOVEA.L   L003F,A5
      JSR       (A5)
      RTS 
      MOVE.W    #$F,D0
L002C:MOVE.W    (A0)+,D1
      MOVE.W    (A1)+,D2
      MOVE.W    (A2)+,D3
      LSL.W     #8,D1 
      LSL.W     #4,D2 
      OR.W      D1,D3 
      OR.W      D2,D3 
      MOVE.W    D3,(A3)+
      DBF       D0,L002C
      RTS 
 DATA
L002D:DC.B      $00,$00,$04,$44,$04,$55,$04,$66
      DC.B      $04,$77,$05,$77,$06,$77,$07,$77
      DC.B      $07,$67,$07,$57,$07,$47,$07,$37 
      DC.B      $07,$27,$07,$17,$07,$07,$06,$06 
L002E:DC.B      $00,$00,$00,$01,$00,$02,$00,$03 
      DC.B      $00,$04,$00,$05,$00,$06,$00,$07 
      DC.B      $00,$07,$00,$06,$00,$05,$00,$04 
      DC.B      $00,$03,$00,$02,$00,$01,$00,$01 
L002F:DC.B      $00,$00,$00,$08,$00,$01,$00,$09 
      DC.B      $00,$02,$00,$0A,$00,$03,$00,$0B 
      DC.B      $00,$04,$00,$0C,$00,$05,$00,$0D 
      DC.B      $00,$06,$00,$0E,$00,$07,$00,$0F 
L0030:DC.B      $00,$0F,$00,$07,$00,$0E,$00,$06 
      DC.B      $00,$0D,$00,$05,$00,$0C,$00,$04 
      DC.B      $00,$0B,$00,$03,$00,$0A,$00,$02 
      DC.B      $00,$09,$00,$01,$00,$08,$00,$00 
L0031:DC.B      $00,$00,$00,$01,$00,$01,$00,$02 
      DC.B      $00,$02,$00,$03,$00,$03,$00,$04 
      DC.B      $00,$04,$00,$05,$00,$05,$00,$06 
      DC.B      $00,$06,$00,$07,$00,$07 
L0032:DC.B      $00,$00,$00,$01,$00,$02,$00,$02 
      DC.B      $00,$03,$00,$03,$00,$03,$00,$04 
      DC.B      $00,$04,$00,$04,$00,$04,$00,$04 
      DC.B      $00,$05,$00,$05,$00,$05,$00,$00 
      DC.B      $00,$04,$00,$04,$00,$04,$00,$04 
      DC.B      $00,$04,$00,$04,$00,$04,$00,$04 
      DC.B      $00,$04,$00,$04,$00,$04,$00,$04 
      DC.B      $00,$04,$00,$04 
      DC.L      L002E 
      DC.L      L002F 
      DC.L      L002F 
      DC.L      L0030 
      DC.L      L0031 
      DC.L      L002E 
      DC.L      L0032 
      DC.L      L002F 
      DC.L      L002F 
      DC.B      $00,$67,$00,$57,$00,$47,$00,$37 
      DC.B      $00,$27,$00,$17,$00,$07,$00,$06 
L0033:DC.B      $01,$01,$01,$02,$02,$03,$03,$04 
      DC.B      $04,$05,$05,$06,$06,$07,$07,$08 
      DC.B      $08,$09,$09,$0A,$0A,$0B,$0B,$0C 
      DC.B      $0C,$0D,$0D,$0E,$0E,$0F,$0F,$0F 
      DC.B      $0F,$0E,$0E,$0D,$0D,$0C,$0C,$0B 
      DC.B      $0B,$0A,$0A,$09,$09,$08,$08,$07 
      DC.B      $07,$06,$06,$05,$05,$04,$04,$03 
      DC.B      $03,$02,$02,$01,$01,$01,$01,$01 
      DC.B      $01,$02,$02,$03,$03,$04,$04,$05 
      DC.B      $05,$06,$06,$07,$07,$08,$08,$09 
      DC.B      $09,$0A,$0A,$0B,$0B,$0C,$0C,$0D 
      DC.B      $0D,$0E,$0E,$0F,$0F,$0F,$0F,$0E 
      DC.B      $0E,$0D,$0D,$0C,$0C,$0B,$0B,$0A 
      DC.B      $0A,$09,$09,$08,$08,$07,$07,$06 
      DC.B      $06,$05,$05,$04,$04,$03,$03,$02 
      DC.B      $02,$01,$01,$01,$01,$01,$01,$02 
      DC.B      $02,$03,$03,$04,$04,$05,$05,$06 
      DC.B      $06,$07,$07,$08,$08,$09,$09,$0A 
      DC.B      $0A,$0B,$0B,$0C,$0C,$0D,$0D,$0E 
      DC.B      $0E,$0F,$0F,$0F,$0F,$0E,$0E,$0D 
      DC.B      $0D,$0C,$0C,$0B,$0B,$0A,$0A,$09 
      DC.B      $09,$08,$08,$07,$07,$06,$06,$05 
      DC.B      $05,$04,$04,$03,$03,$02,$02,$01 
      DC.B      $01,$01,$01,$01,$01,$02,$02,$03 
      DC.B      $03,$04,$04,$05,$05,$06,$06,$07 
      DC.B      $07,$08,$08,$09,$09,$0A,$0A,$0B 
      DC.B      $0B,$0C,$0C,$0D,$0D,$0E,$0E,$0F 
      DC.B      $0F,$0F,$0F,$0E,$0E,$0D,$0D,$0C 
      DC.B      $0C,$0B,$0B,$0A,$0A,$09,$09,$08 
      DC.B      $08,$07,$07,$06,$06,$05,$05,$04 
      DC.B      $04,$03,$03,$02,$02,$01,$01,$01 
      DC.B      $01,$01,$01,$02,$02,$03,$03,$04 
      DC.B      $04,$05,$05,$06,$06,$07,$07,$08 
      DC.B      $08,$09,$09,$0A,$0A,$0B,$0B,$0C 
      DC.B      $0C,$0D,$0D,$0E,$0E,$0F,$0F,$0F 
      DC.B      $0F,$0E,$0E,$0D,$0D,$0C,$0C,$0B 
      DC.B      $0B,$0A,$0A,$09,$09,$08,$08,$07 
      DC.B      $07,$06,$06,$05,$05,$04,$04,$03 
      DC.B      $03,$02,$02,$01,$01,$01,$01,$01 
      DC.B      $01,$02,$02,$03,$03,$04,$04,$05 
      DC.B      $05,$06,$06,$07,$07,$08,$08,$09 
      DC.B      $09,$0A,$0A,$0B,$0B,$0C,$0C,$0D 
      DC.B      $0D,$0E,$0E,$0F,$0F,$0F,$0F,$0E 
      DC.B      $0E,$0D,$0D,$0C,$0C,$0B,$0B,$0A 
      DC.B      $0A,$09,$09,$08,$08,$07,$07,$06 
      DC.B      $06,$05,$05,$04,$04,$03,$03,$02 
      DC.B      $02,$01,$01,$01,$01,$01,$01,$02 
      DC.B      $02,$03,$03,$04,$04,$05,$05,$06 
      DC.B      $06,$07,$07,$08,$08,$09,$09,$0A 
      DC.B      $0A,$0B,$0B,$0C,$0C,$0D,$0D,$0E 
      DC.B      $0E,$0F,$0F,$0F,$0F,$0E,$0E,$0D 
      DC.B      $0D,$0C,$0C,$0B,$0B,$0A,$0A,$09 
      DC.B      $09,$08,$08,$07,$07,$06,$06,$05 
      DC.B      $05,$04,$04,$03,$03,$02,$02,$01 
      DC.B      $01,$01,$01,$01,$01,$02,$02,$03 
      DC.B      $03,$04,$04,$05,$05,$06,$06,$07 
      DC.B      $07,$08,$08,$09,$09,$0A,$0A,$0B 
      DC.B      $0B,$0C,$0C,$0D,$0D,$0E,$0E,$0F 
      DC.B      $0F,$0F,$0F,$0E,$0E,$0D,$0D,$0C 
      DC.B      $0C,$0B,$0B,$0A,$0A,$09,$09,$08 
      DC.B      $08,$07,$07,$06,$06,$05,$05,$04 
      DC.B      $04,$03,$03,$02,$02,$01,$01,$01 
      DC.B      $01,$01,$01,$02,$02,$03,$03,$04 
      DC.B      $04,$05,$05,$06,$06,$07,$07,$08 
      DC.B      $08,$09,$09,$0A,$0A,$0B,$0B,$0C 
      DC.B      $0C,$0D,$0D,$0E,$0E,$0F,$0F,$0F 
      DC.B      $0F,$0E,$0E,$0D,$0D,$0C,$0C,$0B 
      DC.B      $0B,$0A,$0A,$09,$09,$08,$08,$07 
      DC.B      $07,$06,$06,$05,$05,$04,$04,$03 
      DC.B      $03,$02,$02,$01,$01,$01,$01,$01 
      DC.B      $01,$02,$02,$03,$03,$04,$04,$05 
      DC.B      $05,$06,$06,$07,$07,$08,$08,$09 
      DC.B      $09,$0A,$0A,$0B,$0B,$0C,$0C,$0D 
      DC.B      $0D,$0E,$0E,$0F,$0F,$0F,$0F,$0E 
      DC.B      $0E,$0D,$0D,$0C,$0C,$0B,$0B,$0A 
      DC.B      $0A,$09,$09,$08,$08,$07,$07,$06 
      DC.B      $06,$05,$05,$04,$04,$03,$03,$02 
      DC.B      $02,$01,$01,$01,$01,$01,$01,$02 
      DC.B      $02,$03,$03,$04,$04,$05,$05,$06 
      DC.B      $06,$07,$07,$08,$08,$09,$09,$0A 
      DC.B      $0A,$0B,$0B,$0C,$0C,$0D,$0D,$0E 
      DC.B      $0E,$0F,$0F,$0F,$0F,$0E,$0E,$0D 
      DC.B      $0D,$0C,$0C,$0B,$0B,$0A,$0A,$09 
      DC.B      $09,$08,$08,$07,$07,$06,$06,$05 
      DC.B      $05,$04,$04,$03,$03,$02,$02,$01 
      DC.B      $01,$01,$01,$01,$01,$02,$02,$03 
      DC.B      $03,$04,$04,$05,$05,$06,$06,$07 
      DC.B      $07,$08,$08,$09,$09,$0A,$0A,$0B 
      DC.B      $0B,$0C,$0C,$0D,$0D,$0E,$0E,$0F 
      DC.B      $0F,$0F,$0F,$0E,$0E,$0D,$0D,$0C 
      DC.B      $0C,$0B,$0B,$0A,$0A,$09,$09,$08 
      DC.B      $08,$07,$07,$06,$06,$05,$05,$04 
      DC.B      $04,$03,$03,$02,$02,$01,$01,$01 
      DC.B      $01,$01,$01,$02,$02,$03,$03,$04 
      DC.B      $04,$05,$05,$06,$06,$07,$07,$08 
      DC.B      $08,$09,$09,$0A,$0A,$0B,$0B,$0C 
      DC.B      $0C,$0D,$0D,$0E,$0E,$0F,$0F,$0F 
      DC.B      $0F,$0E,$0E,$0D,$0D,$0C,$0C,$0B 
      DC.B      $0B,$0A,$0A,$09,$09,$08,$08,$07 
      DC.B      $07,$06,$06,$05,$05,$04,$04,$03 
      DC.B      $03,$02,$02,$01,$01,$01,$01,$01 
      DC.B      $01,$02,$02,$03,$03,$04,$04,$05 
      DC.B      $05,$06,$06,$07,$07,$08,$08,$09 
      DC.B      $09,$0A,$0A,$0B,$0B,$0C,$0C,$0D 
      DC.B      $0D,$0E,$0E,$0F,$0F,$0F,$0F,$0E 
      DC.B      $0E,$0D,$0D,$0C,$0C,$0B,$0B,$0A 
      DC.B      $0A,$09,$09,$08,$08,$07,$07,$06 
      DC.B      $06,$05,$05,$04,$04,$03,$03,$02 
      DC.B      $02,$01,$01,$01,$01,$01,$01,$02 
      DC.B      $02,$03,$03,$04,$04,$05,$05,$06 
      DC.B      $06,$07,$07,$08,$08,$09,$09,$0A 
      DC.B      $0A,$0B,$0B,$0C,$0C,$0D,$0D,$0E 
      DC.B      $0E,$0F,$0F,$0F,$0F,$0E,$0E,$0D 
      DC.B      $0D,$0C,$0C,$0B,$0B,$0A,$0A,$09 
      DC.B      $09,$08,$08,$07,$07,$06,$06,$05 
      DC.B      $05,$04,$04,$03,$03,$02,$02,$01 
      DC.B      $01,$01,$01,$01,$01,$02,$02,$03 
      DC.B      $03,$04,$04,$05,$05,$06,$06,$07 
      DC.B      $07,$08,$08,$09,$09,$0A,$0A,$0B 
      DC.B      $0B,$0C,$0C,$0D,$0D,$0E,$0E,$0F 
      DC.B      $0F,$0F,$0F,$0E,$0E,$0D,$0D,$0C 
      DC.B      $0C,$0B,$0B,$0A,$0A,$09,$09,$08 
      DC.B      $08,$07,$07,$06,$06,$05,$05,$04 
      DC.B      $04,$03,$03,$02,$02,$01,$01,$01 
      DC.B      $01,$01,$01,$02,$02,$03,$03,$04 
      DC.B      $04,$05,$05,$06,$06,$07,$07,$08 
      DC.B      $08,$09,$09,$0A,$0A,$0B,$0B,$0C 
      DC.B      $0C,$0D,$0D,$0E,$0E,$0F,$0F,$0F 
      DC.B      $0F,$0E,$0E,$0D,$0D,$0C,$0C,$0B 
      DC.B      $0B,$0A,$0A,$09,$09,$08,$08,$07 
      DC.B      $07,$06,$06,$05,$05,$04,$04,$03 
      DC.B      $03,$02,$02,$01,$01,$01,$01,$01 
      DC.B      $01,$02,$02,$03,$03,$04,$04,$05 
      DC.B      $05,$06,$06,$07,$07,$08,$08,$09 
      DC.B      $09,$0A,$0A,$0B,$0B,$0C,$0C,$0D 
      DC.B      $0D,$0E,$0E,$0F,$0F,$0F,$0F,$0E 
      DC.B      $0E,$0D,$0D,$0C,$0C,$0B,$0B,$0A 
      DC.B      $0A,$09,$09,$08,$08,$07,$07,$06 
      DC.B      $06,$05,$05,$04,$04,$03,$03,$02 
      DC.B      $02,$01,$01,$01,$01,$01,$01,$02 
      DC.B      $02,$03,$03,$04,$04,$05,$05,$06 
      DC.B      $06,$07,$07,$08,$08,$09,$09,$0A 
      DC.B      $0A,$0B,$0B,$0C,$0C,$0D,$0D,$0E 
      DC.B      $0E,$0F,$0F,$0F,$0F,$0E,$0E,$0D 
      DC.B      $0D,$0C,$0C,$0B,$0B,$0A,$0A,$09 
      DC.B      $09,$08,$08,$07,$07,$06,$06,$05 
      DC.B      $05,$04,$04,$03,$03,$02,$02,$01 
      DC.B      $01,$01,$01,$01,$01,$02,$02,$03 
      DC.B      $03,$04,$04,$05,$05,$06,$06,$07 
      DC.B      $07,$08,$08,$09,$09,$0A,$0A,$0B 
      DC.B      $0B,$0C,$0C,$0D,$0D,$0E,$0E,$0F 
      DC.B      $0F,$0F,$0F,$0E,$0E,$0D,$0D,$0C 
      DC.B      $0C,$0B,$0B,$0A,$0A,$09,$09,$08 
      DC.B      $08,$07,$07,$06,$06,$05,$05,$04 
      DC.B      $04,$03,$03,$02,$02,$01,$01,$01 
      DC.B      $01,$01,$01,$02,$02,$03,$03,$04 
      DC.B      $04,$05,$05,$06,$06,$07,$07,$08 
      DC.B      $08,$09,$09,$0A,$0A,$0B,$0B,$0C 
      DC.B      $0C,$0D,$0D,$0E,$0E,$0F,$0F,$0F 
      DC.B      $0F,$0E,$0E,$0D,$0D,$0C,$0C,$0B 
      DC.B      $0B,$0A,$0A,$09,$09,$08,$08,$07 
      DC.B      $07,$06,$06,$05,$05,$04,$04,$03 
      DC.B      $03,$02,$02,$01,$01,$01,$01,$01 
      DC.B      $01,$02,$02,$03,$03,$04,$04,$05 
      DC.B      $05,$06,$06,$07,$07,$08,$08,$09 
      DC.B      $09,$0A,$0A,$0B,$0B,$0C,$0C,$0D 
      DC.B      $0D,$0E,$0E,$0F,$0F,$0F,$0F,$0E 
      DC.B      $0E,$0D,$0D,$0C,$0C,$0B,$0B,$0A 
      DC.B      $0A,$09,$09,$08,$08,$07,$07,$06 
      DC.B      $06,$05,$05,$04,$04,$03,$03,$02 
      DC.B      $02,$01,$01,$01,$01,$01,$01,$02 
      DC.B      $02,$03,$03,$04,$04,$05,$05,$06 
      DC.B      $06,$07,$07,$08,$08,$09,$09,$0A 
      DC.B      $0A,$0B,$0B,$0C,$0C,$0D,$0D,$0E 
      DC.B      $0E,$0F,$0F,$0F,$0F,$0E,$0E,$0D 
      DC.B      $0D,$0C,$0C,$0B,$0B,$0A,$0A,$09 
      DC.B      $09,$08,$08,$07,$07,$06,$06,$05 
      DC.B      $05,$04,$04,$03,$03,$02,$02,$01 
      DC.B      $01,$01,$01,$01,$01,$02,$02,$03 
      DC.B      $03,$04,$04,$05,$05,$06,$06,$07 
      DC.B      $07,$08,$08,$09,$09,$0A,$0A,$0B 
      DC.B      $0B,$0C,$0C,$0D,$0D,$0E,$0E,$0F 
      DC.B      $0F,$0F,$0F,$0E,$0E,$0D,$0D,$0C 
      DC.B      $0C,$0B,$0B,$0A,$0A,$09,$09,$08 
      DC.B      $08,$07,$07,$06,$06,$05,$05,$04 
      DC.B      $04,$03,$03,$02,$02,$01,$01,$01 
      DC.B      $01,$01,$01,$02,$02,$03,$03,$04 
      DC.B      $04,$05,$05,$06,$06,$07,$07,$08 
      DC.B      $08,$09,$09,$0A,$0A,$0B,$0B,$0C 
      DC.B      $0C,$0D,$0D,$0E,$0E,$0F,$0F,$0F 
      DC.B      $0F,$0E,$0E,$0D,$0D,$0C,$0C,$0B 
      DC.B      $0B,$0A,$0A,$09,$09,$08,$08,$07 
      DC.B      $07,$06,$06,$05,$05,$04,$04,$03 
      DC.B      $03,$02,$02,$01,$01,$01,$01,$01 
      DC.B      $01,$02,$02,$03,$03,$04,$04,$05 
      DC.B      $05,$06,$06,$07,$07,$08,$08,$09 
      DC.B      $09,$0A,$0A,$0B,$0B,$0C,$0C,$0D 
      DC.B      $0D,$0E,$0E,$0F,$0F,$0F,$0F,$0E 
      DC.B      $0E,$0D,$0D,$0C,$0C,$0B,$0B,$0A 
      DC.B      $0A,$09,$09,$08,$08,$07,$07,$06 
      DC.B      $06,$05,$05,$04,$04,$03,$03,$02 
      DC.B      $02,$01,$01,$01,$01,$01,$01,$02 
      DC.B      $02,$03,$03,$04,$04,$05,$05,$06 
      DC.B      $06,$07,$07,$08,$08,$09,$09,$0A 
      DC.B      $0A,$0B,$0B,$0C,$0C,$0D,$0D,$0E 
      DC.B      $0E,$0F,$0F,$0F,$0F,$0E,$0E,$0D 
      DC.B      $0D,$0C,$0C,$0B,$0B,$0A,$0A,$09 
      DC.B      $09,$08,$08,$07,$07,$06,$06,$05 
      DC.B      $05,$04,$04,$03,$03,$02,$02,$01 
      DC.B      $01,$01,$01,$01,$01,$02,$02,$03 
      DC.B      $03,$04,$04,$05,$05,$06,$06,$07 
      DC.B      $07,$08,$08,$09,$09,$0A,$0A,$0B 
      DC.B      $0B,$0C,$0C,$0D,$0D,$0E,$0E,$0F 
      DC.B      $0F,$0F,$0F,$0E,$0E,$0D,$0D,$0C 
      DC.B      $0C,$0B,$0B,$0A,$0A,$09,$09,$08 
      DC.B      $08,$07,$07,$06,$06,$05,$05,$04 
      DC.B      $04,$03,$03,$02,$02,$01,$01,$01 
      DC.B      $01,$01,$01,$02,$02,$03,$03,$04 
      DC.B      $04,$05,$05,$06,$06,$07,$07,$08 
      DC.B      $08,$09,$09,$0A,$0A,$0B,$0B,$0C 
      DC.B      $0C,$0D,$0D,$0E,$0E,$0F,$0F,$0F 
      DC.B      $0F,$0E,$0E,$0D,$0D,$0C,$0C,$0B 
      DC.B      $0B,$0A,$0A,$09,$09,$08,$08,$07 
      DC.B      $07,$06,$06,$05,$05,$04,$04,$03 
      DC.B      $03,$02,$02,$01,$01,$01,$01,$01 
      DC.B      $01,$02,$02,$03,$03,$04,$04,$05 
      DC.B      $05,$06,$06,$07,$07,$08,$08,$09 
      DC.B      $09,$0A,$0A,$0B,$0B,$0C,$0C,$0D 
      DC.B      $0D,$0E,$0E,$0F,$0F,$0F,$0F,$0E 
      DC.B      $0E,$0D,$0D,$0C,$0C,$0B,$0B,$0A 
      DC.B      $0A,$09,$09,$08,$08,$07,$07,$06 
      DC.B      $06,$05,$05,$04,$04,$03,$03,$02 
      DC.B      $02,$01,$01,$01,$01,$01,$01,$02 
      DC.B      $02,$03,$03,$04,$04,$05,$05,$06 
      DC.B      $06,$07,$07,$08,$08,$09,$09,$0A 
      DC.B      $0A,$0B,$0B,$0C,$0C,$0D,$0D,$0E 
      DC.B      $0E,$0F,$0F,$0F,$0F,$0E,$0E,$0D 
      DC.B      $0D,$0C,$0C,$0B,$0B,$0A,$0A,$09 
      DC.B      $09,$08,$08,$07,$07,$06,$06,$05 
      DC.B      $05,$04,$04,$03,$03,$02,$02,$01 
      DC.B      $01,$01,$01,$01,$01,$02,$02,$03 
      DC.B      $03,$04,$04,$05,$05,$06,$06,$07 
      DC.B      $07,$08,$08,$09,$09,$0A,$0A,$0B 
      DC.B      $0B,$0C,$0C,$0D,$0D,$0E,$0E,$0F 
      DC.B      $0F,$0F,$0F,$0E,$0E,$0D,$0D,$0C 
      DC.B      $0C,$0B,$0B,$0A,$0A,$09,$09,$08 
      DC.B      $08,$07,$07,$06,$06,$05,$05,$04 
      DC.B      $04,$03,$03,$02,$02,$01,$01,$01 
      DC.B      $01,$01,$01,$02,$02,$03,$03,$04 
      DC.B      $04,$05,$05,$06,$06,$07,$07,$08 
      DC.B      $08,$09,$09,$0A,$0A,$0B,$0B,$0C 
      DC.B      $0C,$0D,$0D,$0E,$0E,$0F,$0F,$0F 
      DC.B      $0F,$0E,$0E,$0D,$0D,$0C,$0C,$0B 
      DC.B      $0B,$0A,$0A,$09,$09,$08,$08,$07 
      DC.B      $07,$06,$06,$05,$05,$04,$04,$03 
      DC.B      $03,$02,$02,$01,$01,$01,$01,$01 
      DC.B      $01,$02,$02,$03,$03,$04,$04,$05 
      DC.B      $05,$06,$06,$07,$07,$08,$08,$09 
      DC.B      $09,$0A,$0A,$0B,$0B,$0C,$0C,$0D 
      DC.B      $0D,$0E,$0E,$0F,$0F,$0F,$0F,$0E 
      DC.B      $0E,$0D,$0D,$0C,$0C,$0B,$0B,$0A 
      DC.B      $0A,$09,$09,$08,$08,$07,$07,$06 
      DC.B      $06,$05,$05,$04,$04,$03,$03,$02 
      DC.B      $02,$01,$01,$01,$01,$01,$01,$02 
      DC.B      $02,$03,$03,$04,$04,$05,$05,$06 
      DC.B      $06,$07,$07,$08,$08,$09,$09,$0A 
      DC.B      $0A,$0B,$0B,$0C,$0C,$0D,$0D,$0E 
      DC.B      $0E,$0F,$0F,$0F,$0F,$0E,$0E,$0D 
      DC.B      $0D,$0C,$0C,$0B,$0B,$0A,$0A,$09 
      DC.B      $09,$08,$08,$07,$07,$06,$06,$05 
      DC.B      $05,$04,$04,$03,$03,$02,$02,$01 
      DC.B      $01,$01,$01,$01,$01,$02,$02,$03 
      DC.B      $03,$04,$04,$05,$05,$06,$06,$07 
      DC.B      $07,$08,$08,$09,$09,$0A,$0A,$0B 
      DC.B      $0B,$0C,$0C,$0D,$0D,$0E,$0E,$0F 
      DC.B      $0F,$0F,$0F,$0E,$0E,$0D,$0D,$0C 
      DC.B      $0C,$0B,$0B,$0A,$0A,$09,$09,$08 
      DC.B      $08,$07,$07,$06,$06,$05,$05,$04 
      DC.B      $04,$03,$03,$02,$02,$01,$01,$01 
      DC.B      $01,$01,$01,$02,$02,$03,$03,$04 
      DC.B      $04,$05,$05,$06,$06,$07,$07,$08 
      DC.B      $08,$09,$09,$0A,$0A,$0B,$0B,$0C 
      DC.B      $0C,$0D,$0D,$0E,$0E,$0F,$0F,$0F 
      DC.B      $0F,$0E,$0E,$0D,$0D,$0C,$0C,$0B 
      DC.B      $0B,$0A,$0A,$09,$09,$08,$08,$07 
      DC.B      $07,$06,$06,$05,$05,$04,$04,$03 
      DC.B      $03,$02,$02,$01,$01,$01,$01,$01 
      DC.B      $01,$02,$02,$03,$03,$04,$04,$05 
      DC.B      $05,$06,$06,$07,$07,$08,$08,$09 
      DC.B      $09,$0A,$0A,$0B,$0B,$0C,$0C,$0D 
      DC.B      $0D,$0E,$0E,$0F,$0F,$0F,$0F,$0E 
      DC.B      $0E,$0D,$0D,$0C,$0C,$0B,$0B,$0A 
      DC.B      $0A,$09,$09,$08,$08,$07,$07,$06 
      DC.B      $06,$05,$05,$04,$04,$03,$03,$02 
      DC.B      $02,$01,$01,$01,$01,$01,$01,$02 
      DC.B      $02,$03,$03,$04,$04,$05,$05,$06 
      DC.B      $06,$07,$07,$08,$08,$09,$09,$0A 
      DC.B      $0A,$0B,$0B,$0C,$0C,$0D,$0D,$0E 
      DC.B      $0E,$0F,$0F,$0F,$0F,$0E,$0E,$0D 
      DC.B      $0D,$0C,$0C,$0B,$0B,$0A,$0A,$09 
      DC.B      $09,$08,$08,$07,$07,$06,$06,$05 
      DC.B      $05,$04,$04,$03,$03,$02,$02,$01 
      DC.B      $01,$01,$01,$01,$01,$02,$02,$03 
      DC.B      $03,$04,$04,$05,$05,$06,$06,$07 
      DC.B      $07,$08,$08,$09,$09,$0A,$0A,$0B 
      DC.B      $0B,$0C,$0C,$0D,$0D,$0E,$0E,$0F 
      DC.B      $0F,$0F,$0F,$0E,$0E,$0D,$0D,$0C 
      DC.B      $0C,$0B,$0B,$0A,$0A,$09,$09,$08 
      DC.B      $08,$07,$07,$06,$06,$05,$05,$04 
      DC.B      $04,$03,$03,$02,$02,$01,$01,$01 
      DC.B      $01,$01,$01,$02,$02,$03,$03,$04 
      DC.B      $04,$05,$05,$06,$06,$07,$07,$08 
      DC.B      $08,$09,$09,$0A,$0A,$0B,$0B,$0C 
      DC.B      $0C,$0D,$0D,$0E,$0E,$0F,$0F,$0F 
      DC.B      $0F,$0E,$0E,$0D,$0D,$0C,$0C,$0B 
      DC.B      $0B,$0A,$0A,$09,$09,$08,$08,$07 
      DC.B      $07,$06,$06,$05,$05,$04,$04,$03 
      DC.B      $03,$02,$02,$01,$01,$01,$01,$01 
      DC.B      $01,$02,$02,$03,$03,$04,$04,$05 
      DC.B      $05,$06,$06,$07,$07,$08,$08,$09 
      DC.B      $09,$0A,$0A,$0B,$0B,$0C,$0C,$0D 
      DC.B      $0D,$0E,$0E,$0F,$0F,$0F,$0F,$0E 
      DC.B      $0E,$0D,$0D,$0C,$0C,$0B,$0B,$0A 
      DC.B      $0A,$09,$09,$08,$08,$07,$07,$06 
      DC.B      $06,$05,$05,$04,$04,$03,$03,$02 
      DC.B      $02,$01,$01,$01,$01,$01,$01,$02 
      DC.B      $02,$03,$03,$04,$04,$05,$05,$06 
      DC.B      $06,$07,$07,$08,$08,$09,$09,$0A 
      DC.B      $0A,$0B,$0B,$0C,$0C,$0D,$0D,$0E 
      DC.B      $0E,$0F,$0F,$0F,$0F,$0E,$0E,$0D 
      DC.B      $0D,$0C,$0C,$0B,$0B,$0A,$0A,$09 
      DC.B      $09,$08,$08,$07,$07,$06,$06,$05 
      DC.B      $05,$04,$04,$03,$03,$02,$02,$01 
      DC.B      $01,$01,$01,$01,$01,$02,$02,$03 
      DC.B      $03,$04,$04,$05,$05,$06,$06,$07 
      DC.B      $07,$08,$08,$09,$09,$0A,$0A,$0B 
      DC.B      $0B,$0C,$0C,$0D,$0D,$0E,$0E,$0F 
      DC.B      $0F,$0F,$0F,$0E,$0E,$0D,$0D,$0C 
      DC.B      $0C,$0B,$0B,$0A,$0A,$09,$09,$08 
      DC.B      $08,$07,$07,$06,$06,$05,$05,$04 
      DC.B      $04,$03,$03,$02,$02,$01,$01,$01 
      DC.B      $01,$01,$01,$02,$02,$03,$03,$04 
      DC.B      $04,$05,$05,$06,$06,$07,$07,$08 
      DC.B      $08,$09,$09,$0A,$0A,$0B,$0B,$0C 
      DC.B      $0C,$0D,$0D,$0E,$0E,$0F,$0F,$0F 
      DC.B      $0F,$0E,$0E,$0D,$0D,$0C,$0C,$0B 
      DC.B      $0B,$0A,$0A,$09,$09,$08,$08,$07 
      DC.B      $07,$06,$06,$05,$05,$04,$04,$03 
      DC.B      $03,$02,$02,$01,$01,$01,$01,$01 
      DC.B      $01,$02,$02,$03,$03,$04,$04,$05 
      DC.B      $05,$06,$06,$07,$07,$08,$08,$09 
      DC.B      $09,$0A,$0A,$0B,$0B,$0C,$0C,$0D 
      DC.B      $0D,$0E,$0E,$0F,$0F,$0F,$0F,$0E 
      DC.B      $0E,$0D,$0D,$0C,$0C,$0B,$0B,$0A 
      DC.B      $0A,$09,$09,$08,$08,$07,$07,$06 
      DC.B      $06,$05,$05,$04,$04,$03,$03,$02 
      DC.B      $02,$01,$01,$01,$01,$01,$01,$02 
      DC.B      $02,$03,$03,$04,$04,$05,$05,$06 
      DC.B      $06,$07,$07,$08,$08,$09,$09,$0A 
      DC.B      $0A,$0B,$0B,$0C,$0C,$0D,$0D,$0E 
      DC.B      $0E,$0F,$0F,$0F,$0F,$0E,$0E,$0D 
      DC.B      $0D,$0C,$0C,$0B,$0B,$0A,$0A,$09 
      DC.B      $09,$08,$08,$07,$07,$06,$06,$05 
      DC.B      $05,$04,$04,$03,$03,$02,$02,$01 
      DC.B      $01,$01,$01,$01,$01,$02,$02,$03 
      DC.B      $03,$04,$04,$05,$05,$06,$06,$07 
      DC.B      $07,$08,$08,$09,$09,$0A,$0A,$0B 
      DC.B      $0B,$0C,$0C,$0D,$0D,$0E,$0E,$0F 
      DC.B      $0F,$0F,$0F,$0E,$0E,$0D,$0D,$0C 
      DC.B      $0C,$0B,$0B,$0A,$0A,$09,$09,$08 
      DC.B      $08,$07,$07,$06,$06,$05,$05,$04 
      DC.B      $04,$03,$03,$02,$02,$01,$01,$01 
      DC.B      $01,$01,$01,$02,$02,$03,$03,$04 
      DC.B      $04,$05,$05,$06,$06,$07,$07,$08 
      DC.B      $08,$09,$09,$0A,$0A,$0B,$0B,$0C 
      DC.B      $0C,$0D,$0D,$0E,$0E,$0F,$0F,$0F 
      DC.B      $0F,$0E,$0E,$0D,$0D,$0C,$0C,$0B 
      DC.B      $0B,$0A,$0A,$09,$09,$08,$08,$07 
      DC.B      $07,$06,$06,$05,$05,$04,$04,$03 
      DC.B      $03,$02,$02,$01,$01,$01,$01,$01 
      DC.B      $01,$02,$02,$03,$03,$04,$04,$05 
      DC.B      $05,$06,$06,$07,$07,$08,$08,$09 
      DC.B      $09,$0A,$0A,$0B,$0B,$0C,$0C,$0D 
      DC.B      $0D,$0E,$0E,$0F,$0F,$0F,$0F,$0E 
      DC.B      $0E,$0D,$0D,$0C,$0C,$0B,$0B,$0A 
      DC.B      $0A,$09,$09,$08,$08,$07,$07,$06 
      DC.B      $06,$05,$05,$04,$04,$03,$03,$02 
      DC.B      $02,$01,$01,$01,$01,$01,$01,$02 
      DC.B      $02,$03,$03,$04,$04,$05,$05,$06 
      DC.B      $06,$07,$07,$08,$08,$09,$09,$0A 
      DC.B      $0A,$0B,$0B,$0C,$0C,$0D,$0D,$0E 
      DC.B      $0E,$0F,$0F,$0F,$0F,$0E,$0E,$0D 
      DC.B      $0D,$0C,$0C,$0B,$0B,$0A,$0A,$09 
      DC.B      $09,$08,$08,$07,$07,$06,$06,$05 
      DC.B      $05,$04,$04,$03,$03,$02,$02,$01 
      DC.B      $01,$01,$01,$01,$01,$02,$02,$03 
      DC.B      $03,$04,$04,$05,$05,$06,$06,$07 
      DC.B      $07,$08,$08,$09,$09,$0A,$0A,$0B 
      DC.B      $0B,$0C,$0C,$0D,$0D,$0E,$0E,$0F 
      DC.B      $0F,$0F,$0F,$0E,$0E,$0D,$0D,$0C 
      DC.B      $0C,$0B,$0B,$0A,$0A,$09,$09,$08 
      DC.B      $08,$07,$07,$06,$06,$05,$05,$04 
      DC.B      $04,$03,$03,$02,$02,$01,$01,$01 
      DC.B      $01,$01,$01,$02,$02,$03,$03,$04 
      DC.B      $04,$05,$05,$06,$06,$07,$07,$08 
      DC.B      $08,$09,$09,$0A,$0A,$0B,$0B,$0C 
      DC.B      $0C,$0D,$0D,$0E,$0E,$0F,$0F,$0F 
      DC.B      $0F,$0E,$0E,$0D,$0D,$0C,$0C,$0B 
      DC.B      $0B,$0A,$0A,$09,$09,$08,$08,$07 
      DC.B      $07,$06,$06,$05,$05,$04,$04,$03 
      DC.B      $03,$02,$02,$01,$01,$01,$01,$01 
      DC.B      $01,$02,$02,$03,$03,$04,$04,$05 
      DC.B      $05,$06,$06,$07,$07,$08,$08,$09 
      DC.B      $09,$0A,$0A,$0B,$0B,$0C,$0C,$0D 
      DC.B      $0D,$0E,$0E,$0F,$0F,$0F,$0F,$0E 
      DC.B      $0E,$0D,$0D,$0C,$0C,$0B,$0B,$0A 
      DC.B      $0A,$09,$09,$08,$08,$07,$07,$06 
      DC.B      $06,$05,$05,$04,$04,$03,$03,$02 
      DC.B      $02,$01,$01,$01,$01,$01,$01,$02 
      DC.B      $02,$03,$03,$04,$04,$05,$05,$06 
      DC.B      $06,$07,$07,$08,$08,$09,$09,$0A 
      DC.B      $0A,$0B,$0B,$0C,$0C,$0D,$0D,$0E 
      DC.B      $0E,$0F,$0F,$0F,$0F,$0E,$0E,$0D 
      DC.B      $0D,$0C,$0C,$0B,$0B,$0A,$0A,$09 
      DC.B      $09,$08,$08,$07,$07,$06,$06,$05 
      DC.B      $05,$04,$04,$03,$03,$02,$02,$01 
      DC.B      $01,$01,$01,$01,$01,$02,$02,$03 
      DC.B      $03,$04,$04,$05,$05,$06,$06,$07 
      DC.B      $07,$08,$08,$09,$09,$0A,$0A,$0B 
      DC.B      $0B,$0C,$0C,$0D,$0D,$0E,$0E,$0F 
      DC.B      $0F,$0F,$0F,$0E,$0E,$0D,$0D,$0C 
      DC.B      $0C,$0B,$0B,$0A,$0A,$09,$09,$08 
      DC.B      $08,$07,$07,$06,$06,$05,$05,$04 
      DC.B      $04,$03,$03,$02,$02,$01,$01,$01 
      DC.B      $01,$01,$01,$02,$02,$03,$03,$04 
      DC.B      $04,$05,$05,$06,$06,$07,$07,$08 
      DC.B      $08,$09,$09,$0A,$0A,$0B,$0B,$0C 
      DC.B      $0C,$0D,$0D,$0E,$0E,$0F,$0F,$0F 
      DC.B      $0F,$0E,$0E,$0D,$0D,$0C,$0C,$0B 
      DC.B      $0B,$0A,$0A,$09,$09,$08,$08,$07 
      DC.B      $07,$06,$06,$05,$05,$04,$04,$03 
      DC.B      $03,$02,$02,$01,$01,$01,$01,$01 
      DC.B      $01,$02,$02,$03,$03,$04,$04,$05 
      DC.B      $05,$06,$06,$07,$07,$08,$08,$09 
      DC.B      $09,$0A,$0A,$0B,$0B,$0C,$0C,$0D 
      DC.B      $0D,$0E,$0E,$0F,$0F,$0F,$0F,$0E 
      DC.B      $0E,$0D,$0D,$0C,$0C,$0B,$0B,$0A 
      DC.B      $0A,$09,$09,$08,$08,$07,$07,$06 
      DC.B      $06,$05,$05,$04,$04,$03,$03,$02 
      DC.B      $02,$01,$01,$01,$01,$01,$01,$02 
      DC.B      $02,$03,$03,$04,$04,$05,$05,$06 
      DC.B      $06,$07,$07,$08,$08,$09,$09,$0A 
      DC.B      $0A,$0B,$0B,$0C,$0C,$0D,$0D,$0E 
      DC.B      $0E,$0F,$0F,$0F,$0F,$0E,$0E,$0D 
      DC.B      $0D,$0C,$0C,$0B,$0B,$0A,$0A,$09 
      DC.B      $09,$08,$08,$07,$07,$06,$06,$05 
      DC.B      $05,$04,$04,$03,$03,$02,$02,$01 
      DC.B      $01,$01,$01,$01,$01,$02,$02,$03 
      DC.B      $03,$04,$04,$05,$05,$06,$06,$07 
      DC.B      $07,$08,$08,$09,$09,$0A,$0A,$0B 
      DC.B      $0B,$0C,$0C,$0D,$0D,$0E,$0E,$0F 
      DC.B      $0F,$0F,$0F,$0E,$0E,$0D,$0D,$0C 
      DC.B      $0C,$0B,$0B,$0A,$0A,$09,$09,$08 
      DC.B      $08,$07,$07,$06,$06,$05,$05,$04 
      DC.B      $04,$03,$03,$02,$02,$01,$01,$01 
      DC.B      $01,$01,$01,$02,$02,$03,$03,$04 
      DC.B      $04,$05,$05,$06,$06,$07,$07,$08 
      DC.B      $08,$09,$09,$0A,$0A,$0B,$0B,$0C 
      DC.B      $0C,$0D,$0D,$0E,$0E,$0F,$0F,$0F 
      DC.B      $0F,$0E,$0E,$0D,$0D,$0C,$0C,$0B 
      DC.B      $0B,$0A,$0A,$09,$09,$08,$08,$07 
      DC.B      $07,$06,$06,$05,$05,$04,$04,$03 
      DC.B      $03,$02,$02,$01,$01,$01,$01,$01 
      DC.B      $01,$02,$02,$03,$03,$04,$04,$05 
      DC.B      $05,$06,$06,$07,$07,$08,$08,$09 
      DC.B      $09,$0A,$0A,$0B,$0B,$0C,$0C,$0D 
      DC.B      $0D,$0E,$0E,$0F,$0F,$0F,$0F,$0E 
      DC.B      $0E,$0D,$0D,$0C,$0C,$0B,$0B,$0A 
      DC.B      $0A,$09,$09,$08,$08,$07,$07,$06 
      DC.B      $06,$05,$05,$04,$04,$03,$03,$02 
      DC.B      $02,$01,$01,$01,$01,$01,$01,$02 
      DC.B      $02,$03,$03,$04,$04,$05,$05,$06 
      DC.B      $06,$07,$07,$08,$08,$09,$09,$0A 
      DC.B      $0A,$0B,$0B,$0C,$0C,$0D,$0D,$0E 
      DC.B      $0E,$0F,$0F,$0F,$0F,$0E,$0E,$0D 
      DC.B      $0D,$0C,$0C,$0B,$0B,$0A,$0A,$09 
      DC.B      $09,$08,$08,$07,$07,$06,$06,$05 
      DC.B      $05,$04,$04,$03,$03,$02,$02,$01 
      DC.B      $01,$01,$01,$01,$01,$02,$02,$03 
      DC.B      $03,$04,$04,$05,$05,$06,$06,$07 
      DC.B      $07,$08,$08,$09,$09,$0A,$0A,$0B 
      DC.B      $0B,$0C,$0C,$0D,$0D,$0E,$0E,$0F 
      DC.B      $0F,$0F,$0F,$0E,$0E,$0D,$0D,$0C 
      DC.B      $0C,$0B,$0B,$0A,$0A,$09,$09,$08 
      DC.B      $08,$07,$07,$06,$06,$05,$05,$04 
      DC.B      $04,$03,$03,$02,$02,$01,$01,$01 
      DC.B      $01,$01,$01,$02,$02,$03,$03,$04 
      DC.B      $04,$05,$05,$06,$06,$07,$07,$08 
      DC.B      $08,$09,$09,$0A,$0A,$0B,$0B,$0C 
      DC.B      $0C,$0D,$0D,$0E,$0E,$0F,$0F,$0F 
      DC.B      $0F,$0E,$0E,$0D,$0D,$0C,$0C,$0B 
      DC.B      $0B,$0A,$0A,$09,$09,$08,$08,$07 
      DC.B      $07,$06,$06,$05,$05,$04,$04,$03 
      DC.B      $03,$02,$02,$01,$01,$01,$01,$01 
      DC.B      $01,$02,$02,$03,$03,$04,$04,$05 
      DC.B      $05,$06,$06,$07,$07,$08,$08,$09 
      DC.B      $09,$0A,$0A,$0B,$0B,$0C,$0C,$0D 
      DC.B      $0D,$0E,$0E,$0F,$0F,$0F,$0F,$0E 
      DC.B      $0E,$0D,$0D,$0C,$0C,$0B,$0B,$0A 
      DC.B      $0A,$09,$09,$08,$08,$07,$07,$06 
      DC.B      $06,$05,$05,$04,$04,$03,$03,$02 
      DC.B      $02,$01,$01,$01,$01,$01,$01,$02 
      DC.B      $02,$03,$03,$04,$04,$05,$05,$06 
      DC.B      $06,$07,$07,$08,$08,$09,$09,$0A 
      DC.B      $0A,$0B,$0B,$0C,$0C,$0D,$0D,$0E 
      DC.B      $0E,$0F,$0F,$0F,$0F,$0E,$0E,$0D 
      DC.B      $0D,$0C,$0C,$0B,$0B,$0A,$0A,$09 
      DC.B      $09,$08,$08,$07,$07,$06,$06,$05 
      DC.B      $05,$04,$04,$03,$03,$02,$02,$01 
      DC.B      $01,$01,$01,$01,$01,$02,$02,$03 
      DC.B      $03,$04,$04,$05,$05,$06,$06,$07 
      DC.B      $07,$08,$08,$09,$09,$0A,$0A,$0B 
      DC.B      $0B,$0C,$0C,$0D,$0D,$0E,$0E,$0F 
      DC.B      $0F,$0F,$0F,$0E,$0E,$0D,$0D,$0C 
      DC.B      $0C,$0B,$0B,$0A,$0A,$09,$09,$08 
      DC.B      $08,$07,$07,$06,$06,$05,$05,$04 
      DC.B      $04,$03,$03,$02,$02,$01,$01,$01 
      DC.B      $01,$01,$01,$02,$02,$03,$03,$04 
      DC.B      $04,$05,$05,$06,$06,$07,$07,$08 
      DC.B      $08,$09,$09,$0A,$0A,$0B,$0B,$0C 
      DC.B      $0C,$0D,$0D,$0E,$0E,$0F,$0F,$0F 
      DC.B      $0F,$0E,$0E,$0D,$0D,$0C,$0C,$0B 
      DC.B      $0B,$0A,$0A,$09,$09,$08,$08,$07 
      DC.B      $07,$06,$06,$05,$05,$04,$04,$03 
      DC.B      $03,$02,$02,$01,$01,$01,$01,$01 
      DC.B      $01,$02,$02,$03,$03,$04,$04,$05 
      DC.B      $05,$06,$06,$07,$07,$08,$08,$09 
      DC.B      $09,$0A,$0A,$0B,$0B,$0C,$0C,$0D 
      DC.B      $0D,$0E,$0E,$0F,$0F,$0F,$0F,$0E 
      DC.B      $0E,$0D,$0D,$0C,$0C,$0B,$0B,$0A 
      DC.B      $0A,$09,$09,$08,$08,$07,$07,$06 
      DC.B      $06,$05,$05,$04,$04,$03,$03,$02 
      DC.B      $02,$01,$01,$01,$01,$01,$01,$02 
      DC.B      $02,$03,$03,$04,$04,$05,$05,$06 
      DC.B      $06,$07,$07,$08,$08,$09,$09,$0A 
      DC.B      $0A,$0B,$0B,$0C,$0C,$0D,$0D,$0E 
      DC.B      $0E,$0F,$0F,$0F,$0F,$0E,$0E,$0D 
      DC.B      $0D,$0C,$0C,$0B,$0B,$0A,$0A,$09 
      DC.B      $09,$08,$08,$07,$07,$06,$06,$05 
      DC.B      $05,$04,$04,$03,$03,$02,$02,$01 
      DC.B      $01,$01,$01,$01,$01,$02,$02,$03 
      DC.B      $03,$04,$04,$05,$05,$06,$06,$07 
      DC.B      $07,$08,$08,$09,$09,$0A,$0A,$0B 
      DC.B      $0B,$0C,$0C,$0D,$0D,$0E,$0E,$0F 
      DC.B      $0F,$0F,$0F,$0E,$0E,$0D,$0D,$0C 
      DC.B      $0C,$0B,$0B,$0A,$0A,$09,$09,$08 
      DC.B      $08,$07,$07,$06,$06,$05,$05,$04 
      DC.B      $04,$03,$03,$02,$02,$01,$01,$01 
      DC.B      $01,$01,$01,$02,$02,$03,$03,$04 
      DC.B      $04,$05,$05,$06,$06,$07,$07,$08 
      DC.B      $08,$09,$09,$0A,$0A,$0B,$0B,$0C 
      DC.B      $0C,$0D,$0D,$0E,$0E,$0F,$0F,$0F 
      DC.B      $0F,$0E,$0E,$0D,$0D,$0C,$0C,$0B 
      DC.B      $0B,$0A,$0A,$09,$09,$08,$08,$07 
      DC.B      $07,$06,$06,$05,$05,$04,$04,$03 
      DC.B      $03,$02,$02,$01,$01,$01,$01,$01 
      DC.B      $01,$02,$02,$03,$03,$04,$04,$05 
      DC.B      $05,$06,$06,$07,$07,$08,$08,$09 
      DC.B      $09,$0A,$0A,$0B,$0B,$0C,$0C,$0D 
      DC.B      $0D,$0E,$0E,$0F,$0F,$0F,$0F,$0E 
      DC.B      $0E,$0D,$0D,$0C,$0C,$0B,$0B,$0A 
      DC.B      $0A,$09,$09,$08,$08,$07,$07,$06 
      DC.B      $06,$05,$05,$04,$04,$03,$03,$02 
      DC.B      $02,$01,$01,$01,$01,$01,$01,$02 
      DC.B      $02,$03,$03,$04,$04,$05,$05,$06 
      DC.B      $06,$07,$07,$08,$08,$09,$09,$0A 
      DC.B      $0A,$0B,$0B,$0C,$0C,$0D,$0D,$0E 
      DC.B      $0E,$0F,$0F,$0F,$0F,$0E,$0E,$0D 
      DC.B      $0D,$0C,$0C,$0B,$0B,$0A,$0A,$09 
      DC.B      $09,$08,$08,$07,$07,$06,$06,$05 
      DC.B      $05,$04,$04,$03,$03,$02,$02,$01 
      DC.B      $01,$01,$01,$01,$01,$02,$02,$03 
      DC.B      $03,$04,$04,$05,$05,$06,$06,$07 
      DC.B      $07,$08,$08,$09,$09,$0A,$0A,$0B 
      DC.B      $0B,$0C,$0C,$0D,$0D,$0E,$0E,$0F 
      DC.B      $0F,$0F,$0F,$0E,$0E,$0D,$0D,$0C 
      DC.B      $0C,$0B,$0B,$0A,$0A,$09,$09,$08 
      DC.B      $08,$07,$07,$06,$06,$05,$05,$04 
      DC.B      $04,$03,$03,$02,$02,$01,$01,$01 
      DC.B      $01,$01,$01,$02,$02,$03,$03,$04 
      DC.B      $04,$05,$05,$06,$06,$07,$07,$08 
      DC.B      $08,$09,$09,$0A,$0A,$0B,$0B,$0C 
      DC.B      $0C,$0D,$0D,$0E,$0E,$0F,$0F,$0F 
      DC.B      $0F,$0E,$0E,$0D,$0D,$0C,$0C,$0B 
      DC.B      $0B,$0A,$0A,$09,$09,$08,$08,$07 
      DC.B      $07,$06,$06,$05,$05,$04,$04,$03 
      DC.B      $03,$02,$02,$01,$01,$01,$01,$01 
      DC.B      $01,$02,$02,$03,$03,$04,$04,$05 
      DC.B      $05,$06,$06,$07,$07,$08,$08,$09 
      DC.B      $09,$0A,$0A,$0B,$0B,$0C,$0C,$0D 
      DC.B      $0D,$0E,$0E,$0F,$0F,$0F,$0F,$0E 
      DC.B      $0E,$0D,$0D,$0C,$0C,$0B,$0B,$0A 
      DC.B      $0A,$09,$09,$08,$08,$07,$07,$06 
      DC.B      $06,$05,$05,$04,$04,$03,$03,$02 
      DC.B      $02,$01,$01,$01,$01,$01,$01,$02 
      DC.B      $02,$03,$03,$04,$04,$05,$05,$06 
      DC.B      $06,$07,$07,$08,$08,$09,$09,$0A 
      DC.B      $0A,$0B,$0B,$0C,$0C,$0D,$0D,$0E 
      DC.B      $0E,$0F,$0F,$0F,$0F,$0E,$0E,$0D 
      DC.B      $0D,$0C,$0C,$0B,$0B,$0A,$0A,$09 
      DC.B      $09,$08,$08,$07,$07,$06,$06,$05 
      DC.B      $05,$04,$04,$03,$03,$02,$02,$01 
      DC.B      $01,$01,$01,$01,$01,$02,$02,$03 
      DC.B      $03,$04,$04,$05,$05,$06,$06,$07 
      DC.B      $07,$08,$08,$09,$09,$0A,$0A,$0B 
      DC.B      $0B,$0C,$0C,$0D,$0D,$0E,$0E,$0F 
      DC.B      $0F,$0F,$0F,$0E,$0E,$0D,$0D,$0C 
      DC.B      $0C,$0B,$0B,$0A,$0A,$09,$09,$08 
      DC.B      $08,$07,$07,$06,$06,$05,$05,$04 
      DC.B      $04,$03,$03,$02,$02,$01,$01,$01 
      DC.B      $01,$01,$01,$02,$02,$03,$03,$04 
      DC.B      $04,$05,$05,$06,$06,$07,$07,$08 
      DC.B      $08,$09,$09,$0A,$0A,$0B,$0B,$0C 
      DC.B      $0C,$0D,$0D,$0E,$0E,$0F,$0F,$0F 
      DC.B      $0F,$0E,$0E,$0D,$0D,$0C,$0C,$0B 
      DC.B      $0B,$0A,$0A,$09,$09,$08,$08,$07 
      DC.B      $07,$06,$06,$05,$05,$04,$04,$03 
      DC.B      $03,$02,$02,$01,$01,$01,$01,$01 
      DC.B      $01,$02,$02,$03,$03,$04,$04,$05 
      DC.B      $05,$06,$06,$07,$07,$08,$08,$09 
      DC.B      $09,$0A,$0A,$0B,$0B,$0C,$0C,$0D 
      DC.B      $0D,$0E,$0E,$0F,$0F,$0F,$0F,$0E 
      DC.B      $0E,$0D,$0D,$0C,$0C,$0B,$0B,$0A 
      DC.B      $0A,$09,$09,$08,$08,$07,$07,$06 
      DC.B      $06,$05,$05,$04,$04,$03,$03,$02 
      DC.B      $02,$01,$01,$01,$01,$01,$01,$02 
      DC.B      $02,$03,$03,$04,$04,$05,$05,$06 
      DC.B      $06,$07,$07,$08,$08,$09,$09,$0A 
      DC.B      $0A,$0B,$0B,$0C,$0C,$0D,$0D,$0E 
      DC.B      $0E,$0F,$0F,$0F,$0F,$0E,$0E,$0D 
      DC.B      $0D,$0C,$0C,$0B,$0B,$0A,$0A,$09 
      DC.B      $09,$08,$08,$07,$07,$06,$06,$05 
      DC.B      $05,$04,$04,$03,$03,$02,$02,$01 
      DC.B      $01,$01,$01,$01,$01,$02,$02,$03 
      DC.B      $03,$04,$04,$05,$05,$06,$06,$07 
      DC.B      $07,$08,$08,$09,$09,$0A,$0A,$0B 
      DC.B      $0B,$0C,$0C,$0D,$0D,$0E,$0E,$0F 
      DC.B      $0F,$0F,$0F,$0E,$0E,$0D,$0D,$0C 
      DC.B      $0C,$0B,$0B,$0A,$0A,$09,$09,$08 
      DC.B      $08,$07,$07,$06,$06,$05,$05,$04 
      DC.B      $04,$03,$03,$02,$02,$01,$01,$01 
      DC.B      $01,$01,$01,$02,$02,$03,$03,$04 
      DC.B      $04,$05,$05,$06,$06,$07,$07,$08 
      DC.B      $08,$09,$09,$0A,$0A,$0B,$0B,$0C 
      DC.B      $0C,$0D,$0D,$0E,$0E,$0F,$0F,$0F 
      DC.B      $0F,$0E,$0E,$0D,$0D,$0C,$0C,$0B 
      DC.B      $0B,$0A,$0A,$09,$09,$08,$08,$07 
      DC.B      $07,$06,$06,$05,$05,$04,$04,$03 
      DC.B      $03,$02,$02,$01,$01,$01,$01,$01 
      DC.B      $01,$02,$02,$03,$03,$04,$04,$05 
      DC.B      $05,$06,$06,$07,$07,$08,$08,$09 
      DC.B      $09,$0A,$0A,$0B,$0B,$0C,$0C,$0D 
      DC.B      $0D,$0E,$0E,$0F,$0F,$0F,$0F,$0E 
      DC.B      $0E,$0D,$0D,$0C,$0C,$0B,$0B,$0A 
      DC.B      $0A,$09,$09,$08,$08,$07,$07,$06 
      DC.B      $06,$05,$05,$04,$04,$03,$03,$02 
      DC.B      $02,$01,$01,$01,$01,$01,$01,$02 
      DC.B      $02,$03,$03,$04,$04,$05,$05,$06 
      DC.B      $06,$07,$07,$08,$08,$09,$09,$0A 
      DC.B      $0A,$0B,$0B,$0C,$0C,$0D,$0D,$0E 
      DC.B      $0E,$0F,$0F,$0F,$0F,$0E,$0E,$0D 
      DC.B      $0D,$0C,$0C,$0B,$0B,$0A,$0A,$09 
      DC.B      $09,$08,$08,$07,$07,$06,$06,$05 
      DC.B      $05,$04,$04,$03,$03,$02,$02,$01 
      DC.B      $01,$01,$01,$01,$01,$02,$02,$03 
      DC.B      $03,$04,$04,$05,$05,$06,$06,$07 
      DC.B      $07,$08,$08,$09,$09,$0A,$0A,$0B 
      DC.B      $0B,$0C,$0C,$0D,$0D,$0E,$0E,$0F 
      DC.B      $0F,$0F,$0F,$0E,$0E,$0D,$0D,$0C 
      DC.B      $0C,$0B,$0B,$0A,$0A,$09,$09,$08 
      DC.B      $08,$07,$07,$06,$06,$05,$05,$04 
      DC.B      $04,$03,$03,$02,$02,$01,$01,$01 
      DC.B      $01,$01,$01,$02,$02,$03,$03,$04 
      DC.B      $04,$05,$05,$06,$06,$07,$07,$08 
      DC.B      $08,$09,$09,$0A,$0A,$0B,$0B,$0C 
      DC.B      $0C,$0D,$0D,$0E,$0E,$0F,$0F,$0F 
      DC.B      $0F,$0E,$0E,$0D,$0D,$0C,$0C,$0B 
      DC.B      $0B,$0A,$0A,$09,$09,$08,$08,$07 
      DC.B      $07,$06,$06,$05,$05,$04,$04,$03 
      DC.B      $03,$02,$02,$01,$01,$01,$01,$01 
      DC.B      $01,$02,$02,$03,$03,$04,$04,$05 
      DC.B      $05,$06,$06,$07,$07,$08,$08,$09 
      DC.B      $09,$0A,$0A,$0B,$0B,$0C,$0C,$0D 
      DC.B      $0D,$0E,$0E,$0F,$0F,$0F,$0F,$0E 
      DC.B      $0E,$0D,$0D,$0C,$0C,$0B,$0B,$0A 
      DC.B      $0A,$09,$09,$08,$08,$07,$07,$06 
      DC.B      $06,$05,$05,$04,$04,$03,$03,$02 
      DC.B      $02,$01,$01,$01,$01,$01,$01,$02 
      DC.B      $02,$03,$03,$04,$04,$05,$05,$06 
      DC.B      $06,$07,$07,$08,$08,$09,$09,$0A 
      DC.B      $0A,$0B,$0B,$0C,$0C,$0D,$0D,$0E 
      DC.B      $0E,$0F,$0F,$0F,$0F,$0E,$0E,$0D 
      DC.B      $0D,$0C,$0C,$0B,$0B,$0A,$0A,$09 
      DC.B      $09,$08,$08,$07,$07,$06,$06,$05 
      DC.B      $05,$04,$04,$03,$03,$02,$02,$01 
      DC.B      $01,$01,$01,$01,$01,$02,$02,$03 
      DC.B      $03,$04,$04,$05,$05,$06,$06,$07 
      DC.B      $07,$08,$08,$09,$09,$0A,$0A,$0B 
      DC.B      $0B,$0C,$0C,$0D,$0D,$0E,$0E,$0F 
      DC.B      $0F,$0F,$0F,$0E,$0E,$0D,$0D,$0C 
      DC.B      $0C,$0B,$0B,$0A,$0A,$09,$09,$08 
      DC.B      $08,$07,$07,$06,$06,$05,$05,$04 
      DC.B      $04,$03,$03,$02,$02,$01,$01,$01 
      DC.B      $01,$01,$01,$02,$02,$03,$03,$04 
      DC.B      $04,$05,$05,$06,$06,$07,$07,$08 
      DC.B      $08,$09,$09,$0A,$0A,$0B,$0B,$0C 
      DC.B      $0C,$0D,$0D,$0E,$0E,$0F,$0F,$0F 
      DC.B      $0F,$0E,$0E,$0D,$0D,$0C,$0C,$0B 
      DC.B      $0B,$0A,$0A,$09,$09,$08,$08,$07 
      DC.B      $07,$06,$06,$05,$05,$04,$04,$03 
      DC.B      $03,$02,$02,$01,$01,$01,$01,$01 
      DC.B      $01,$02,$02,$03,$03,$04,$04,$05 
      DC.B      $05,$06,$06,$07,$07,$08,$08,$09 
      DC.B      $09,$0A,$0A,$0B,$0B,$0C,$0C,$0D 
      DC.B      $0D,$0E,$0E,$0F,$0F,$0F,$0F,$0E 
      DC.B      $0E,$0D,$0D,$0C,$0C,$0B,$0B,$0A 
      DC.B      $0A,$09,$09,$08,$08,$07,$07,$06 
      DC.B      $06,$05,$05,$04,$04,$03,$03,$02 
      DC.B      $02,$01,$01,$01,$01,$01,$01,$02 
      DC.B      $02,$03,$03,$04,$04,$05,$05,$06 
      DC.B      $06,$07,$07,$08,$08,$09,$09,$0A 
      DC.B      $0A,$0B,$0B,$0C,$0C,$0D,$0D,$0E 
      DC.B      $0E,$0F,$0F,$0F,$0F,$0E,$0E,$0D 
      DC.B      $0D,$0C,$0C,$0B,$0B,$0A,$0A,$09 
      DC.B      $09,$08,$08,$07,$07,$06,$06,$05 
      DC.B      $05,$04,$04,$03,$03,$02,$02,$01 
      DC.B      $01,$01,$01,$01,$01,$02,$02,$03 
      DC.B      $03,$04,$04,$05,$05,$06,$06,$07 
      DC.B      $07,$08,$08,$09,$09,$0A,$0A,$0B 
      DC.B      $0B,$0C,$0C,$0D,$0D,$0E,$0E,$0F 
      DC.B      $0F,$0F,$0F,$0E,$0E,$0D,$0D,$0C 
      DC.B      $0C,$0B,$0B,$0A,$0A,$09,$09,$08 
      DC.B      $08,$07,$07,$06,$06,$05,$05,$04 
      DC.B      $04,$03,$03,$02,$02,$01,$01,$01 
      DC.B      $01,$01,$01,$02,$02,$03,$03,$04 
      DC.B      $04,$05,$05,$06,$06,$07,$07,$08 
      DC.B      $08,$09,$09,$0A,$0A,$0B,$0B,$0C 
      DC.B      $0C,$0D,$0D,$0E,$0E,$0F,$0F,$0F 
      DC.B      $0F,$0E,$0E,$0D,$0D,$0C,$0C,$0B 
      DC.B      $0B,$0A,$0A,$09,$09,$08,$08,$07 
      DC.B      $07,$06,$06,$05,$05,$04,$04,$03 
      DC.B      $03,$02,$02,$01,$01,$01,$01,$01 
      DC.B      $01,$02,$02,$03,$03,$04,$04,$05 
      DC.B      $05,$06,$06,$07,$07,$08,$08,$09 
      DC.B      $09,$0A,$0A,$0B,$0B,$0C,$0C,$0D 
      DC.B      $0D,$0E,$0E,$0F,$0F,$0F,$0F,$0E 
      DC.B      $0E,$0D,$0D,$0C,$0C,$0B,$0B,$0A 
      DC.B      $0A,$09,$09,$08,$08,$07,$07,$06 
      DC.B      $06,$05,$05,$04,$04,$03,$03,$02 
      DC.B      $02,$01,$01,$01,$01,$01,$01,$02 
      DC.B      $02,$03,$03,$04,$04,$05,$05,$06 
      DC.B      $06,$07,$07,$08,$08,$09,$09,$0A 
      DC.B      $0A,$0B,$0B,$0C,$0C,$0D,$0D,$0E 
      DC.B      $0E,$0F,$0F,$0F,$0F,$0E,$0E,$0D 
      DC.B      $0D,$0C,$0C,$0B,$0B,$0A,$0A,$09 
      DC.B      $09,$08,$08,$07,$07,$06,$06,$05 
      DC.B      $05,$04,$04,$03,$03,$02,$02,$01 
      DC.B      $01,$01,$01,$01,$01,$02,$02,$03 
      DC.B      $03,$04,$04,$05,$05,$06,$06,$07 
      DC.B      $07,$08,$08,$09,$09,$0A,$0A,$0B 
      DC.B      $0B,$0C,$0C,$0D,$0D,$0E,$0E,$0F 
      DC.B      $0F,$0F,$0F,$0E,$0E,$0D,$0D,$0C 
      DC.B      $0C,$0B,$0B,$0A,$0A,$09,$09,$08 
      DC.B      $08,$07,$07,$06,$06,$05,$05,$04 
      DC.B      $04,$03,$03,$02,$02,$01,$01,$01 
      DC.B      $01,$01,$01,$02,$02,$03,$03,$04 
      DC.B      $04,$05,$05,$06,$06,$07,$07,$08 
      DC.B      $08,$09,$09,$0A,$0A,$0B,$0B,$0C 
      DC.B      $0C,$0D,$0D,$0E,$0E,$0F,$0F,$0F 
      DC.B      $0F,$0E,$0E,$0D,$0D,$0C,$0C,$0B 
      DC.B      $0B,$0A,$0A,$09,$09,$08,$08,$07 
      DC.B      $07,$06,$06,$05,$05,$04,$04,$03 
      DC.B      $03,$02,$02,$01,$01,$01,$01,$01 
      DC.B      $01,$02,$02,$03,$03,$04,$04,$05 
      DC.B      $05,$06,$06,$07,$07,$08,$08,$09 
      DC.B      $09,$0A,$0A,$0B,$0B,$0C,$0C,$0D 
      DC.B      $0D,$0E,$0E,$0F,$0F,$0F,$0F,$0E 
      DC.B      $0E,$0D,$0D,$0C,$0C,$0B,$0B,$0A 
      DC.B      $0A,$09,$09,$08,$08,$07,$07,$06 
      DC.B      $06,$05,$05,$04,$04,$03,$03,$02 
      DC.B      $02,$01,$01,$01,$01,$01,$01,$02 
      DC.B      $02,$03,$03,$04,$04,$05,$05,$06 
      DC.B      $06,$07,$07,$08,$08,$09,$09,$0A 
      DC.B      $0A,$0B,$0B,$0C,$0C,$0D,$0D,$0E 
      DC.B      $0E,$0F,$0F,$0F,$0F,$0E,$0E,$0D 
      DC.B      $0D,$0C,$0C,$0B,$0B,$0A,$0A,$09 
      DC.B      $09,$08,$08,$07,$07,$06,$06,$05 
      DC.B      $05,$04,$04,$03,$03,$02,$02,$01 
      DC.B      $01,$01,$01,$01,$01,$02,$02,$03 
      DC.B      $03,$04,$04,$05,$05,$06,$06,$07 
      DC.B      $07,$08,$08,$09,$09,$0A,$0A,$0B 
      DC.B      $0B,$0C,$0C,$0D,$0D,$0E,$0E,$0F 
      DC.B      $0F,$0F,$0F,$0E,$0E,$0D,$0D,$0C 
      DC.B      $0C,$0B,$0B,$0A,$0A,$09,$09,$08 
      DC.B      $08,$07,$07,$06,$06,$05,$05,$04 
      DC.B      $04,$03,$03,$02,$02,$01,$01,$01 
      DC.B      $01,$01,$01,$02,$02,$03,$03,$04 
      DC.B      $04,$05,$05,$06,$06,$07,$07,$08 
      DC.B      $08,$09,$09,$0A,$0A,$0B,$0B,$0C 
      DC.B      $0C,$0D,$0D,$0E,$0E,$0F,$0F,$0F 
      DC.B      $0F,$0E,$0E,$0D,$0D,$0C,$0C,$0B 
      DC.B      $0B,$0A,$0A,$09,$09,$08,$08,$07 
      DC.B      $07,$06,$06,$05,$05,$04,$04,$03 
      DC.B      $03,$02,$02,$01,$01,$01,$01,$01 
      DC.B      $01,$02,$02,$03,$03,$04,$04,$05 
      DC.B      $05,$06,$06,$07,$07,$08,$08,$09 
      DC.B      $09,$0A,$0A,$0B,$0B,$0C,$0C,$0D 
      DC.B      $0D,$0E,$0E,$0F,$0F,$0F,$0F,$0E 
      DC.B      $0E,$0D,$0D,$0C,$0C,$0B,$0B,$0A 
      DC.B      $0A,$09,$09,$08,$08,$07,$07,$06 
      DC.B      $06,$05,$05,$04,$04,$03,$03,$02 
      DC.B      $02,$01,$01,$01,$01,$01,$01,$02 
      DC.B      $02,$03,$03,$04,$04,$05,$05,$06 
      DC.B      $06,$07,$07,$08,$08,$09,$09,$0A 
      DC.B      $0A,$0B,$0B,$0C,$0C,$0D,$0D,$0E 
      DC.B      $0E,$0F,$0F,$0F,$0F,$0E,$0E,$0D 
      DC.B      $0D,$0C,$0C,$0B,$0B,$0A,$0A,$09 
      DC.B      $09,$08,$08,$07,$07,$06,$06,$05 
      DC.B      $05,$04,$04,$03,$03,$02,$02,$01 
      DC.B      $01,$01,$01,$01,$01,$02,$02,$03 
      DC.B      $03,$04,$04,$05,$05,$06,$06,$07 
      DC.B      $07,$08,$08,$09,$09,$0A,$0A,$0B 
      DC.B      $0B,$0C,$0C,$0D,$0D,$0E,$0E,$0F 
      DC.B      $0F,$0F,$0F,$0E,$0E,$0D,$0D,$0C 
      DC.B      $0C,$0B,$0B,$0A,$0A,$09,$09,$08 
      DC.B      $08,$07,$07,$06,$06,$05,$05,$04 
      DC.B      $04,$03,$03,$02,$02,$01,$01,$01 
      DC.B      $01,$01,$01,$02,$02,$03,$03,$04 
      DC.B      $04,$05,$05,$06,$06,$07,$07,$08 
      DC.B      $08,$09,$09,$0A,$0A,$0B,$0B,$0C 
      DC.B      $0C,$0D,$0D,$0E,$0E,$0F,$0F,$0F 
      DC.B      $0F,$0E,$0E,$0D,$0D,$0C,$0C,$0B 
      DC.B      $0B,$0A,$0A,$09,$09,$08,$08,$07 
      DC.B      $07,$06,$06,$05,$05,$04,$04,$03 
      DC.B      $03,$02,$02,$01,$01,$01,$01,$01 
      DC.B      $01,$02,$02,$03,$03,$04,$04,$05 
      DC.B      $05,$06,$06,$07,$07,$08,$08,$09 
      DC.B      $09,$0A,$0A,$0B,$0B,$0C,$0C,$0D 
      DC.B      $0D,$0E,$0E,$0F,$0F,$0F,$0F,$0E 
      DC.B      $0E,$0D,$0D,$0C,$0C,$0B,$0B,$0A 
      DC.B      $0A,$09,$09,$08,$08,$07,$07,$06 
      DC.B      $06,$05,$05,$04,$04,$03,$03,$02 
      DC.B      $02,$01,$01,$01,$01,$01,$01,$02 
      DC.B      $02,$03,$03,$04,$04,$05,$05,$06 
      DC.B      $06,$07,$07,$08,$08,$09,$09,$0A 
      DC.B      $0A,$0B,$0B,$0C,$0C,$0D,$0D,$0E 
      DC.B      $0E,$0F,$0F,$0F,$0F,$0E,$0E,$0D 
      DC.B      $0D,$0C,$0C,$0B,$0B,$0A,$0A,$09 
      DC.B      $09,$08,$08,$07,$07,$06,$06,$05 
      DC.B      $05,$04,$04,$03,$03,$02,$02,$01 
      DC.B      $01,$01,$01,$01,$01,$02,$02,$03 
      DC.B      $03,$04,$04,$05,$05,$06,$06,$07 
      DC.B      $07,$08,$08,$09,$09,$0A,$0A,$0B 
      DC.B      $0B,$0C,$0C,$0D,$0D,$0E,$0E,$0F 
      DC.B      $0F,$0F,$0F,$0E,$0E,$0D,$0D,$0C 
      DC.B      $0C,$0B,$0B,$0A,$0A,$09,$09,$08 
      DC.B      $08,$07,$07,$06,$06,$05,$05,$04 
      DC.B      $04,$03,$03,$02,$02,$01,$01,$01 
      DC.B      $01,$01,$01,$02,$02,$03,$03,$04 
      DC.B      $04,$05,$05,$06,$06,$07,$07,$08 
      DC.B      $08,$09,$09,$0A,$0A,$0B,$0B,$0C 
      DC.B      $0C,$0D,$0D,$0E,$0E,$0F,$0F,$0F 
      DC.B      $0F,$0E,$0E,$0D,$0D,$0C,$0C,$0B 
      DC.B      $0B,$0A,$0A,$09,$09,$08,$08,$07 
      DC.B      $07,$06,$06,$05,$05,$04,$04,$03 
      DC.B      $03,$02,$02,$01,$01,$01,$01,$01 
      DC.B      $01,$02,$02,$03,$03,$04,$04,$05 
      DC.B      $05,$06,$06,$07,$07,$08,$08,$09 
      DC.B      $09,$0A,$0A,$0B,$0B,$0C,$0C,$0D 
      DC.B      $0D,$0E,$0E,$0F,$0F,$0F,$0F,$0E 
      DC.B      $0E,$0D,$0D,$0C,$0C,$0B,$0B,$0A 
      DC.B      $0A,$09,$09,$08,$08,$07,$07,$06 
      DC.B      $06,$05,$05,$04,$04,$03,$03,$02 
      DC.B      $02,$01,$01,$01,$01,$01,$01,$02 
      DC.B      $02,$03,$03,$04,$04,$05,$05,$06 
      DC.B      $06,$07,$07,$08,$08,$09,$09,$0A 
      DC.B      $0A,$0B,$0B,$0C,$0C,$0D,$0D,$0E 
      DC.B      $0E,$0F,$0F,$0F,$0F,$0E,$0E,$0D 
      DC.B      $0D,$0C,$0C,$0B,$0B,$0A,$0A,$09 
      DC.B      $09,$08,$08,$07,$07,$06,$06,$05 
      DC.B      $05,$04,$04,$03,$03,$02,$02,$01 
      DC.B      $01,$01,$01,$01,$01,$02,$02,$03 
      DC.B      $03,$04,$04,$05,$05,$06,$06,$07 
      DC.B      $07,$08,$08,$09,$09,$0A,$0A,$0B 
      DC.B      $0B,$0C,$0C,$0D,$0D,$0E,$0E,$0F 
      DC.B      $0F,$0F,$0F,$0E,$0E,$0D,$0D,$0C 
      DC.B      $0C,$0B,$0B,$0A,$0A,$09,$09,$08 
      DC.B      $08,$07,$07,$06,$06,$05,$05,$04 
      DC.B      $04,$03,$03,$02,$02,$01,$01,$01 
      DC.B      $01,$01,$01,$02,$02,$03,$03,$04 
      DC.B      $04,$05,$05,$06,$06,$07,$07,$08 
      DC.B      $08,$09,$09,$0A,$0A,$0B,$0B,$0C 
      DC.B      $0C,$0D,$0D,$0E,$0E,$0F,$0F,$0F 
      DC.B      $0F,$0E,$0E,$0D,$0D,$0C,$0C,$0B 
      DC.B      $0B,$0A,$0A,$09,$09,$08,$08,$07 
      DC.B      $07,$06,$06,$05,$05,$04,$04,$03 
      DC.B      $03,$02,$02,$01,$01,$01,$01,$01 
      DC.B      $01,$02,$02,$03,$03,$04,$04,$05 
      DC.B      $05,$06,$06,$07,$07,$08,$08,$09 
      DC.B      $09,$0A,$0A,$0B,$0B,$0C,$0C,$0D 
      DC.B      $0D,$0E,$0E,$0F,$0F,$0F,$0F,$0E 
      DC.B      $0E,$0D,$0D,$0C,$0C,$0B,$0B,$0A 
      DC.B      $0A,$09,$09,$08,$08,$07,$07,$06 
      DC.B      $06,$05,$05,$04,$04,$03,$03,$02 
      DC.B      $02,$01,$01,$01,$01,$01,$01,$02 
      DC.B      $02,$03,$03,$04,$04,$05,$05,$06 
      DC.B      $06,$07,$07,$08,$08,$09,$09,$0A 
      DC.B      $0A,$0B,$0B,$0C,$0C,$0D,$0D,$0E 
      DC.B      $0E,$0F,$0F,$0F,$0F,$0E,$0E,$0D 
      DC.B      $0D,$0C,$0C,$0B,$0B,$0A,$0A,$09 
      DC.B      $09,$08,$08,$07,$07,$06,$06,$05 
      DC.B      $05,$04,$04,$03,$03,$02,$02,$01 
      DC.B      $01,$01,$01,$01,$01,$02,$02,$03 
      DC.B      $03,$04,$04,$05,$05,$06,$06,$07 
      DC.B      $07,$08,$08,$09,$09,$0A,$0A,$0B 
      DC.B      $0B,$0C,$0C,$0D,$0D,$0E,$0E,$0F 
      DC.B      $0F,$0F,$0F,$0E,$0E,$0D,$0D,$0C 
      DC.B      $0C,$0B,$0B,$0A,$0A,$09,$09,$08 
      DC.B      $08,$07,$07,$06,$06,$05,$05,$04 
      DC.B      $04,$03,$03,$02,$02,$01,$01,$01 
      DC.B      $01,$01,$01,$02,$02,$03,$03,$04 
      DC.B      $04,$05,$05,$06,$06,$07,$07,$08 
      DC.B      $08,$09,$09,$0A,$0A,$0B,$0B,$0C 
      DC.B      $0C,$0D,$0D,$0E,$0E,$0F,$0F,$0F 
      DC.B      $0F,$0E,$0E,$0D,$0D,$0C,$0C,$0B 
      DC.B      $0B,$0A,$0A,$09,$09,$08,$08,$07 
      DC.B      $07,$06,$06,$05,$05,$04,$04,$03 
      DC.B      $03,$02,$02,$01,$01,$01,$01,$01 
      DC.B      $01,$02,$02,$03,$03,$04,$04,$05 
      DC.B      $05,$06,$06,$07,$07,$08,$08,$09 
      DC.B      $09,$0A,$0A,$0B,$0B,$0C,$0C,$0D 
      DC.B      $0D,$0E,$0E,$0F,$0F,$0F,$0F,$0E 
      DC.B      $0E,$0D,$0D,$0C,$0C,$0B,$0B,$0A 
      DC.B      $0A,$09,$09,$08,$08,$07,$07,$06 
      DC.B      $06,$05,$05,$04,$04,$03,$03,$02 
      DC.B      $02,$01,$01,$01,$01,$01,$01,$02 
      DC.B      $02,$03,$03,$04,$04,$05,$05,$06 
      DC.B      $06,$07,$07,$08,$08,$09,$09,$0A 
      DC.B      $0A,$0B,$0B,$0C,$0C,$0D,$0D,$0E 
      DC.B      $0E,$0F,$0F,$0F,$0F,$0E,$0E,$0D 
      DC.B      $0D,$0C,$0C,$0B,$0B,$0A,$0A,$09 
      DC.B      $09,$08,$08,$07,$07,$06,$06,$05 
      DC.B      $05,$04,$04,$03,$03,$02,$02,$01 
      DC.B      $01,$01,$01,$01,$01,$02,$02,$03 
      DC.B      $03,$04,$04,$05,$05,$06,$06,$07 
      DC.B      $07,$08,$08,$09,$09,$0A,$0A,$0B 
      DC.B      $0B,$0C,$0C,$0D,$0D,$0E,$0E,$0F 
      DC.B      $0F,$0F,$0F,$0E,$0E,$0D,$0D,$0C 
      DC.B      $0C,$0B,$0B,$0A,$0A,$09,$09,$08 
      DC.B      $08,$07,$07,$06,$06,$05,$05,$04 
      DC.B      $04,$03,$03,$02,$02,$01,$01,$01 
      DC.B      $01,$01,$01,$02,$02,$03,$03,$04 
      DC.B      $04,$05,$05,$06,$06,$07,$07,$08 
      DC.B      $08,$09,$09,$0A,$0A,$0B,$0B,$0C 
      DC.B      $0C,$0D,$0D,$0E,$0E,$0F,$0F,$0F 
      DC.B      $0F,$0E,$0E,$0D,$0D,$0C,$0C,$0B 
      DC.B      $0B,$0A,$0A,$09,$09,$08,$08,$07 
      DC.B      $07,$06,$06,$05,$05,$04,$04,$03 
      DC.B      $03,$02,$02,$01,$01,$01,$01,$01 
      DC.B      $01,$02,$02,$03,$03,$04,$04,$05 
      DC.B      $05,$06,$06,$07,$07,$08,$08,$09 
      DC.B      $09,$0A,$0A,$0B,$0B,$0C,$0C,$0D 
      DC.B      $0D,$0E,$0E,$0F,$0F,$0F,$0F,$0E 
      DC.B      $0E,$0D,$0D,$0C,$0C,$0B,$0B,$0A 
      DC.B      $0A,$09,$09,$08,$08,$07,$07,$06 
      DC.B      $06,$05,$05,$04,$04,$03,$03,$02 
      DC.B      $02,$01,$01,$01,$01,$01,$01,$02 
      DC.B      $02,$03,$03,$04,$04,$05,$05,$06 
      DC.B      $06,$07,$07,$08,$08,$09,$09,$0A 
      DC.B      $0A,$0B,$0B,$0C,$0C,$0D,$0D,$0E 
      DC.B      $0E,$0F,$0F,$0F,$0F,$0E,$0E,$0D 
      DC.B      $0D,$0C,$0C,$0B,$0B,$0A,$0A,$09 
      DC.B      $09,$08,$08,$07,$07,$06,$06,$05 
      DC.B      $05,$04,$04,$03,$03,$02,$02,$01 
      DC.B      $01,$01,$01,$01,$01,$02,$02,$03 
      DC.B      $03,$04,$04,$05,$05,$06,$06,$07 
      DC.B      $07,$08,$08,$09,$09,$0A,$0A,$0B 
      DC.B      $0B,$0C,$0C,$0D,$0D,$0E,$0E,$0F 
      DC.B      $0F,$0F,$0F,$0E,$0E,$0D,$0D,$0C 
      DC.B      $0C,$0B,$0B,$0A,$0A,$09,$09,$08 
      DC.B      $08,$07,$07,$06,$06,$05,$05,$04 
      DC.B      $04,$03,$03,$02,$02,$01,$01,$01 
      DC.B      $01,$01,$01,$02,$02,$03,$03,$04 
      DC.B      $04,$05,$05,$06,$06,$07,$07,$08 
      DC.B      $08,$09,$09,$0A,$0A,$0B,$0B,$0C 
      DC.B      $0C,$0D,$0D,$0E,$0E,$0F,$0F,$0F 
      DC.B      $0F,$0E,$0E,$0D,$0D,$0C,$0C,$0B 
      DC.B      $0B,$0A,$0A,$09,$09,$08,$08,$07 
      DC.B      $07,$06,$06,$05,$05,$04,$04,$03 
      DC.B      $03,$02,$02,$01,$01,$01,$01,$01 
      DC.B      $01,$02,$02,$03,$03,$04,$04,$05 
      DC.B      $05,$06,$06,$07,$07,$08,$08,$09 
      DC.B      $09,$0A,$0A,$0B,$0B,$0C,$0C,$0D 
      DC.B      $0D,$0E,$0E,$0F,$0F,$0F,$0F,$0E 
      DC.B      $0E,$0D,$0D,$0C,$0C,$0B,$0B,$0A 
      DC.B      $0A,$09,$09,$08,$08,$07,$07,$06 
      DC.B      $06,$05,$05,$04,$04,$03,$03,$02 
      DC.B      $02,$01,$01,$01,$01,$01,$01,$02 
      DC.B      $02,$03,$03,$04,$04,$05,$05,$06 
      DC.B      $06,$07,$07,$08,$08,$09,$09,$0A 
      DC.B      $0A,$0B,$0B,$0C,$0C,$0D,$0D,$0E 
      DC.B      $0E,$0F,$0F,$0F,$0F,$0E,$0E,$0D 
      DC.B      $0D,$0C,$0C,$0B,$0B,$0A,$0A,$09 
      DC.B      $09,$08,$08,$07,$07,$06,$06,$05 
      DC.B      $05,$04,$04,$03,$03,$02,$02,$01 
      DC.B      $01,$01,$01,$01,$01,$02,$02,$03 
      DC.B      $03,$04,$04,$05,$05,$06,$06,$07 
      DC.B      $07,$08,$08,$09,$09,$0A,$0A,$0B 
      DC.B      $0B,$0C,$0C,$0D,$0D,$0E,$0E,$0F 
      DC.B      $0F,$0F,$0F,$0E,$0E,$0D,$0D,$0C 
      DC.B      $0C,$0B,$0B,$0A,$0A,$09,$09,$08 
      DC.B      $08,$07,$07,$06,$06,$05,$05,$04 
      DC.B      $04,$03,$03,$02,$02,$01,$01,$01 
      DC.B      $01,$01,$01,$02,$02,$03,$03,$04 
      DC.B      $04,$05,$05,$06,$06,$07,$07,$08 
      DC.B      $08,$09,$09,$0A,$0A,$0B,$0B,$0C 
      DC.B      $0C,$0D,$0D,$0E,$0E,$0F,$0F,$0F 
      DC.B      $0F,$0E,$0E,$0D,$0D,$0C,$0C,$0B 
      DC.B      $0B,$0A,$0A,$09,$09,$08,$08,$07 
      DC.B      $07,$06,$06,$05,$05,$04,$04,$03 
      DC.B      $03,$02,$02,$01,$01,$01,$01,$01 
      DC.B      $01,$02,$02,$03,$03,$04,$04,$05 
      DC.B      $05,$06,$06,$07,$07,$08,$08,$09 
      DC.B      $09,$0A,$0A,$0B,$0B,$0C,$0C,$0D 
      DC.B      $0D,$0E,$0E,$0F,$0F,$0F,$0F,$0E 
      DC.B      $0E,$0D,$0D,$0C,$0C,$0B,$0B,$0A 
      DC.B      $0A,$09,$09,$08,$08,$07,$07,$06 
      DC.B      $06,$05,$05,$04,$04,$03,$03,$02 
      DC.B      $02,$01,$01,$01,$01,$02,$02,$01 
L0034:DC.B      $00,$19,$00,$4B,$00,$7E,$00,$B0 
      DC.B      $00,$E2,$01,$14,$01,$47,$01,$79 
      DC.B      $01,$AB,$01,$DD,$02,$10,$02,$42 
      DC.B      $02,$74,$02,$A6,$02,$D9,$03,$0B 
      DC.B      $03,$3D,$03,$6F,$03,$A1,$03,$D4 
      DC.B      $04,$06,$04,$38,$04,$6A,$04,$9C 
      DC.B      $04,$CE,$05,$00,$05,$33,$05,$65 
      DC.B      $05,$97,$05,$C9,$05,$FB,$06,$2D 
      DC.B      $06,$5F,$06,$91,$06,$C3,$06,$F5 
      DC.B      $07,$27,$07,$59,$07,$8B,$07,$BD 
      DC.B      $07,$EE,$08,$20,$08,$52,$08,$84 
      DC.B      $08,$B6,$08,$E8,$09,$19,$09,$4B 
      DC.B      $09,$7D,$09,$AF,$09,$E0,$0A,$12 
      DC.B      $0A,$43,$0A,$75,$0A,$A7,$0A,$D8 
      DC.B      $0B,$0A,$0B,$3B,$0B,$6D,$0B,$9E 
      DC.B      $0B,$D0,$0C,$01,$0C,$32,$0C,$64 
      DC.B      $0C,$95,$0C,$C6,$0C,$F7,$0D,$29 
      DC.B      $0D,$5A,$0D,$8B,$0D,$BC,$0D,$ED 
      DC.B      $0E,$1E,$0E,$4F,$0E,$80,$0E,$B1 
      DC.B      $0E,$E2,$0F,$13,$0F,$44,$0F,$74 
      DC.B      $0F,$A5,$0F,$D6,$10,$07,$10,$37 
      DC.B      $10,$68,$10,$98,$10,$C9,$10,$F9 
      DC.B      $11,$2A,$11,$5A,$11,$8B,$11,$BB 
      DC.B      $11,$EB,$12,$1B,$12,$4C,$12,$7C 
      DC.B      $12,$AC,$12,$DC,$13,$0C,$13,$3C 
      DC.B      $13,$6C,$13,$9C,$13,$CC,$13,$FB 
      DC.B      $14,$2B,$14,$5B,$14,$8A,$14,$BA 
      DC.B      $14,$E9,$15,$19,$15,$48,$15,$78 
      DC.B      $15,$A7,$15,$D6,$16,$06,$16,$35 
      DC.B      $16,$64,$16,$93,$16,$C2,$16,$F1 
      DC.B      $17,$20,$17,$4F,$17,$7D,$17,$AC 
      DC.B      $17,$DB,$18,$09,$18,$38,$18,$66 
      DC.B      $18,$95,$18,$C3,$18,$F2,$19,$20 
      DC.B      $19,$4E,$19,$7C,$19,$AA,$19,$D8 
      DC.B      $1A,$06,$1A,$34,$1A,$62,$1A,$90 
      DC.B      $1A,$BD,$1A,$EB,$1B,$19,$1B,$46 
      DC.B      $1B,$74,$1B,$A1,$1B,$CE,$1B,$FB 
      DC.B      $1C,$29,$1C,$56,$1C,$83,$1C,$B0 
      DC.B      $1C,$DD,$1D,$09,$1D,$36,$1D,$63 
      DC.B      $1D,$90,$1D,$BC,$1D,$E9,$1E,$15 
      DC.B      $1E,$41,$1E,$6E,$1E,$9A,$1E,$C6 
      DC.B      $1E,$F2,$1F,$1E,$1F,$4A,$1F,$76 
      DC.B      $1F,$A1,$1F,$CD,$1F,$F8,$20,$24 
      DC.B      $20,$4F,$20,$7B,$20,$A6,$20,$D1 
      DC.B      $20,$FC,$21,$27,$21,$52,$21,$7D 
      DC.B      $21,$A8,$21,$D3,$21,$FD,$22,$28 
      DC.B      $22,$52,$22,$7D,$22,$A7,$22,$D1 
      DC.B      $22,$FB,$23,$25,$23,$4F,$23,$79 
      DC.B      $23,$A3,$23,$CD,$23,$F6,$24,$20 
      DC.B      $24,$49,$24,$73,$24,$9C,$24,$C5 
      DC.B      $24,$EE,$25,$17,$25,$40,$25,$69 
      DC.B      $25,$92,$25,$BA,$25,$E3,$26,$0B 
      DC.B      $26,$34,$26,$5C,$26,$84,$26,$AC 
      DC.B      $26,$D4,$26,$FC,$27,$24,$27,$4C 
      DC.B      $27,$73,$27,$9B,$27,$C2,$27,$EA 
      DC.B      $28,$11,$28,$38,$28,$5F,$28,$86 
      DC.B      $28,$AD,$28,$D4,$28,$FA,$29,$21 
      DC.B      $29,$47,$29,$6E,$29,$94,$29,$BA 
      DC.B      $29,$E0,$2A,$06,$2A,$2C,$2A,$52 
      DC.B      $2A,$78,$2A,$9D,$2A,$C3,$2A,$E8 
      DC.B      $2B,$0D,$2B,$32,$2B,$57,$2B,$7C 
      DC.B      $2B,$A1,$2B,$C6,$2B,$EA,$2C,$0F 
      DC.B      $2C,$33,$2C,$58,$2C,$7C,$2C,$A0 
      DC.B      $2C,$C4,$2C,$E8,$2D,$0B,$2D,$2F 
      DC.B      $2D,$53,$2D,$76,$2D,$99,$2D,$BD 
      DC.B      $2D,$E0,$2E,$03,$2E,$26,$2E,$48 
      DC.B      $2E,$6B,$2E,$8E,$2E,$B0,$2E,$D2 
      DC.B      $2E,$F5,$2F,$17,$2F,$39,$2F,$5A 
      DC.B      $2F,$7C,$2F,$9E,$2F,$BF,$2F,$E1 
      DC.B      $30,$02,$30,$23,$30,$44,$30,$65 
      DC.B      $30,$86,$30,$A7,$30,$C7,$30,$E8 
      DC.B      $31,$08,$31,$29,$31,$49,$31,$69 
      DC.B      $31,$89,$31,$A8,$31,$C8,$31,$E7 
      DC.B      $32,$07,$32,$26,$32,$45,$32,$64 
      DC.B      $32,$83,$32,$A2,$32,$C1,$32,$DF 
      DC.B      $32,$FE,$33,$1C,$33,$3A,$33,$58 
      DC.B      $33,$76,$33,$94,$33,$B2,$33,$CF 
      DC.B      $33,$ED,$34,$0A,$34,$27,$34,$44 
      DC.B      $34,$61,$34,$7E,$34,$9B,$34,$B7 
      DC.B      $34,$D4,$34,$F0,$35,$0C,$35,$28 
      DC.B      $35,$44,$35,$60,$35,$7C,$35,$97 
      DC.B      $35,$B3,$35,$CE,$35,$E9,$36,$04 
      DC.B      $36,$1F,$36,$3A,$36,$54,$36,$6F 
      DC.B      $36,$89,$36,$A4,$36,$BE,$36,$D8 
      DC.B      $36,$F2,$37,$0B,$37,$25,$37,$3E 
      DC.B      $37,$58,$37,$71,$37,$8A,$37,$A3 
      DC.B      $37,$BB,$37,$D4,$37,$ED,$38,$05 
      DC.B      $38,$1D,$38,$35,$38,$4D,$38,$65 
      DC.B      $38,$7D,$38,$94,$38,$AC,$38,$C3 
      DC.B      $38,$DA,$38,$F1,$39,$08,$39,$1F 
      DC.B      $39,$35,$39,$4C,$39,$62,$39,$78 
      DC.B      $39,$8E,$39,$A4,$39,$BA,$39,$D0 
      DC.B      $39,$E5,$39,$FB,$3A,$10,$3A,$25 
      DC.B      $3A,$3A,$3A,$4F,$3A,$63,$3A,$78 
      DC.B      $3A,$8C,$3A,$A0,$3A,$B4,$3A,$C8 
      DC.B      $3A,$DC,$3A,$F0,$3B,$03,$3B,$17 
      DC.B      $3B,$2A,$3B,$3D,$3B,$50,$3B,$63 
      DC.B      $3B,$75,$3B,$88,$3B,$9A,$3B,$AD 
      DC.B      $3B,$BF,$3B,$D1,$3B,$E2,$3B,$F4 
      DC.B      $3C,$06,$3C,$17,$3C,$28,$3C,$39 
      DC.B      $3C,$4A,$3C,$5B,$3C,$6C,$3C,$7C 
      DC.B      $3C,$8D,$3C,$9D,$3C,$AD,$3C,$BD 
      DC.B      $3C,$CC,$3C,$DC,$3C,$EC,$3C,$FB 
      DC.B      $3D,$0A,$3D,$19,$3D,$28,$3D,$37 
      DC.B      $3D,$45,$3D,$54,$3D,$62,$3D,$70 
      DC.B      $3D,$7E,$3D,$8C,$3D,$9A,$3D,$A7 
      DC.B      $3D,$B5,$3D,$C2,$3D,$CF,$3D,$DC 
      DC.B      $3D,$E9,$3D,$F6,$3E,$02,$3E,$0E 
      DC.B      $3E,$1B,$3E,$27,$3E,$33,$3E,$3E 
      DC.B      $3E,$4A,$3E,$55,$3E,$61,$3E,$6C 
      DC.B      $3E,$77,$3E,$82,$3E,$8C,$3E,$97 
      DC.B      $3E,$A1,$3E,$AC,$3E,$B6,$3E,$C0 
      DC.B      $3E,$CA,$3E,$D3,$3E,$DD,$3E,$E6 
      DC.B      $3E,$EF,$3E,$F8,$3F,$01,$3F,$0A 
      DC.B      $3F,$13,$3F,$1B,$3F,$23,$3F,$2B 
      DC.B      $3F,$33,$3F,$3B,$3F,$43,$3F,$4A 
      DC.B      $3F,$52,$3F,$59,$3F,$60,$3F,$67 
      DC.B      $3F,$6E,$3F,$74,$3F,$7B,$3F,$81 
      DC.B      $3F,$87,$3F,$8D,$3F,$93,$3F,$99 
      DC.B      $3F,$9E,$3F,$A4,$3F,$A9,$3F,$AE 
      DC.B      $3F,$B3,$3F,$B8,$3F,$BC,$3F,$C1 
      DC.B      $3F,$C5,$3F,$C9,$3F,$CD,$3F,$D1 
      DC.B      $3F,$D5,$3F,$D8,$3F,$DC,$3F,$DF 
      DC.B      $3F,$E2,$3F,$E5,$3F,$E8,$3F,$EB 
      DC.B      $3F,$ED,$3F,$EF,$3F,$F1,$3F,$F3 
      DC.B      $3F,$F5,$3F,$F7,$3F,$F9,$3F,$FA 
      DC.B      $3F,$FB,$3F,$FC,$3F,$FD,$3F,$FE 
      DC.B      $3F,$FF,$3F,$FF,$3F,$FF,$3F,$FF 
      DC.B      $3F,$FF,$3F,$FF,$3F,$FF,$3F,$FF 
      DC.B      $3F,$FE,$3F,$FD,$3F,$FC,$3F,$FB 
      DC.B      $3F,$FA,$3F,$F9,$3F,$F7,$3F,$F5 
      DC.B      $3F,$F3,$3F,$F1,$3F,$EF,$3F,$ED 
      DC.B      $3F,$EB,$3F,$E8,$3F,$E5,$3F,$E2 
      DC.B      $3F,$DF,$3F,$DC,$3F,$D8,$3F,$D5 
      DC.B      $3F,$D1,$3F,$CD,$3F,$C9,$3F,$C5 
      DC.B      $3F,$C1,$3F,$BC,$3F,$B8,$3F,$B3 
      DC.B      $3F,$AE,$3F,$A9,$3F,$A4,$3F,$9E 
      DC.B      $3F,$99,$3F,$93,$3F,$8D,$3F,$87 
      DC.B      $3F,$81,$3F,$7B,$3F,$74,$3F,$6E 
      DC.B      $3F,$67,$3F,$60,$3F,$59,$3F,$52 
      DC.B      $3F,$4A,$3F,$43,$3F,$3B,$3F,$33 
      DC.B      $3F,$2B,$3F,$23,$3F,$1B,$3F,$13 
      DC.B      $3F,$0A,$3F,$01,$3E,$F8,$3E,$EF 
      DC.B      $3E,$E6,$3E,$DD,$3E,$D3,$3E,$CA 
      DC.B      $3E,$C0,$3E,$B6,$3E,$AC,$3E,$A1 
      DC.B      $3E,$97,$3E,$8C,$3E,$82,$3E,$77 
      DC.B      $3E,$6C,$3E,$61,$3E,$55,$3E,$4A 
      DC.B      $3E,$3E,$3E,$33,$3E,$27,$3E,$1B 
      DC.B      $3E,$0E,$3E,$02,$3D,$F6,$3D,$E9 
      DC.B      $3D,$DC,$3D,$CF,$3D,$C2,$3D,$B5 
      DC.B      $3D,$A7,$3D,$9A,$3D,$8C,$3D,$7E 
      DC.B      $3D,$70,$3D,$62,$3D,$54,$3D,$45 
      DC.B      $3D,$37,$3D,$28,$3D,$19,$3D,$0A 
      DC.B      $3C,$FB,$3C,$EC,$3C,$DC,$3C,$CC 
      DC.B      $3C,$BD,$3C,$AD,$3C,$9D,$3C,$8D 
      DC.B      $3C,$7C,$3C,$6C,$3C,$5B,$3C,$4A 
      DC.B      $3C,$39,$3C,$28,$3C,$17,$3C,$06 
      DC.B      $3B,$F4,$3B,$E2,$3B,$D1,$3B,$BF 
      DC.B      $3B,$AD,$3B,$9A,$3B,$88,$3B,$75 
      DC.B      $3B,$63,$3B,$50,$3B,$3D,$3B,$2A 
      DC.B      $3B,$17,$3B,$03,$3A,$F0,$3A,$DC 
      DC.B      $3A,$C8,$3A,$B4,$3A,$A0,$3A,$8C 
      DC.B      $3A,$78,$3A,$63,$3A,$4F,$3A,$3A 
      DC.B      $3A,$25,$3A,$10,$39,$FB,$39,$E5 
      DC.B      $39,$D0,$39,$BA,$39,$A4,$39,$8E 
      DC.B      $39,$78,$39,$62,$39,$4C,$39,$35 
      DC.B      $39,$1F,$39,$08,$38,$F1,$38,$DA 
      DC.B      $38,$C3,$38,$AC,$38,$94,$38,$7D 
      DC.B      $38,$65,$38,$4D,$38,$35,$38,$1D 
      DC.B      $38,$05,$37,$ED,$37,$D4,$37,$BB 
      DC.B      $37,$A3,$37,$8A,$37,$71,$37,$58 
      DC.B      $37,$3E,$37,$25,$37,$0B,$36,$F2 
      DC.B      $36,$D8,$36,$BE,$36,$A4,$36,$89 
      DC.B      $36,$6F,$36,$54,$36,$3A,$36,$1F 
      DC.B      $36,$04,$35,$E9,$35,$CE,$35,$B3 
      DC.B      $35,$97,$35,$7C,$35,$60,$35,$44 
      DC.B      $35,$28,$35,$0C,$34,$F0,$34,$D4 
      DC.B      $34,$B7,$34,$9B,$34,$7E,$34,$61 
      DC.B      $34,$44,$34,$27,$34,$0A,$33,$ED 
      DC.B      $33,$CF,$33,$B2,$33,$94,$33,$76 
      DC.B      $33,$58,$33,$3A,$33,$1C,$32,$FE 
      DC.B      $32,$DF,$32,$C1,$32,$A2,$32,$83 
      DC.B      $32,$64,$32,$45,$32,$26,$32,$07 
      DC.B      $31,$E7,$31,$C8,$31,$A8,$31,$89 
      DC.B      $31,$69,$31,$49,$31,$29,$31,$08 
      DC.B      $30,$E8,$30,$C7,$30,$A7,$30,$86 
      DC.B      $30,$65,$30,$44,$30,$23,$30,$02 
      DC.B      $2F,$E1,$2F,$BF,$2F,$9E,$2F,$7C 
      DC.B      $2F,$5A,$2F,$39,$2F,$17,$2E,$F5 
      DC.B      $2E,$D2,$2E,$B0,$2E,$8E,$2E,$6B 
      DC.B      $2E,$48,$2E,$26,$2E,$03,$2D,$E0 
      DC.B      $2D,$BD,$2D,$99,$2D,$76,$2D,$53 
      DC.B      $2D,$2F,$2D,$0B,$2C,$E8,$2C,$C4 
      DC.B      $2C,$A0,$2C,$7C,$2C,$58,$2C,$33 
      DC.B      $2C,$0F,$2B,$EA,$2B,$C6,$2B,$A1 
      DC.B      $2B,$7C,$2B,$57,$2B,$32,$2B,$0D 
      DC.B      $2A,$E8,$2A,$C3,$2A,$9D,$2A,$78 
      DC.B      $2A,$52,$2A,$2C,$2A,$06,$29,$E0 
      DC.B      $29,$BA,$29,$94,$29,$6E,$29,$47 
      DC.B      $29,$21,$28,$FA,$28,$D4,$28,$AD 
      DC.B      $28,$86,$28,$5F,$28,$38,$28,$11 
      DC.B      $27,$EA,$27,$C2,$27,$9B,$27,$73 
      DC.B      $27,$4C,$27,$24,$26,$FC,$26,$D4 
      DC.B      $26,$AC,$26,$84,$26,$5C,$26,$34 
      DC.B      $26,$0B,$25,$E3,$25,$BA,$25,$92 
      DC.B      $25,$69,$25,$40,$25,$17,$24,$EE 
      DC.B      $24,$C5,$24,$9C,$24,$73,$24,$49 
      DC.B      $24,$20,$23,$F6,$23,$CD,$23,$A3 
      DC.B      $23,$79,$23,$4F,$23,$25,$22,$FB 
      DC.B      $22,$D1,$22,$A7,$22,$7D,$22,$52 
      DC.B      $22,$28,$21,$FD,$21,$D3,$21,$A8 
      DC.B      $21,$7D,$21,$52,$21,$27,$20,$FC 
      DC.B      $20,$D1,$20,$A6,$20,$7B,$20,$4F 
      DC.B      $20,$24,$1F,$F8,$1F,$CD,$1F,$A1 
      DC.B      $1F,$76,$1F,$4A,$1F,$1E,$1E,$F2 
      DC.B      $1E,$C6,$1E,$9A,$1E,$6E,$1E,$41 
      DC.B      $1E,$15,$1D,$E9,$1D,$BC,$1D,$90 
      DC.B      $1D,$63,$1D,$36,$1D,$09,$1C,$DD 
      DC.B      $1C,$B0,$1C,$83,$1C,$56,$1C,$29 
      DC.B      $1B,$FB,$1B,$CE,$1B,$A1,$1B,$74 
      DC.B      $1B,$46,$1B,$19,$1A,$EB,$1A,$BD 
      DC.B      $1A,$90,$1A,$62,$1A,$34,$1A,$06 
      DC.B      $19,$D8,$19,$AA,$19,$7C,$19,$4E 
      DC.B      $19,$20,$18,$F2,$18,$C3,$18,$95 
      DC.B      $18,$66,$18,$38,$18,$09,$17,$DB 
      DC.B      $17,$AC,$17,$7D,$17,$4F,$17,$20 
      DC.B      $16,$F1,$16,$C2,$16,$93,$16,$64 
      DC.B      $16,$35,$16,$06,$15,$D6,$15,$A7 
      DC.B      $15,$78,$15,$48,$15,$19,$14,$E9 
      DC.B      $14,$BA,$14,$8A,$14,$5B,$14,$2B 
      DC.B      $13,$FB,$13,$CC,$13,$9C,$13,$6C 
      DC.B      $13,$3C,$13,$0C,$12,$DC,$12,$AC 
      DC.B      $12,$7C,$12,$4C,$12,$1B,$11,$EB 
      DC.B      $11,$BB,$11,$8B,$11,$5A,$11,$2A 
      DC.B      $10,$F9,$10,$C9,$10,$98,$10,$68 
      DC.B      $10,$37,$10,$07,$0F,$D6,$0F,$A5 
      DC.B      $0F,$74,$0F,$44,$0F,$13,$0E,$E2 
      DC.B      $0E,$B1,$0E,$80,$0E,$4F,$0E,$1E 
      DC.B      $0D,$ED,$0D,$BC,$0D,$8B,$0D,$5A 
      DC.B      $0D,$29,$0C,$F7,$0C,$C6,$0C,$95 
      DC.B      $0C,$64,$0C,$32,$0C,$01,$0B,$D0 
      DC.B      $0B,$9E,$0B,$6D,$0B,$3B,$0B,$0A 
      DC.B      $0A,$D8,$0A,$A7,$0A,$75,$0A,$43 
      DC.B      $0A,$12,$09,$E0,$09,$AF,$09,$7D 
      DC.B      $09,$4B,$09,$19,$08,$E8,$08,$B6 
      DC.B      $08,$84,$08,$52,$08,$20,$07,$EE 
      DC.B      $07,$BD,$07,$8B,$07,$59,$07,$27 
      DC.B      $06,$F5,$06,$C3,$06,$91,$06,$5F 
      DC.B      $06,$2D,$05,$FB,$05,$C9,$05,$97 
      DC.B      $05,$65,$05,$33,$05,$00,$04,$CE 
      DC.B      $04,$9C,$04,$6A,$04,$38,$04,$06 
      DC.B      $03,$D4,$03,$A1,$03,$6F,$03,$3D 
      DC.B      $03,$0B,$02,$D9,$02,$A6,$02,$74 
      DC.B      $02,$42,$02,$10,$01,$DD,$01,$AB 
      DC.B      $01,$79,$01,$47,$01,$14,$00,$E2 
      DC.B      $00,$B0,$00,$7E,$00,$4B,$00,$19 
      DC.B      $00,$E7,$00,$B5,$00,$82,$00,$50 
      DC.B      $00,$1E,$FF,$EC,$FF,$B9,$FF,$87 
      DC.B      $FF,$55,$FF,$23,$FE,$F0,$FE,$BE 
      DC.B      $FE,$8C,$FE,$5A,$FE,$27,$FD,$F5 
      DC.B      $FD,$C3,$FD,$91,$FD,$5F,$FD,$2C 
      DC.B      $FC,$FA,$FC,$C8,$FC,$96,$FC,$64 
      DC.B      $FC,$32,$FB,$00,$FB,$CD,$FB,$9B 
      DC.B      $FB,$69,$FB,$37,$FB,$05,$FA,$D3 
      DC.B      $FA,$A1,$FA,$6F,$FA,$3D,$FA,$0B 
      DC.B      $F9,$D9,$F9,$A7,$F9,$75,$F9,$43 
      DC.B      $F9,$12,$F8,$E0,$F8,$AE,$F8,$7C 
      DC.B      $F8,$4A,$F8,$18,$F7,$E7,$F7,$B5 
      DC.B      $F7,$83,$F7,$51,$F7,$20,$F6,$EE 
      DC.B      $F6,$BD,$F6,$8B,$F6,$59,$F6,$28 
      DC.B      $F5,$F6,$F5,$C5,$F5,$93,$F5,$62 
      DC.B      $F5,$30,$F4,$FF,$F4,$CE,$F4,$9C 
      DC.B      $F4,$6B,$F4,$3A,$F4,$09,$F3,$D7 
      DC.B      $F3,$A6,$F3,$75,$F3,$44,$F3,$13 
      DC.B      $F2,$E2,$F2,$B1,$F2,$80,$F2,$4F 
      DC.B      $F2,$1E,$F1,$ED,$F1,$BC,$F1,$8C 
      DC.B      $F1,$5B,$F1,$2A,$F0,$F9,$F0,$C9 
      DC.B      $F0,$98,$F0,$68,$F0,$37,$F0,$07 
      DC.B      $EF,$D6,$EF,$A6,$EF,$75,$EF,$45 
      DC.B      $EF,$15,$EE,$E5,$EE,$B4,$EE,$84 
      DC.B      $EE,$54,$EE,$24,$ED,$F4,$ED,$C4 
      DC.B      $ED,$94,$ED,$64,$ED,$34,$ED,$05 
      DC.B      $EC,$D5,$EC,$A5,$EC,$76,$EC,$46 
      DC.B      $EC,$17,$EB,$E7,$EB,$B8,$EB,$88 
      DC.B      $EB,$59,$EB,$2A,$EA,$FA,$EA,$CB 
      DC.B      $EA,$9C,$EA,$6D,$EA,$3E,$EA,$0F 
      DC.B      $E9,$E0,$E9,$B1,$E9,$83,$E9,$54 
      DC.B      $E9,$25,$E8,$F7,$E8,$C8,$E8,$9A 
      DC.B      $E8,$6B,$E8,$3D,$E8,$0E,$E7,$E0 
      DC.B      $E7,$B2,$E7,$84,$E7,$56,$E7,$28 
      DC.B      $E6,$FA,$E6,$CC,$E6,$9E,$E6,$70 
      DC.B      $E6,$43,$E6,$15,$E5,$E7,$E5,$BA 
      DC.B      $E5,$8C,$E5,$5F,$E5,$32,$E5,$05 
      DC.B      $E4,$D7,$E4,$AA,$E4,$7D,$E4,$50 
      DC.B      $E4,$23,$E3,$F7,$E3,$CA,$E3,$9D 
      DC.B      $E3,$70,$E3,$44,$E3,$17,$E2,$EB 
      DC.B      $E2,$BF,$E2,$92,$E2,$66,$E2,$3A 
      DC.B      $E2,$0E,$E1,$E2,$E1,$B6,$E1,$8A 
      DC.B      $E1,$5F,$E1,$33,$E1,$08,$E0,$DC 
      DC.B      $E0,$B1,$E0,$85,$E0,$5A,$E0,$2F 
      DC.B      $E0,$04,$DF,$D9,$DF,$AE,$DF,$83 
      DC.B      $DF,$58,$DF,$2D,$DF,$03,$DE,$D8 
      DC.B      $DE,$AE,$DE,$83,$DE,$59,$DE,$2F 
      DC.B      $DE,$05,$DD,$DB,$DD,$B1,$DD,$87 
      DC.B      $DD,$5D,$DD,$33,$DD,$0A,$DC,$E0 
      DC.B      $DC,$B7,$DC,$8D,$DC,$64,$DC,$3B 
      DC.B      $DC,$12,$DB,$E9,$DB,$C0,$DB,$97 
      DC.B      $DB,$6E,$DB,$46,$DB,$1D,$DA,$F5 
      DC.B      $DA,$CC,$DA,$A4,$DA,$7C,$DA,$54 
      DC.B      $DA,$2C,$DA,$04,$D9,$DC,$D9,$B4 
      DC.B      $D9,$8D,$D9,$65,$D9,$3E,$D9,$16 
      DC.B      $D8,$EF,$D8,$C8,$D8,$A1,$D8,$7A 
      DC.B      $D8,$53,$D8,$2C,$D8,$06,$D7,$DF 
      DC.B      $D7,$B9,$D7,$92,$D7,$6C,$D7,$46 
      DC.B      $D7,$20,$D6,$FA,$D6,$D4,$D6,$AE 
      DC.B      $D6,$88,$D6,$63,$D6,$3D,$D6,$18 
      DC.B      $D5,$F3,$D5,$CE,$D5,$A9,$D5,$84 
      DC.B      $D5,$5F,$D5,$3A,$D5,$16,$D4,$F1 
      DC.B      $D4,$CD,$D4,$A8,$D4,$84,$D4,$60 
      DC.B      $D4,$3C,$D4,$18,$D3,$F5,$D3,$D1 
      DC.B      $D3,$AD,$D3,$8A,$D3,$67,$D3,$43 
      DC.B      $D3,$20,$D2,$FD,$D2,$DA,$D2,$B8 
      DC.B      $D2,$95,$D2,$72,$D2,$50,$D2,$2E 
      DC.B      $D2,$0B,$D1,$E9,$D1,$C7,$D1,$A6 
      DC.B      $D1,$84,$D1,$62,$D1,$41,$D1,$1F 
      DC.B      $D0,$FE,$D0,$DD,$D0,$BC,$D0,$9B 
      DC.B      $D0,$7A,$D0,$59,$D0,$39,$D0,$18 
      DC.B      $CF,$F8,$CF,$D7,$CF,$B7,$CF,$97 
      DC.B      $CF,$77,$CF,$58,$CF,$38,$CF,$19 
      DC.B      $CE,$F9,$CE,$DA,$CE,$BB,$CE,$9C 
      DC.B      $CE,$7D,$CE,$5E,$CE,$3F,$CE,$21 
      DC.B      $CE,$02,$CD,$E4,$CD,$C6,$CD,$A8 
      DC.B      $CD,$8A,$CD,$6C,$CD,$4E,$CD,$31 
      DC.B      $CD,$13,$CC,$F6,$CC,$D9,$CC,$BC 
      DC.B      $CC,$9F,$CC,$82,$CC,$65,$CC,$49 
      DC.B      $CC,$2C,$CC,$10,$CB,$F4,$CB,$D8 
      DC.B      $CB,$BC,$CB,$A0,$CB,$84,$CB,$69 
      DC.B      $CB,$4D,$CB,$32,$CB,$17,$CA,$FC 
      DC.B      $CA,$E1,$CA,$C6,$CA,$AC,$CA,$91 
      DC.B      $CA,$77,$CA,$5C,$CA,$42,$CA,$28 
      DC.B      $CA,$0E,$C9,$F5,$C9,$DB,$C9,$C2 
      DC.B      $C9,$A8,$C9,$8F,$C9,$76,$C9,$5D 
      DC.B      $C9,$45,$C9,$2C,$C9,$13,$C8,$FB 
      DC.B      $C8,$E3,$C8,$CB,$C8,$B3,$C8,$9B 
      DC.B      $C8,$83,$C8,$6C,$C8,$54,$C8,$3D 
      DC.B      $C8,$26,$C8,$0F,$C7,$F8,$C7,$E1 
      DC.B      $C7,$CB,$C7,$B4,$C7,$9E,$C7,$88 
      DC.B      $C7,$72,$C7,$5C,$C7,$46,$C7,$30 
      DC.B      $C7,$1B,$C7,$05,$C6,$F0,$C6,$DB 
      DC.B      $C6,$C6,$C6,$B1,$C6,$9D,$C6,$88 
      DC.B      $C6,$74,$C6,$60,$C6,$4C,$C6,$38 
      DC.B      $C6,$24,$C6,$10,$C5,$FD,$C5,$E9 
      DC.B      $C5,$D6,$C5,$C3,$C5,$B0,$C5,$9D 
      DC.B      $C5,$8B,$C5,$78,$C5,$66,$C5,$53 
      DC.B      $C5,$41,$C5,$2F,$C5,$1E,$C5,$0C 
      DC.B      $C4,$FA,$C4,$E9,$C4,$D8,$C4,$C7 
      DC.B      $C4,$B6,$C4,$A5,$C4,$94,$C4,$84 
      DC.B      $C4,$73,$C4,$63,$C4,$53,$C4,$43 
      DC.B      $C4,$34,$C4,$24,$C4,$14,$C4,$05 
      DC.B      $C3,$F6,$C3,$E7,$C3,$D8,$C3,$C9 
      DC.B      $C3,$BB,$C3,$AC,$C3,$9E,$C3,$90 
      DC.B      $C3,$82,$C3,$74,$C3,$66,$C3,$59 
      DC.B      $C3,$4B,$C3,$3E,$C3,$31,$C3,$24 
      DC.B      $C3,$17,$C3,$0A,$C2,$FE,$C2,$F2 
      DC.B      $C2,$E5,$C2,$D9,$C2,$CD,$C2,$C2 
      DC.B      $C2,$B6,$C2,$AB,$C2,$9F,$C2,$94 
      DC.B      $C2,$89,$C2,$7E,$C2,$74,$C2,$69 
      DC.B      $C2,$5F,$C2,$54,$C2,$4A,$C2,$40 
      DC.B      $C2,$36,$C2,$2D,$C2,$23,$C2,$1A 
      DC.B      $C2,$11,$C2,$08,$C1,$FF,$C1,$F6 
      DC.B      $C1,$ED,$C1,$E5,$C1,$DD,$C1,$D5 
      DC.B      $C1,$CD,$C1,$C5,$C1,$BD,$C1,$B6 
      DC.B      $C1,$AE,$C1,$A7,$C1,$A0,$C1,$99 
      DC.B      $C1,$92,$C1,$8C,$C1,$85,$C1,$7F 
      DC.B      $C1,$79,$C1,$73,$C1,$6D,$C1,$67 
      DC.B      $C1,$62,$C1,$5C,$C1,$57,$C1,$52 
      DC.B      $C1,$4D,$C1,$48,$C1,$44,$C1,$3F 
      DC.B      $C1,$3B,$C1,$37,$C1,$33,$C1,$2F 
      DC.B      $C1,$2B,$C1,$28,$C1,$24,$C1,$21 
      DC.B      $C1,$1E,$C1,$1B,$C1,$18,$C1,$15 
      DC.B      $C1,$13,$C1,$11,$C1,$0F,$C1,$0D 
      DC.B      $C1,$0B,$C1,$09,$C1,$07,$C1,$06 
      DC.B      $C1,$05,$C1,$04,$C1,$03,$C1,$02 
      DC.B      $C1,$01,$C1,$01,$C1,$01,$C1,$01 
      DC.B      $C1,$01,$C1,$01,$C1,$01,$C1,$01 
      DC.B      $C1,$02,$C1,$03,$C1,$04,$C1,$05 
      DC.B      $C1,$06,$C1,$07,$C1,$09,$C1,$0B 
      DC.B      $C1,$0D,$C1,$0F,$C1,$11,$C1,$13 
      DC.B      $C1,$15,$C1,$18,$C1,$1B,$C1,$1E 
      DC.B      $C1,$21,$C1,$24,$C1,$28,$C1,$2B 
      DC.B      $C1,$2F,$C1,$33,$C1,$37,$C1,$3B 
      DC.B      $C1,$3F,$C1,$44,$C1,$48,$C1,$4D 
      DC.B      $C1,$52,$C1,$57,$C1,$5C,$C1,$62 
      DC.B      $C1,$67,$C1,$6D,$C1,$73,$C1,$79 
      DC.B      $C1,$7F,$C1,$85,$C1,$8C,$C1,$92 
      DC.B      $C1,$99,$C1,$A0,$C1,$A7,$C1,$AE 
      DC.B      $C1,$B6,$C1,$BD,$C1,$C5,$C1,$CD 
      DC.B      $C1,$D5,$C1,$DD,$C1,$E5,$C1,$ED 
      DC.B      $C1,$F6,$C1,$FF,$C2,$08,$C2,$11 
      DC.B      $C2,$1A,$C2,$23,$C2,$2D,$C2,$36 
      DC.B      $C2,$40,$C2,$4A,$C2,$54,$C2,$5F 
      DC.B      $C2,$69,$C2,$74,$C2,$7E,$C2,$89 
      DC.B      $C2,$94,$C2,$9F,$C2,$AB,$C2,$B6 
      DC.B      $C2,$C2,$C2,$CD,$C2,$D9,$C2,$E5 
      DC.B      $C2,$F2,$C2,$FE,$C3,$0A,$C3,$17 
      DC.B      $C3,$24,$C3,$31,$C3,$3E,$C3,$4B 
      DC.B      $C3,$59,$C3,$66,$C3,$74,$C3,$82 
      DC.B      $C3,$90,$C3,$9E,$C3,$AC,$C3,$BB 
      DC.B      $C3,$C9,$C3,$D8,$C3,$E7,$C3,$F6 
      DC.B      $C4,$05,$C4,$14,$C4,$24,$C4,$34 
      DC.B      $C4,$43,$C4,$53,$C4,$63,$C4,$73 
      DC.B      $C4,$84,$C4,$94,$C4,$A5,$C4,$B6 
      DC.B      $C4,$C7,$C4,$D8,$C4,$E9,$C4,$FA 
      DC.B      $C5,$0C,$C5,$1E,$C5,$2F,$C5,$41 
      DC.B      $C5,$53,$C5,$66,$C5,$78,$C5,$8B 
      DC.B      $C5,$9D,$C5,$B0,$C5,$C3,$C5,$D6 
      DC.B      $C5,$E9,$C5,$FD,$C6,$10,$C6,$24 
      DC.B      $C6,$38,$C6,$4C,$C6,$60,$C6,$74 
      DC.B      $C6,$88,$C6,$9D,$C6,$B1,$C6,$C6 
      DC.B      $C6,$DB,$C6,$F0,$C7,$05,$C7,$1B 
      DC.B      $C7,$30,$C7,$46,$C7,$5C,$C7,$72 
      DC.B      $C7,$88,$C7,$9E,$C7,$B4,$C7,$CB 
      DC.B      $C7,$E1,$C7,$F8,$C8,$0F,$C8,$26 
      DC.B      $C8,$3D,$C8,$54,$C8,$6C,$C8,$83 
      DC.B      $C8,$9B,$C8,$B3,$C8,$CB,$C8,$E3 
      DC.B      $C8,$FB,$C9,$13,$C9,$2C,$C9,$45 
      DC.B      $C9,$5D,$C9,$76,$C9,$8F,$C9,$A8 
      DC.B      $C9,$C2,$C9,$DB,$C9,$F5,$CA,$0E 
      DC.B      $CA,$28,$CA,$42,$CA,$5C,$CA,$77 
      DC.B      $CA,$91,$CA,$AC,$CA,$C6,$CA,$E1 
      DC.B      $CA,$FC,$CB,$17,$CB,$32,$CB,$4D 
      DC.B      $CB,$69,$CB,$84,$CB,$A0,$CB,$BC 
      DC.B      $CB,$D8,$CB,$F4,$CC,$10,$CC,$2C 
      DC.B      $CC,$49,$CC,$65,$CC,$82,$CC,$9F 
      DC.B      $CC,$BC,$CC,$D9,$CC,$F6,$CD,$13 
      DC.B      $CD,$31,$CD,$4E,$CD,$6C,$CD,$8A 
      DC.B      $CD,$A8,$CD,$C6,$CD,$E4,$CE,$02 
      DC.B      $CE,$21,$CE,$3F,$CE,$5E,$CE,$7D 
      DC.B      $CE,$9C,$CE,$BB,$CE,$DA,$CE,$F9 
      DC.B      $CF,$19,$CF,$38,$CF,$58,$CF,$77 
      DC.B      $CF,$97,$CF,$B7,$CF,$D7,$CF,$F8 
      DC.B      $D0,$18,$D0,$39,$D0,$59,$D0,$7A 
      DC.B      $D0,$9B,$D0,$BC,$D0,$DD,$D0,$FE 
      DC.B      $D1,$1F,$D1,$41,$D1,$62,$D1,$84 
      DC.B      $D1,$A6,$D1,$C7,$D1,$E9,$D2,$0B 
      DC.B      $D2,$2E,$D2,$50,$D2,$72,$D2,$95 
      DC.B      $D2,$B8,$D2,$DA,$D2,$FD,$D3,$20 
      DC.B      $D3,$43,$D3,$67,$D3,$8A,$D3,$AD 
      DC.B      $D3,$D1,$D3,$F5,$D4,$18,$D4,$3C 
      DC.B      $D4,$60,$D4,$84,$D4,$A8,$D4,$CD 
      DC.B      $D4,$F1,$D5,$16,$D5,$3A,$D5,$5F 
      DC.B      $D5,$84,$D5,$A9,$D5,$CE,$D5,$F3 
      DC.B      $D6,$18,$D6,$3D,$D6,$63,$D6,$88 
      DC.B      $D6,$AE,$D6,$D4,$D6,$FA,$D7,$20 
      DC.B      $D7,$46,$D7,$6C,$D7,$92,$D7,$B9 
      DC.B      $D7,$DF,$D8,$06,$D8,$2C,$D8,$53 
      DC.B      $D8,$7A,$D8,$A1,$D8,$C8,$D8,$EF 
      DC.B      $D9,$16,$D9,$3E,$D9,$65,$D9,$8D 
      DC.B      $D9,$B4,$D9,$DC,$DA,$04,$DA,$2C 
      DC.B      $DA,$54,$DA,$7C,$DA,$A4,$DA,$CC 
      DC.B      $DA,$F5,$DB,$1D,$DB,$46,$DB,$6E 
      DC.B      $DB,$97,$DB,$C0,$DB,$E9,$DC,$12 
      DC.B      $DC,$3B,$DC,$64,$DC,$8D,$DC,$B7 
      DC.B      $DC,$E0,$DD,$0A,$DD,$33,$DD,$5D 
      DC.B      $DD,$87,$DD,$B1,$DD,$DB,$DE,$05 
      DC.B      $DE,$2F,$DE,$59,$DE,$83,$DE,$AE 
      DC.B      $DE,$D8,$DF,$03,$DF,$2D,$DF,$58 
      DC.B      $DF,$83,$DF,$AE,$DF,$D9,$E0,$04 
      DC.B      $E0,$2F,$E0,$5A,$E0,$85,$E0,$B1 
      DC.B      $E0,$DC,$E1,$08,$E1,$33,$E1,$5F 
      DC.B      $E1,$8A,$E1,$B6,$E1,$E2,$E2,$0E 
      DC.B      $E2,$3A,$E2,$66,$E2,$92,$E2,$BF 
      DC.B      $E2,$EB,$E3,$17,$E3,$44,$E3,$70 
      DC.B      $E3,$9D,$E3,$CA,$E3,$F7,$E4,$23 
      DC.B      $E4,$50,$E4,$7D,$E4,$AA,$E4,$D7 
      DC.B      $E5,$05,$E5,$32,$E5,$5F,$E5,$8C 
      DC.B      $E5,$BA,$E5,$E7,$E6,$15,$E6,$43 
      DC.B      $E6,$70,$E6,$9E,$E6,$CC,$E6,$FA 
      DC.B      $E7,$28,$E7,$56,$E7,$84,$E7,$B2 
      DC.B      $E7,$E0,$E8,$0E,$E8,$3D,$E8,$6B 
      DC.B      $E8,$9A,$E8,$C8,$E8,$F7,$E9,$25 
      DC.B      $E9,$54,$E9,$83,$E9,$B1,$E9,$E0 
      DC.B      $EA,$0F,$EA,$3E,$EA,$6D,$EA,$9C 
      DC.B      $EA,$CB,$EA,$FA,$EB,$2A,$EB,$59 
      DC.B      $EB,$88,$EB,$B8,$EB,$E7,$EC,$17 
      DC.B      $EC,$46,$EC,$76,$EC,$A5,$EC,$D5 
      DC.B      $ED,$05,$ED,$34,$ED,$64,$ED,$94 
      DC.B      $ED,$C4,$ED,$F4,$EE,$24,$EE,$54 
      DC.B      $EE,$84,$EE,$B4,$EE,$E5,$EF,$15 
      DC.B      $EF,$45,$EF,$75,$EF,$A6,$EF,$D6 
      DC.B      $F0,$07,$F0,$37,$F0,$68,$F0,$98 
      DC.B      $F0,$C9,$F0,$F9,$F1,$2A,$F1,$5B 
      DC.B      $F1,$8C,$F1,$BC,$F1,$ED,$F2,$1E 
      DC.B      $F2,$4F,$F2,$80,$F2,$B1,$F2,$E2 
      DC.B      $F3,$13,$F3,$44,$F3,$75,$F3,$A6 
      DC.B      $F3,$D7,$F4,$09,$F4,$3A,$F4,$6B 
      DC.B      $F4,$9C,$F4,$CE,$F4,$FF,$F5,$30 
      DC.B      $F5,$62,$F5,$93,$F5,$C5,$F5,$F6 
      DC.B      $F6,$28,$F6,$59,$F6,$8B,$F6,$BD 
      DC.B      $F6,$EE,$F7,$20,$F7,$51,$F7,$83 
      DC.B      $F7,$B5,$F7,$E7,$F8,$18,$F8,$4A 
      DC.B      $F8,$7C,$F8,$AE,$F8,$E0,$F9,$12 
      DC.B      $F9,$43,$F9,$75,$F9,$A7,$F9,$D9 
      DC.B      $FA,$0B,$FA,$3D,$FA,$6F,$FA,$A1 
      DC.B      $FA,$D3,$FB,$05,$FB,$37,$FB,$69 
      DC.B      $FB,$9B,$FB,$CD,$FB,$00,$FC,$32 
      DC.B      $FC,$64,$FC,$96,$FC,$C8,$FC,$FA 
      DC.B      $FD,$2C,$FD,$5F,$FD,$91,$FD,$C3
      DC.B      $FD,$F5,$FE,$27,$FE,$5A,$FE,$8C 
      DC.B      $FE,$BE,$FE,$F0,$FF,$23,$FF,$55 
      DC.B      $FF,$87,$FF,$B9,$FF,$EC,$00,$1E 
      DC.B      $00,$50,$00,$82,$00,$B5,$00,$E7 
 BSS
gloky_step:	ds.w	1
gloky_fade:	ds.w	3
L0035:DS.B      6
L0036:DS.B      6 
L0037:DS.B      12
L0038:DS.L      1 
L0039:DS.L      1 
L003A:DS.B      32
L003B:DS.W      1 
L003C:DS.B      272
L003E:DS.B      1280
L003F:DS.L      1 
L0040:DS.L      1 
L0041:DS.B      6144
L0042:DS.B      12288
L0043:DS.B      12288 
L0044:DS.B      8192
L0045:DS.B      12288
L0046:DS.B      12288 
L0047:DS.B      8192
L0048:DS.B      16
L0049:DS.B      2048
L004A:DS.B      2048
L004B:DS.B      4096
L004C:DS.W      1 
L004D:DS.L      1 
L004E:DS.L      1 
L004F:DS.B      18436
L0050:DS.B      27348 

