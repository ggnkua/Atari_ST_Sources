;tbl4000.s
sinsinsin4000:
		dc.w 0,507,1015,1523,2030,2537,3042,3548
		dc.w 4052,4555,5057,5557,6056,6554,7049,7543
		dc.w 8035,8525,9012,9497,9980,10460,10937,11411
		dc.w 11882,12351,12815,13277,13735,14190,14641,15088
		dc.w 15531,15970,16405,16836,17262,17684,18102,18515
		dc.w 18923,19326,19725,20119,20507,20890,21269,21642
		dc.w 22009,22371,22728,23079,23424,23763,24097,24425
		dc.w 24747,25063,25373,25677,25975,26267,26553,26832
		dc.w 27105,27372,27633,27887,28134,28376,28610,28839
		dc.w 29061,29276,29485,29687,29883,30072,30255,30431
		dc.w 30601,30764,30921,31071,31214,31351,31481,31605
		dc.w 31723,31834,31939,32037,32129,32214,32294,32366
		dc.w 32433,32494,32548,32596,32638,32674,32704,32728
		dc.w 32746,32758,32764,32765,32760,32749,32733,32711
		dc.w 32683,32650,32612,32568,32520,32466,32406,32342
		dc.w 32273,32199,32120,32036,31948,31854,31757,31655
		dc.w 31548,31437,31322,31202,31079,30951,30819,30684
		dc.w 30544,30401,30254,30104,29950,29793,29632,29468
		dc.w 29301,29130,28957,28781,28601,28419,28234,28047
		dc.w 27857,27664,27469,27272,27072,26870,26666,26460
		dc.w 26252,26042,25830,25617,25401,25184,24966,24746
		dc.w 24525,24302,24078,23853,23627,23400,23171,22942
		dc.w 22712,22481,22250,22017,21784,21551,21317,21083
		dc.w 20848,20613,20378,20143,19907,19671,19436,19200
		dc.w 18965,18729,18494,18259,18024,17790,17556,17323
		dc.w 17090,16857,16625,16394,16164,15934,15704,15476
		dc.w 15249,15022,14796,14571,14348,14125,13903,13682
		dc.w 13463,13244,13027,12811,12597,12383,12171,11960
		dc.w 11751,11543,11336,11131,10927,10725,10524,10325
		dc.w 10128,9932,9737,9545,9353,9164,8976,8790
		dc.w 8606,8423,8243,8064,7886,7711,7537,7365
		dc.w 7195,7027,6861,6697,6534,6373,6215,6058
		dc.w 5903,5750,5599,5450,5303,5158,5015,4874
		dc.w 4735,4597,4462,4329,4198,4069,3942,3817
		dc.w 3693,3572,3453,3336,3221,3108,2998,2889
		dc.w 2782,2677,2574,2473,2375,2278,2184,2091
		dc.w 2000,1912,1826,1741,1659,1578,1500,1424
		dc.w 1350,1277,1207,1139,1073,1009,946,886
		dc.w 828,772,718,666,616,568,521,477
		dc.w 435,395,357,320,286,254,223,195
		dc.w 169,144,121,101,82,65,50,37
		dc.w 26,17,10,5,1,0,0,2
		dc.w 6,12,20,30,41,54,70,87
		dc.w 105,126,149,173,199,227,257,288
		dc.w 321,356,393,432,472,514,558,603
		dc.w 651,700,751,803,857,913,971,1030
		dc.w 1091,1153,1218,1284,1351,1420,1491,1564
		dc.w 1638,1713,1791,1870,1950,2032,2116,2201
		dc.w 2288,2376,2466,2557,2650,2745,2840,2938
		dc.w 3037,3137,3239,3342,3447,3553,3661,3770
		dc.w 3880,3992,4105,4220,4336,4453,4572,4692
		dc.w 4813,4935,5059,5185,5311,5439,5568,5698
		dc.w 5829,5962,6096,6231,6367,6504,6643,6782
		dc.w 6923,7065,7208,7352,7497,7643,7790,7938
		dc.w 8087,8237,8388,8540,8693,8847,9002,9158
		dc.w 9314,9472,9630,9789,9949,10110,10271,10434
		dc.w 10597,10760,10925,11090,11256,11422,11589,11757
		dc.w 11925,12094,12263,12433,12604,12775,12946,13118
		dc.w 13290,13463,13636,13810,13984,14158,14333,14507
		dc.w 14683,14858,15034,15210,15386,15562,15738,15915
		dc.w 16092,16268,16445,16622,16799,16976,17153,17330
		dc.w 17506,17683,17860,18036,18213,18389,18565,18741
		dc.w 18916,19092,19267,19441,19616,19790,19964,20137
		dc.w 20310,20482,20654,20826,20997,21168,21338,21507
		dc.w 21676,21845,22012,22179,22346,22511,22676,22841
		dc.w 23004,23167,23329,23490,23650,23810,23969,24126
		dc.w 24283,24439,24594,24748,24901,25053,25204,25354
		dc.w 25502,25650,25797,25942,26087,26230,26372,26513
		dc.w 26652,26791,26928,27064,27198,27331,27463,27594
		dc.w 27723,27851,27978,28103,28227,28349,28470,28590
		dc.w 28708,28824,28939,29053,29165,29275,29384,29491
		dc.w 29597,29701,29804,29905,30004,30102,30198,30292
		dc.w 30385,30476,30566,30653,30739,30824,30906,30987
		dc.w 31067,31144,31220,31294,31366,31436,31505,31572
		dc.w 31637,31700,31761,31821,31879,31935,31989,32042
		dc.w 32092,32141,32188,32233,32276,32318,32358,32395
		dc.w 32431,32465,32498,32528,32557,32583,32608,32631
		dc.w 32653,32672,32690,32705,32719,32731,32742,32750
		dc.w 32757,32761,32764,32765,32765,32762,32758,32752
		dc.w 32744,32735,32723,32710,32695,32679,32660,32640
		dc.w 32618,32594,32569,32542,32513,32483,32451,32417
		dc.w 32381,32344,32305,32265,32223,32179,32134,32087
		dc.w 32038,31988,31936,31883,31828,31772,31714,31654
		dc.w 31593,31531,31467,31401,31334,31266,31196,31125
		dc.w 31052,30978,30903,30826,30748,30669,30588,30506
		dc.w 30422,30337,30251,30164,30076,29986,29895,29803
		dc.w 29709,29614,29519,29422,29324,29225,29124,29023
		dc.w 28920,28817,28712,28606,28500,28392,28283,28174
		dc.w 28063,27952,27839,27726,27611,27496,27380,27263
		dc.w 27145,27027,26907,26787,26666,26544,26422,26299
		dc.w 26175,26050,25925,25799,25672,25545,25417,25288
		dc.w 25159,25029,24899,24768,24636,24504,24372,24239
		dc.w 24105,23971,23837,23702,23567,23431,23295,23158
		dc.w 23021,22884,22747,22609,22470,22332,22193,22054
		dc.w 21915,21775,21635,21495,21355,21215,21074,20933
		dc.w 20792,20651,20510,20369,20227,20086,19944,19802
		dc.w 19661,19519,19377,19235,19093,18952,18810,18668
		dc.w 18526,18384,18243,18101,17960,17818,17677,17536
		dc.w 17395,17254,17113,16973,16832,16692,16552,16412
		dc.w 16272,16133,15994,15855,15716,15577,15439,15301
		dc.w 15164,15026,14889,14752,14616,14480,14344,14209
		dc.w 14074,13939,13805,13671,13537,13404,13271,13139
		dc.w 13007,12875,12744,12613,12483,12353,12224,12095
		dc.w 11967,11839,11711,11584,11458,11332,11207,11082
		dc.w 10957,10833,10710,10587,10465,10343,10222,10102
		dc.w 9982,9862,9743,9625,9507,9390,9274,9158
		dc.w 9042,8928,8814,8700,8587,8475,8363,8252
		dc.w 8142,8032,7923,7815,7707,7600,7494,7388
		dc.w 7283,7179,7075,6972,6870,6768,6667,6567
		dc.w 6467,6368,6270,6172,6076,5980,5884,5789
		dc.w 5696,5602,5510,5418,5327,5237,5147,5058
		dc.w 4970,4883,4796,4710,4625,4540,4457,4374
		dc.w 4291,4210,4129,4049,3970,3892,3814,3737
		dc.w 3661,3586,3511,3437,3364,3292,3220,3149
		dc.w 3079,3010,2941,2874,2807,2741,2675,2611
		dc.w 2547,2484,2421,2360,2299,2239,2180,2122
		dc.w 2064,2007,1951,1896,1841,1788,1735,1683
		dc.w 1632,1581,1531,1482,1434,1387,1340,1294
		dc.w 1250,1205,1162,1119,1077,1036,996,957
		dc.w 918,880,843,807,772,737,703,670
		dc.w 638,606,575,545,516,488,461,434
		dc.w 408,383,358,335,312,290,269,249
		dc.w 229,211,193,175,159,144,129,115
		dc.w 102,89,78,67,57,48,39,32
		dc.w 25,19,14,9,6,3,1,0
		dc.w 0,0,1,3,6,9,14,19
		dc.w 25,32,39,48,57,67,78,89
		dc.w 102,115,129,144,159,175,193,211
		dc.w 229,249,269,290,312,335,358,383
		dc.w 408,434,461,488,516,545,575,606
		dc.w 638,670,703,737,772,807,843,880
		dc.w 918,957,996,1036,1077,1119,1162,1205
		dc.w 1250,1294,1340,1387,1434,1482,1531,1581
		dc.w 1632,1683,1735,1788,1841,1896,1951,2007
		dc.w 2064,2122,2180,2239,2299,2360,2421,2484
		dc.w 2547,2611,2675,2741,2807,2874,2941,3010
		dc.w 3079,3149,3220,3292,3364,3437,3511,3586
		dc.w 3661,3737,3814,3892,3970,4049,4129,4210
		dc.w 4291,4374,4457,4540,4625,4710,4796,4883
		dc.w 4970,5058,5147,5237,5327,5418,5510,5602
		dc.w 5696,5789,5884,5980,6076,6172,6270,6368
		dc.w 6467,6567,6667,6768,6870,6972,7075,7179
		dc.w 7283,7388,7494,7600,7707,7815,7923,8032
		dc.w 8142,8252,8363,8475,8587,8700,8814,8928
		dc.w 9042,9158,9274,9390,9507,9625,9743,9862
		dc.w 9982,10102,10222,10343,10465,10587,10710,10833
		dc.w 10957,11082,11207,11332,11458,11584,11711,11839
		dc.w 11967,12095,12224,12353,12483,12613,12744,12875
		dc.w 13007,13139,13271,13404,13537,13671,13805,13939
		dc.w 14074,14209,14344,14480,14616,14752,14889,15026
		dc.w 15164,15301,15439,15577,15716,15855,15994,16133
		dc.w 16272,16412,16552,16692,16832,16973,17113,17254
		dc.w 17395,17536,17677,17818,17960,18101,18243,18384
		dc.w 18526,18668,18810,18952,19093,19235,19377,19519
		dc.w 19661,19802,19944,20086,20227,20369,20510,20651
		dc.w 20792,20933,21074,21215,21355,21495,21635,21775
		dc.w 21915,22054,22193,22332,22470,22609,22747,22884
		dc.w 23021,23158,23295,23431,23567,23702,23837,23971
		dc.w 24105,24239,24372,24504,24636,24768,24899,25029
		dc.w 25159,25288,25417,25545,25672,25799,25925,26050
		dc.w 26175,26299,26422,26544,26666,26787,26907,27027
		dc.w 27145,27263,27380,27496,27611,27726,27839,27952
		dc.w 28063,28174,28283,28392,28500,28606,28712,28817
		dc.w 28920,29023,29124,29225,29324,29422,29519,29614
		dc.w 29709,29803,29895,29986,30076,30164,30251,30337
		dc.w 30422,30506,30588,30669,30748,30826,30903,30978
		dc.w 31052,31125,31196,31266,31334,31401,31467,31531
		dc.w 31593,31654,31714,31772,31828,31883,31936,31988
		dc.w 32038,32087,32134,32179,32223,32265,32305,32344
		dc.w 32381,32417,32451,32483,32513,32542,32569,32594
		dc.w 32618,32640,32660,32679,32695,32710,32723,32735
		dc.w 32744,32752,32758,32762,32765,32765,32764,32761
		dc.w 32757,32750,32742,32731,32719,32705,32690,32672
		dc.w 32653,32631,32608,32583,32557,32528,32498,32465
		dc.w 32431,32395,32358,32318,32276,32233,32188,32141
		dc.w 32092,32042,31989,31935,31879,31821,31761,31700
		dc.w 31637,31572,31505,31436,31366,31294,31220,31144
		dc.w 31067,30987,30906,30824,30739,30653,30566,30476
		dc.w 30385,30292,30198,30102,30004,29905,29804,29701
		dc.w 29597,29491,29384,29275,29165,29053,28939,28824
		dc.w 28708,28590,28470,28349,28227,28103,27978,27851
		dc.w 27723,27594,27463,27331,27198,27064,26928,26791
		dc.w 26652,26513,26372,26230,26087,25942,25797,25650
		dc.w 25502,25354,25204,25053,24901,24748,24594,24439
		dc.w 24283,24126,23969,23810,23650,23490,23329,23167
		dc.w 23004,22841,22676,22511,22346,22179,22012,21845
		dc.w 21676,21507,21338,21168,20997,20826,20654,20482
		dc.w 20310,20137,19964,19790,19616,19441,19267,19092
		dc.w 18916,18741,18565,18389,18213,18036,17860,17683
		dc.w 17506,17330,17153,16976,16799,16622,16445,16268
		dc.w 16092,15915,15738,15562,15386,15210,15034,14858
		dc.w 14683,14507,14333,14158,13984,13810,13636,13463
		dc.w 13290,13118,12946,12775,12604,12433,12263,12094
		dc.w 11925,11757,11589,11422,11256,11090,10925,10760
		dc.w 10597,10434,10271,10110,9949,9789,9630,9472
		dc.w 9314,9158,9002,8847,8693,8540,8388,8237
		dc.w 8087,7938,7790,7643,7497,7352,7208,7065
		dc.w 6923,6782,6643,6504,6367,6231,6096,5962
		dc.w 5829,5698,5568,5439,5311,5185,5059,4935
		dc.w 4813,4692,4572,4453,4336,4220,4105,3992
		dc.w 3880,3770,3661,3553,3447,3342,3239,3137
		dc.w 3037,2938,2840,2745,2650,2557,2466,2376
		dc.w 2288,2201,2116,2032,1950,1870,1791,1713
		dc.w 1638,1564,1491,1420,1351,1284,1218,1153
		dc.w 1091,1030,971,913,857,803,751,700
		dc.w 651,603,558,514,472,432,393,356
		dc.w 321,288,257,227,199,173,149,126
		dc.w 105,87,70,54,41,30,20,12
		dc.w 6,2,0,0,1,5,10,17
		dc.w 26,37,50,65,82,101,121,144
		dc.w 169,195,223,254,286,320,357,395
		dc.w 435,477,521,568,616,666,718,772
		dc.w 828,886,946,1009,1073,1139,1207,1277
		dc.w 1350,1424,1500,1578,1659,1741,1826,1912
		dc.w 2000,2091,2184,2278,2375,2473,2574,2677
		dc.w 2782,2889,2998,3108,3221,3336,3453,3572
		dc.w 3693,3817,3942,4069,4198,4329,4462,4597
		dc.w 4735,4874,5015,5158,5303,5450,5599,5750
		dc.w 5903,6058,6215,6373,6534,6697,6861,7027
		dc.w 7195,7365,7537,7711,7886,8064,8243,8423
		dc.w 8606,8790,8976,9164,9353,9545,9737,9932
		dc.w 10128,10325,10524,10725,10927,11131,11336,11543
		dc.w 11751,11960,12171,12383,12597,12811,13027,13244
		dc.w 13463,13682,13903,14125,14348,14571,14796,15022
		dc.w 15249,15476,15704,15934,16164,16394,16625,16857
		dc.w 17090,17323,17556,17790,18024,18259,18494,18729
		dc.w 18965,19200,19436,19671,19907,20143,20378,20613
		dc.w 20848,21083,21317,21551,21784,22017,22250,22481
		dc.w 22712,22942,23171,23400,23627,23853,24078,24302
		dc.w 24525,24746,24966,25184,25401,25617,25830,26042
		dc.w 26252,26460,26666,26870,27072,27272,27469,27664
		dc.w 27857,28047,28234,28419,28601,28781,28957,29130
		dc.w 29301,29468,29632,29793,29950,30104,30254,30401
		dc.w 30544,30684,30819,30951,31079,31202,31322,31437
		dc.w 31548,31655,31757,31854,31948,32036,32120,32199
		dc.w 32273,32342,32406,32466,32520,32568,32612,32650
		dc.w 32683,32711,32733,32749,32760,32765,32764,32758
		dc.w 32746,32728,32704,32674,32638,32596,32548,32494
		dc.w 32433,32366,32294,32214,32129,32037,31939,31834
		dc.w 31723,31605,31481,31351,31214,31071,30921,30764
		dc.w 30601,30431,30255,30072,29883,29687,29485,29276
		dc.w 29061,28839,28610,28376,28134,27887,27633,27372
		dc.w 27105,26832,26553,26267,25975,25677,25373,25063
		dc.w 24747,24425,24097,23763,23424,23079,22728,22371
		dc.w 22009,21642,21269,20890,20507,20119,19725,19326
		dc.w 18923,18515,18102,17684,17262,16836,16405,15970
		dc.w 15531,15088,14641,14190,13735,13277,12815,12351
		dc.w 11882,11411,10937,10460,9980,9497,9012,8525
		dc.w 8035,7543,7049,6554,6056,5557,5057,4555
		dc.w 4052,3548,3042,2537,2030,1523,1015,507
		dc.w 0,-507,-1015,-1523,-2030,-2537,-3042,-3548
		dc.w -4052,-4555,-5057,-5557,-6056,-6554,-7049,-7543
		dc.w -8035,-8525,-9012,-9497,-9980,-10460,-10937,-11411
		dc.w -11882,-12351,-12815,-13277,-13735,-14190,-14641,-15088
		dc.w -15531,-15970,-16405,-16836,-17262,-17684,-18102,-18515
		dc.w -18923,-19326,-19725,-20119,-20507,-20890,-21269,-21642
		dc.w -22009,-22371,-22728,-23079,-23424,-23763,-24097,-24425
		dc.w -24747,-25063,-25373,-25677,-25975,-26267,-26553,-26832
		dc.w -27105,-27372,-27633,-27887,-28134,-28376,-28610,-28839
		dc.w -29061,-29276,-29485,-29687,-29883,-30072,-30255,-30431
		dc.w -30601,-30764,-30921,-31071,-31214,-31351,-31481,-31605
		dc.w -31723,-31834,-31939,-32037,-32129,-32214,-32294,-32366
		dc.w -32433,-32494,-32548,-32596,-32638,-32674,-32704,-32728
		dc.w -32746,-32758,-32764,-32765,-32760,-32749,-32733,-32711
		dc.w -32683,-32650,-32612,-32568,-32520,-32466,-32406,-32342
		dc.w -32273,-32199,-32120,-32036,-31948,-31854,-31757,-31655
		dc.w -31548,-31437,-31322,-31202,-31079,-30951,-30819,-30684
		dc.w -30544,-30401,-30254,-30104,-29950,-29793,-29632,-29468
		dc.w -29301,-29130,-28957,-28781,-28601,-28419,-28234,-28047
		dc.w -27857,-27664,-27469,-27272,-27072,-26870,-26666,-26460
		dc.w -26252,-26042,-25830,-25617,-25401,-25184,-24966,-24746
		dc.w -24525,-24302,-24078,-23853,-23627,-23400,-23171,-22942
		dc.w -22712,-22481,-22250,-22017,-21784,-21551,-21317,-21083
		dc.w -20848,-20613,-20378,-20143,-19907,-19671,-19436,-19200
		dc.w -18965,-18729,-18494,-18259,-18024,-17790,-17556,-17323
		dc.w -17090,-16857,-16625,-16394,-16164,-15934,-15704,-15476
		dc.w -15249,-15022,-14796,-14571,-14348,-14125,-13903,-13682
		dc.w -13463,-13244,-13027,-12811,-12597,-12383,-12171,-11960
		dc.w -11751,-11543,-11336,-11131,-10927,-10725,-10524,-10325
		dc.w -10128,-9932,-9737,-9545,-9353,-9164,-8976,-8790
		dc.w -8606,-8423,-8243,-8064,-7886,-7711,-7537,-7365
		dc.w -7195,-7027,-6861,-6697,-6534,-6373,-6215,-6058
		dc.w -5903,-5750,-5599,-5450,-5303,-5158,-5015,-4874
		dc.w -4735,-4597,-4462,-4329,-4198,-4069,-3942,-3817
		dc.w -3693,-3572,-3453,-3336,-3221,-3108,-2998,-2889
		dc.w -2782,-2677,-2574,-2473,-2375,-2278,-2184,-2091
		dc.w -2000,-1912,-1826,-1741,-1659,-1578,-1500,-1424
		dc.w -1350,-1277,-1207,-1139,-1073,-1009,-946,-886
		dc.w -828,-772,-718,-666,-616,-568,-521,-477
		dc.w -435,-395,-357,-320,-286,-254,-223,-195
		dc.w -169,-144,-121,-101,-82,-65,-50,-37
		dc.w -26,-17,-10,-5,-1,0,0,-2
		dc.w -6,-12,-20,-30,-41,-54,-70,-87
		dc.w -105,-126,-149,-173,-199,-227,-257,-288
		dc.w -321,-356,-393,-432,-472,-514,-558,-603
		dc.w -651,-700,-751,-803,-857,-913,-971,-1030
		dc.w -1091,-1153,-1218,-1284,-1351,-1420,-1491,-1564
		dc.w -1638,-1713,-1791,-1870,-1950,-2032,-2116,-2201
		dc.w -2288,-2376,-2466,-2557,-2650,-2745,-2840,-2938
		dc.w -3037,-3137,-3239,-3342,-3447,-3553,-3661,-3770
		dc.w -3880,-3992,-4105,-4220,-4336,-4453,-4572,-4692
		dc.w -4813,-4935,-5059,-5185,-5311,-5439,-5568,-5698
		dc.w -5829,-5962,-6096,-6231,-6367,-6504,-6643,-6782
		dc.w -6923,-7065,-7208,-7352,-7497,-7643,-7790,-7938
		dc.w -8087,-8237,-8388,-8540,-8693,-8847,-9002,-9158
		dc.w -9314,-9472,-9630,-9789,-9949,-10110,-10271,-10434
		dc.w -10597,-10760,-10925,-11090,-11256,-11422,-11589,-11757
		dc.w -11925,-12094,-12263,-12433,-12604,-12775,-12946,-13118
		dc.w -13290,-13463,-13636,-13810,-13984,-14158,-14333,-14507
		dc.w -14683,-14858,-15034,-15210,-15386,-15562,-15738,-15915
		dc.w -16092,-16268,-16445,-16622,-16799,-16976,-17153,-17330
		dc.w -17506,-17683,-17860,-18036,-18213,-18389,-18565,-18741
		dc.w -18916,-19092,-19267,-19441,-19616,-19790,-19964,-20137
		dc.w -20310,-20482,-20654,-20826,-20997,-21168,-21338,-21507
		dc.w -21676,-21845,-22012,-22179,-22346,-22511,-22676,-22841
		dc.w -23004,-23167,-23329,-23490,-23650,-23810,-23969,-24126
		dc.w -24283,-24439,-24594,-24748,-24901,-25053,-25204,-25354
		dc.w -25502,-25650,-25797,-25942,-26087,-26230,-26372,-26513
		dc.w -26652,-26791,-26928,-27064,-27198,-27331,-27463,-27594
		dc.w -27723,-27851,-27978,-28103,-28227,-28349,-28470,-28590
		dc.w -28708,-28824,-28939,-29053,-29165,-29275,-29384,-29491
		dc.w -29597,-29701,-29804,-29905,-30004,-30102,-30198,-30292
		dc.w -30385,-30476,-30566,-30653,-30739,-30824,-30906,-30987
		dc.w -31067,-31144,-31220,-31294,-31366,-31436,-31505,-31572
		dc.w -31637,-31700,-31761,-31821,-31879,-31935,-31989,-32042
		dc.w -32092,-32141,-32188,-32233,-32276,-32318,-32358,-32395
		dc.w -32431,-32465,-32498,-32528,-32557,-32583,-32608,-32631
		dc.w -32653,-32672,-32690,-32705,-32719,-32731,-32742,-32750
		dc.w -32757,-32761,-32764,-32765,-32765,-32762,-32758,-32752
		dc.w -32744,-32735,-32723,-32710,-32695,-32679,-32660,-32640
		dc.w -32618,-32594,-32569,-32542,-32513,-32483,-32451,-32417
		dc.w -32381,-32344,-32305,-32265,-32223,-32179,-32134,-32087
		dc.w -32038,-31988,-31936,-31883,-31828,-31772,-31714,-31654
		dc.w -31593,-31531,-31467,-31401,-31334,-31266,-31196,-31125
		dc.w -31052,-30978,-30903,-30826,-30748,-30669,-30588,-30506
		dc.w -30422,-30337,-30251,-30164,-30076,-29986,-29895,-29803
		dc.w -29709,-29614,-29519,-29422,-29324,-29225,-29124,-29023
		dc.w -28920,-28817,-28712,-28606,-28500,-28392,-28283,-28174
		dc.w -28063,-27952,-27839,-27726,-27611,-27496,-27380,-27263
		dc.w -27145,-27027,-26907,-26787,-26666,-26544,-26422,-26299
		dc.w -26175,-26050,-25925,-25799,-25672,-25545,-25417,-25288
		dc.w -25159,-25029,-24899,-24768,-24636,-24504,-24372,-24239
		dc.w -24105,-23971,-23837,-23702,-23567,-23431,-23295,-23158
		dc.w -23021,-22884,-22747,-22609,-22470,-22332,-22193,-22054
		dc.w -21915,-21775,-21635,-21495,-21355,-21215,-21074,-20933
		dc.w -20792,-20651,-20510,-20369,-20227,-20086,-19944,-19802
		dc.w -19661,-19519,-19377,-19235,-19093,-18952,-18810,-18668
		dc.w -18526,-18384,-18243,-18101,-17960,-17818,-17677,-17536
		dc.w -17395,-17254,-17113,-16973,-16832,-16692,-16552,-16412
		dc.w -16272,-16133,-15994,-15855,-15716,-15577,-15439,-15301
		dc.w -15164,-15026,-14889,-14752,-14616,-14480,-14344,-14209
		dc.w -14074,-13939,-13805,-13671,-13537,-13404,-13271,-13139
		dc.w -13007,-12875,-12744,-12613,-12483,-12353,-12224,-12095
		dc.w -11967,-11839,-11711,-11584,-11458,-11332,-11207,-11082
		dc.w -10957,-10833,-10710,-10587,-10465,-10343,-10222,-10102
		dc.w -9982,-9862,-9743,-9625,-9507,-9390,-9274,-9158
		dc.w -9042,-8928,-8814,-8700,-8587,-8475,-8363,-8252
		dc.w -8142,-8032,-7923,-7815,-7707,-7600,-7494,-7388
		dc.w -7283,-7179,-7075,-6972,-6870,-6768,-6667,-6567
		dc.w -6467,-6368,-6270,-6172,-6076,-5980,-5884,-5789
		dc.w -5696,-5602,-5510,-5418,-5327,-5237,-5147,-5058
		dc.w -4970,-4883,-4796,-4710,-4625,-4540,-4457,-4374
		dc.w -4291,-4210,-4129,-4049,-3970,-3892,-3814,-3737
		dc.w -3661,-3586,-3511,-3437,-3364,-3292,-3220,-3149
		dc.w -3079,-3010,-2941,-2874,-2807,-2741,-2675,-2611
		dc.w -2547,-2484,-2421,-2360,-2299,-2239,-2180,-2122
		dc.w -2064,-2007,-1951,-1896,-1841,-1788,-1735,-1683
		dc.w -1632,-1581,-1531,-1482,-1434,-1387,-1340,-1294
		dc.w -1250,-1205,-1162,-1119,-1077,-1036,-996,-957
		dc.w -918,-880,-843,-807,-772,-737,-703,-670
		dc.w -638,-606,-575,-545,-516,-488,-461,-434
		dc.w -408,-383,-358,-335,-312,-290,-269,-249
		dc.w -229,-211,-193,-175,-159,-144,-129,-115
		dc.w -102,-89,-78,-67,-57,-48,-39,-32
		dc.w -25,-19,-14,-9,-6,-3,-1,0
		dc.w 0,0,-1,-3,-6,-9,-14,-19
		dc.w -25,-32,-39,-48,-57,-67,-78,-89
		dc.w -102,-115,-129,-144,-159,-175,-193,-211
		dc.w -229,-249,-269,-290,-312,-335,-358,-383
		dc.w -408,-434,-461,-488,-516,-545,-575,-606
		dc.w -638,-670,-703,-737,-772,-807,-843,-880
		dc.w -918,-957,-996,-1036,-1077,-1119,-1162,-1205
		dc.w -1250,-1294,-1340,-1387,-1434,-1482,-1531,-1581
		dc.w -1632,-1683,-1735,-1788,-1841,-1896,-1951,-2007
		dc.w -2064,-2122,-2180,-2239,-2299,-2360,-2421,-2484
		dc.w -2547,-2611,-2675,-2741,-2807,-2874,-2941,-3010
		dc.w -3079,-3149,-3220,-3292,-3364,-3437,-3511,-3586
		dc.w -3661,-3737,-3814,-3892,-3970,-4049,-4129,-4210
		dc.w -4291,-4374,-4457,-4540,-4625,-4710,-4796,-4883
		dc.w -4970,-5058,-5147,-5237,-5327,-5418,-5510,-5602
		dc.w -5696,-5789,-5884,-5980,-6076,-6172,-6270,-6368
		dc.w -6467,-6567,-6667,-6768,-6870,-6972,-7075,-7179
		dc.w -7283,-7388,-7494,-7600,-7707,-7815,-7923,-8032
		dc.w -8142,-8252,-8363,-8475,-8587,-8700,-8814,-8928
		dc.w -9042,-9158,-9274,-9390,-9507,-9625,-9743,-9862
		dc.w -9982,-10102,-10222,-10343,-10465,-10587,-10710,-10833
		dc.w -10957,-11082,-11207,-11332,-11458,-11584,-11711,-11839
		dc.w -11967,-12095,-12224,-12353,-12483,-12613,-12744,-12875
		dc.w -13007,-13139,-13271,-13404,-13537,-13671,-13805,-13939
		dc.w -14074,-14209,-14344,-14480,-14616,-14752,-14889,-15026
		dc.w -15164,-15301,-15439,-15577,-15716,-15855,-15994,-16133
		dc.w -16272,-16412,-16552,-16692,-16832,-16973,-17113,-17254
		dc.w -17395,-17536,-17677,-17818,-17960,-18101,-18243,-18384
		dc.w -18526,-18668,-18810,-18952,-19093,-19235,-19377,-19519
		dc.w -19661,-19802,-19944,-20086,-20227,-20369,-20510,-20651
		dc.w -20792,-20933,-21074,-21215,-21355,-21495,-21635,-21775
		dc.w -21915,-22054,-22193,-22332,-22470,-22609,-22747,-22884
		dc.w -23021,-23158,-23295,-23431,-23567,-23702,-23837,-23971
		dc.w -24105,-24239,-24372,-24504,-24636,-24768,-24899,-25029
		dc.w -25159,-25288,-25417,-25545,-25672,-25799,-25925,-26050
		dc.w -26175,-26299,-26422,-26544,-26666,-26787,-26907,-27027
		dc.w -27145,-27263,-27380,-27496,-27611,-27726,-27839,-27952
		dc.w -28063,-28174,-28283,-28392,-28500,-28606,-28712,-28817
		dc.w -28920,-29023,-29124,-29225,-29324,-29422,-29519,-29614
		dc.w -29709,-29803,-29895,-29986,-30076,-30164,-30251,-30337
		dc.w -30422,-30506,-30588,-30669,-30748,-30826,-30903,-30978
		dc.w -31052,-31125,-31196,-31266,-31334,-31401,-31467,-31531
		dc.w -31593,-31654,-31714,-31772,-31828,-31883,-31936,-31988
		dc.w -32038,-32087,-32134,-32179,-32223,-32265,-32305,-32344
		dc.w -32381,-32417,-32451,-32483,-32513,-32542,-32569,-32594
		dc.w -32618,-32640,-32660,-32679,-32695,-32710,-32723,-32735
		dc.w -32744,-32752,-32758,-32762,-32765,-32765,-32764,-32761
		dc.w -32757,-32750,-32742,-32731,-32719,-32705,-32690,-32672
		dc.w -32653,-32631,-32608,-32583,-32557,-32528,-32498,-32465
		dc.w -32431,-32395,-32358,-32318,-32276,-32233,-32188,-32141
		dc.w -32092,-32042,-31989,-31935,-31879,-31821,-31761,-31700
		dc.w -31637,-31572,-31505,-31436,-31366,-31294,-31220,-31144
		dc.w -31067,-30987,-30906,-30824,-30739,-30653,-30566,-30476
		dc.w -30385,-30292,-30198,-30102,-30004,-29905,-29804,-29701
		dc.w -29597,-29491,-29384,-29275,-29165,-29053,-28939,-28824
		dc.w -28708,-28590,-28470,-28349,-28227,-28103,-27978,-27851
		dc.w -27723,-27594,-27463,-27331,-27198,-27064,-26928,-26791
		dc.w -26652,-26513,-26372,-26230,-26087,-25942,-25797,-25650
		dc.w -25502,-25354,-25204,-25053,-24901,-24748,-24594,-24439
		dc.w -24283,-24126,-23969,-23810,-23650,-23490,-23329,-23167
		dc.w -23004,-22841,-22676,-22511,-22346,-22179,-22012,-21845
		dc.w -21676,-21507,-21338,-21168,-20997,-20826,-20654,-20482
		dc.w -20310,-20137,-19964,-19790,-19616,-19441,-19267,-19092
		dc.w -18916,-18741,-18565,-18389,-18213,-18036,-17860,-17683
		dc.w -17506,-17330,-17153,-16976,-16799,-16622,-16445,-16268
		dc.w -16092,-15915,-15738,-15562,-15386,-15210,-15034,-14858
		dc.w -14683,-14507,-14333,-14158,-13984,-13810,-13636,-13463
		dc.w -13290,-13118,-12946,-12775,-12604,-12433,-12263,-12094
		dc.w -11925,-11757,-11589,-11422,-11256,-11090,-10925,-10760
		dc.w -10597,-10434,-10271,-10110,-9949,-9789,-9630,-9472
		dc.w -9314,-9158,-9002,-8847,-8693,-8540,-8388,-8237
		dc.w -8087,-7938,-7790,-7643,-7497,-7352,-7208,-7065
		dc.w -6923,-6782,-6643,-6504,-6367,-6231,-6096,-5962
		dc.w -5829,-5698,-5568,-5439,-5311,-5185,-5059,-4935
		dc.w -4813,-4692,-4572,-4453,-4336,-4220,-4105,-3992
		dc.w -3880,-3770,-3661,-3553,-3447,-3342,-3239,-3137
		dc.w -3037,-2938,-2840,-2745,-2650,-2557,-2466,-2376
		dc.w -2288,-2201,-2116,-2032,-1950,-1870,-1791,-1713
		dc.w -1638,-1564,-1491,-1420,-1351,-1284,-1218,-1153
		dc.w -1091,-1030,-971,-913,-857,-803,-751,-700
		dc.w -651,-603,-558,-514,-472,-432,-393,-356
		dc.w -321,-288,-257,-227,-199,-173,-149,-126
		dc.w -105,-87,-70,-54,-41,-30,-20,-12
		dc.w -6,-2,0,0,-1,-5,-10,-17
		dc.w -26,-37,-50,-65,-82,-101,-121,-144
		dc.w -169,-195,-223,-254,-286,-320,-357,-395
		dc.w -435,-477,-521,-568,-616,-666,-718,-772
		dc.w -828,-886,-946,-1009,-1073,-1139,-1207,-1277
		dc.w -1350,-1424,-1500,-1578,-1659,-1741,-1826,-1912
		dc.w -2000,-2091,-2184,-2278,-2375,-2473,-2574,-2677
		dc.w -2782,-2889,-2998,-3108,-3221,-3336,-3453,-3572
		dc.w -3693,-3817,-3942,-4069,-4198,-4329,-4462,-4597
		dc.w -4735,-4874,-5015,-5158,-5303,-5450,-5599,-5750
		dc.w -5903,-6058,-6215,-6373,-6534,-6697,-6861,-7027
		dc.w -7195,-7365,-7537,-7711,-7886,-8064,-8243,-8423
		dc.w -8606,-8790,-8976,-9164,-9353,-9545,-9737,-9932
		dc.w -10128,-10325,-10524,-10725,-10927,-11131,-11336,-11543
		dc.w -11751,-11960,-12171,-12383,-12597,-12811,-13027,-13244
		dc.w -13463,-13682,-13903,-14125,-14348,-14571,-14796,-15022
		dc.w -15249,-15476,-15704,-15934,-16164,-16394,-16625,-16857
		dc.w -17090,-17323,-17556,-17790,-18024,-18259,-18494,-18729
		dc.w -18965,-19200,-19436,-19671,-19907,-20143,-20378,-20613
		dc.w -20848,-21083,-21317,-21551,-21784,-22017,-22250,-22481
		dc.w -22712,-22942,-23171,-23400,-23627,-23853,-24078,-24302
		dc.w -24525,-24746,-24966,-25184,-25401,-25617,-25830,-26042
		dc.w -26252,-26460,-26666,-26870,-27072,-27272,-27469,-27664
		dc.w -27857,-28047,-28234,-28419,-28601,-28781,-28957,-29130
		dc.w -29301,-29468,-29632,-29793,-29950,-30104,-30254,-30401
		dc.w -30544,-30684,-30819,-30951,-31079,-31202,-31322,-31437
		dc.w -31548,-31655,-31757,-31854,-31948,-32036,-32120,-32199
		dc.w -32273,-32342,-32406,-32466,-32520,-32568,-32612,-32650
		dc.w -32683,-32711,-32733,-32749,-32760,-32765,-32764,-32758
		dc.w -32746,-32728,-32704,-32674,-32638,-32596,-32548,-32494
		dc.w -32433,-32366,-32294,-32214,-32129,-32037,-31939,-31834
		dc.w -31723,-31605,-31481,-31351,-31214,-31071,-30921,-30764
		dc.w -30601,-30431,-30255,-30072,-29883,-29687,-29485,-29276
		dc.w -29061,-28839,-28610,-28376,-28134,-27887,-27633,-27372
		dc.w -27105,-26832,-26553,-26267,-25975,-25677,-25373,-25063
		dc.w -24747,-24425,-24097,-23763,-23424,-23079,-22728,-22371
		dc.w -22009,-21642,-21269,-20890,-20507,-20119,-19725,-19326
		dc.w -18923,-18515,-18102,-17684,-17262,-16836,-16405,-15970
		dc.w -15531,-15088,-14641,-14190,-13735,-13277,-12815,-12351
		dc.w -11882,-11411,-10937,-10460,-9980,-9497,-9012,-8525
		dc.w -8035,-7543,-7049,-6554,-6056,-5557,-5057,-4555
		dc.w -4052,-3548,-3042,-2537,-2030,-1523,-1015,-507



