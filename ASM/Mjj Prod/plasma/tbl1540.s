;tbl1540.s
sinsin1540:
		dc.w 0,419,839,1259,1679,2098,2517,2935
		dc.w 3353,3770,4187,4602,5017,5432,5845,6257
		dc.w 6668,7077,7486,7893,8298,8703,9105,9506
		dc.w 9906,10303,10699,11092,11484,11874,12262,12647
		dc.w 13030,13411,13790,14166,14539,14910,15279,15645
		dc.w 16008,16368,16725,17079,17431,17779,18124,18467
		dc.w 18806,19141,19474,19803,20128,20451,20769,21085
		dc.w 21396,21704,22009,22309,22606,22899,23188,23474
		dc.w 23755,24032,24306,24575,24841,25102,25359,25613
		dc.w 25861,26106,26347,26583,26815,27043,27266,27485
		dc.w 27700,27910,28116,28317,28514,28707,28895,29079
		dc.w 29258,29433,29603,29769,29930,30087,30239,30387
		dc.w 30530,30669,30803,30932,31058,31178,31294,31406
		dc.w 31513,31615,31714,31807,31896,31981,32061,32137
		dc.w 32208,32275,32338,32396,32450,32500,32545,32586
		dc.w 32623,32655,32683,32707,32727,32743,32754,32762
		dc.w 32765,32765,32760,32751,32739,32722,32702,32677
		dc.w 32649,32617,32581,32542,32499,32452,32402,32348
		dc.w 32290,32229,32164,32096,32025,31950,31872,31791
		dc.w 31706,31618,31527,31433,31336,31236,31133,31027
		dc.w 30918,30806,30691,30574,30453,30330,30205,30077
		dc.w 29946,29813,29677,29539,29399,29256,29111,28964
		dc.w 28814,28663,28509,28353,28195,28035,27874,27710
		dc.w 27545,27378,27209,27038,26866,26692,26516,26339
		dc.w 26161,25981,25800,25617,25433,25248,25062,24874
		dc.w 24686,24496,24305,24113,23921,23727,23532,23337
		dc.w 23141,22944,22746,22548,22349,22150,21950,21749
		dc.w 21548,21346,21145,20942,20740,20537,20334,20130
		dc.w 19927,19723,19520,19316,19112,18908,18704,18500
		dc.w 18297,18093,17890,17686,17483,17281,17078,16876
		dc.w 16674,16473,16272,16071,15871,15671,15472,15274
		dc.w 15076,14878,14681,14485,14290,14095,13901,13707
		dc.w 13515,13323,13132,12942,12753,12564,12377,12190
		dc.w 12004,11820,11636,11453,11272,11091,10911,10733
		dc.w 10555,10379,10204,10030,9857,9685,9515,9345
		dc.w 9177,9010,8845,8680,8517,8356,8195,8036
		dc.w 7878,7722,7567,7413,7260,7109,6960,6812
		dc.w 6665,6520,6376,6233,6092,5953,5815,5678
		dc.w 5543,5409,5277,5147,5018,4890,4764,4640
		dc.w 4517,4396,4276,4158,4041,3926,3813,3701
		dc.w 3591,3482,3375,3270,3166,3064,2963,2865
		dc.w 2767,2672,2578,2485,2395,2306,2218,2132
		dc.w 2048,1966,1885,1806,1729,1653,1579,1507
		dc.w 1436,1367,1300,1234,1170,1108,1047,988
		dc.w 931,875,822,770,719,670,623,578
		dc.w 534,493,452,414,377,342,309,277
		dc.w 247,219,192,167,144,123,103,85
		dc.w 69,54,41,30,21,13,7,3
		dc.w 0,0,0,3,7,13,21,30
		dc.w 41,54,69,85,103,123,144,167
		dc.w 192,219,247,277,309,342,377,414
		dc.w 452,493,534,578,623,670,719,770
		dc.w 822,875,931,988,1047,1108,1170,1234
		dc.w 1300,1367,1436,1507,1579,1653,1729,1806
		dc.w 1885,1966,2048,2132,2218,2306,2395,2485
		dc.w 2578,2672,2767,2865,2963,3064,3166,3270
		dc.w 3375,3482,3591,3701,3813,3926,4041,4158
		dc.w 4276,4396,4517,4640,4764,4890,5018,5147
		dc.w 5277,5409,5543,5678,5815,5953,6092,6233
		dc.w 6376,6520,6665,6812,6960,7109,7260,7413
		dc.w 7567,7722,7878,8036,8195,8356,8517,8680
		dc.w 8845,9010,9177,9345,9515,9685,9857,10030
		dc.w 10204,10379,10555,10733,10911,11091,11272,11453
		dc.w 11636,11820,12004,12190,12377,12564,12753,12942
		dc.w 13132,13323,13515,13707,13901,14095,14290,14485
		dc.w 14681,14878,15076,15274,15472,15671,15871,16071
		dc.w 16272,16473,16674,16876,17078,17281,17483,17686
		dc.w 17890,18093,18297,18500,18704,18908,19112,19316
		dc.w 19520,19723,19927,20130,20334,20537,20740,20942
		dc.w 21145,21346,21548,21749,21950,22150,22349,22548
		dc.w 22746,22944,23141,23337,23532,23727,23921,24113
		dc.w 24305,24496,24686,24874,25062,25248,25433,25617
		dc.w 25800,25981,26161,26339,26516,26692,26866,27038
		dc.w 27209,27378,27545,27710,27874,28035,28195,28353
		dc.w 28509,28663,28814,28964,29111,29256,29399,29539
		dc.w 29677,29813,29946,30077,30205,30330,30453,30574
		dc.w 30691,30806,30918,31027,31133,31236,31336,31433
		dc.w 31527,31618,31706,31791,31872,31950,32025,32096
		dc.w 32164,32229,32290,32348,32402,32452,32499,32542
		dc.w 32581,32617,32649,32677,32702,32722,32739,32751
		dc.w 32760,32765,32765,32762,32754,32743,32727,32707
		dc.w 32683,32655,32623,32586,32545,32500,32450,32396
		dc.w 32338,32275,32208,32137,32061,31981,31896,31807
		dc.w 31714,31615,31513,31406,31294,31178,31058,30932
		dc.w 30803,30669,30530,30387,30239,30087,29930,29769
		dc.w 29603,29433,29258,29079,28895,28707,28514,28317
		dc.w 28116,27910,27700,27485,27266,27043,26815,26583
		dc.w 26347,26106,25861,25613,25359,25102,24841,24575
		dc.w 24306,24032,23755,23474,23188,22899,22606,22309
		dc.w 22009,21704,21396,21085,20769,20451,20128,19803
		dc.w 19474,19141,18806,18467,18124,17779,17431,17079
		dc.w 16725,16368,16008,15645,15279,14910,14539,14166
		dc.w 13790,13411,13030,12647,12262,11874,11484,11092
		dc.w 10699,10303,9906,9506,9105,8703,8298,7893
		dc.w 7486,7077,6668,6257,5845,5432,5017,4602
		dc.w 4187,3770,3353,2935,2517,2098,1679,1259
		dc.w 839,419,0,-419,-839,-1259,-1679,-2098
		dc.w -2517,-2935,-3353,-3770,-4187,-4602,-5017,-5432
		dc.w -5845,-6257,-6668,-7077,-7486,-7893,-8298,-8703
		dc.w -9105,-9506,-9906,-10303,-10699,-11092,-11484,-11874
		dc.w -12262,-12647,-13030,-13411,-13790,-14166,-14539,-14910
		dc.w -15279,-15645,-16008,-16368,-16725,-17079,-17431,-17779
		dc.w -18124,-18467,-18806,-19141,-19474,-19803,-20128,-20451
		dc.w -20769,-21085,-21396,-21704,-22009,-22309,-22606,-22899
		dc.w -23188,-23474,-23755,-24032,-24306,-24575,-24841,-25102
		dc.w -25359,-25613,-25861,-26106,-26347,-26583,-26815,-27043
		dc.w -27266,-27485,-27700,-27910,-28116,-28317,-28514,-28707
		dc.w -28895,-29079,-29258,-29433,-29603,-29769,-29930,-30087
		dc.w -30239,-30387,-30530,-30669,-30803,-30932,-31058,-31178
		dc.w -31294,-31406,-31513,-31615,-31714,-31807,-31896,-31981
		dc.w -32061,-32137,-32208,-32275,-32338,-32396,-32450,-32500
		dc.w -32545,-32586,-32623,-32655,-32683,-32707,-32727,-32743
		dc.w -32754,-32762,-32765,-32765,-32760,-32751,-32739,-32722
		dc.w -32702,-32677,-32649,-32617,-32581,-32542,-32499,-32452
		dc.w -32402,-32348,-32290,-32229,-32164,-32096,-32025,-31950
		dc.w -31872,-31791,-31706,-31618,-31527,-31433,-31336,-31236
		dc.w -31133,-31027,-30918,-30806,-30691,-30574,-30453,-30330
		dc.w -30205,-30077,-29946,-29813,-29677,-29539,-29399,-29256
		dc.w -29111,-28964,-28814,-28663,-28509,-28353,-28195,-28035
		dc.w -27874,-27710,-27545,-27378,-27209,-27038,-26866,-26692
		dc.w -26516,-26339,-26161,-25981,-25800,-25617,-25433,-25248
		dc.w -25062,-24874,-24686,-24496,-24305,-24113,-23921,-23727
		dc.w -23532,-23337,-23141,-22944,-22746,-22548,-22349,-22150
		dc.w -21950,-21749,-21548,-21346,-21145,-20942,-20740,-20537
		dc.w -20334,-20130,-19927,-19723,-19520,-19316,-19112,-18908
		dc.w -18704,-18500,-18297,-18093,-17890,-17686,-17483,-17281
		dc.w -17078,-16876,-16674,-16473,-16272,-16071,-15871,-15671
		dc.w -15472,-15274,-15076,-14878,-14681,-14485,-14290,-14095
		dc.w -13901,-13707,-13515,-13323,-13132,-12942,-12753,-12564
		dc.w -12377,-12190,-12004,-11820,-11636,-11453,-11272,-11091
		dc.w -10911,-10733,-10555,-10379,-10204,-10030,-9857,-9685
		dc.w -9515,-9345,-9177,-9010,-8845,-8680,-8517,-8356
		dc.w -8195,-8036,-7878,-7722,-7567,-7413,-7260,-7109
		dc.w -6960,-6812,-6665,-6520,-6376,-6233,-6092,-5953
		dc.w -5815,-5678,-5543,-5409,-5277,-5147,-5018,-4890
		dc.w -4764,-4640,-4517,-4396,-4276,-4158,-4041,-3926
		dc.w -3813,-3701,-3591,-3482,-3375,-3270,-3166,-3064
		dc.w -2963,-2865,-2767,-2672,-2578,-2485,-2395,-2306
		dc.w -2218,-2132,-2048,-1966,-1885,-1806,-1729,-1653
		dc.w -1579,-1507,-1436,-1367,-1300,-1234,-1170,-1108
		dc.w -1047,-988,-931,-875,-822,-770,-719,-670
		dc.w -623,-578,-534,-493,-452,-414,-377,-342
		dc.w -309,-277,-247,-219,-192,-167,-144,-123
		dc.w -103,-85,-69,-54,-41,-30,-21,-13
		dc.w -7,-3,0,0,0,-3,-7,-13
		dc.w -21,-30,-41,-54,-69,-85,-103,-123
		dc.w -144,-167,-192,-219,-247,-277,-309,-342
		dc.w -377,-414,-452,-493,-534,-578,-623,-670
		dc.w -719,-770,-822,-875,-931,-988,-1047,-1108
		dc.w -1170,-1234,-1300,-1367,-1436,-1507,-1579,-1653
		dc.w -1729,-1806,-1885,-1966,-2048,-2132,-2218,-2306
		dc.w -2395,-2485,-2578,-2672,-2767,-2865,-2963,-3064
		dc.w -3166,-3270,-3375,-3482,-3591,-3701,-3813,-3926
		dc.w -4041,-4158,-4276,-4396,-4517,-4640,-4764,-4890
		dc.w -5018,-5147,-5277,-5409,-5543,-5678,-5815,-5953
		dc.w -6092,-6233,-6376,-6520,-6665,-6812,-6960,-7109
		dc.w -7260,-7413,-7567,-7722,-7878,-8036,-8195,-8356
		dc.w -8517,-8680,-8845,-9010,-9177,-9345,-9515,-9685
		dc.w -9857,-10030,-10204,-10379,-10555,-10733,-10911,-11091
		dc.w -11272,-11453,-11636,-11820,-12004,-12190,-12377,-12564
		dc.w -12753,-12942,-13132,-13323,-13515,-13707,-13901,-14095
		dc.w -14290,-14485,-14681,-14878,-15076,-15274,-15472,-15671
		dc.w -15871,-16071,-16272,-16473,-16674,-16876,-17078,-17281
		dc.w -17483,-17686,-17890,-18093,-18297,-18500,-18704,-18908
		dc.w -19112,-19316,-19520,-19723,-19927,-20130,-20334,-20537
		dc.w -20740,-20942,-21145,-21346,-21548,-21749,-21950,-22150
		dc.w -22349,-22548,-22746,-22944,-23141,-23337,-23532,-23727
		dc.w -23921,-24113,-24305,-24496,-24686,-24874,-25062,-25248
		dc.w -25433,-25617,-25800,-25981,-26161,-26339,-26516,-26692
		dc.w -26866,-27038,-27209,-27378,-27545,-27710,-27874,-28035
		dc.w -28195,-28353,-28509,-28663,-28814,-28964,-29111,-29256
		dc.w -29399,-29539,-29677,-29813,-29946,-30077,-30205,-30330
		dc.w -30453,-30574,-30691,-30806,-30918,-31027,-31133,-31236
		dc.w -31336,-31433,-31527,-31618,-31706,-31791,-31872,-31950
		dc.w -32025,-32096,-32164,-32229,-32290,-32348,-32402,-32452
		dc.w -32499,-32542,-32581,-32617,-32649,-32677,-32702,-32722
		dc.w -32739,-32751,-32760,-32765,-32765,-32762,-32754,-32743
		dc.w -32727,-32707,-32683,-32655,-32623,-32586,-32545,-32500
		dc.w -32450,-32396,-32338,-32275,-32208,-32137,-32061,-31981
		dc.w -31896,-31807,-31714,-31615,-31513,-31406,-31294,-31178
		dc.w -31058,-30932,-30803,-30669,-30530,-30387,-30239,-30087
		dc.w -29930,-29769,-29603,-29433,-29258,-29079,-28895,-28707
		dc.w -28514,-28317,-28116,-27910,-27700,-27485,-27266,-27043
		dc.w -26815,-26583,-26347,-26106,-25861,-25613,-25359,-25102
		dc.w -24841,-24575,-24306,-24032,-23755,-23474,-23188,-22899
		dc.w -22606,-22309,-22009,-21704,-21396,-21085,-20769,-20451
		dc.w -20128,-19803,-19474,-19141,-18806,-18467,-18124,-17779
		dc.w -17431,-17079,-16725,-16368,-16008,-15645,-15279,-14910
		dc.w -14539,-14166,-13790,-13411,-13030,-12647,-12262,-11874
		dc.w -11484,-11092,-10699,-10303,-9906,-9506,-9105,-8703
		dc.w -8298,-7893,-7486,-7077,-6668,-6257,-5845,-5432
		dc.w -5017,-4602,-4187,-3770,-3353,-2935,-2517,-2098
		dc.w -1679,-1259,-839,-419
cossin1540:
		dc.w 32766,32763,32755,32741,32722,32698,32669,32634
		dc.w 32593,32548,32497,32441,32379,32312,32240,32163
		dc.w 32080,31992,31899,31801,31697,31589,31475,31356
		dc.w 31232,31103,30969,30831,30687,30538,30385,30226
		dc.w 30063,29895,29722,29545,29363,29176,28985,28789
		dc.w 28589,28384,28175,27962,27744,27522,27296,27066
		dc.w 26831,26593,26350,26104,25854,25599,25342,25080
		dc.w 24815,24546,24273,23997,23718,23435,23149,22859
		dc.w 22567,22271,21972,21671,21366,21058,20748,20434
		dc.w 20118,19800,19479,19155,18829,18500,18170,17836
		dc.w 17501,17164,16824,16483,16140,15795,15448,15099
		dc.w 14749,14397,14043,13689,13332,12975,12616,12256
		dc.w 11895,11532,11169,10805,10440,10074,9708,9341
		dc.w 8973,8604,8235,7866,7497,7127,6757,6386
		dc.w 6016,5645,5275,4904,4534,4164,3794,3424
		dc.w 3055,2686,2318,1950,1583,1216,850,485
		dc.w 121,-242,-604,-966,-1327,-1687,-2045,-2403
		dc.w -2759,-3114,-3468,-3820,-4172,-4521,-4870,-5216
		dc.w -5562,-5905,-6247,-6588,-6927,-7264,-7599,-7932
		dc.w -8264,-8594,-8922,-9248,-9572,-9894,-10214,-10532
		dc.w -10848,-11161,-11473,-11782,-12090,-12395,-12698,-12998
		dc.w -13296,-13592,-13886,-14177,-14466,-14753,-15037,-15319
		dc.w -15598,-15875,-16150,-16422,-16691,-16958,-17223,-17485
		dc.w -17744,-18001,-18255,-18507,-18756,-19003,-19247,-19488
		dc.w -19727,-19964,-20197,-20428,-20657,-20883,-21106,-21327
		dc.w -21545,-21760,-21973,-22184,-22391,-22596,-22799,-22999
		dc.w -23196,-23391,-23583,-23773,-23960,-24145,-24327,-24506
		dc.w -24683,-24857,-25029,-25199,-25366,-25530,-25692,-25852
		dc.w -26009,-26164,-26316,-26466,-26614,-26759,-26902,-27043
		dc.w -27181,-27317,-27450,-27582,-27711,-27838,-27962,-28085
		dc.w -28205,-28323,-28439,-28553,-28665,-28775,-28882,-28988
		dc.w -29091,-29193,-29292,-29390,-29485,-29579,-29670,-29760
		dc.w -29848,-29934,-30019,-30101,-30182,-30261,-30338,-30413
		dc.w -30487,-30559,-30630,-30698,-30766,-30831,-30895,-30958
		dc.w -31019,-31078,-31136,-31192,-31248,-31301,-31353,-31404
		dc.w -31454,-31502,-31549,-31595,-31639,-31682,-31724,-31765
		dc.w -31804,-31843,-31880,-31916,-31951,-31985,-32018,-32050
		dc.w -32080,-32110,-32139,-32167,-32194,-32220,-32245,-32270
		dc.w -32293,-32316,-32338,-32359,-32379,-32398,-32417,-32435
		dc.w -32453,-32469,-32485,-32501,-32515,-32529,-32543,-32556
		dc.w -32568,-32580,-32591,-32602,-32612,-32622,-32631,-32640
		dc.w -32648,-32656,-32664,-32671,-32678,-32684,-32690,-32696
		dc.w -32701,-32706,-32711,-32716,-32720,-32724,-32727,-32731
		dc.w -32734,-32737,-32740,-32742,-32745,-32747,-32749,-32751
		dc.w -32752,-32754,-32755,-32756,-32758,-32759,-32760,-32760
		dc.w -32761,-32762,-32762,-32763,-32763,-32764,-32764,-32764
		dc.w -32765,-32765,-32765,-32765,-32765,-32765,-32765,-32765
		dc.w -32765,-32765,-32765,-32765,-32765,-32765,-32765,-32765
		dc.w -32765,-32766,-32765,-32765,-32765,-32765,-32765,-32765
		dc.w -32765,-32765,-32765,-32765,-32765,-32765,-32765,-32765
		dc.w -32765,-32765,-32765,-32764,-32764,-32764,-32763,-32763
		dc.w -32762,-32762,-32761,-32760,-32760,-32759,-32758,-32756
		dc.w -32755,-32754,-32752,-32751,-32749,-32747,-32745,-32742
		dc.w -32740,-32737,-32734,-32731,-32727,-32724,-32720,-32716
		dc.w -32711,-32706,-32701,-32696,-32690,-32684,-32678,-32671
		dc.w -32664,-32656,-32648,-32640,-32631,-32622,-32612,-32602
		dc.w -32591,-32580,-32568,-32556,-32543,-32529,-32515,-32501
		dc.w -32485,-32469,-32453,-32435,-32417,-32398,-32379,-32359
		dc.w -32338,-32316,-32293,-32270,-32245,-32220,-32194,-32167
		dc.w -32139,-32110,-32080,-32050,-32018,-31985,-31951,-31916
		dc.w -31880,-31843,-31804,-31765,-31724,-31682,-31639,-31595
		dc.w -31549,-31502,-31454,-31404,-31353,-31301,-31248,-31192
		dc.w -31136,-31078,-31019,-30958,-30895,-30831,-30766,-30698
		dc.w -30630,-30559,-30487,-30413,-30338,-30261,-30182,-30101
		dc.w -30019,-29934,-29848,-29760,-29670,-29579,-29485,-29390
		dc.w -29292,-29193,-29091,-28988,-28882,-28775,-28665,-28553
		dc.w -28439,-28323,-28205,-28085,-27962,-27838,-27711,-27582
		dc.w -27450,-27317,-27181,-27043,-26902,-26759,-26614,-26466
		dc.w -26316,-26164,-26009,-25852,-25692,-25530,-25366,-25199
		dc.w -25029,-24857,-24683,-24506,-24327,-24145,-23960,-23773
		dc.w -23583,-23391,-23196,-22999,-22799,-22596,-22391,-22184
		dc.w -21973,-21760,-21545,-21327,-21106,-20883,-20657,-20428
		dc.w -20197,-19964,-19727,-19488,-19247,-19003,-18756,-18507
		dc.w -18255,-18001,-17744,-17485,-17223,-16958,-16691,-16422
		dc.w -16150,-15875,-15598,-15319,-15037,-14753,-14466,-14177
		dc.w -13886,-13592,-13296,-12998,-12698,-12395,-12090,-11782
		dc.w -11473,-11161,-10848,-10532,-10214,-9894,-9572,-9248
		dc.w -8922,-8594,-8264,-7932,-7599,-7264,-6927,-6588
		dc.w -6247,-5905,-5562,-5216,-4870,-4521,-4172,-3820
		dc.w -3468,-3114,-2759,-2403,-2045,-1687,-1327,-966
		dc.w -604,-242,121,485,850,1216,1583,1950
		dc.w 2318,2686,3055,3424,3794,4164,4534,4904
		dc.w 5275,5645,6016,6386,6757,7127,7497,7866
		dc.w 8235,8604,8973,9341,9708,10074,10440,10805
		dc.w 11169,11532,11895,12256,12616,12975,13332,13689
		dc.w 14043,14397,14749,15099,15448,15795,16140,16483
		dc.w 16824,17164,17501,17836,18170,18500,18829,19155
		dc.w 19479,19800,20118,20434,20748,21058,21366,21671
		dc.w 21972,22271,22567,22859,23149,23435,23718,23997
		dc.w 24273,24546,24815,25080,25342,25599,25854,26104
		dc.w 26350,26593,26831,27066,27296,27522,27744,27962
		dc.w 28175,28384,28589,28789,28985,29176,29363,29545
		dc.w 29722,29895,30063,30226,30385,30538,30687,30831
		dc.w 30969,31103,31232,31356,31475,31589,31697,31801
		dc.w 31899,31992,32080,32163,32240,32312,32379,32441
		dc.w 32497,32548,32593,32634,32669,32698,32722,32741
		dc.w 32755,32763,32766,32763,32755,32741,32722,32698
		dc.w 32669,32634,32593,32548,32497,32441,32379,32312
		dc.w 32240,32163,32080,31992,31899,31801,31697,31589
		dc.w 31475,31356,31232,31103,30969,30831,30687,30538
		dc.w 30385,30226,30063,29895,29722,29545,29363,29176
		dc.w 28985,28789,28589,28384,28175,27962,27744,27522
		dc.w 27296,27066,26831,26593,26350,26104,25854,25599
		dc.w 25342,25080,24815,24546,24273,23997,23718,23435
		dc.w 23149,22859,22567,22271,21972,21671,21366,21058
		dc.w 20748,20434,20118,19800,19479,19155,18829,18500
		dc.w 18170,17836,17501,17164,16824,16483,16140,15795
		dc.w 15448,15099,14749,14397,14043,13689,13332,12975
		dc.w 12616,12256,11895,11532,11169,10805,10440,10074
		dc.w 9708,9341,8973,8604,8235,7866,7497,7127
		dc.w 6757,6386,6016,5645,5275,4904,4534,4164
		dc.w 3794,3424,3055,2686,2318,1950,1583,1216
		dc.w 850,485,121,-242,-604,-966,-1327,-1687
		dc.w -2045,-2403,-2759,-3114,-3468,-3820,-4172,-4521
		dc.w -4870,-5216,-5562,-5905,-6247,-6588,-6927,-7264
		dc.w -7599,-7932,-8264,-8594,-8922,-9248,-9572,-9894
		dc.w -10214,-10532,-10848,-11161,-11473,-11782,-12090,-12395
		dc.w -12698,-12998,-13296,-13592,-13886,-14177,-14466,-14753
		dc.w -15037,-15319,-15598,-15875,-16150,-16422,-16691,-16958
		dc.w -17223,-17485,-17744,-18001,-18255,-18507,-18756,-19003
		dc.w -19247,-19488,-19727,-19964,-20197,-20428,-20657,-20883
		dc.w -21106,-21327,-21545,-21760,-21973,-22184,-22391,-22596
		dc.w -22799,-22999,-23196,-23391,-23583,-23773,-23960,-24145
		dc.w -24327,-24506,-24683,-24857,-25029,-25199,-25366,-25530
		dc.w -25692,-25852,-26009,-26164,-26316,-26466,-26614,-26759
		dc.w -26902,-27043,-27181,-27317,-27450,-27582,-27711,-27838
		dc.w -27962,-28085,-28205,-28323,-28439,-28553,-28665,-28775
		dc.w -28882,-28988,-29091,-29193,-29292,-29390,-29485,-29579
		dc.w -29670,-29760,-29848,-29934,-30019,-30101,-30182,-30261
		dc.w -30338,-30413,-30487,-30559,-30630,-30698,-30766,-30831
		dc.w -30895,-30958,-31019,-31078,-31136,-31192,-31248,-31301
		dc.w -31353,-31404,-31454,-31502,-31549,-31595,-31639,-31682
		dc.w -31724,-31765,-31804,-31843,-31880,-31916,-31951,-31985
		dc.w -32018,-32050,-32080,-32110,-32139,-32167,-32194,-32220
		dc.w -32245,-32270,-32293,-32316,-32338,-32359,-32379,-32398
		dc.w -32417,-32435,-32453,-32469,-32485,-32501,-32515,-32529
		dc.w -32543,-32556,-32568,-32580,-32591,-32602,-32612,-32622
		dc.w -32631,-32640,-32648,-32656,-32664,-32671,-32678,-32684
		dc.w -32690,-32696,-32701,-32706,-32711,-32716,-32720,-32724
		dc.w -32727,-32731,-32734,-32737,-32740,-32742,-32745,-32747
		dc.w -32749,-32751,-32752,-32754,-32755,-32756,-32758,-32759
		dc.w -32760,-32760,-32761,-32762,-32762,-32763,-32763,-32764
		dc.w -32764,-32764,-32765,-32765,-32765,-32765,-32765,-32765
		dc.w -32765,-32765,-32765,-32765,-32765,-32765,-32765,-32765
		dc.w -32765,-32765,-32765,-32766,-32765,-32765,-32765,-32765
		dc.w -32765,-32765,-32765,-32765,-32765,-32765,-32765,-32765
		dc.w -32765,-32765,-32765,-32765,-32765,-32764,-32764,-32764
		dc.w -32763,-32763,-32762,-32762,-32761,-32760,-32760,-32759
		dc.w -32758,-32756,-32755,-32754,-32752,-32751,-32749,-32747
		dc.w -32745,-32742,-32740,-32737,-32734,-32731,-32727,-32724
		dc.w -32720,-32716,-32711,-32706,-32701,-32696,-32690,-32684
		dc.w -32678,-32671,-32664,-32656,-32648,-32640,-32631,-32622
		dc.w -32612,-32602,-32591,-32580,-32568,-32556,-32543,-32529
		dc.w -32515,-32501,-32485,-32469,-32453,-32435,-32417,-32398
		dc.w -32379,-32359,-32338,-32316,-32293,-32270,-32245,-32220
		dc.w -32194,-32167,-32139,-32110,-32080,-32050,-32018,-31985
		dc.w -31951,-31916,-31880,-31843,-31804,-31765,-31724,-31682
		dc.w -31639,-31595,-31549,-31502,-31454,-31404,-31353,-31301
		dc.w -31248,-31192,-31136,-31078,-31019,-30958,-30895,-30831
		dc.w -30766,-30698,-30630,-30559,-30487,-30413,-30338,-30261
		dc.w -30182,-30101,-30019,-29934,-29848,-29760,-29670,-29579
		dc.w -29485,-29390,-29292,-29193,-29091,-28988,-28882,-28775
		dc.w -28665,-28553,-28439,-28323,-28205,-28085,-27962,-27838
		dc.w -27711,-27582,-27450,-27317,-27181,-27043,-26902,-26759
		dc.w -26614,-26466,-26316,-26164,-26009,-25852,-25692,-25530
		dc.w -25366,-25199,-25029,-24857,-24683,-24506,-24327,-24145
		dc.w -23960,-23773,-23583,-23391,-23196,-22999,-22799,-22596
		dc.w -22391,-22184,-21973,-21760,-21545,-21327,-21106,-20883
		dc.w -20657,-20428,-20197,-19964,-19727,-19488,-19247,-19003
		dc.w -18756,-18507,-18255,-18001,-17744,-17485,-17223,-16958
		dc.w -16691,-16422,-16150,-15875,-15598,-15319,-15037,-14753
		dc.w -14466,-14177,-13886,-13592,-13296,-12998,-12698,-12395
		dc.w -12090,-11782,-11473,-11161,-10848,-10532,-10214,-9894
		dc.w -9572,-9248,-8922,-8594,-8264,-7932,-7599,-7264
		dc.w -6927,-6588,-6247,-5905,-5562,-5216,-4870,-4521
		dc.w -4172,-3820,-3468,-3114,-2759,-2403,-2045,-1687
		dc.w -1327,-966,-604,-242,121,485,850,1216
		dc.w 1583,1950,2318,2686,3055,3424,3794,4164
		dc.w 4534,4904,5275,5645,6016,6386,6757,7127
		dc.w 7497,7866,8235,8604,8973,9341,9708,10074
		dc.w 10440,10805,11169,11532,11895,12256,12616,12975
		dc.w 13332,13689,14043,14397,14749,15099,15448,15795
		dc.w 16140,16483,16824,17164,17501,17836,18170,18500
		dc.w 18829,19155,19479,19800,20118,20434,20748,21058
		dc.w 21366,21671,21972,22271,22567,22859,23149,23435
		dc.w 23718,23997,24273,24546,24815,25080,25342,25599
		dc.w 25854,26104,26350,26593,26831,27066,27296,27522
		dc.w 27744,27962,28175,28384,28589,28789,28985,29176
		dc.w 29363,29545,29722,29895,30063,30226,30385,30538
		dc.w 30687,30831,30969,31103,31232,31356,31475,31589
		dc.w 31697,31801,31899,31992,32080,32163,32240,32312
		dc.w 32379,32441,32497,32548,32593,32634,32669,32698
		dc.w 32722,32741,32755,32763
