; TBLSIN1.S

cos900:
		dc.w 32766,32765,32762,32758,32753,32746,32737,32726
		dc.w 32714,32701,32686,32669,32651,32631,32609,32586
		dc.w 32561,32535,32507,32478,32447,32414,32380,32344
		dc.w 32307,32268,32227,32185,32141,32096,32049,32001
		dc.w 31951,31900,31847,31792,31736,31678,31619,31558
		dc.w 31496,31432,31367,31300,31232,31162,31090,31017
		dc.w 30943,30867,30789,30710,30630,30548,30465,30380
		dc.w 30293,30205,30116,30025,29933,29839,29744,29647
		dc.w 29549,29449,29348,29246,29142,29037,28930,28822
		dc.w 28713,28602,28489,28376,28261,28144,28026,27907
		dc.w 27787,27665,27542,27417,27291,27164,27035,26905
		dc.w 26774,26642,26508,26373,26236,26099,25960,25819
		dc.w 25678,25535,25391,25246,25100,24952,24803,24653
		dc.w 24502,24349,24196,24041,23885,23728,23569,23410
		dc.w 23249,23088,22925,22761,22596,22429,22262,22094
		dc.w 21924,21754,21582,21409,21236,21061,20885,20709
		dc.w 20531,20352,20172,19992,19810,19627,19443,19259
		dc.w 19073,18887,18700,18511,18322,18132,17941,17749
		dc.w 17556,17363,17168,16973,16777,16580,16383,16184
		dc.w 15985,15785,15584,15382,15180,14977,14773,14568
		dc.w 14363,14157,13951,13743,13535,13327,13117,12907
		dc.w 12697,12486,12274,12061,11848,11635,11421,11206
		dc.w 10991,10775,10559,10342,10125,9907,9689,9470
		dc.w 9251,9031,8811,8590,8369,8148,7926,7704
		dc.w 7482,7259,7036,6812,6588,6364,6139,5914
		dc.w 5689,5464,5238,5012,4786,4560,4333,4106
		dc.w 3879,3652,3424,3197,2969,2741,2513,2285
		dc.w 2057,1829,1600,1372,1143,914,686,457
		dc.w 228,0,-228,-457,-686,-914,-1143,-1372
		dc.w -1600,-1829,-2057,-2285,-2513,-2741,-2969,-3197
		dc.w -3424,-3652,-3879,-4106,-4333,-4560,-4786,-5012
		dc.w -5238,-5464,-5689,-5914,-6139,-6364,-6588,-6812
		dc.w -7036,-7259,-7482,-7704,-7926,-8148,-8369,-8590
		dc.w -8811,-9031,-9251,-9470,-9689,-9907,-10125,-10342
		dc.w -10559,-10775,-10991,-11206,-11421,-11635,-11848,-12061
		dc.w -12274,-12486,-12697,-12907,-13117,-13327,-13535,-13743
		dc.w -13951,-14157,-14363,-14568,-14773,-14977,-15180,-15382
		dc.w -15584,-15785,-15985,-16184,-16382,-16580,-16777,-16973
		dc.w -17168,-17363,-17556,-17749,-17941,-18132,-18322,-18511
		dc.w -18700,-18887,-19073,-19259,-19443,-19627,-19810,-19992
		dc.w -20172,-20352,-20531,-20709,-20885,-21061,-21236,-21409
		dc.w -21582,-21754,-21924,-22094,-22262,-22429,-22596,-22761
		dc.w -22925,-23088,-23249,-23410,-23569,-23728,-23885,-24041
		dc.w -24196,-24349,-24502,-24653,-24803,-24952,-25100,-25246
		dc.w -25391,-25535,-25678,-25819,-25960,-26099,-26236,-26373
		dc.w -26508,-26642,-26774,-26905,-27035,-27164,-27291,-27417
		dc.w -27542,-27665,-27787,-27907,-28026,-28144,-28261,-28376
		dc.w -28489,-28602,-28713,-28822,-28930,-29037,-29142,-29246
		dc.w -29348,-29449,-29549,-29647,-29744,-29839,-29933,-30025
		dc.w -30116,-30205,-30293,-30380,-30465,-30548,-30630,-30710
		dc.w -30789,-30867,-30943,-31017,-31090,-31162,-31232,-31300
		dc.w -31367,-31432,-31496,-31558,-31619,-31678,-31736,-31792
		dc.w -31847,-31900,-31951,-32001,-32049,-32096,-32141,-32185
		dc.w -32227,-32268,-32307,-32344,-32380,-32414,-32447,-32478
		dc.w -32507,-32535,-32561,-32586,-32609,-32631,-32651,-32669
		dc.w -32686,-32701,-32714,-32726,-32737,-32746,-32753,-32758
		dc.w -32762,-32765,-32766,-32765,-32762,-32758,-32753,-32746
		dc.w -32737,-32726,-32714,-32701,-32686,-32669,-32651,-32631
		dc.w -32609,-32586,-32561,-32535,-32507,-32478,-32447,-32414
		dc.w -32380,-32344,-32307,-32268,-32227,-32185,-32141,-32096
		dc.w -32049,-32001,-31951,-31900,-31847,-31792,-31736,-31678
		dc.w -31619,-31558,-31496,-31432,-31367,-31300,-31232,-31162
		dc.w -31090,-31017,-30943,-30867,-30789,-30710,-30630,-30548
		dc.w -30465,-30380,-30293,-30205,-30116,-30025,-29933,-29839
		dc.w -29744,-29647,-29549,-29449,-29348,-29246,-29142,-29037
		dc.w -28930,-28822,-28713,-28602,-28489,-28376,-28261,-28144
		dc.w -28026,-27907,-27787,-27665,-27542,-27417,-27291,-27164
		dc.w -27035,-26905,-26774,-26642,-26508,-26373,-26236,-26099
		dc.w -25960,-25819,-25678,-25535,-25391,-25246,-25100,-24952
		dc.w -24803,-24653,-24502,-24349,-24196,-24041,-23885,-23728
		dc.w -23569,-23410,-23249,-23088,-22925,-22761,-22596,-22429
		dc.w -22262,-22094,-21924,-21754,-21582,-21409,-21236,-21061
		dc.w -20885,-20709,-20531,-20352,-20172,-19992,-19810,-19627
		dc.w -19443,-19259,-19073,-18887,-18700,-18511,-18322,-18132
		dc.w -17941,-17749,-17556,-17363,-17168,-16973,-16777,-16580
		dc.w -16383,-16184,-15985,-15785,-15584,-15382,-15180,-14977
		dc.w -14773,-14568,-14363,-14157,-13951,-13743,-13535,-13327
		dc.w -13117,-12907,-12697,-12486,-12274,-12061,-11848,-11635
		dc.w -11421,-11206,-10991,-10775,-10559,-10342,-10125,-9907
		dc.w -9689,-9470,-9251,-9031,-8811,-8590,-8369,-8148
		dc.w -7926,-7704,-7482,-7259,-7036,-6812,-6588,-6364
		dc.w -6139,-5914,-5689,-5464,-5238,-5012,-4786,-4560
		dc.w -4333,-4106,-3879,-3652,-3424,-3197,-2969,-2741
		dc.w -2513,-2285,-2057,-1829,-1600,-1372,-1143,-914
		dc.w -686,-457,-228,0,228,457,686,914
		dc.w 1143,1372,1600,1829,2057,2285,2513,2741
		dc.w 2969,3197,3424,3652,3879,4106,4333,4560
		dc.w 4786,5012,5238,5464,5689,5914,6139,6364
		dc.w 6588,6812,7036,7259,7482,7704,7926,8148
		dc.w 8369,8590,8811,9031,9251,9470,9689,9907
		dc.w 10125,10342,10559,10775,10991,11206,11421,11635
		dc.w 11848,12061,12274,12486,12697,12907,13117,13327
		dc.w 13535,13743,13951,14157,14363,14568,14773,14977
		dc.w 15180,15382,15584,15785,15985,16184,16382,16580
		dc.w 16777,16973,17168,17363,17556,17749,17941,18132
		dc.w 18322,18511,18700,18887,19073,19259,19443,19627
		dc.w 19810,19992,20172,20352,20531,20709,20885,21061
		dc.w 21236,21409,21582,21754,21924,22094,22262,22429
		dc.w 22596,22761,22925,23088,23249,23410,23569,23728
		dc.w 23885,24041,24196,24349,24502,24653,24803,24952
		dc.w 25100,25246,25391,25535,25678,25819,25960,26099
		dc.w 26236,26373,26508,26642,26774,26905,27035,27164
		dc.w 27291,27417,27542,27665,27787,27907,28026,28144
		dc.w 28261,28376,28489,28602,28713,28822,28930,29037
		dc.w 29142,29246,29348,29449,29549,29647,29744,29839
		dc.w 29933,30025,30116,30205,30293,30380,30465,30548
		dc.w 30630,30710,30789,30867,30943,31017,31090,31162
		dc.w 31232,31300,31367,31432,31496,31558,31619,31678
		dc.w 31736,31792,31847,31900,31951,32001,32049,32096
		dc.w 32141,32185,32227,32268,32307,32344,32380,32414
		dc.w 32447,32478,32507,32535,32561,32586,32609,32631
		dc.w 32651,32669,32686,32701,32714,32726,32737,32746
		dc.w 32753,32758,32762,32765
sin900:
		dc.w 0,228,457,686,914,1143,1372,1600
		dc.w 1829,2057,2285,2513,2741,2969,3197,3424
		dc.w 3652,3879,4106,4333,4560,4786,5012,5238
		dc.w 5464,5689,5914,6139,6364,6588,6812,7036
		dc.w 7259,7482,7704,7926,8148,8369,8590,8811
		dc.w 9031,9251,9470,9689,9907,10125,10342,10559
		dc.w 10775,10991,11206,11421,11635,11848,12061,12274
		dc.w 12486,12697,12907,13117,13327,13535,13743,13951
		dc.w 14157,14363,14568,14773,14977,15180,15382,15584
		dc.w 15785,15985,16184,16382,16580,16777,16973,17168
		dc.w 17363,17556,17749,17941,18132,18322,18511,18700
		dc.w 18887,19073,19259,19443,19627,19810,19992,20172
		dc.w 20352,20531,20709,20885,21061,21236,21409,21582
		dc.w 21754,21924,22094,22262,22429,22596,22761,22925
		dc.w 23088,23249,23410,23569,23728,23885,24041,24196
		dc.w 24349,24502,24653,24803,24952,25100,25246,25391
		dc.w 25535,25678,25819,25960,26099,26236,26373,26508
		dc.w 26642,26774,26905,27035,27164,27291,27417,27542
		dc.w 27665,27787,27907,28026,28144,28261,28376,28489
		dc.w 28602,28713,28822,28930,29037,29142,29246,29348
		dc.w 29449,29549,29647,29744,29839,29933,30025,30116
		dc.w 30205,30293,30380,30465,30548,30630,30710,30789
		dc.w 30867,30943,31017,31090,31162,31232,31300,31367
		dc.w 31432,31496,31558,31619,31678,31736,31792,31847
		dc.w 31900,31951,32001,32049,32096,32141,32185,32227
		dc.w 32268,32307,32344,32380,32414,32447,32478,32507
		dc.w 32535,32561,32586,32609,32631,32651,32669,32686
		dc.w 32701,32714,32726,32737,32746,32753,32758,32762
		dc.w 32765,32766,32765,32762,32758,32753,32746,32737
		dc.w 32726,32714,32701,32686,32669,32651,32631,32609
		dc.w 32586,32561,32535,32507,32478,32447,32414,32380
		dc.w 32344,32307,32268,32227,32185,32141,32096,32049
		dc.w 32001,31951,31900,31847,31792,31736,31678,31619
		dc.w 31558,31496,31432,31367,31300,31232,31162,31090
		dc.w 31017,30943,30867,30789,30710,30630,30548,30465
		dc.w 30380,30293,30205,30116,30025,29933,29839,29744
		dc.w 29647,29549,29449,29348,29246,29142,29037,28930
		dc.w 28822,28713,28602,28489,28376,28261,28144,28026
		dc.w 27907,27787,27665,27542,27417,27291,27164,27035
		dc.w 26905,26774,26642,26508,26373,26236,26099,25960
		dc.w 25819,25678,25535,25391,25246,25100,24952,24803
		dc.w 24653,24502,24349,24196,24041,23885,23728,23569
		dc.w 23410,23249,23088,22925,22761,22596,22429,22262
		dc.w 22094,21924,21754,21582,21409,21236,21061,20885
		dc.w 20709,20531,20352,20172,19992,19810,19627,19443
		dc.w 19259,19073,18887,18700,18511,18322,18132,17941
		dc.w 17749,17556,17363,17168,16973,16777,16580,16383
		dc.w 16184,15985,15785,15584,15382,15180,14977,14773
		dc.w 14568,14363,14157,13951,13743,13535,13327,13117
		dc.w 12907,12697,12486,12274,12061,11848,11635,11421
		dc.w 11206,10991,10775,10559,10342,10125,9907,9689
		dc.w 9470,9251,9031,8811,8590,8369,8148,7926
		dc.w 7704,7482,7259,7036,6812,6588,6364,6139
		dc.w 5914,5689,5464,5238,5012,4786,4560,4333
		dc.w 4106,3879,3652,3424,3197,2969,2741,2513
		dc.w 2285,2057,1829,1600,1372,1143,914,686
		dc.w 457,228,0,-228,-457,-686,-914,-1143
		dc.w -1372,-1600,-1829,-2057,-2285,-2513,-2741,-2969
		dc.w -3197,-3424,-3652,-3879,-4106,-4333,-4560,-4786
		dc.w -5012,-5238,-5464,-5689,-5914,-6139,-6364,-6588
		dc.w -6812,-7036,-7259,-7482,-7704,-7926,-8148,-8369
		dc.w -8590,-8811,-9031,-9251,-9470,-9689,-9907,-10125
		dc.w -10342,-10559,-10775,-10991,-11206,-11421,-11635,-11848
		dc.w -12061,-12274,-12486,-12697,-12907,-13117,-13327,-13535
		dc.w -13743,-13951,-14157,-14363,-14568,-14773,-14977,-15180
		dc.w -15382,-15584,-15785,-15985,-16184,-16382,-16580,-16777
		dc.w -16973,-17168,-17363,-17556,-17749,-17941,-18132,-18322
		dc.w -18511,-18700,-18887,-19073,-19259,-19443,-19627,-19810
		dc.w -19992,-20172,-20352,-20531,-20709,-20885,-21061,-21236
		dc.w -21409,-21582,-21754,-21924,-22094,-22262,-22429,-22596
		dc.w -22761,-22925,-23088,-23249,-23410,-23569,-23728,-23885
		dc.w -24041,-24196,-24349,-24502,-24653,-24803,-24952,-25100
		dc.w -25246,-25391,-25535,-25678,-25819,-25960,-26099,-26236
		dc.w -26373,-26508,-26642,-26774,-26905,-27035,-27164,-27291
		dc.w -27417,-27542,-27665,-27787,-27907,-28026,-28144,-28261
		dc.w -28376,-28489,-28602,-28713,-28822,-28930,-29037,-29142
		dc.w -29246,-29348,-29449,-29549,-29647,-29744,-29839,-29933
		dc.w -30025,-30116,-30205,-30293,-30380,-30465,-30548,-30630
		dc.w -30710,-30789,-30867,-30943,-31017,-31090,-31162,-31232
		dc.w -31300,-31367,-31432,-31496,-31558,-31619,-31678,-31736
		dc.w -31792,-31847,-31900,-31951,-32001,-32049,-32096,-32141
		dc.w -32185,-32227,-32268,-32307,-32344,-32380,-32414,-32447
		dc.w -32478,-32507,-32535,-32561,-32586,-32609,-32631,-32651
		dc.w -32669,-32686,-32701,-32714,-32726,-32737,-32746,-32753
		dc.w -32758,-32762,-32765,-32766,-32765,-32762,-32758,-32753
		dc.w -32746,-32737,-32726,-32714,-32701,-32686,-32669,-32651
		dc.w -32631,-32609,-32586,-32561,-32535,-32507,-32478,-32447
		dc.w -32414,-32380,-32344,-32307,-32268,-32227,-32185,-32141
		dc.w -32096,-32049,-32001,-31951,-31900,-31847,-31792,-31736
		dc.w -31678,-31619,-31558,-31496,-31432,-31367,-31300,-31232
		dc.w -31162,-31090,-31017,-30943,-30867,-30789,-30710,-30630
		dc.w -30548,-30465,-30380,-30293,-30205,-30116,-30025,-29933
		dc.w -29839,-29744,-29647,-29549,-29449,-29348,-29246,-29142
		dc.w -29037,-28930,-28822,-28713,-28602,-28489,-28376,-28261
		dc.w -28144,-28026,-27907,-27787,-27665,-27542,-27417,-27291
		dc.w -27164,-27035,-26905,-26774,-26642,-26508,-26373,-26236
		dc.w -26099,-25960,-25819,-25678,-25535,-25391,-25246,-25100
		dc.w -24952,-24803,-24653,-24502,-24349,-24196,-24041,-23885
		dc.w -23728,-23569,-23410,-23249,-23088,-22925,-22761,-22596
		dc.w -22429,-22262,-22094,-21924,-21754,-21582,-21409,-21236
		dc.w -21061,-20885,-20709,-20531,-20352,-20172,-19992,-19810
		dc.w -19627,-19443,-19259,-19073,-18887,-18700,-18511,-18322
		dc.w -18132,-17941,-17749,-17556,-17363,-17168,-16973,-16777
		dc.w -16580,-16383,-16184,-15985,-15785,-15584,-15382,-15180
		dc.w -14977,-14773,-14568,-14363,-14157,-13951,-13743,-13535
		dc.w -13327,-13117,-12907,-12697,-12486,-12274,-12061,-11848
		dc.w -11635,-11421,-11206,-10991,-10775,-10559,-10342,-10125
		dc.w -9907,-9689,-9470,-9251,-9031,-8811,-8590,-8369
		dc.w -8148,-7926,-7704,-7482,-7259,-7036,-6812,-6588
		dc.w -6364,-6139,-5914,-5689,-5464,-5238,-5012,-4786
		dc.w -4560,-4333,-4106,-3879,-3652,-3424,-3197,-2969
		dc.w -2741,-2513,-2285,-2057,-1829,-1600,-1372,-1143
		dc.w -914,-686,-457,-228

sinsin900:
		dc.w 0,718,1436,2154,2870,3585,4298,5008
		dc.w 5716,6421,7123,7821,8514,9203,9888,10567
		dc.w 11241,11909,12570,13225,13874,14515,15148,15774
		dc.w 16392,17001,17601,18193,18776,19349,19912,20465
		dc.w 21008,21540,22062,22573,23073,23562,24039,24504
		dc.w 24958,25399,25829,26246,26650,27043,27422,27789
		dc.w 28143,28484,28812,29127,29429,29718,29993,30256
		dc.w 30505,30741,30963,31173,31369,31552,31722,31879
		dc.w 32023,32153,32271,32376,32468,32548,32615,32669
		dc.w 32712,32742,32760,32766,32760,32742,32713,32673
		dc.w 32621,32558,32485,32400,32306,32201,32085,31960
		dc.w 31825,31681,31527,31364,31193,31012,30823,30626
		dc.w 30421,30208,29987,29759,29524,29282,29033,28777
		dc.w 28516,28248,27975,27696,27411,27122,26827,26528
		dc.w 26225,25917,25605,25289,24970,24648,24322,23993
		dc.w 23662,23328,22992,22654,22314,21972,21628,21284
		dc.w 20938,20591,20243,19895,19547,19198,18849,18500
		dc.w 18152,17804,17456,17110,16764,16419,16076,15734
		dc.w 15393,15054,14716,14381,14047,13716,13387,13060
		dc.w 12736,12414,12095,11779,11465,11155,10848,10544
		dc.w 10243,9945,9651,9360,9073,8790,8510,8234
		dc.w 7962,7694,7430,7170,6914,6662,6414,6170
		dc.w 5931,5696,5466,5239,5018,4801,4588,4380
		dc.w 4176,3977,3783,3593,3408,3228,3053,2882
		dc.w 2716,2555,2399,2247,2101,1959,1822,1690
		dc.w 1563,1441,1323,1211,1104,1001,904,811
		dc.w 724,641,563,491,423,361,303,250
		dc.w 203,160,122,90,62,40,22,10
		dc.w 2,0,2,10,22,40,62,90
		dc.w 122,160,203,250,303,361,423,491
		dc.w 563,641,724,811,904,1001,1104,1211
		dc.w 1323,1441,1563,1690,1822,1959,2101,2247
		dc.w 2399,2555,2716,2882,3053,3228,3408,3593
		dc.w 3783,3977,4176,4380,4588,4801,5018,5239
		dc.w 5466,5696,5931,6170,6414,6662,6914,7170
		dc.w 7430,7694,7962,8234,8510,8790,9073,9360
		dc.w 9651,9945,10243,10544,10848,11155,11465,11779
		dc.w 12095,12414,12736,13060,13387,13716,14047,14381
		dc.w 14716,15054,15393,15734,16076,16419,16764,17110
		dc.w 17456,17804,18152,18500,18849,19198,19547,19895
		dc.w 20243,20591,20938,21284,21628,21972,22314,22654
		dc.w 22992,23328,23662,23993,24322,24648,24970,25289
		dc.w 25605,25917,26225,26528,26827,27122,27411,27696
		dc.w 27975,28248,28516,28777,29033,29282,29524,29759
		dc.w 29987,30208,30421,30626,30823,31012,31193,31364
		dc.w 31527,31681,31825,31960,32085,32201,32306,32400
		dc.w 32485,32558,32621,32673,32713,32742,32760,32766
		dc.w 32760,32742,32712,32669,32615,32548,32468,32376
		dc.w 32271,32153,32023,31879,31722,31552,31369,31173
		dc.w 30963,30741,30505,30256,29993,29718,29429,29127
		dc.w 28812,28484,28143,27789,27422,27043,26650,26246
		dc.w 25829,25399,24958,24504,24039,23562,23073,22573
		dc.w 22062,21540,21008,20465,19912,19349,18776,18193
		dc.w 17601,17001,16392,15774,15148,14515,13874,13225
		dc.w 12570,11909,11241,10567,9888,9203,8514,7821
		dc.w 7123,6421,5716,5008,4298,3585,2870,2154
		dc.w 1436,718,0,-718,-1436,-2154,-2870,-3585
		dc.w -4298,-5008,-5716,-6421,-7123,-7821,-8514,-9203
		dc.w -9888,-10567,-11241,-11909,-12570,-13225,-13874,-14515
		dc.w -15148,-15774,-16392,-17001,-17601,-18193,-18776,-19349
		dc.w -19912,-20465,-21008,-21540,-22062,-22573,-23073,-23562
		dc.w -24039,-24504,-24958,-25399,-25829,-26246,-26650,-27043
		dc.w -27422,-27789,-28143,-28484,-28812,-29127,-29429,-29718
		dc.w -29993,-30256,-30505,-30741,-30963,-31173,-31369,-31552
		dc.w -31722,-31879,-32023,-32153,-32271,-32376,-32468,-32548
		dc.w -32615,-32669,-32712,-32742,-32760,-32766,-32760,-32742
		dc.w -32713,-32673,-32621,-32558,-32485,-32400,-32306,-32201
		dc.w -32085,-31960,-31825,-31681,-31527,-31364,-31193,-31012
		dc.w -30823,-30626,-30421,-30208,-29987,-29759,-29524,-29282
		dc.w -29033,-28777,-28516,-28248,-27975,-27696,-27411,-27122
		dc.w -26827,-26528,-26225,-25917,-25605,-25289,-24970,-24648
		dc.w -24322,-23993,-23662,-23328,-22992,-22654,-22314,-21972
		dc.w -21628,-21284,-20938,-20591,-20243,-19895,-19547,-19198
		dc.w -18849,-18500,-18152,-17804,-17456,-17110,-16764,-16419
		dc.w -16076,-15734,-15393,-15054,-14716,-14381,-14047,-13716
		dc.w -13387,-13060,-12736,-12414,-12095,-11779,-11465,-11155
		dc.w -10848,-10544,-10243,-9945,-9651,-9360,-9073,-8790
		dc.w -8510,-8234,-7962,-7694,-7430,-7170,-6914,-6662
		dc.w -6414,-6170,-5931,-5696,-5466,-5239,-5018,-4801
		dc.w -4588,-4380,-4176,-3977,-3783,-3593,-3408,-3228
		dc.w -3053,-2882,-2716,-2555,-2399,-2247,-2101,-1959
		dc.w -1822,-1690,-1563,-1441,-1323,-1211,-1104,-1001
		dc.w -904,-811,-724,-641,-563,-491,-423,-361
		dc.w -303,-250,-203,-160,-122,-90,-62,-40
		dc.w -22,-10,-2,0,-2,-10,-22,-40
		dc.w -62,-90,-122,-160,-203,-250,-303,-361
		dc.w -423,-491,-563,-641,-724,-811,-904,-1001
		dc.w -1104,-1211,-1323,-1441,-1563,-1690,-1822,-1959
		dc.w -2101,-2247,-2399,-2555,-2716,-2882,-3053,-3228
		dc.w -3408,-3593,-3783,-3977,-4176,-4380,-4588,-4801
		dc.w -5018,-5239,-5466,-5696,-5931,-6170,-6414,-6662
		dc.w -6914,-7170,-7430,-7694,-7962,-8234,-8510,-8790
		dc.w -9073,-9360,-9651,-9945,-10243,-10544,-10848,-11155
		dc.w -11465,-11779,-12095,-12414,-12736,-13060,-13387,-13716
		dc.w -14047,-14381,-14716,-15054,-15393,-15734,-16076,-16419
		dc.w -16764,-17110,-17456,-17804,-18152,-18500,-18849,-19198
		dc.w -19547,-19895,-20243,-20591,-20938,-21284,-21628,-21972
		dc.w -22314,-22654,-22992,-23328,-23662,-23993,-24322,-24648
		dc.w -24970,-25289,-25605,-25917,-26225,-26528,-26827,-27122
		dc.w -27411,-27696,-27975,-28248,-28516,-28777,-29033,-29282
		dc.w -29524,-29759,-29987,-30208,-30421,-30626,-30823,-31012
		dc.w -31193,-31364,-31527,-31681,-31825,-31960,-32085,-32201
		dc.w -32306,-32400,-32485,-32558,-32621,-32673,-32713,-32742
		dc.w -32760,-32766,-32760,-32742,-32712,-32669,-32615,-32548
		dc.w -32468,-32376,-32271,-32153,-32023,-31879,-31722,-31552
		dc.w -31369,-31173,-30963,-30741,-30505,-30256,-29993,-29718
		dc.w -29429,-29127,-28812,-28484,-28143,-27789,-27422,-27043
		dc.w -26650,-26246,-25829,-25399,-24958,-24504,-24039,-23562
		dc.w -23073,-22573,-22062,-21540,-21008,-20465,-19912,-19349
		dc.w -18776,-18193,-17601,-17001,-16392,-15774,-15148,-14515
		dc.w -13874,-13225,-12570,-11909,-11241,-10567,-9888,-9203
		dc.w -8514,-7821,-7123,-6421,-5716,-5008,-4298,-3585
		dc.w -2870,-2154,-1436,-718

cossin900:
		dc.w 32766,32758,32734,32695,32640,32569,32482,32380
		dc.w 32263,32130,31982,31818,31640,31446,31238,31015
		dc.w 30777,30525,30258,29978,29683,29375,29053,28718
		dc.w 28370,28010,27636,27250,26852,26442,26021,25588
		dc.w 25144,24690,24224,23749,23264,22769,22265,21751
		dc.w 21229,20699,20161,19615,19061,18500,17933,17359
		dc.w 16779,16193,15602,15006,14405,13799,13189,12576
		dc.w 11959,11339,10716,10091,9463,8834,8203,7571
		dc.w 6937,6304,5670,5036,4402,3769,3137,2506
		dc.w 1877,1249,623,0,-621,-1239,-1854,-2466
		dc.w -3075,-3680,-4281,-4877,-5470,-6058,-6641,-7219
		dc.w -7792,-8360,-8922,-9478,-10029,-10574,-11113,-11645
		dc.w -12171,-12691,-13204,-13710,-14210,-14702,-15188,-15666
		dc.w -16138,-16602,-17058,-17508,-17950,-18384,-18811,-19231
		dc.w -19643,-20047,-20444,-20833,-21214,-21588,-21955,-22313
		dc.w -22664,-23008,-23344,-23672,-23993,-24306,-24613,-24911
		dc.w -25203,-25487,-25764,-26034,-26296,-26552,-26801,-27043
		dc.w -27278,-27506,-27728,-27943,-28152,-28354,-28551,-28741
		dc.w -28925,-29102,-29274,-29441,-29601,-29756,-29906,-30050
		dc.w -30189,-30323,-30451,-30575,-30694,-30808,-30918,-31023
		dc.w -31123,-31220,-31312,-31400,-31484,-31564,-31641,-31714
		dc.w -31783,-31849,-31912,-31971,-32028,-32081,-32132,-32179
		dc.w -32224,-32266,-32306,-32344,-32379,-32412,-32443,-32471
		dc.w -32498,-32523,-32546,-32568,-32588,-32606,-32623,-32638
		dc.w -32653,-32666,-32678,-32688,-32698,-32707,-32715,-32722
		dc.w -32728,-32734,-32739,-32743,-32747,-32750,-32753,-32755
		dc.w -32757,-32759,-32761,-32762,-32763,-32764,-32764,-32765
		dc.w -32765,-32765,-32765,-32765,-32765,-32765,-32765,-32765
		dc.w -32765,-32766,-32765,-32765,-32765,-32765,-32765,-32765
		dc.w -32765,-32765,-32765,-32765,-32764,-32764,-32763,-32762
		dc.w -32761,-32759,-32757,-32755,-32753,-32750,-32747,-32743
		dc.w -32739,-32734,-32728,-32722,-32715,-32707,-32698,-32688
		dc.w -32678,-32666,-32653,-32638,-32623,-32606,-32588,-32568
		dc.w -32546,-32523,-32498,-32471,-32443,-32412,-32379,-32344
		dc.w -32306,-32266,-32224,-32179,-32132,-32081,-32028,-31971
		dc.w -31912,-31849,-31783,-31714,-31641,-31564,-31484,-31400
		dc.w -31312,-31220,-31123,-31023,-30918,-30808,-30694,-30575
		dc.w -30451,-30323,-30189,-30050,-29906,-29756,-29601,-29441
		dc.w -29274,-29102,-28925,-28741,-28551,-28354,-28152,-27943
		dc.w -27728,-27506,-27278,-27043,-26801,-26552,-26296,-26034
		dc.w -25764,-25487,-25203,-24911,-24613,-24306,-23993,-23672
		dc.w -23344,-23008,-22664,-22313,-21955,-21588,-21214,-20833
		dc.w -20444,-20047,-19643,-19231,-18811,-18384,-17950,-17508
		dc.w -17058,-16602,-16138,-15666,-15188,-14702,-14210,-13710
		dc.w -13204,-12691,-12171,-11645,-11113,-10574,-10029,-9478
		dc.w -8922,-8360,-7792,-7219,-6641,-6058,-5470,-4877
		dc.w -4281,-3680,-3075,-2466,-1854,-1239,-621,0
		dc.w 623,1249,1877,2506,3137,3769,4402,5036
		dc.w 5670,6304,6937,7571,8203,8834,9463,10091
		dc.w 10716,11339,11959,12576,13189,13799,14405,15006
		dc.w 15602,16193,16779,17359,17933,18500,19061,19615
		dc.w 20161,20699,21229,21751,22265,22769,23264,23749
		dc.w 24224,24690,25144,25588,26021,26442,26852,27250
		dc.w 27636,28010,28370,28718,29053,29375,29683,29978
		dc.w 30258,30525,30777,31015,31238,31446,31640,31818
		dc.w 31982,32130,32263,32380,32482,32569,32640,32695
		dc.w 32734,32758,32766,32758,32734,32695,32640,32569
		dc.w 32482,32380,32263,32130,31982,31818,31640,31446
		dc.w 31238,31015,30777,30525,30258,29978,29683,29375
		dc.w 29053,28718,28370,28010,27636,27250,26852,26442
		dc.w 26021,25588,25144,24690,24224,23749,23264,22769
		dc.w 22265,21751,21229,20699,20161,19615,19061,18500
		dc.w 17933,17359,16779,16193,15602,15006,14405,13799
		dc.w 13189,12576,11959,11339,10716,10091,9463,8834
		dc.w 8203,7571,6937,6304,5670,5036,4402,3769
		dc.w 3137,2506,1877,1249,623,0,-621,-1239
		dc.w -1854,-2466,-3075,-3680,-4281,-4877,-5470,-6058
		dc.w -6641,-7219,-7792,-8360,-8922,-9478,-10029,-10574
		dc.w -11113,-11645,-12171,-12691,-13204,-13710,-14210,-14702
		dc.w -15188,-15666,-16138,-16602,-17058,-17508,-17950,-18384
		dc.w -18811,-19231,-19643,-20047,-20444,-20833,-21214,-21588
		dc.w -21955,-22313,-22664,-23008,-23344,-23672,-23993,-24306
		dc.w -24613,-24911,-25203,-25487,-25764,-26034,-26296,-26552
		dc.w -26801,-27043,-27278,-27506,-27728,-27943,-28152,-28354
		dc.w -28551,-28741,-28925,-29102,-29274,-29441,-29601,-29756
		dc.w -29906,-30050,-30189,-30323,-30451,-30575,-30694,-30808
		dc.w -30918,-31023,-31123,-31220,-31312,-31400,-31484,-31564
		dc.w -31641,-31714,-31783,-31849,-31912,-31971,-32028,-32081
		dc.w -32132,-32179,-32224,-32266,-32306,-32344,-32379,-32412
		dc.w -32443,-32471,-32498,-32523,-32546,-32568,-32588,-32606
		dc.w -32623,-32638,-32653,-32666,-32678,-32688,-32698,-32707
		dc.w -32715,-32722,-32728,-32734,-32739,-32743,-32747,-32750
		dc.w -32753,-32755,-32757,-32759,-32761,-32762,-32763,-32764
		dc.w -32764,-32765,-32765,-32765,-32765,-32765,-32765,-32765
		dc.w -32765,-32765,-32765,-32766,-32765,-32765,-32765,-32765
		dc.w -32765,-32765,-32765,-32765,-32765,-32765,-32764,-32764
		dc.w -32763,-32762,-32761,-32759,-32757,-32755,-32753,-32750
		dc.w -32747,-32743,-32739,-32734,-32728,-32722,-32715,-32707
		dc.w -32698,-32688,-32678,-32666,-32653,-32638,-32623,-32606
		dc.w -32588,-32568,-32546,-32523,-32498,-32471,-32443,-32412
		dc.w -32379,-32344,-32306,-32266,-32224,-32179,-32132,-32081
		dc.w -32028,-31971,-31912,-31849,-31783,-31714,-31641,-31564
		dc.w -31484,-31400,-31312,-31220,-31123,-31023,-30918,-30808
		dc.w -30694,-30575,-30451,-30323,-30189,-30050,-29906,-29756
		dc.w -29601,-29441,-29274,-29102,-28925,-28741,-28551,-28354
		dc.w -28152,-27943,-27728,-27506,-27278,-27043,-26801,-26552
		dc.w -26296,-26034,-25764,-25487,-25203,-24911,-24613,-24306
		dc.w -23993,-23672,-23344,-23008,-22664,-22313,-21955,-21588
		dc.w -21214,-20833,-20444,-20047,-19643,-19231,-18811,-18384
		dc.w -17950,-17508,-17058,-16602,-16138,-15666,-15188,-14702
		dc.w -14210,-13710,-13204,-12691,-12171,-11645,-11113,-10574
		dc.w -10029,-9478,-8922,-8360,-7792,-7219,-6641,-6058
		dc.w -5470,-4877,-4281,-3680,-3075,-2466,-1854,-1239
		dc.w -621,0,623,1249,1877,2506,3137,3769
		dc.w 4402,5036,5670,6304,6937,7571,8203,8834
		dc.w 9463,10091,10716,11339,11959,12576,13189,13799
		dc.w 14405,15006,15602,16193,16779,17359,17933,18500
		dc.w 19061,19615,20161,20699,21229,21751,22265,22769
		dc.w 23264,23749,24224,24690,25144,25588,26021,26442
		dc.w 26852,27250,27636,28010,28370,28718,29053,29375
		dc.w 29683,29978,30258,30525,30777,31015,31238,31446
		dc.w 31640,31818,31982,32130,32263,32380,32482,32569
		dc.w 32640,32695,32734,32758

