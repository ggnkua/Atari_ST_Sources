Gen30 Macro Assembler Copyright ½ HiSoft 1985-93
All Rights Reserved - version 3.10

Assembling D:\SOURCE\BINLINER\FX\WORSHIP\3DCAM8.S
Pass 1
Error: file not found at line 84 in file D:\SOURCE\BINLINER\FX\WORSHIP\3DCAM8.S

1 error found
83 lines assembled into 0 bytes, Atari executable position-independent code
518 bytes used out of 1629348, took 1.0 seconds

Gen30 Macro Assembler Copyright ½ HiSoft 1985-93
All Rights Reserved - version 3.10

Assembling D:\SOURCE\BINLINER\FX\WORSHIP\3DCAM8.S
Pass 1
Error: file not found at line 84 in file D:\SOURCE\BINLINER\FX\WORSHIP\3DCAM8.S

1 error found
83 lines assembled into 0 bytes, Atari executable position-independent code
518 bytes used out of 1629348, took 1.2 seconds

Gen30 Macro Assembler Copyright ½ HiSoft 1985-93
All Rights Reserved - version 3.10

Assembling D:\SOURCE\BINLINER\FX\WORSHIP\3DCAM8.S
Pass 1
Pass 2

0 errors found
4117 lines assembled into 364462 bytes, Atari executable relocatable code
12 optimisations saving 40 bytes
70590 bytes used out of 1629348, took 7.4 seconds

