
	lea	$FFFF8200.w,a1
	bsr	$8F39E
	movem.l	(a0)+,d0-d2
	movem.l	d0-d2,$82(a1)
	movem.l	(a0)+,d0-d2
	movem.l	d0-d2,$A2(a1)
	move.w	(a0)+,$A(a1)
	move.w	(a0)+,$C0(a1)
	clr.w	$66(a1)
	tst.w	(a0)+
	bne.s	$8F25E
	bsr	$8F3B0
	move.w	(a0)+,$66(a1)
	bra.s	$8F264
	move.w	(a0)+,d0
	move.b	d0,$60(a1)
	move.w	(a0)+,$C2(a1)
	move.w	(a0)+,$10(a1)
	clr.w	$E(a1)
	move.l	$44E.w,d0
	lsr.w	#8,d0
	move.l	d0,(a1)
	rts
	move.w	$8F4F0(pc),d0
	beq	$8F2DA
	cmp.w	#1,d0
	bne	$8F2DA
	lea	$FFFF9203.w,a0
	bsr	$8F39E
	move.b	#$FF,(a0)
	bsr	$8F39E
	move.b	$FFFF8006.w,d0
	eori.b	#$C0,d0
	move.b	#0,(a0)
	bsr	$8F39E
	move.b	#$AA,(a0)
	move.w	$468.w,d1
	addq.w	#2,d1
	cmp.b	$FFFF8006.w,d0
	beq.s	$8F2C6
	cmp.w	$468.w,d1
	bne.s	$8F2B4
	move.b	#$FF,(a0)
	rts
	move.b	$8F4F2,(a0)
	bsr	$8F39E
	bsr	$8F39E
	move.b	#$FF,(a0)
	rts
	rts
	pea	$8EB57(pc)
	move.l	$8EB64(pc),-(a7)
	bsr	$8F3F8
	addq.w	#8,a7
	clr.w	-(a7)
	pea	$8EACE(pc)
	move.w	#$3C,-(a7)
	trap	#1
	addq.l	#8,a7
	move.l	d0,d7
	bmi.s	$8F316
	pea	$8FC78(pc)
	move.l	#$12,-(a7)
	move.w	d7,-(a7)
	move.w	#$40,-(a7)
	trap	#1
	lea	$C(a7),a7
	bsr	$8F3D6
	rts
	move.w	#8,d0
	lea	$8FC78(pc),a0
	clr.w	(a0)+
	dbf	d0,$8F320
	pea	$8EB57(pc)
