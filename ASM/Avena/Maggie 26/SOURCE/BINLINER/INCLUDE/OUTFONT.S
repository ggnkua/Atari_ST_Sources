fontdata:;d:\source\binliner\font\A.fon
 dc.w 20
 dc.w spline,-17441,3770,-17441,-89,-13001,-1885,-8879,-2334
 dc.w spline,-8879,-2334,-4756,-2783,-4122,-3321,-4122,-4129
 dc.w spline,-4122,-4129,-4122,-4937,-5179,-6194,-7610,-6194
 dc.w spline,-7610,-6194,-10253,-6194,-12050,-4847,-11838,-4039
 dc.w line,-11838,-4039,-16806,-4578
 dc.w spline,-16806,-4578,-15644,-7720,-12367,-9875,-7293,-9875
 dc.w spline,-7293,-9875,-1479,-9875,1479,-7361,1479,-4129
 dc.w line,1479,-4129,1479,4847
 dc.w spline,1479,4847,1479,7092,1902,8169,2748,8887
 dc.w line,2748,8887,-2853,8887
 dc.w line,-2853,8887,-3593,6284
 dc.w spline,-3593,6284,-4439,7990,-7187,9426,-10464,9426
 dc.w spline,-10464,9426,-14375,9516,-17441,7271,-17441,3770
 dc.w spline,-11838,3680,-11944,2244,-10358,1346,-8033,1167
 dc.w spline,-8033,1167,-5707,987,-4862,359,-4122,-89
 dc.w line,-4122,-89,-4122,1975
 dc.w spline,-4122,1975,-4122,4309,-5707,5745,-8139,5745
 dc.w spline,-8139,5745,-10570,5745,-11733,5027,-11838,3680
 dc.w fill
 dc.w fill
 dc.w 20189   ;width
;d:\source\binliner\font\B.fon
 dc.w 15
 dc.w line,-17441,-15800,-11838,-15800
 dc.w line,-11838,-15800,-11838,-6643
 dc.w spline,-11838,-6643,-10993,-8259,-8139,-9875,-5602,-9875
 dc.w spline,-5602,-9875,-634,-9875,2642,-5745,2748,-448
 dc.w spline,2748,-448,2959,5117,-739,9426,-5390,9426
 dc.w spline,-5390,9426,-9090,9336,-11310,7092,-11838,5655
 dc.w line,-11838,5655,-11838,8887
 dc.w line,-11838,8887,-17441,8887
 dc.w line,-17441,8887,-17441,-15800
 dc.w spline,-11838,-448,-11944,-3591,-9407,-6194,-7293,-6194
 dc.w spline,-7293,-6194,-4968,-6194,-2748,-3950,-2853,-179
 dc.w spline,-2853,-179,-2959,3591,-4333,5476,-7082,5745
 dc.w spline,-7082,5745,-9724,5745,-11733,3411,-11838,-448
 dc.w fill
 dc.w fill
 dc.w 20400   ;width
;d:\source\binliner\font\C.fon
 dc.w 12
 dc.w spline,-17441,-359,-17441,-7271,-12261,-9875,-7610,-9875
 dc.w spline,-7610,-9875,-2959,-9875,1374,-7271,1479,-4039
 dc.w line,1479,-4039,-4122,-3411
 dc.w spline,-4122,-3411,-4122,-4847,-5707,-6104,-7504,-6284
 dc.w spline,-7504,-6284,-9513,-6284,-11838,-4488,-11838,-269
 dc.w spline,-11838,-269,-11838,3950,-9513,5745,-7399,5835
 dc.w spline,-7399,5835,-5390,5745,-3488,4578,-3488,2513
 dc.w line,-3488,2513,2114,3052
 dc.w spline,2114,3052,1902,6284,-2536,9336,-7399,9426
 dc.w spline,-7399,9426,-12261,9516,-17441,6284,-17441,-359
 dc.w fill
 dc.w fill
 dc.w 19555   ;width
;d:\source\binliner\font\D.fon
 dc.w 15
 dc.w spline,-17441,-538,-17441,-6284,-13318,-9875,-8773,-9875
 dc.w spline,-8773,-9875,-6342,-9875,-2853,-8259,-2853,-6463
 dc.w line,-2853,-6463,-2853,-15800
 dc.w line,-2853,-15800,2748,-15800
 dc.w line,2748,-15800,2748,8887
 dc.w line,2748,8887,-2853,8887
 dc.w line,-2853,8887,-2853,5476
 dc.w spline,-2853,5476,-2959,7271,-6130,9426,-9196,9426
 dc.w spline,-9196,9426,-12261,9426,-17441,7182,-17441,-538
 dc.w spline,-11838,-359,-11838,-4129,-9513,-6194,-7399,-6194
 dc.w spline,-7399,-6194,-5285,-6194,-2748,-4309,-2853,-359
 dc.w spline,-2853,-359,-2959,3591,-4862,5745,-7187,5745
 dc.w spline,-7187,5745,-9513,5745,-11838,4219,-11838,-359
 dc.w fill
 dc.w fill
 dc.w 20189   ;width
;d:\source\binliner\font\E.fon
 dc.w 13
 dc.w spline,-17441,-179,-17441,-6553,-12684,-9875,-7293,-9875
 dc.w spline,-7293,-9875,-1902,-9875,2853,-7002,2748,1346
 dc.w line,2748,1346,-11838,1346
 dc.w spline,-11838,1346,-11838,4219,-9407,5745,-6870,5745
 dc.w spline,-6870,5745,-4968,5835,-3488,4219,-3276,2872
 dc.w line,-3276,2872,2114,3591
 dc.w spline,2114,3591,1796,5655,-1162,9246,-6870,9426
 dc.w spline,-6870,9426,-12578,9605,-17441,6643,-17441,-179
 dc.w spline,-11838,-1256,-11838,-4668,-9301,-6194,-6976,-6194
 dc.w spline,-6976,-6194,-4650,-6194,-2853,-3770,-2853,-1256
 dc.w line,-2853,-1256,-11838,-1256
 dc.w fill
 dc.w fill
 dc.w 20294   ;width
;d:\source\binliner\font\F.fon
 dc.w 18
 dc.w line,-17441,-5655,-17441,-9336
 dc.w line,-17441,-9336,-14269,-9336
 dc.w line,-14269,-9336,-14269,-11401
 dc.w spline,-14269,-11401,-14269,-14992,-11098,-16339,-8033,-16339
 dc.w spline,-8033,-16339,-6342,-16339,-3699,-15800,-3488,-15531
 dc.w line,-3488,-15531,-4333,-12029
 dc.w spline,-4333,-12029,-4650,-12568,-5496,-12927,-6447,-13017
 dc.w spline,-6447,-13017,-7822,-13196,-8667,-12209,-8667,-10144
 dc.w line,-8667,-10234,-8667,-9336
 dc.w line,-8667,-9336,-4862,-9336
 dc.w line,-4862,-9336,-4862,-5655
 dc.w line,-4862,-5655,-8667,-5655
 dc.w line,-8667,-5655,-8667,8887
 dc.w line,-8667,8887,-14269,8887
 dc.w line,-14269,8887,-14269,-5655
 dc.w line,-14269,-5655,-17441,-5655
 dc.w fill
 dc.w fill
 dc.w 13953   ;width
;d:\source\binliner\font\G.fon
 dc.w 21
 dc.w spline,-17441,-538,-17441,-7182,-13001,-9875,-8879,-9875
 dc.w spline,-8879,-9875,-4756,-9875,-3065,-7271,-2853,-6284
 dc.w line,-2853,-6284,-2853,-9336
 dc.w line,-2853,-9336,2748,-9336
 dc.w line,2748,-9336,2748,8438
 dc.w spline,2748,8438,2853,14094,-528,16428,-7082,16428
 dc.w spline,-7082,16428,-13952,16339,-17018,14723,-16806,10054
 dc.w line,-16806,10054,-11204,10593
 dc.w spline,-11204,10593,-11098,12209,-9936,12837,-7610,12748
 dc.w spline,-7610,12748,-4545,12748,-2959,12119,-2853,9695
 dc.w line,-2853,9695,-2853,5117
 dc.w spline,-2853,5117,-2959,7002,-6025,8887,-9196,8887
 dc.w spline,-9196,8887,-13530,8887,-17441,5296,-17441,-538
 dc.w spline,-11838,-538,-11944,-4398,-9830,-6194,-7293,-6194
 dc.w spline,-7293,-6194,-4545,-6104,-2853,-3501,-2853,-359
 dc.w spline,-2853,-359,-2853,2783,-4650,5206,-7610,5206
 dc.w spline,-7610,5206,-10570,5206,-11838,2603,-11838,-538
 dc.w fill
 dc.w fill
 dc.w fill
 dc.w fill
 dc.w 20294   ;width
;d:\source\binliner\font\H.fon
 dc.w 16
 dc.w line,-17441,-15800,-11838,-15800
 dc.w line,-11838,-15800,-11838,-7002
 dc.w spline,-11838,-7002,-10993,-8887,-7610,-9875,-5496,-9875
 dc.w spline,-5496,-9875,-1796,-9875,1479,-7541,1479,-3860
 dc.w line,1479,-3860,1479,8887
 dc.w line,1479,8887,-4122,8887
 dc.w line,-4122,8887,-4122,-2872
 dc.w spline,-4122,-2872,-4122,-5117,-5707,-6194,-7504,-6194
 dc.w spline,-7504,-6194,-9301,-6194,-11521,-4758,-11838,-1526
 dc.w line,-11838,-1526,-11838,8887
 dc.w line,-11838,8887,-17441,8887
 dc.w line,-17441,8887,-17441,-15800
 dc.w fill
 dc.w fill
 dc.w fill
 dc.w fill
 dc.w 18920   ;width
;d:\source\binliner\font\I.fon
 dc.w 10
 dc.w line,-17441,-15800,-11838,-15800
 dc.w line,-11838,-15800,-11838,-11581
 dc.w line,-11838,-11581,-17441,-11581
 dc.w line,-17441,-11581,-17441,-15800
 dc.w line,-17441,-9336,-11838,-9336
 dc.w line,-11838,-9336,-11838,8887
 dc.w line,-11838,8887,-17441,8887
 dc.w line,-17441,8887,-17441,-9336
 dc.w fill
 dc.w fill
 dc.w 5603   ;width
;d:\source\binliner\font\J.fon
 dc.w 15
 dc.w line,-13001,-11581,-13001,-15800
 dc.w line,-13001,-15800,-7399,-15800
 dc.w line,-7399,-15800,-7399,-11581
 dc.w line,-7399,-11581,-13001,-11581
 dc.w line,-13001,-9336,-7399,-9336
 dc.w line,-7399,-9336,-7399,10144
 dc.w spline,-7399,10144,-7293,14364,-9513,16428,-13530,16428
 dc.w spline,-13530,16428,-16066,16249,-17441,15620,-17441,15172
 dc.w line,-17441,15172,-16278,11760
 dc.w spline,-16278,11760,-13952,13017,-13107,11311,-13001,10413
 dc.w line,-13001,10413,-13001,-9336
 dc.w fill
 dc.w fill
 dc.w fill
 dc.w fill
 dc.w 10148   ;width
;d:\source\binliner\font\K.fon
 dc.w 16
 dc.w line,-17441,-15800,-11838,-15800
 dc.w line,-11838,-15800,-11838,-3052
 dc.w line,-11838,-3052,-5073,-9336
 dc.w line,-5073,-9336,1268,-9336
 dc.w line,1268,-9336,-6553,-2603
 dc.w line,-6553,-2603,1796,8887
 dc.w line,1796,8887,-4122,8887
 dc.w line,-4122,8887,-9618,538
 dc.w line,-9618,538,-11733,3052
 dc.w line,-11733,3052,-11733,8887
 dc.w line,-11733,8887,-17441,8887
 dc.w line,-17441,8887,-17441,-15800
 dc.w fill
 dc.w fill
 dc.w fill
 dc.w fill
 dc.w 19237   ;width
;d:\source\binliner\font\L.fon
 dc.w 6
 dc.w line,-17441,-15800,-11838,-15800
 dc.w line,-11838,-15800,-11838,8887
 dc.w line,-11838,8887,-17441,8887
 dc.w line,-17441,8887,-17441,-15800
 dc.w fill
 dc.w fill
 dc.w 5603   ;width
;d:\source\binliner\font\M.fon
 dc.w 25
 dc.w line,-17441,-9336,-11838,-9336
 dc.w line,-11838,-9336,-11838,-6463
 dc.w spline,-11838,-6463,-11944,-7630,-8033,-9875,-5496,-9875
 dc.w spline,-5496,-9875,-2959,-9875,422,-7990,422,-6822
 dc.w spline,422,-6822,422,-7990,4650,-9875,7082,-9875
 dc.w spline,7082,-9875,9513,-9875,13635,-8079,13635,-4219
 dc.w line,13635,-4219,13635,8887
 dc.w line,13635,8887,7927,8887
 dc.w line,7927,8887,7927,-2962
 dc.w spline,7927,-2962,7927,-4937,6553,-6194,5073,-6194
 dc.w spline,5073,-6194,3593,-6194,845,-4129,845,-1705
 dc.w line,845,-1705,845,8887
 dc.w line,845,8887,-4756,8887
 dc.w line,-4756,8887,-4756,-2783
 dc.w spline,-4756,-2783,-4756,-4758,-6342,-6194,-7610,-6194
 dc.w spline,-7610,-6194,-9618,-6104,-11521,-4309,-11838,-1526
 dc.w line,-11838,-1526,-11838,8887
 dc.w line,-11838,8887,-17441,8887
 dc.w line,-17441,8887,-17441,-9336
 dc.w fill
 dc.w fill
 dc.w fill
 dc.w fill
 dc.w fill
 dc.w fill
 dc.w 31076   ;width
;d:\source\binliner\font\N.fon
 dc.w 16
 dc.w line,-17441,-9336,-11838,-9336
 dc.w line,-11838,-9336,-11838,-6374
 dc.w spline,-11838,-6374,-11838,-7720,-7822,-9875,-5285,-9875
 dc.w spline,-5285,-9875,-2748,-9875,1585,-7900,1479,-3860
 dc.w line,1479,-3860,1479,8887
 dc.w line,1479,8887,-4122,8887
 dc.w line,-4122,8887,-4122,-2334
 dc.w spline,-4122,-2334,-4122,-4488,-5919,-6194,-7610,-6194
 dc.w spline,-7610,-6194,-10253,-6104,-11627,-4488,-11838,-1975
 dc.w line,-11838,-1975,-11838,8887
 dc.w line,-11838,8887,-17441,8887
 dc.w line,-17441,8887,-17441,-9336
 dc.w fill
 dc.w fill
 dc.w fill
 dc.w fill
 dc.w 19026   ;width
;d:\source\binliner\font\O.fon
 dc.w 12
 dc.w spline,-17441,-359,-17441,-5925,-11944,-9875,-6659,-9875
 dc.w spline,-6659,-9875,-1374,-9875,4016,-6463,4016,-89
 dc.w spline,4016,-89,4016,6284,-1691,9426,-6659,9426
 dc.w spline,-6659,9426,-11627,9426,-17441,6643,-17441,-359
 dc.w spline,-11838,-359,-11838,-2962,-9301,-6104,-6659,-6194
 dc.w spline,-6659,-6194,-4016,-6284,-1585,-2962,-1585,-359
 dc.w spline,-1585,-359,-1585,2244,-3065,5745,-6659,5745
 dc.w spline,-6659,5745,-10253,5745,-11838,2423,-11838,-359
 dc.w fill
 dc.w fill
 dc.w fill
 dc.w fill
 dc.w 21457   ;width
;d:\source\binliner\font\P.fon
 dc.w 17
 dc.w line,-17441,-9336,-11838,-9336
 dc.w line,-11838,-9336,-11838,-6284
 dc.w spline,-11838,-6284,-11733,-7990,-7716,-9875,-5602,-9875
 dc.w spline,-5602,-9875,-3488,-9875,2748,-7630,2748,-538
 dc.w spline,2748,-538,2748,6553,-1796,9426,-5707,9426
 dc.w spline,-5707,9426,-9618,9426,-11733,7630,-11838,6284
 dc.w line,-11838,6284,-11838,15890
 dc.w line,-11838,15890,-17441,15890
 dc.w line,-17441,15890,-17441,-9336
 dc.w spline,-11838,-628,-11838,-3052,-9301,-6104,-7293,-6194
 dc.w spline,-7293,-6194,-5179,-6104,-2959,-4488,-2853,-628
 dc.w spline,-2853,-628,-2748,3231,-3911,5745,-7187,5745
 dc.w spline,-7187,5745,-10464,5745,-11838,2962,-11838,-628
 dc.w fill
 dc.w fill
 dc.w fill
 dc.w fill
 dc.w 20189   ;width
;d:\source\binliner\font\Q.fon
 dc.w 17
 dc.w spline,-17441,-628,-17441,-5027,-13530,-9875,-9407,-9875
 dc.w spline,-9407,-9875,-5285,-9875,-2853,-7271,-2853,-6374
 dc.w line,-2853,-6374,-2853,-9336
 dc.w line,-2853,-9336,2748,-9336
 dc.w line,2748,-9336,2748,15890
 dc.w line,2748,15890,-2853,15890
 dc.w line,-2853,15890,-2853,6463
 dc.w spline,-2853,6463,-2959,8618,-6447,9426,-9090,9426
 dc.w spline,-9090,9426,-11733,9426,-17441,7182,-17441,-628
 dc.w spline,-11838,-628,-11838,-4129,-9936,-6104,-7399,-6194
 dc.w spline,-7399,-6194,-4862,-6284,-2959,-4129,-2853,-628
 dc.w spline,-2853,-628,-2748,2872,-4439,5745,-7399,5745
 dc.w spline,-7399,5745,-10358,5745,-11733,4039,-11838,-628
 dc.w fill
 dc.w fill
 dc.w fill
 dc.w fill
 dc.w 20189   ;width
;d:\source\binliner\font\R.fon
 dc.w 11
 dc.w line,-17441,-9336,-11838,-9336
 dc.w line,-11838,-9336,-11838,-5925
 dc.w spline,-11838,-5925,-10464,-10952,-4650,-10503,-4122,-8797
 dc.w line,-4122,-8797,-6130,-4039
 dc.w spline,-6130,-4039,-8667,-7361,-11733,-3321,-11838,448
 dc.w line,-11838,448,-11838,8887
 dc.w line,-11838,8887,-17441,8887
 dc.w line,-17441,8887,-17441,-9336
 dc.w fill
 dc.w fill
 dc.w fill
 dc.w 13319   ;width
;d:\source\binliner\font\S.fon
 dc.w 18
 dc.w spline,-17441,-4398,-17441,-8169,-12472,-9875,-8139,-9965
 dc.w spline,-8139,-9965,-3805,-10054,1268,-7002,1585,-4578
 dc.w line,1585,-4578,-4122,-3950
 dc.w spline,-4122,-3950,-4016,-4937,-5919,-6284,-8033,-6284
 dc.w spline,-8033,-6284,-9618,-6194,-11733,-5925,-11944,-5027
 dc.w spline,-11944,-5027,-12155,-3052,-6765,-2423,-4016,-1975
 dc.w spline,-4016,-1975,-1268,-1526,2114,448,2114,3501
 dc.w spline,2114,3501,2114,6553,-1585,9426,-7399,9426
 dc.w spline,-7399,9426,-13212,9426,-17441,6643,-17441,3591
 dc.w line,-17441,3591,-12367,2962
 dc.w spline,-12367,2962,-12050,4937,-10147,5655,-7610,5745
 dc.w spline,-7610,5745,-5496,5745,-3488,5027,-3488,4219
 dc.w spline,-3488,4219,-3488,3411,-4333,2154,-9196,1615
 dc.w spline,-9196,1615,-14058,1077,-17441,-1167,-17441,-4398
 dc.w fill
 dc.w fill
 dc.w fill
 dc.w fill
 dc.w 19555   ;width
;d:\source\binliner\font\T.fon
 dc.w 20
 dc.w line,-17441,-5655,-17441,-9336
 dc.w line,-17441,-9336,-14904,-9336
 dc.w line,-14904,-9336,-14904,-12568
 dc.w line,-14904,-12568,-9301,-15351
 dc.w line,-9301,-15351,-9301,-9336
 dc.w line,-9301,-9336,-5496,-9336
 dc.w line,-5496,-9336,-5496,-5655
 dc.w line,-5496,-5655,-9301,-5655
 dc.w line,-9301,-5655,-9301,3950
 dc.w spline,-9301,3950,-8667,6194,-6765,6104,-4968,5206
 dc.w line,-4968,5206,-4228,8349
 dc.w spline,-4228,8349,-4968,8887,-6870,9336,-9301,9426
 dc.w spline,-9301,9426,-11733,9516,-14904,7271,-14904,4847
 dc.w line,-14904,4847,-14904,-5655
 dc.w line,-14904,-5655,-17441,-5655
 dc.w fill
 dc.w fill
 dc.w fill
 dc.w fill
 dc.w fill
 dc.w 13213   ;width
;d:\source\binliner\font\U.fon
 dc.w 16
 dc.w line,-17441,-9336,-11838,-9336
 dc.w line,-11838,-9336,-11838,2334
 dc.w spline,-11838,2334,-11838,4578,-10570,5745,-8350,5745
 dc.w spline,-8350,5745,-6130,5745,-4122,4488,-4122,1167
 dc.w line,-4122,1167,-4122,-9336
 dc.w line,-4122,-9336,1479,-9336
 dc.w line,1479,-9336,1479,8887
 dc.w line,1479,8887,-4122,8887
 dc.w line,-4122,8887,-4122,6014
 dc.w spline,-4122,6014,-4228,7451,-7822,9426,-10781,9426
 dc.w spline,-10781,9426,-13741,9426,-17441,7451,-17441,3501
 dc.w line,-17441,3501,-17441,-9336
 dc.w fill
 dc.w fill
 dc.w fill
 dc.w fill
 dc.w 18920   ;width
;d:\source\binliner\font\V.fon
 dc.w 10
 dc.w line,-17441,-9336,-11838,-9336
 dc.w line,-11838,-9336,-6976,3231
 dc.w line,-6976,3231,-2219,-9336
 dc.w line,-2219,-9336,3382,-9336
 dc.w line,3382,-9336,-4228,8887
 dc.w line,-4228,8887,-9830,8887
 dc.w line,-9830,8887,-17441,-9336
 dc.w fill
 dc.w fill
 dc.w fill
 dc.w 20823   ;width
;d:\source\binliner\font\W.fon
 dc.w 18
 dc.w line,-17441,-9336,-11838,-9336
 dc.w line,-11838,-9336,-7716,2783
 dc.w line,-7716,2783,-4122,-9336
 dc.w line,-4122,-9336,1479,-9336
 dc.w line,1479,-9336,5073,2783
 dc.w line,5073,2783,9196,-9336
 dc.w line,9196,-9336,14798,-9336
 dc.w line,14798,-9336,7822,8887
 dc.w line,7822,8887,2219,8887
 dc.w line,2219,8887,-1374,-3231
 dc.w line,-1374,-3231,-4862,8887
 dc.w line,-4862,8887,-10464,8887
 dc.w line,-10464,8887,-17441,-9336
 dc.w fill
 dc.w fill
 dc.w fill
 dc.w fill
 dc.w fill
 dc.w 32239   ;width
;d:\source\binliner\font\X.fon
 dc.w 16
 dc.w line,-16912,-9336,-9936,-9336
 dc.w line,-9936,-9336,-6976,-4039
 dc.w line,-6976,-4039,-3488,-9336
 dc.w line,-3488,-9336,3382,-9336
 dc.w line,3382,-9336,-3805,-628
 dc.w line,-3805,-628,4016,8887
 dc.w line,4016,8887,-2853,8887
 dc.w line,-2853,8887,-6976,3052
 dc.w line,-6976,3052,-10570,8887
 dc.w line,-10570,8887,-17441,8887
 dc.w line,-17441,8887,-9936,-538
 dc.w line,-9936,-538,-16912,-9336
 dc.w fill
 dc.w fill
 dc.w fill
 dc.w fill
 dc.w 21457   ;width
;d:\source\binliner\font\Y.fon
 dc.w 12
 dc.w line,-17441,-9336,-11838,-9336
 dc.w line,-11838,-9336,-6976,3770
 dc.w line,-6976,3770,-2219,-9336
 dc.w line,-2219,-9336,3382,-9336
 dc.w line,3382,-9336,-5602,12658
 dc.w spline,-5602,12658,-7293,15980,-12050,16428,-15538,16428
 dc.w line,-15538,16428,-16278,12299
 dc.w spline,-16278,12299,-12050,13825,-9407,10773,-9830,9157
 dc.w line,-9830,9157,-17441,-9336
 dc.w fill
 dc.w fill
 dc.w fill
 dc.w 20823   ;width
;d:\source\binliner\font\Z.fon
 dc.w 14
 dc.w line,-16806,-9336,845,-9336
 dc.w line,845,-9336,845,-5835
 dc.w line,845,-5835,-10993,5206
 dc.w line,-10993,5206,1479,5206
 dc.w line,1479,5206,1479,8887
 dc.w line,1479,8887,-17441,8887
 dc.w line,-17441,8887,-17441,4937
 dc.w line,-17441,4937,-5919,-5655
 dc.w line,-5919,-5655,-16806,-5655
 dc.w line,-16806,-5655,-16806,-9336
 dc.w fill
 dc.w fill
 dc.w fill
 dc.w fill
 dc.w 18920   ;width
fontoffsets:
 dc.w 0
 dc.w 292
 dc.w 494
 dc.w 666
 dc.w 868
 dc.w 1050
 dc.w 1250
 dc.w 1528
 dc.w 1692
 dc.w 1780
 dc.w 1926
 dc.w 2058
 dc.w 2106
 dc.w 2376
 dc.w 2540
 dc.w 2696
 dc.w 2902
 dc.w 3108
 dc.w 3214
 dc.w 3462
 dc.w 3650
 dc.w 3814
 dc.w 3894
 dc.w 4038
 dc.w 4170
 dc.w 4286
