
		opt	inconce
		ifd	binliner
		include	binmacro.s
		else
		include	tosmacro.s
		endc
