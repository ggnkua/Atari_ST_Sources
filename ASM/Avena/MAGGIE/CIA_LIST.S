;CIA-Timing table by Griff/DC
	dc.w	$0000,$E02A,$F015,$A00E,$780A,$6008,$5007,$4498 
	dc.w	$3C05,$355A,$3004,$2BA6,$2803,$24EF,$224C,$2002 
	dc.w	$1E02,$1C3E,$1AAD,$1945,$1802,$16DD,$15D3,$14E0 
	dc.w	$1401,$1334,$1277,$11C8,$1126,$108E,$1001,$0F7D 
	dc.w	$0F01,$0E8C,$0E1F,$0DB8,$0D56,$0CFA,$0CA2,$0C4F 
	dc.w	$0C01,$0BB6,$0B6E,$0B2A,$0AE9,$0AAB,$0A70,$0A37 
	dc.w	$0A00,$09CC,$099A,$096A,$093B,$090F,$08E4,$08BA 
	dc.w	$0893,$086C,$0847,$0823,$0800,$07DF,$07BE,$079F 
	dc.w	$0780,$0763,$0746,$072A,$070F,$06F5,$06DC,$06C3 
	dc.w	$06AB,$0693,$067D,$0666,$0651,$063C,$0627,$0613 
	dc.w	$0600,$05ED,$05DB,$05C8,$05B7,$05A6,$0595,$0584 
	dc.w	$0574,$0565,$0555,$0546,$0538,$0529,$051B,$050D 
	dc.w	$0500,$04F3,$04E6,$04D9,$04CD,$04C1,$04B5,$04A9 
	dc.w	$049D,$0492,$0487,$047C,$0472,$0467,$045D,$0453 
	dc.w	$0449,$043F,$0436,$042C,$0423,$041A,$0411,$0408 
	dc.w	$0400,$03F7,$03EF,$03E7,$03DF,$03D7,$03CF,$03C7 
	dc.w	$03C0,$03B8,$03B1,$03AA,$03A3,$039C,$0395,$038E 
	dc.w	$0387,$0381,$037A,$0374,$036E,$0367,$0361,$035B 
	dc.w	$0355,$034F,$0349,$0344,$033E,$0338,$0333,$032E 
	dc.w	$0328,$0323,$031E,$0319,$0313,$030E,$0309,$0305 
	dc.w	$0300,$02FB,$02F6,$02F2,$02ED,$02E8,$02E4,$02E0 
	dc.w	$02DB,$02D7,$02D3,$02CE,$02CA,$02C6,$02C2,$02BE 
	dc.w	$02BA,$02B6,$02B2,$02AE,$02AA,$02A7,$02A3,$029F 
	dc.w	$029C,$0298,$0294,$0291,$028D,$028A,$0286,$0283 
	dc.w	$0280,$027C,$0279,$0276,$0273,$026F,$026C,$0269 
	dc.w	$0266,$0263,$0260,$025D,$025A,$0257,$0254,$0251 
	dc.w	$024E,$024C,$0249,$0246,$0243,$0241,$023E,$023B 
	dc.w	$0239,$0236,$0233,$0231,$022E,$022C,$0229,$0227 
	dc.w	$0224,$0222,$021F,$021D,$021B,$0218,$0216,$0214 
	dc.w	$0211,$020F,$020D,$020B,$0208,$0206,$0204,$0202 
	dc.w	$0200,$01FE,$01FB,$01F9,$01F7,$01F5,$01F3,$01F1 
	dc.w	$01EF,$01ED,$01EB,$01E9,$01E7,$01E5,$01E3,$01E2 
