; CIA List, 49170 hertz.
cia_list:
	dcb.w	32
	dc.w	$0F01,$0E8D,$0E1F,$0DB8,$0D57,$0CFA,$0CA3,$C50
	dc.w	$0C01,$0BB6,$0B6F,$0B2B,$0AEA,$0AAC,$0A70,$A37
	dc.w	$0A01,$09CD,$099B,$096A,$093C,$090F,$08E4,$8BB
	dc.w	$0893,$086D,$0847,$0823,$0801,$07DF,$07BF,$79F
	dc.w	$0781,$0763,$0747,$072B,$0710,$06F6,$06DC,$6C3
	dc.w	$06AB,$0694,$067D,$0667,$0651,$063C,$0628,$614
	dc.w	$0601,$05EE,$05DB,$05C9,$05B7,$05A6,$0595,$585
	dc.w	$0575,$0565,$0556,$0547,$0538,$052A,$051C,$50E
	dc.w	$0500,$04F3,$04E6,$04DA,$04CD,$04C1,$04B5,$4A9
	dc.w	$049E,$0493,$0488,$047D,$0472,$0468,$045E,$453
	dc.w	$044A,$0440,$0436,$042D,$0424,$041B,$0412,$409
	dc.w	$0400,$03F8,$03F0,$03E7,$03DF,$03D7,$03D0,$3C8
	dc.w	$03C0,$03B9,$03B2,$03AA,$03A3,$039C,$0395,$38F
	dc.w	$0388,$0381,$037B,$0374,$036E,$0368,$0362,$35C
	dc.w	$0356,$0350,$034A,$0344,$033F,$0339,$0334,$32E
	dc.w	$0329,$0323,$031E,$0319,$0314,$030F,$030A,$305
	dc.w	$0300,$02FC,$02F7,$02F2,$02EE,$02E9,$02E5,$2E0
	dc.w	$02DC,$02D7,$02D3,$02CF,$02CB,$02C7,$02C2,$2BE
	dc.w	$02BA,$02B6,$02B3,$02AF,$02AB,$02A7,$02A3,$2A0
	dc.w	$029C,$0298,$0295,$0291,$028E,$028A,$0287,$284
	dc.w	$0280,$027D,$027A,$0276,$0273,$0270,$026D,$26A
	dc.w	$0267,$0264,$0261,$025E,$025B,$0258,$0255,$252
	dc.w	$024F,$024C,$0249,$0247,$0244,$0241,$023E,$23C
	dc.w	$0239,$0236,$0234,$0231,$022F,$022C,$022A,$227
	dc.w	$0225,$0222,$0220,$021E,$021B,$0219,$0216,$214
	dc.w	$0212,$0210,$020D,$020B,$0209,$0207,$0204,$202
	dc.w	$0200,$01FE,$01FC,$01FA,$01F8,$01F6,$01F4,$1F2
	dc.w	$01F0,$01EE,$01EC,$01EA,$01E8,$01E6,$01E4,$1E2
