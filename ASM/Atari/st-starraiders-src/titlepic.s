*
*	TITLEPIC.S   ST Star-Raiders Title Picture Image Data
*		Copyright 1986 ATARI Corp.
*

*
*	PUBLIC SYMBOLS
*
	.globl	titlepic

*
*	TITLEPIC Image data
*		Raw Image_Data (just pour and serve)
*

	.data
	.even

titlepic:		* Title Picture Image
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$4000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0080,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0100,$0000,$0000,$0000,$0000,$001F,$001F,$0000
	.dc.w	$0000,$C000,$C000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0040,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$00FF,$00E0,$0000
	.dc.w	$0000,$F800,$3800,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$DC00,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$001F,$01FF,$0120,$0000
	.dc.w	$C000,$FC00,$2400,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0003,$0003,$0000,$0000,$FC00,$FE80,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$00C0,$03E0,$023F,$0000
	.dc.w	$1800,$3E00,$E200,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0006,$0007,$0001,$0001,$D780,$7FC0,$A800,$A800
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$013F,$0700,$04FF,$003F
	.dc.w	$E400,$0700,$F900,$E000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0005,$0027,$0002,$0002,$FD80,$FEA0,$0300,$0300
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0001,$0000,$0000,$6660,$E19F,$1FFF,$01C0
	.dc.w	$3330,$CC3C,$FFC0,$1C00,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$00DF,$0000,$0000
	.dc.w	$0000,$D800,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$007F,$007F,$0000,$0000,$07F0,$07F0,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$7005,$7FDE,$0FBA,$700E
	.dc.w	$0070,$DF80,$EF80,$8000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$00DF,$01FF,$0000,$0000
	.dc.w	$D800,$FC00,$0000,$0000,$0020,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0058,$00E8,$0030,$0030,$0090,$00F0,$0060,$0060
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0003,$000F,$0000,$0000,$33E0,$0CFF,$FF1F,$0F0F
	.dc.w	$3E66,$F987,$C7F8,$8780,$0000,$8000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0180,$03A0,$005F,$0000
	.dc.w	$0400,$2600,$D800,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$00F8,$00F8,$0000,$0000,$02D0,$03F4,$0020,$0020
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$FFFF,$FFFF,$0000
	.dc.w	$0000,$FFF8,$FFF8,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$025F,$0620,$01DF,$001F
	.dc.w	$D200,$2300,$DC00,$C000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$01A0,$03E0,$0040,$0040,$00FC,$07FE,$0200,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0001,$0001,$0000,$3500,$F0FF,$8FDF,$04DF
	.dc.w	$0560,$F87C,$DF8C,$D900,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0001,$0000,$0000,$0480,$CC7F,$03DF,$0040
	.dc.w	$0B00,$F39C,$DC00,$1000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0160,$01E0,$0080,$0080,$0154,$0F3E,$04C8,$0008
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0008,$0000,$0000,$0000
	.dc.w	$0000,$0001,$0001,$0000,$4E85,$C07A,$3FDF,$0250
	.dc.w	$0B90,$F01C,$DFE4,$5200,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0100,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0001,$0001,$0000,$0000,$C50F,$CCF2,$03DF,$80CD
	.dc.w	$851C,$799C,$DE00,$9808,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$01C0,$03C0,$0000,$0000,$2516,$3F3E,$00C8,$0008
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0003,$0002,$0000,$D275,$CE2A,$39DF,$0800
	.dc.w	$7258,$A39E,$DCE2,$0080,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0001,$0000,$819D,$8E3D,$41DD,$8002
	.dc.w	$CC08,$E388,$DC14,$0008,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0380,$0780,$0000,$0000,$009A,$0FFE,$0224,$0004
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0003,$0002,$0000,$A520,$9B2A,$7CDF,$1C00
	.dc.w	$2528,$A6CE,$D9F2,$01C0,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0001,$0000,$0001,$0000,$C512,$8CF0,$43D0,$810F
	.dc.w	$451C,$7988,$5E14,$8408,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0290,$0790,$0100,$0100,$400E,$07FB,$0224,$0004
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0003,$0002,$0000,$AEF5,$91FF,$7E0A,$1E00
	.dc.w	$7BA8,$FC4E,$83F2,$03C0,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0001,$0000,$0001,$0000,$C545,$8CA2,$43C0,$815E
	.dc.w	$151C,$2988,$1E14,$D408,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0380,$0780,$0000,$0000,$000A,$008F,$0004,$0004
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0003,$0002,$0000,$A420,$9BFD,$7F08,$1F00
	.dc.w	$2128,$FECE,$87F2,$07C0,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0001,$0000,$0001,$0000,$F14F,$9EA2,$61C0,$815F
	.dc.w	$947C,$2BC8,$1C34,$D408,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0020,$0020,$0100,$0000,$008E,$008F,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0080,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0003,$0002,$0000,$D160,$CE78,$3F88,$0E00
	.dc.w	$3458,$F39E,$8FE2,$0380,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0001,$0000,$8545,$8CA2,$43C0,$815F
	.dc.w	$1508,$2988,$1E14,$D408,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0380,$0400,$0000,$000A,$000F,$0004,$0004
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0001,$0001,$0000,$4E40,$C070,$3F90,$0000
	.dc.w	$1390,$701C,$4FE4,$0000,$0000,$0000,$00F8,$00F8
	.dc.w	$0001,$0001,$0001,$0000,$FFFF,$FFFF,$FFFF,$0000
	.dc.w	$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000
	.dc.w	$FFFF,$FFFF,$FFFE,$0000,$F512,$FCF0,$33D0,$810F
	.dc.w	$457F,$79FF,$5E63,$8408,$FFFF,$FFFF,$FFFF,$0000
	.dc.w	$FFF0,$FFF0,$FFF0,$0000,$0000,$0000,$0000,$0000
	.dc.w	$3860,$3BE0,$3D60,$0100,$0FFE,$0FFF,$0FF0,$0000
	.dc.w	$FFFF,$FFFF,$FFFF,$0000,$F003,$F003,$F003,$0000
	.dc.w	$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000
	.dc.w	$FFC0,$FFC1,$FFC1,$0000,$3180,$F1F0,$8E30,$0000
	.dc.w	$0C63,$7C7F,$638F,$0000,$FC88,$FCF8,$FD8C,$0174
	.dc.w	$000F,$000F,$000F,$0000,$0000,$0000,$FFFF,$FFFF
	.dc.w	$0000,$0000,$FFFF,$FFFF,$0000,$0000,$FFFF,$FFFF
	.dc.w	$0001,$0001,$FFFE,$FFFE,$C19D,$CE3D,$31DD,$B002
	.dc.w	$CC1C,$E39C,$DC63,$006B,$0000,$0000,$FFFF,$FFFF
	.dc.w	$001E,$001E,$FFFE,$FFE0,$0400,$0000,$0000,$0000
	.dc.w	$E038,$E3F8,$FC30,$1800,$081A,$081F,$0FE4,$07E4
	.dc.w	$0000,$0000,$FFFF,$FFFF,$1E02,$1E02,$FE03,$E001
	.dc.w	$0000,$0000,$FFFF,$FFFF,$0000,$0000,$FFFF,$FFFF
	.dc.w	$0078,$0078,$FFF8,$FF80,$1F03,$FFE3,$C063,$0000
	.dc.w	$C7C0,$FFF8,$F01F,$0007,$0488,$0470,$FE72,$FB8E
	.dc.w	$0038,$0038,$003F,$0007,$7FFF,$7FFF,$FFFF,$8000
	.dc.w	$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000
	.dc.w	$FFFE,$FFFF,$FFFE,$0000,$B50F,$FCF2,$33DF,$80CD
	.dc.w	$856B,$79FF,$DE63,$9808,$FEFF,$FEFF,$FFFF,$0100
	.dc.w	$FFC3,$FFC3,$FFFF,$003C,$8003,$8003,$8003,$0000
	.dc.w	$880E,$8FEE,$F89E,$7090,$0BFF,$0BF7,$0FE9,$0408
	.dc.w	$BFFF,$BFFF,$FFFF,$4000,$C382,$C382,$FF83,$3C01
	.dc.w	$FFFF,$FFFF,$FFFF,$0000,$FEFF,$FEFF,$FFFF,$0100
	.dc.w	$FF0E,$FF0E,$FFFE,$00F0,$000E,$7FCE,$60CF,$0001
	.dc.w	$000F,$1FFF,$F83F,$E000,$F400,$F5EC,$FE8A,$0B76
	.dc.w	$00E3,$00E3,$00FF,$001C,$8000,$8000,$8000,$7FFF
	.dc.w	$0002,$0002,$0002,$FFFD,$A055,$A055,$A055,$5FAA
	.dc.w	$02AA,$02AB,$02AA,$FD54,$2680,$EE7F,$21DF,$1040
	.dc.w	$0922,$F1BE,$DE22,$1041,$8280,$8280,$8380,$7D7F
	.dc.w	$0038,$0038,$003F,$FFC7,$E006,$E006,$E007,$0001
	.dc.w	$3003,$37E3,$F25F,$CA5C,$0A34,$0A3E,$0C08,$05C9
	.dc.w	$A005,$A005,$E005,$5FFA,$38E2,$38E2,$3FE3,$C701
	.dc.w	$8000,$8000,$8000,$7FFF,$0280,$0280,$0380,$FD7F
	.dc.w	$00E3,$00E3,$00FF,$FF1C,$8038,$9F38,$9F3F,$0007
	.dc.w	$E014,$E7D4,$E7D4,$182B,$1400,$15FC,$1EAA,$EB56
	.dc.w	$018C,$018C,$01FC,$0073,$7FFF,$0000,$0000,$FFFF
	.dc.w	$FFFD,$0000,$0000,$FFFF,$5FAA,$0000,$0000,$FFFF
	.dc.w	$FD55,$0000,$0000,$FFFF,$525F,$0620,$01DF,$F81F
	.dc.w	$D2DF,$238A,$DC8A,$C075,$FABF,$8280,$8380,$7D7F
	.dc.w	$FFC6,$0006,$0007,$FFF9,$300C,$300C,$F00F,$C003
	.dc.w	$C819,$C7F9,$C017,$3806,$8FEC,$8D3E,$8A10,$02D1
	.dc.w	$AFFA,$A000,$E000,$5FFF,$C632,$0632,$07F3,$F9C1
	.dc.w	$BFFF,$8000,$8000,$7FFF,$FABF,$0280,$0380,$FD7F
	.dc.w	$FF18,$0018,$001F,$FFE7,$C063,$C063,$C07F,$001C
	.dc.w	$1EFF,$0054,$0054,$FFAB,$D400,$15FC,$1E9A,$EB66
	.dc.w	$0333,$0330,$03F0,$00CF,$8000,$7FFF,$0000,$FFFF
	.dc.w	$0002,$FFFD,$0000,$FFFF,$A055,$5FAA,$0000,$FFFF
	.dc.w	$02AA,$FD55,$0000,$FFFF,$A900,$5720,$00DF,$FC00
	.dc.w	$0420,$2755,$D800,$01FF,$0AA0,$729F,$0380,$FD7F
	.dc.w	$0039,$FFC1,$0001,$FFFE,$9819,$9819,$F81F,$6006
	.dc.w	$3006,$0EF6,$0105,$FE89,$CAFA,$CAFC,$CC00,$0503
	.dc.w	$A805,$A7FA,$E000,$5FFF,$399A,$C19A,$01FB,$FE61
	.dc.w	$A000,$9FFF,$8000,$7FFF,$0AA0,$F29F,$0380,$FD7F
	.dc.w	$00E6,$FF06,$0007,$FFF9,$60CC,$60CC,$E0FC,$8033
	.dc.w	$E100,$1EAB,$0000,$FFFF,$5400,$95FC,$1EAA,$EB56
	.dc.w	$064C,$0643,$07C0,$01BF,$7FFF,$FFFF,$0000,$FFFF
	.dc.w	$FFFD,$FFFF,$0000,$FFFF,$5FAA,$FFFF,$0000,$FFFF
	.dc.w	$FD55,$FFFF,$0000,$FFFF,$54DF,$FFFF,$0000,$FE00
	.dc.w	$D9DF,$FF75,$0000,$03FF,$EAAF,$729F,$0380,$FD7F
	.dc.w	$FFC6,$FFF8,$0000,$FFFF,$4C32,$4C32,$7C3E,$B00D
	.dc.w	$4702,$3F72,$00A3,$FF2D,$6B9A,$6BFC,$CE60,$846F
	.dc.w	$ABFA,$A7FF,$E000,$5FFF,$C64E,$F84E,$007F,$FFB1
	.dc.w	$AFFF,$9FFF,$8000,$7FFF,$EAAF,$F29F,$0380,$FD7F
	.dc.w	$FF19,$FFE1,$0001,$FFFE,$3193,$3190,$F1F0,$C06F
	.dc.w	$1EFF,$FFAB,$0000,$FFFF,$5488,$9470,$1E72,$EB8E
	.dc.w	$0C93,$0C8F,$0F80,$037F,$FFFF,$C000,$0000,$C000
	.dc.w	$FFFF,$0002,$0000,$0002,$FFFF,$A055,$0000,$A055
	.dc.w	$FFFF,$02AA,$0000,$02AA,$FF20,$AAFF,$0000,$AA20
	.dc.w	$2775,$FAAA,$0000,$22AA,$6AAF,$B298,$0380,$BD78
	.dc.w	$FFF9,$007E,$0000,$007F,$2625,$2624,$3E3C,$D81B
	.dc.w	$9F87,$78FF,$0008,$F880,$5F7A,$7FFC,$A880,$A08F
	.dc.w	$ABFF,$A605,$E000,$5E05,$F926,$7E26,$003F,$7FD9
	.dc.w	$AFFF,$9800,$8000,$7800,$EAAF,$3298,$0380,$3D78
	.dc.w	$FFE4,$01F8,$0000,$01FF,$9B24,$9B23,$FBE0,$60DF
	.dc.w	$FFAB,$F155,$0000,$F155,$5488,$94F8,$1D8C,$E974
	.dc.w	$0967,$091E,$0F00,$06FE,$FFFF,$3FFF,$0000,$3FFF
	.dc.w	$FFFD,$FFFF,$0000,$FFFF,$5FAA,$FFFF,$0000,$FFFF
	.dc.w	$FD55,$FFFF,$0000,$FFFF,$5555,$FFFF,$0000,$FFFF
	.dc.w	$55DF,$FF75,$0000,$FFFF,$EAAF,$729B,$0380,$FD7B
	.dc.w	$FFFC,$FF8F,$0000,$FF8F,$D269,$1268,$1E78,$EC17
	.dc.w	$7FDD,$E73F,$0022,$E712,$ADDA,$FEEC,$5300,$530F
	.dc.w	$ABFA,$A6FF,$E000,$5EFF,$FCD2,$8F12,$001F,$8FED
	.dc.w	$AFFF,$9BFF,$8000,$7BFF,$EAAF,$F29B,$0380,$FD7B
	.dc.w	$FFF3,$FE3C,$0000,$FE3F,$4A59,$4A47,$7BC0,$B1BF
	.dc.w	$FEFF,$8FAB,$0000,$8FFF,$5400,$9400,$1CF8,$E8F8
	.dc.w	$1A5F,$1A39,$1E00,$05F9,$C000,$FFFF,$0000,$FFFF
	.dc.w	$0002,$FFFD,$0000,$FFFF,$A055,$5FAA,$0000,$FFFF
	.dc.w	$02AA,$FD55,$0000,$FFFF,$AAAA,$5555,$0000,$FFFF
	.dc.w	$AA20,$5555,$0000,$FFFF,$0AAE,$729B,$0380,$FD7B
	.dc.w	$007F,$FFF3,$0000,$FFF3,$4B4A,$8B49,$0F78,$F437
	.dc.w	$F8ED,$DFDF,$0012,$DFCA,$5AAB,$B7D3,$ED03,$ED3C
	.dc.w	$AB85,$A6FA,$E000,$5EFF,$7F4A,$F38A,$000F,$F3F5
	.dc.w	$AE00,$9BFF,$8000,$7BFF,$0AAE,$F29B,$0380,$FD7B
	.dc.w	$01FD,$FFCE,$0000,$FFCF,$2E97,$2E8E,$3F80,$D17E
	.dc.w	$F100,$7EAB,$0000,$7FFF,$5400,$9400,$1C00,$E800
	.dc.w	$12BE,$1277,$1E00,$0DF7,$3FFF,$C000,$0000,$FFFF
	.dc.w	$FFFD,$0000,$0000,$FFFF,$5FAA,$0000,$0000,$FFFF
	.dc.w	$FD55,$0000,$0000,$FFFF,$5555,$0000,$0000,$FFFF
	.dc.w	$55DF,$008A,$008A,$FF75,$FAAE,$829B,$8380,$7D7B
	.dc.w	$FF8F,$007D,$0000,$FFFD,$A9D4,$C9D3,$0FF0,$F62F
	.dc.w	$E73E,$B8EF,$0001,$BFE9,$87BA,$DFEC,$7800,$786F
	.dc.w	$ABBA,$A6C0,$E000,$5EFF,$8FA8,$7DC8,$000F,$FDF7
	.dc.w	$AEFF,$9B00,$8000,$7BFF,$FAAE,$029B,$0380,$FD7B
	.dc.w	$FE3E,$01F7,$0000,$FFF7,$A4AF,$249D,$3F80,$DB7D
	.dc.w	$8EFF,$F054,$0054,$FFAB,$D400,$1400,$1C00,$E800
	.dc.w	$353D,$34EE,$3C00,$0BEF,$C000,$0000,$0000,$FFFF
	.dc.w	$0002,$0002,$0002,$FFFD,$A055,$A055,$A055,$5FAA
	.dc.w	$02AA,$02AA,$02AA,$FD55,$AAAA,$AAAA,$AAAA,$5555
	.dc.w	$AAAA,$AAAA,$AAAA,$5555,$82AE,$829B,$8380,$7D7B
	.dc.w	$8077,$000E,$0000,$FFFE,$9595,$E593,$07F0,$FA6F
	.dc.w	$EDBF,$7077,$0000,$7FF4,$CFAB,$CB93,$7783,$347C
	.dc.w	$ABA5,$A6C5,$E005,$5EFA,$7794,$0EE4,$0007,$FEFB
	.dc.w	$AE80,$9B00,$8000,$7BFF,$02AE,$029B,$0380,$FD7B
	.dc.w	$81DE,$003B,$0000,$FFFB,$554F,$953B,$1F00,$EAFB
	.dc.w	$7154,$8154,$0154,$FEAB,$1400,$1400,$1C00,$E800
	.dc.w	$2573,$24DC,$3C00,$1BDF,$3FFF,$3FFF,$3FFF,$C000
	.dc.w	$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000
	.dc.w	$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000
	.dc.w	$FFFF,$FFFF,$FFFF,$0000,$FEAE,$FE9B,$FF80,$017B
	.dc.w	$BF99,$3F87,$3F80,$C07F,$D4AB,$64A7,$07E0,$7B5F
	.dc.w	$D25E,$6237,$0200,$7DF7,$AABA,$2A6C,$3E00,$D5EF
	.dc.w	$ABAF,$A6CF,$E00F,$5EF0,$99D4,$8764,$8007,$7F7B
	.dc.w	$AEBF,$9B3F,$803F,$7BC0,$FEAE,$FE9B,$FF80,$017B
	.dc.w	$BE67,$3E1D,$3E00,$C1FD,$515C,$9137,$1F00,$EEF7
	.dc.w	$CFFF,$0FFF,$0FFF,$F000,$F400,$F400,$FC00,$0800
	.dc.w	$2A74,$29D8,$3800,$17DF,$C000,$C000,$FFFF,$3FFF
	.dc.w	$0000,$0000,$FFFF,$FFFF,$0000,$0000,$FFFF,$FFFF
	.dc.w	$0000,$0000,$FFFF,$FFFF,$0000,$0000,$FFFF,$FFFF
	.dc.w	$0000,$0000,$FFFF,$FFFF,$00AE,$009B,$FF80,$FF7B
	.dc.w	$A065,$2063,$3FE0,$DF9F,$CAAB,$72A6,$03E0,$7D5E
	.dc.w	$B56E,$C51B,$0700,$FAFB,$AB55,$2B39,$3F01,$D4FE
	.dc.w	$ABA8,$A6C8,$E00F,$5EF7,$65CA,$6372,$E003,$9F7D
	.dc.w	$D560,$CE60,$C07F,$3F9F,$00AE,$009B,$FF80,$FF7B
	.dc.w	$A197,$218D,$3F80,$DE7D,$2A9D,$CA76,$0E00,$F5F7
	.dc.w	$3000,$3000,$3FFF,$CFFF,$0400,$0400,$FC00,$F800
	.dc.w	$2AED,$29B1,$3801,$17BE,$1FFF,$1FFF,$FFFF,$E000
	.dc.w	$F7FF,$F7FF,$FFFF,$0800,$FFFD,$FFFD,$FFFF,$0002
	.dc.w	$F8F8,$F8F8,$FFFF,$0707,$FFBF,$FFBF,$FFFF,$0040
	.dc.w	$FFC3,$FFC3,$FFFF,$003C,$FED5,$FECE,$FFC0,$013F
	.dc.w	$6F16,$6F11,$7FF0,$90EF,$EA2B,$B226,$03E0,$BDDE
	.dc.w	$A8AE,$C89B,$0F80,$F77B,$A2BA,$226C,$3E00,$DDEF
	.dc.w	$ABAB,$A6CB,$E00F,$5EF4,$16EA,$11B2,$F003,$EFBD
	.dc.w	$AEAF,$9B2F,$803F,$7BD0,$FED5,$FECE,$FFC0,$013F
	.dc.w	$6C5B,$6C46,$7FC0,$93BE,$AABB,$CA6C,$0E00,$F5EF
	.dc.w	$47FF,$47FF,$7FFF,$B800,$FC00,$FC00,$FC00,$0000
	.dc.w	$2AEA,$29B2,$3803,$17BD,$7000,$7000,$F000,$8000
	.dc.w	$1414,$1414,$1C14,$0BEB,$0285,$0285,$0287,$FD7A
	.dc.w	$6306,$6306,$7F07,$1CF9,$30A0,$30A0,$F0E0,$C05F
	.dc.w	$0538,$0538,$053F,$FAC7,$E2AE,$E29B,$E380,$017B
	.dc.w	$A9CA,$29C9,$39F8,$D037,$EA57,$B24E,$03C0,$BDBE
	.dc.w	$AAAF,$CA9B,$0F80,$F57B,$53AB,$9393,$1F83,$EC7C
	.dc.w	$ABAB,$A6CB,$E00F,$5EF4,$CAEA,$C9B2,$F803,$37BD
	.dc.w	$D568,$CE68,$C078,$3F90,$02AE,$029B,$0380,$017B
	.dc.w	$AF2B,$2F26,$3FE0,$D0DE,$AABA,$CA6C,$0E00,$F5EF
	.dc.w	$9C00,$9C00,$FC00,$6000,$0000,$0000,$0000,$0000
	.dc.w	$2AEA,$29B2,$3803,$17BD,$C000,$C000,$C000,$0000
	.dc.w	$15EB,$1400,$1C00,$0BFF,$FDF5,$0085,$0087,$FF7A
	.dc.w	$CCF9,$CC01,$FC01,$33FE,$98AF,$98A0,$F8E0,$605F
	.dc.w	$FAC6,$0006,$0007,$FFF9,$32D5,$32CE,$F3C0,$C13F
	.dc.w	$686A,$6869,$7878,$9017,$EA57,$B24D,$03C0,$BDBD
	.dc.w	$5257,$924D,$1FC0,$EDBD,$52BA,$926C,$1E00,$EDEF
	.dc.w	$ABAA,$A6CA,$E00E,$5EF4,$6AEA,$69B2,$7803,$17BD
	.dc.w	$AEAF,$9B2F,$803F,$7BD0,$FED5,$FECE,$FFC0,$013F
	.dc.w	$69AB,$69A6,$79E0,$905E,$AABA,$CA6C,$0E00,$F5EF
	.dc.w	$B000,$B000,$F000,$4000,$0000,$0000,$0000,$0000
	.dc.w	$2AEA,$29B2,$3803,$17BD,$8001,$8000,$8000,$0000
	.dc.w	$1514,$14EB,$1C00,$0BFF,$0215,$FD65,$0007,$FFFA
	.dc.w	$9306,$90F8,$F000,$6FFF,$4CA8,$4CA7,$7CE0,$B05F
	.dc.w	$0539,$FAC1,$0001,$FFFE,$9AAE,$9A9B,$FB80,$617B
	.dc.w	$A82A,$2829,$3838,$D017,$EA57,$B24D,$03C0,$BDBD
	.dc.w	$5757,$974D,$1FC0,$E8BD,$5355,$9339,$1F01,$ECFE
	.dc.w	$ABAA,$A6CA,$E00E,$5EF4,$2AEA,$29B2,$3803,$17BD
	.dc.w	$D560,$CE60,$C07F,$3F9F,$00AE,$009B,$FF80,$FF7B
	.dc.w	$AF2B,$2F26,$3FE0,$D0DE,$AABA,$CA6C,$0E00,$F5EF
	.dc.w	$B000,$B000,$F000,$4000,$0000,$0000,$0000,$0000
	.dc.w	$2AEA,$29B2,$3803,$17BD,$C000,$C000,$C000,$0000
	.dc.w	$156B,$14FF,$1C00,$0BFF,$FDD5,$FF65,$0007,$FFFA
	.dc.w	$2471,$23FE,$E000,$DFFF,$26AB,$26A7,$3EE0,$D85F
	.dc.w	$FAC6,$FFF8,$0000,$FFFF,$4ED5,$4ECE,$7FC0,$B13F
	.dc.w	$682A,$6829,$7838,$9017,$EA57,$B24D,$03C0,$BDBD
	.dc.w	$5557,$954D,$1DC0,$E8BD,$52BA,$926C,$1E00,$EDEF
	.dc.w	$ABAA,$A6CA,$E00E,$5EF4,$2AEA,$29B2,$3803,$17BD
	.dc.w	$AEBF,$9B3F,$803F,$7BC0,$FED5,$FECE,$FFC0,$013F
	.dc.w	$6C6B,$6C66,$7FE0,$939E,$AABA,$CA6C,$0E00,$F5EF
	.dc.w	$9C00,$9C00,$FC00,$6000,$0000,$0000,$0000,$0000
	.dc.w	$2AEA,$29B2,$3803,$17BD,$7000,$7000,$F000,$8000
	.dc.w	$157F,$14D4,$1C00,$0BD4,$FF54,$02E4,$0007,$02FB
	.dc.w	$59FC,$478F,$C000,$BF8F,$D2AB,$12A6,$1EE0,$EC5E
	.dc.w	$FFF9,$057E,$0000,$057F,$26AE,$269B,$3F80,$D97B
	.dc.w	$A8AA,$2829,$3838,$D017,$EAAE,$B29B,$0380,$BD7B
	.dc.w	$A72B,$2726,$3FE0,$D8DE,$AB55,$CB39,$0F01,$F4FE
	.dc.w	$ABAA,$A6CA,$E00E,$5EF4,$2AEA,$29B2,$3803,$17BD
	.dc.w	$AE80,$9B00,$8000,$7BFF,$02AE,$029B,$0380,$FD7B
	.dc.w	$A1DB,$21C6,$3FC0,$DE3E,$AABB,$CA6C,$0E00,$F5EF
	.dc.w	$47F8,$47F8,$7FF8,$B800,$0000,$0000,$0000,$0000
	.dc.w	$2AED,$29B1,$3801,$17BE,$1FF0,$1FF0,$FFF0,$E000
	.dc.w	$156B,$14FF,$1C00,$0BFF,$FDD4,$BF64,$0007,$BFFB
	.dc.w	$97FF,$8E73,$8000,$7E73,$4BAB,$8BA6,$0FE0,$F45E
	.dc.w	$FAFC,$FF8F,$0000,$FF8F,$D2D5,$12CE,$1FC0,$ED3F
	.dc.w	$682A,$6829,$7838,$9017,$EAAE,$B29B,$0380,$BD7B
	.dc.w	$A02B,$2026,$3FE0,$DFDE,$AABA,$CA6C,$0E00,$F5EF
	.dc.w	$ABAA,$A6CA,$E00E,$5EF4,$2AEA,$29B2,$3803,$17BD
	.dc.w	$AEFF,$9B00,$8000,$7BFF,$FAD5,$02CE,$03C0,$FD3F
	.dc.w	$7F97,$7F8D,$7F80,$807D,$2A9D,$CA76,$0E00,$F5F7
	.dc.w	$300F,$300F,$3FFF,$CFF0,$0000,$0000,$0000,$0000
	.dc.w	$2A74,$29D8,$3800,$17DF,$C01E,$C01E,$FFFE,$3FE0
	.dc.w	$1514,$14EB,$1C00,$0BFF,$E214,$BD64,$0007,$BFFB
	.dc.w	$AF8F,$9DFD,$8000,$7DFD,$A9AB,$C9A6,$0FE0,$F65E
	.dc.w	$857F,$FAF3,$0000,$FFF3,$4AAE,$8A9B,$0F80,$F57B
	.dc.w	$A82A,$2829,$3838,$D017,$EAAE,$B29B,$0380,$BD7B
	.dc.w	$BFEB,$3FE6,$3FE0,$C01E,$AABA,$CA6C,$0E00,$F5EF
	.dc.w	$ABAA,$A6CA,$E00E,$5EF4,$2AEA,$29B2,$3803,$17BD
	.dc.w	$AE00,$9BFF,$8000,$7BFF,$0AAE,$F29B,$0380,$FD7B
	.dc.w	$BE67,$3E1D,$3E00,$C1FD,$515C,$9137,$1F00,$EEF7
	.dc.w	$CFE1,$0FE1,$0FFF,$F01E,$C000,$C000,$C000,$0000
	.dc.w	$2573,$24DC,$3C00,$1BDF,$3FC3,$3FC3,$3FFF,$C03C
	.dc.w	$95EA,$9401,$9C00,$0BFF,$EDF5,$B085,$0087,$BF7A
	.dc.w	$4E73,$3B8E,$0000,$FBFE,$95AB,$E5A6,$07E0,$FA5E
	.dc.w	$BA8F,$C07D,$0000,$FFFD,$A8AE,$C89B,$0F80,$F77B
	.dc.w	$A86A,$2869,$3878,$D017,$EAAE,$B29B,$0380,$BD7B
	.dc.w	$950B,$1506,$1500,$EAFE,$AABA,$CA6C,$0E00,$F5EF
	.dc.w	$ABAA,$A6CA,$E00E,$5EF4,$2D56,$2CE6,$3C07,$13F9
	.dc.w	$AFFF,$9BFF,$8000,$7BFF,$EAAE,$F29B,$0380,$FD7B
	.dc.w	$81DE,$003B,$0000,$FFFB,$514F,$913B,$1F00,$EEFB
	.dc.w	$701C,$801C,$001F,$FFE3,$6000,$6000,$E000,$8000
	.dc.w	$353D,$34EE,$3C00,$0BEF,$D538,$1538,$153F,$EAC7
	.dc.w	$F416,$F415,$FC14,$0BEB,$EA85,$B285,$0287,$BD7A
	.dc.w	$5EDB,$3707,$0000,$F7FF,$D4AB,$64A6,$07E0,$7B5E
	.dc.w	$A577,$C50E,$0500,$FAFE,$94AE,$E49B,$0780,$FB7B
	.dc.w	$A9CA,$29C9,$39F8,$D037,$EAAE,$B29B,$0380,$BD7B
	.dc.w	$FEFB,$1406,$1400,$EBFE,$AABA,$CA6C,$0E00,$F5EF
	.dc.w	$ABAA,$A6CA,$E00E,$5EF4,$2AEA,$29B2,$3803,$17BD
	.dc.w	$AFFF,$9800,$8000,$7800,$EAAE,$329B,$0380,$3D7B
	.dc.w	$FE3E,$01F7,$0000,$FFF7,$A4AF,$249D,$3F80,$DB7D
	.dc.w	$8FE3,$F003,$0003,$FFFC,$1800,$1800,$F800,$E000
	.dc.w	$12BA,$1277,$1E00,$0DF7,$2BC6,$C106,$0107,$FEF9
	.dc.w	$37FA,$37F9,$FFF8,$C807,$EBFE,$B3FE,$03FE,$BC01
	.dc.w	$BD25,$7623,$0020,$F7DF,$EAAB,$72A6,$03E0,$7D5E
	.dc.w	$AF99,$CF87,$0F80,$F07F,$D4AE,$649B,$0780,$7B7B
	.dc.w	$AF16,$2F11,$3FF0,$D0EF,$EAAE,$B29B,$0380,$BD7B
	.dc.w	$0103,$EAFE,$0000,$FFFE,$AABA,$CA6C,$0E00,$F5EF
	.dc.w	$ABAB,$A6CA,$E00E,$5EF4,$2D56,$2CE6,$3C07,$13F9
	.dc.w	$AFFF,$9BFF,$8000,$7BFF,$EAAE,$F29B,$0380,$FD7B
	.dc.w	$01FD,$FFCE,$0000,$FFCF,$2E97,$2E8E,$3F80,$D17E
	.dc.w	$F01C,$7FE0,$0000,$7FFF,$CC00,$CC00,$FC00,$3000
	.dc.w	$1A5F,$1A39,$1E00,$05F9,$D439,$EAC1,$0001,$FFFE
	.dc.w	$900A,$9009,$FFF8,$6FF7,$EA02,$B202,$03FE,$BDFD
	.dc.w	$BB56,$6C51,$0070,$EFAF,$EAAB,$B2A6,$03E0,$BD5E
	.dc.w	$A865,$C863,$0FE0,$F79F,$CAAE,$729B,$0380,$7D7B
	.dc.w	$A065,$2063,$3FE0,$DF9F,$CAAF,$729B,$0380,$7D7B
	.dc.w	$FEFF,$EBFE,$0000,$FFFE,$AABA,$CA6C,$0E00,$F5EF
	.dc.w	$ABAA,$A6CA,$E00E,$5EF4,$2AEA,$29B2,$3803,$17BD
	.dc.w	$AE00,$9BFF,$8000,$7BFF,$0AAF,$F29B,$0380,$FD7B
	.dc.w	$FFF3,$FE3C,$0000,$FE3F,$4E59,$4E47,$7FC0,$B1BF
	.dc.w	$FFE3,$8FFC,$0000,$8FFF,$2600,$2600,$3E00,$D800
	.dc.w	$0967,$091E,$0F00,$06FE,$EBC6,$3EF8,$0000,$3FFF
	.dc.w	$4FEA,$4FE9,$7FF8,$B017,$EAF2,$B2F2,$03FE,$BD0D
	.dc.w	$BA8A,$6C89,$00F8,$EF77,$EA2B,$B226,$03E0,$BDDE
	.dc.w	$AB16,$CB11,$0FF0,$F4EF,$EAAE,$B29B,$0380,$BD7B
	.dc.w	$BF99,$3F87,$3F80,$C07F,$D4AF,$6498,$0780,$7B78
	.dc.w	$EBFF,$1500,$0000,$1500,$AB55,$CB39,$0F01,$F4FE
	.dc.w	$ABAA,$A6CA,$E00E,$5EF4,$2EAE,$2E4E,$3E0F,$11F1
	.dc.w	$AEFF,$9B00,$8000,$7BFF,$FAAF,$0298,$0380,$FD78
	.dc.w	$FFE4,$01F8,$0000,$01FF,$CB24,$CB23,$FBE0,$30DF
	.dc.w	$FFFC,$F03F,$0000,$F03F,$9300,$1300,$1F00,$EC00
	.dc.w	$0C93,$0C8F,$0F80,$037F,$FEF9,$D57E,$0000,$D57F
	.dc.w	$262A,$2629,$3E38,$D817,$EA95,$B294,$039C,$BD0B
	.dc.w	$7AAA,$ECA9,$00F8,$EF57,$F535,$B933,$01F0,$BECF
	.dc.w	$5BCA,$9BC9,$1FF8,$E437,$EAAE,$B29B,$0380,$BD7B
	.dc.w	$8577,$050E,$0500,$FAFE,$94AF,$E49B,$0780,$FB7B
	.dc.w	$FEFF,$EBFE,$0000,$FFFE,$AABA,$CA6C,$0E00,$F5EF
	.dc.w	$ABAA,$A6CA,$E00E,$5EF4,$2AEA,$29B2,$3803,$17BD
	.dc.w	$AE80,$9B00,$8000,$7BFF,$02AF,$029B,$0380,$FD7B
	.dc.w	$FFF3,$FE3C,$0000,$FE3F,$6D93,$6D90,$7DF0,$906F
	.dc.w	$1FFE,$FFC7,$0000,$FFC7,$6900,$8900,$0F00,$F600
	.dc.w	$064C,$0643,$07C0,$01BF,$6BFC,$FE8F,$0000,$FF8F
	.dc.w	$D22D,$122C,$1E3C,$EC13,$5695,$E694,$079C,$F90B
	.dc.w	$7525,$D924,$01FC,$DEDB,$752B,$D926,$01E0,$DEDE
	.dc.w	$AA6A,$CA69,$0E78,$F417,$EAAE,$B29B,$0380,$BD7B
	.dc.w	$FA8F,$007D,$0000,$FFFD,$A8AE,$C89B,$0F80,$F77B
	.dc.w	$0103,$EAFE,$0000,$FFFE,$AB55,$CB39,$0F01,$F4FE
	.dc.w	$ABAA,$A6CA,$E00E,$5EF4,$2EAE,$2E4E,$3E0F,$11F1
	.dc.w	$AEBF,$9B3F,$803F,$7BC0,$FEAE,$FE9B,$FF80,$017B
	.dc.w	$01FD,$FFCE,$0000,$FFCF,$26CC,$26CC,$3EFC,$D833
	.dc.w	$E03F,$1FF9,$0000,$FFF9,$A580,$C580,$0780,$FA00
	.dc.w	$0333,$0330,$03F0,$00CF,$947F,$6AF3,$0000,$FFF3
	.dc.w	$4B2A,$8B29,$0F38,$F417,$EAB5,$B2B4,$03BC,$BD0B
	.dc.w	$7575,$D974,$01FC,$DE8B,$7535,$D933,$01F0,$DECF
	.dc.w	$5A4A,$9A49,$1E78,$E437,$EAAE,$B29B,$0380,$BD7B
	.dc.w	$057F,$FAF3,$0000,$FFF3,$4AAE,$8A9B,$0F80,$F57B
	.dc.w	$FEFB,$1406,$1400,$EBFE,$AABA,$CA6C,$0E00,$F5EF
	.dc.w	$ABAA,$A6CA,$E00E,$5EF4,$2AEA,$29B2,$3803,$17BD
	.dc.w	$AEA0,$9B20,$803F,$7BDF,$00AE,$009B,$FF80,$FF7B
	.dc.w	$FE3E,$01F7,$0000,$FFF7,$B663,$3663,$3E7F,$C81C
	.dc.w	$1FC7,$003E,$0000,$FFFE,$D480,$E480,$0780,$FB00
	.dc.w	$018C,$018C,$01FC,$0073,$6B8F,$017D,$0100,$FEFD
	.dc.w	$A92D,$C92C,$0F3C,$F613,$56A5,$E6A4,$07BC,$F91B
	.dc.w	$7555,$D954,$01DC,$DE8B,$752B,$D926,$01E0,$DEDE
	.dc.w	$AB9A,$CB99,$0FF8,$F467,$EAAF,$B29B,$0380,$BD7B
	.dc.w	$FAFC,$FF8F,$0000,$FF8F,$D2AE,$129B,$1F80,$ED7B
	.dc.w	$950B,$1506,$1500,$EAFE,$AB55,$CB39,$0F01,$F4FE
	.dc.w	$ABAA,$A6CA,$E00E,$5EF4,$2D56,$2CE6,$3C07,$13F9
	.dc.w	$AEA8,$9B28,$8038,$7BD0,$02AE,$029B,$0380,$017B
	.dc.w	$81DE,$003B,$0000,$FFFB,$5238,$9238,$1E3F,$EC07
	.dc.w	$E03B,$E007,$E000,$1FFF,$CAC0,$72C0,$03C0,$7D00
	.dc.w	$00E3,$00E3,$00FF,$001C,$9577,$950E,$9500,$6AFE
	.dc.w	$95AA,$E5A9,$07B8,$FA17,$EAAA,$B2A9,$03B8,$BD17
	.dc.w	$EA72,$B272,$03FE,$BD8D,$BAB5,$6CB3,$00F0,$EF4F
	.dc.w	$5A36,$9A31,$1FF0,$E5CF,$EAAF,$B298,$0380,$BD78
	.dc.w	$FFF9,$057E,$0000,$057F,$26AE,$269B,$3F80,$D97B
	.dc.w	$BFEB,$3FE6,$3FE0,$C01E,$AABA,$CA6C,$0E00,$F5EF
	.dc.w	$B55A,$B39A,$F01E,$4FE4,$2AEA,$29B2,$3803,$17BD
	.dc.w	$D568,$CE68,$C078,$3F90,$02AE,$029B,$0380,$017B
	.dc.w	$BE67,$3E1D,$3E00,$C1FD,$5A0E,$9A0E,$1E0F,$E401
	.dc.w	$1FCC,$1FC3,$FFC0,$E03F,$EA40,$B240,$03C0,$BD80
	.dc.w	$0038,$0038,$003F,$0007,$7F99,$7F87,$FF80,$807F
	.dc.w	$D4AD,$64AC,$07BC,$7B13,$56AA,$E6A9,$07B8,$F917
	.dc.w	$EA02,$B202,$03FE,$BDFD,$BAAB,$6CA6,$00E0,$EF5E
	.dc.w	$A8E5,$C8E3,$0FE0,$F71F,$CAAF,$729B,$0380,$7D7B
	.dc.w	$FAFC,$FF8F,$0000,$FF8F,$D2AE,$129B,$1F80,$ED7B
	.dc.w	$A02B,$2026,$3FE0,$DFDE,$AB55,$CB39,$0F01,$F4FE
	.dc.w	$ABAA,$A6CA,$E00E,$5EF4,$2AEA,$29B2,$3803,$17BD
	.dc.w	$AEA8,$9B28,$8038,$7BD0,$02AE,$029B,$0380,$017B
	.dc.w	$A197,$218D,$3F80,$DE7D,$2A03,$CA03,$0E03,$F400
	.dc.w	$C032,$C031,$FFF0,$3FCF,$E540,$B940,$01C0,$BE80
	.dc.w	$000F,$000F,$000F,$0000,$0065,$0063,$FFE0,$FF9F
	.dc.w	$CAAA,$72A9,$03B8,$7D17,$EAAA,$B2A9,$03B8,$BD17
	.dc.w	$EBFE,$B3FE,$03FE,$BC01,$BAAB,$6CA6,$00E0,$EF5E
	.dc.w	$AF99,$CF87,$0F80,$F07F,$D4AE,$649B,$0780,$7B7B
	.dc.w	$057F,$FAF3,$0000,$FFF3,$4AAE,$8A9B,$0F80,$F57B
	.dc.w	$AFAB,$2FA6,$3FE0,$D05E,$AABA,$CA6C,$0E00,$F5EF
	.dc.w	$B55A,$B39A,$F01E,$4FE4,$2AEA,$29B2,$3803,$17BD
	.dc.w	$D568,$CE68,$C078,$3F90,$02AE,$029B,$0380,$017B
	.dc.w	$AC5B,$2C46,$3FC0,$D3BE,$AA00,$CA00,$0E00,$F400
	.dc.w	$7E0B,$7E08,$7FF8,$01F7,$7540,$D940,$01C0,$DE80
	.dc.w	$0801,$0001,$0001,$0000,$FF16,$FF11,$FFF0,$00EF
	.dc.w	$EAAD,$B2AC,$03BC,$BD13,$56AA,$E6A9,$07B8,$F917
	.dc.w	$E80A,$B00A,$000A,$BFF5,$BAAB,$6CA6,$00E0,$EF5E
	.dc.w	$A577,$C50E,$0500,$FAFE,$94AE,$E49B,$0780,$FB7B
	.dc.w	$FA8F,$007D,$0000,$FFFD,$A8D5,$C8CE,$0FC0,$F73F
	.dc.w	$68AB,$68A6,$78E0,$905E,$AB55,$CB39,$0F01,$F4FE
	.dc.w	$ABAA,$A6CA,$E00E,$5EF4,$2AEA,$29B2,$3803,$17BD
	.dc.w	$AEA9,$9B28,$8038,$7BD0,$02AE,$029B,$0380,$017B
	.dc.w	$AF2B,$2F26,$3FE0,$D0DE,$AA00,$CA00,$0E00,$F400
	.dc.w	$03E5,$03E4,$03FC,$001B,$7540,$D940,$01C0,$DE80
	.dc.w	$0000,$0000,$0000,$0000,$01CA,$01C9,$01F8,$0037
	.dc.w	$EAAA,$B2A9,$03B8,$BD17,$EAAA,$B2A9,$03B8,$BD17
	.dc.w	$EFF5,$B000,$0000,$BFFF,$BAAB,$6CA6,$00E0,$EF5E
	.dc.w	$BA8F,$C07D,$0000,$FFFD,$A8AE,$C89B,$0F80,$F77B
	.dc.w	$8577,$050E,$0500,$FAFE,$94AE,$E49B,$0780,$FB7B
	.dc.w	$A8AB,$28A6,$38E0,$D05E,$AABA,$CA6C,$0E00,$F5EF
	.dc.w	$B55A,$B39A,$F01E,$4FE4,$2AEA,$29B2,$3803,$17BD
	.dc.w	$D568,$CE68,$C078,$3F90,$02AE,$029B,$0380,$017B
	.dc.w	$A9AB,$29A6,$39E0,$D05E,$AA00,$CA00,$0E00,$F400
	.dc.w	$0035,$0034,$003C,$000B,$7540,$D940,$01C0,$DE80
	.dc.w	$0000,$0000,$0000,$0000,$006A,$0069,$0078,$0017
	.dc.w	$EAAD,$B2AC,$03BC,$BD13,$56AA,$E6A9,$07B8,$F917
	.dc.w	$E00A,$BFF5,$0000,$BFFF,$3AAB,$ECA6,$00E0,$EF5E
	.dc.w	$857F,$FAF3,$0000,$FFF3,$4AAE,$8A9B,$0F80,$F57B
	.dc.w	$BF99,$3F87,$3F80,$C07F,$D4D5,$64CE,$07C0,$7B3F
	.dc.w	$68AB,$68A6,$78E0,$905E,$AB55,$CB39,$0F01,$F4FE
	.dc.w	$ABAA,$A6CA,$E00E,$5EF4,$6AEA,$69B2,$7803,$17BD
	.dc.w	$AEA8,$9B28,$8038,$7BD0,$02AE,$029B,$0380,$017B
	.dc.w	$A8AB,$28A6,$38E0,$D05E,$AA00,$CA00,$0E00,$F400
	.dc.w	$0015,$0014,$001C,$000B,$7540,$D940,$01C0,$DE80
	.dc.w	$0000,$0000,$0000,$0000,$002D,$002C,$003C,$0013
	.dc.w	$56AA,$E6A9,$07B8,$F917,$EAAA,$B2A9,$03B8,$BD17
	.dc.w	$FFF5,$BFFF,$0000,$BFFF,$FAAB,$ECA6,$00E0,$EF5E
	.dc.w	$FAFC,$FF8F,$0000,$FF8F,$D2AE,$129B,$1F80,$ED7B
	.dc.w	$A065,$2063,$3FE0,$DF9F,$CAAE,$729B,$0380,$7D7B
	.dc.w	$A8AB,$28A6,$38E0,$D05E,$AABA,$CA6C,$0E00,$F5EF
	.dc.w	$B55B,$B39B,$F01F,$4FE4,$CAEA,$C9B2,$F803,$37BD
	.dc.w	$EAE8,$E4E8,$E0F8,$1F10,$02AE,$029B,$0380,$017B
	.dc.w	$A8AB,$28A6,$38E0,$D05E,$AA00,$CA00,$0E00,$F400
	.dc.w	$0016,$0016,$001E,$0009,$AB40,$7340,$03C0,$FC80
	.dc.w	$0000,$0000,$0000,$0000,$002A,$0029,$0038,$0017
	.dc.w	$EAAD,$B2AC,$03BC,$BD13,$56AA,$E6A9,$07B8,$F917
	.dc.w	$FFFF,$800A,$0000,$800A,$FAAB,$0CA6,$00E0,$0F5E
	.dc.w	$FFF9,$057E,$0000,$057F,$32AE,$329B,$3F80,$CD7B
	.dc.w	$AF16,$2F11,$3FF0,$D0EF,$EAD5,$B2CE,$03C0,$BD3F
	.dc.w	$68AB,$68A6,$78E0,$905E,$AABA,$CA6C,$0E00,$F5EF
	.dc.w	$ABAB,$A6CB,$E00F,$5EF4,$16EA,$11B2,$F003,$EFBD
	.dc.w	$AEAF,$9B2F,$803F,$7BD0,$FEAE,$FE9B,$FF80,$017B
	.dc.w	$A8AB,$28A6,$38E0,$D05E,$AA00,$CA00,$0E00,$F400
	.dc.w	$0015,$0014,$001C,$000B,$7540,$D940,$01C0,$DE80
	.dc.w	$0000,$0000,$0000,$0000,$002D,$002C,$003C,$0013
	.dc.w	$56AA,$E6A9,$07B8,$F917,$EAAA,$B2A9,$03B8,$BD17
	.dc.w	$FFF5,$BFFF,$0000,$BFFF,$FAAB,$ECA6,$00E0,$EF5E
	.dc.w	$FAFC,$FF8F,$0000,$FF8F,$DAAE,$1A9B,$1F80,$E57B
	.dc.w	$A9CA,$29C9,$39F8,$D037,$EAAE,$B29B,$0380,$BD7B
	.dc.w	$A8AB,$28A6,$38E0,$D05E,$AABA,$CA6C,$0E00,$F5EF
	.dc.w	$B558,$B398,$F01F,$4FE7,$65CA,$6372,$E003,$9F7D
	.dc.w	$EAE0,$E4E0,$E0FF,$1F1F,$00D5,$00CE,$FFC0,$FF3F
	.dc.w	$68AB,$68A6,$78E0,$905E,$AA00,$CA00,$0E00,$F400
	.dc.w	$0016,$0016,$001E,$0009,$AB40,$7340,$03C0,$FC80
	.dc.w	$0000,$0000,$0000,$0000,$002A,$0029,$0038,$0017
	.dc.w	$EAAD,$B2AC,$03BC,$BD13,$56AA,$E6A9,$07B8,$F917
	.dc.w	$E00A,$BFF5,$0000,$BFFF,$3AAB,$ECA6,$00E0,$EF5E
	.dc.w	$857F,$FAF3,$0000,$FFF3,$48AE,$889B,$0F80,$F77B
	.dc.w	$A86A,$2869,$3878,$D017,$EAD5,$B2CE,$03C0,$BD3F
	.dc.w	$69B5,$68B3,$78F0,$904F,$5ABA,$9A6C,$1E00,$E5EF
	.dc.w	$ABAF,$A6CF,$E00F,$5EF0,$99D4,$8764,$8007,$7F7B
	.dc.w	$AEBF,$9B3F,$803F,$7BC0,$FEAE,$FE9B,$FF80,$017B
	.dc.w	$A8AB,$28A6,$38E0,$D05E,$AA08,$CA00,$0E00,$F400
	.dc.w	$0015,$0014,$001C,$000B,$7540,$D940,$01C0,$DE80
	.dc.w	$0000,$0000,$0000,$0000,$002E,$002E,$003E,$0011
	.dc.w	$AEAA,$4EA9,$0FB8,$F117,$EAAA,$B2A9,$03B8,$BD17
	.dc.w	$EFF5,$B000,$0000,$BFFF,$BAAB,$6CA6,$00E0,$EF5E
	.dc.w	$BA8F,$C07D,$0000,$FFFD,$ACAE,$CC9B,$0F80,$F37B
	.dc.w	$A82A,$2829,$3838,$D017,$EAAE,$B29B,$0380,$BD7B
	.dc.w	$A8AB,$28A6,$38E0,$D05E,$AABA,$CA6C,$0E00,$F5EF
	.dc.w	$ABA0,$A6C0,$E000,$5EFF,$7794,$0EE4,$0007,$FEFB
	.dc.w	$AE82,$9B02,$8002,$7BFD,$82D5,$82CE,$83C0,$7D3F
	.dc.w	$68AB,$68A6,$78E0,$905E,$AA00,$CA00,$0E00,$F400
	.dc.w	$0016,$0016,$001E,$0009,$AB40,$7340,$03C0,$FC80
	.dc.w	$0000,$0000,$0000,$0000,$002A,$0029,$0038,$0017
	.dc.w	$EAAE,$B2AE,$03BE,$BD11,$AEAA,$4EA9,$0FB8,$F117
	.dc.w	$E80A,$B00A,$000A,$BFF5,$BAAB,$6CA6,$00E0,$EF5E
	.dc.w	$A577,$C50E,$0500,$FAFE,$94D5,$E4CE,$07C0,$FB3F
	.dc.w	$682A,$6829,$7838,$9017,$EAD5,$B2CE,$03C0,$BD3F
	.dc.w	$68BA,$68B9,$78F8,$9047,$BABA,$3A6C,$3E00,$C5EF
	.dc.w	$ABBF,$A6C0,$E000,$5EFF,$8FA8,$7DC8,$000F,$FDF7
	.dc.w	$AEFF,$9B02,$8002,$7BFD,$FAAE,$829B,$8380,$7D7B
	.dc.w	$A8AB,$28A6,$38E0,$D05E,$AA00,$CA00,$0E00,$F400
	.dc.w	$0015,$0014,$001C,$000B,$7540,$D940,$01C0,$DE80
	.dc.w	$0000,$0000,$0000,$0000,$022E,$002E,$003E,$0011
	.dc.w	$AEAA,$4EA9,$0FB8,$F117,$EAAA,$B2A9,$03B8,$BD17
	.dc.w	$EBFE,$B3FE,$03FE,$BC01,$BAAB,$6CA6,$00E0,$EF5E
	.dc.w	$AF99,$CF87,$0F80,$F07F,$D6AE,$669B,$0780,$797B
	.dc.w	$A82A,$2829,$3838,$D017,$EAAE,$B29B,$0380,$BD7B
	.dc.w	$A8AB,$28A6,$38E0,$D05E,$AABA,$CA6C,$0E00,$F5EF
	.dc.w	$AB80,$A6FF,$E000,$5EFF,$7F4A,$F38A,$000F,$F3F5
	.dc.w	$AE00,$9BFD,$8000,$7BFF,$0AD5,$72CE,$03C0,$FD3F
	.dc.w	$68AB,$68A6,$78E0,$905E,$AA00,$CA00,$0E00,$F400
	.dc.w	$0016,$0016,$001E,$0009,$AB40,$7340,$03C0,$FC80
	.dc.w	$0000,$0000,$0000,$0000,$002A,$0029,$0038,$0017
	.dc.w	$EAAE,$B2AE,$03BE,$BD11,$AEAA,$4EA9,$0FB8,$F117
	.dc.w	$EA03,$B203,$03FF,$BDFC,$55AB,$39A6,$01E0,$FE5E
	.dc.w	$A865,$C863,$0FE0,$F79F,$CAD5,$72CE,$03C0,$7D3F
	.dc.w	$682A,$6829,$7838,$9017,$EAD5,$B2CE,$03C0,$BD3F
	.dc.w	$68BA,$68B9,$78F8,$9047,$BABA,$3A6C,$3E00,$C5EF
	.dc.w	$ABFF,$A6FF,$E000,$5EFF,$FCD2,$8F12,$001F,$8FED
	.dc.w	$AFFF,$9BFD,$8000,$7BFF,$EAAE,$729B,$0380,$FD7B
	.dc.w	$A8AB,$28A6,$38E0,$D05E,$AA00,$CA00,$0E00,$F400
	.dc.w	$0015,$0014,$001C,$000B,$7540,$D940,$01C0,$DE80
	.dc.w	$0000,$0000,$0000,$0000,$002D,$002C,$003C,$0013
	.dc.w	$56AA,$E6A9,$07B8,$F917,$EAAA,$B2A9,$03B8,$BD17
	.dc.w	$EAFA,$B2FA,$03FE,$BD05,$BAAB,$6CA6,$00E0,$EF5E
	.dc.w	$AB16,$CB11,$0FF0,$F4EF,$EAAE,$B29B,$0380,$BD7B
	.dc.w	$A82A,$2829,$3838,$D017,$EAAE,$B29B,$0380,$BD7B
	.dc.w	$A8AB,$28A6,$38E0,$D05E,$AABA,$CA6C,$0E00,$F5EF
	.dc.w	$ABFF,$A600,$E000,$5E00,$F926,$7E26,$003F,$7FD9
	.dc.w	$AFFD,$9802,$8000,$7802,$6AAE,$B29B,$0380,$BD7B
	.dc.w	$A8AB,$28A6,$38E0,$D05E,$AA00,$CA00,$0E00,$F400
	.dc.w	$0015,$0014,$001C,$000B,$7540,$D940,$01C0,$DE80
	.dc.w	$0000,$0000,$0000,$0000,$002A,$0029,$0038,$0017
	.dc.w	$EAAD,$B2AC,$03BC,$BD13,$56AA,$E6A9,$07B8,$F917
	.dc.w	$EA8B,$B28B,$038F,$BD04,$55AB,$39A6,$01E0,$FE5E
	.dc.w	$ABCA,$CBC9,$0FF8,$F437,$EAD5,$B2CE,$03C0,$BD3F
	.dc.w	$682A,$6829,$7838,$9017,$EAAE,$B29F,$0380,$BD7F
	.dc.w	$A8AB,$28A7,$38E0,$D05F,$AABA,$CA7C,$0E00,$F5FF
	.dc.w	$ABFF,$A7FF,$E000,$5FFF,$C64E,$F84E,$007F,$FFB1
	.dc.w	$AFFF,$9FFD,$8000,$7FFF,$EAAE,$729F,$0380,$FD7F
	.dc.w	$A8AB,$28A6,$38E0,$D05E,$AA00,$CA00,$0E00,$F400
	.dc.w	$0015,$0014,$001C,$000B,$7540,$D940,$01C0,$DE80
	.dc.w	$0000,$0000,$0000,$0000,$002D,$002C,$003C,$0013
	.dc.w	$56AA,$E6A9,$07B8,$F917,$EAAA,$B2A9,$03B8,$BD17
	.dc.w	$EA8A,$B28A,$038E,$BD05,$BAB5,$6CB3,$00F0,$EF4F
	.dc.w	$5A6A,$9A69,$1E78,$E417,$EAAE,$B29B,$0380,$BD7B
	.dc.w	$A82A,$2829,$3838,$D017,$EAA0,$B29F,$0380,$BD7F
	.dc.w	$A8A8,$28A7,$38E0,$D05F,$2A82,$CA7C,$0E00,$F5FF
	.dc.w	$A800,$A7FF,$E000,$5FFF,$399A,$C19A,$01FB,$FE61
	.dc.w	$A000,$9FFD,$8000,$7FFF,$0AA0,$729F,$0380,$FD7F
	.dc.w	$A8AB,$28A6,$38E0,$D05E,$AA00,$CA00,$0E00,$F400
	.dc.w	$0015,$0014,$001C,$000B,$7540,$D940,$01C0,$DE80
	.dc.w	$0000,$0000,$0000,$0000,$006A,$0069,$0078,$0017
	.dc.w	$EAAE,$B2AE,$03BE,$BD11,$AEAD,$4EAC,$0FBC,$F113
	.dc.w	$568B,$E68B,$078F,$F904,$55AB,$39A6,$01E0,$FE5E
	.dc.w	$AA2A,$CA29,$0E38,$F417,$EAD5,$B2CE,$03C0,$BD3F
	.dc.w	$682A,$6829,$7838,$9017,$EABF,$B280,$0380,$BD7F
	.dc.w	$A8AF,$28A0,$38E0,$D05F,$EAFE,$0A00,$0E00,$F5FF
	.dc.w	$AFFF,$A000,$E000,$5FFF,$C632,$0632,$07F3,$F9C1
	.dc.w	$BFFF,$8002,$8002,$7FFD,$FABF,$8280,$8380,$7D7F
	.dc.w	$A8AB,$28A6,$38E0,$D05E,$AA00,$CA00,$0E00,$F400
	.dc.w	$0035,$0034,$003C,$000B,$7540,$D940,$01C0,$DE80
	.dc.w	$0000,$0000,$0000,$0000,$01CA,$01C9,$01F8,$0037
	.dc.w	$EAAA,$B2A9,$03B8,$BD17,$EAAA,$B2A9,$03B8,$BD17
	.dc.w	$EA8A,$B28A,$038E,$BD05,$BAB5,$6CB3,$00F0,$EF4F
	.dc.w	$5A2A,$9A29,$1E38,$E417,$EAAE,$B29B,$0380,$BD7B
	.dc.w	$A82A,$2829,$3838,$D017,$EA80,$B280,$0380,$BD7F
	.dc.w	$28A0,$28A0,$38E0,$D05F,$0A00,$0A00,$0E00,$F5FF
	.dc.w	$A000,$A000,$E000,$5FFF,$38E2,$38E2,$3FE3,$C701
	.dc.w	$8002,$8002,$8002,$7FFD,$8280,$8280,$8380,$7D7F
	.dc.w	$28B5,$28B3,$38F0,$D04F,$5A00,$9A00,$1E00,$E400
	.dc.w	$03E5,$03E4,$03FC,$001B,$7540,$D940,$01C0,$DE80
	.dc.w	$3FFF,$3FFF,$3FFF,$0000,$FF16,$FF11,$FFF0,$00EF
	.dc.w	$EAAE,$B2AE,$03BE,$BD11,$AEAD,$4EAC,$0FBC,$F113
	.dc.w	$568B,$E68B,$078F,$F904,$55AB,$39A6,$01E0,$FE5E
	.dc.w	$AA2A,$CA29,$0E38,$F417,$EAEA,$B2E4,$03E0,$BD1F
	.dc.w	$E82A,$E829,$F838,$1017,$EAFF,$B2FF,$03FF,$BD00
	.dc.w	$EFBF,$EFBF,$FFFF,$1040,$FBFF,$FBFF,$FFFF,$0400
	.dc.w	$BFFF,$BFFF,$FFFF,$4000,$C3FE,$C3FE,$FFFF,$3C01
	.dc.w	$FFFF,$BFFF,$FFFF,$0000,$FEFF,$FEFF,$FFFF,$0100
	.dc.w	$EFAB,$EFA6,$FFE0,$105E,$ABFF,$CBFF,$0FFF,$F400
	.dc.w	$FE0B,$FE08,$FFF8,$01F7,$7540,$D940,$01C0,$DE80
	.dc.w	$2000,$2000,$3FFF,$1FFF,$0065,$0063,$FFE0,$FF9F
	.dc.w	$CAAA,$72A9,$03B8,$7D17,$EAAA,$B2A9,$03B8,$BD17
	.dc.w	$EA8A,$B28A,$038E,$BD05,$BAB5,$6CB3,$00F0,$EF4F
	.dc.w	$5A2A,$9A29,$1E38,$E417,$EAAE,$B29B,$0380,$BD7B
	.dc.w	$A82A,$2829,$3838,$D017,$EA00,$B200,$03FF,$BDFF
	.dc.w	$0000,$0000,$FFFF,$FFFF,$0000,$0000,$FFFF,$FFFF
	.dc.w	$0000,$0000,$FFFF,$FFFF,$0000,$0000,$FFFF,$FFFF
	.dc.w	$0000,$0000,$FFFF,$BFFF,$0000,$0000,$FFFF,$FFFF
	.dc.w	$00B5,$00B3,$FFF0,$FF4F,$5A00,$9A00,$1FFF,$E5FF
	.dc.w	$0032,$0031,$FFF0,$FFCF,$E540,$B940,$01C0,$BE80
	.dc.w	$2FFF,$2FFF,$3FFF,$1000,$FF99,$FF87,$FF80,$007F
	.dc.w	$D4AA,$64A9,$07B8,$7B17,$EAAD,$B2AC,$03BC,$BD13
	.dc.w	$568B,$E68B,$078F,$F904,$55AB,$39A6,$01E0,$FE5E
	.dc.w	$AA2A,$CA29,$0E38,$F417,$EAEA,$B2E4,$03E0,$BD1F
	.dc.w	$E82A,$E829,$F838,$1017,$EAFF,$B2FF,$03FF,$BD00
	.dc.w	$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000
	.dc.w	$FFFF,$FFFF,$FFFF,$0000,$1FFF,$FFFF,$1FFF,$0000
	.dc.w	$FFFF,$FFFF,$BFFF,$0000,$1FFF,$FFFF,$1FFF,$0000
	.dc.w	$FFAB,$FFA6,$FFE0,$005E,$ABFF,$CBFF,$0FFF,$F400
	.dc.w	$FFCC,$FFC3,$FFC0,$003F,$EB40,$B340,$03C0,$BC80
	.dc.w	$280A,$280A,$380A,$17F5,$AA77,$AA0E,$AA00,$55FE
	.dc.w	$95AA,$E5A9,$07B8,$FA17,$EAAA,$B2A9,$03B8,$BD17
	.dc.w	$EA8A,$B28A,$038E,$BD05,$BABA,$6CB9,$00F8,$EF47
	.dc.w	$BA2A,$3A29,$3E38,$C417,$EAAE,$B29B,$0380,$BD7B
	.dc.w	$A82A,$2829,$3838,$D017,$EA82,$B282,$0382,$BD7D
	.dc.w	$AAAA,$AAAA,$AAAA,$5555,$AAAA,$AAAA,$AAAA,$5555
	.dc.w	$AA80,$AA81,$AA80,$557E,$E540,$F540,$0540,$0ABF
	.dc.w	$5500,$5501,$1500,$AAFE,$EA00,$FA00,$0A00,$05FF
	.dc.w	$00B5,$00B3,$00F0,$FF4F,$5AAA,$9AAA,$1EAA,$E555
	.dc.w	$003B,$0007,$0000,$FFFF,$CA40,$7240,$03C0,$7D80
	.dc.w	$2BFF,$280A,$380A,$17F5,$558F,$007D,$0000,$FFFD
	.dc.w	$A92A,$C929,$0F38,$F617,$EAAE,$B2AE,$03BE,$BD11
	.dc.w	$AE8B,$4E8B,$0F8F,$F104,$55AB,$39A6,$01E0,$FE5E
	.dc.w	$AA2A,$CA29,$0E38,$F417,$EAAE,$B29B,$0380,$BD7B
	.dc.w	$A8AA,$2829,$3838,$D017,$EABF,$B282,$0382,$BD7D
	.dc.w	$F5F5,$A0A0,$A0A0,$5F5F,$5555,$0000,$0000,$FFFF
	.dc.w	$557D,$0003,$0000,$FFFC,$12BF,$1800,$E000,$07FF
	.dc.w	$AAFD,$4003,$0000,$BFFC,$15FF,$1800,$E000,$07FF
	.dc.w	$FFAB,$00A6,$00E0,$FF5E,$AB55,$CA00,$0E00,$F5FF
	.dc.w	$FFC7,$003E,$0000,$FFFE,$D4C0,$E4C0,$07C0,$FB00
	.dc.w	$2A00,$29F5,$3800,$17FF,$AA7F,$55F3,$0000,$FFF3
	.dc.w	$4B2A,$8B29,$0F38,$F417,$EAAA,$B2A9,$03B8,$BD17
	.dc.w	$EA8A,$B28A,$038E,$BD05,$BABA,$6CB9,$00F8,$EF47
	.dc.w	$BA2A,$3A29,$3E38,$C417,$EAAE,$B29B,$0380,$BD7B
	.dc.w	$A82A,$2829,$3838,$D017,$EAA0,$B29D,$0380,$BD7F
	.dc.w	$0A0A,$5555,$0000,$FFFF,$AAAA,$5555,$0000,$FFFF
	.dc.w	$AA82,$557E,$0001,$FFF8,$4940,$0EBF,$F000,$03FF
	.dc.w	$1502,$EAFE,$0001,$BFF8,$4A00,$0DFF,$F000,$03FF
	.dc.w	$00B5,$FFB3,$00F0,$FF4F,$5AAA,$9B55,$1E00,$E5FF
	.dc.w	$003F,$FFF9,$0000,$FFF9,$A580,$C580,$0780,$FA00
	.dc.w	$2AFF,$29F5,$3800,$17FF,$55FC,$FF8F,$0000,$FF8F
	.dc.w	$D22A,$1229,$1E38,$EC17,$EAEE,$B2EE,$03BE,$BD11
	.dc.w	$AECA,$4ECA,$0F8E,$F105,$BAAB,$6CA6,$00E0,$EF5E
	.dc.w	$AA2A,$CA29,$0E38,$F417,$EAAE,$B29B,$0380,$BD7B
	.dc.w	$A82D,$282C,$383C,$D013,$56AF,$E69D,$0780,$F97F
	.dc.w	$F5F5,$5F5F,$0000,$FFFF,$5555,$FFFF,$0000,$FFFF
	.dc.w	$5574,$FFFC,$0003,$FFF0,$A4A4,$47FF,$F800,$41E4
	.dc.w	$00F4,$FFFC,$0003,$04F0,$A5FF,$47FF,$F800,$41FF
	.dc.w	$FFAB,$FFA6,$00E0,$FF5E,$AB55,$CBFF,$0E00,$F5FF
	.dc.w	$FFFE,$FFC7,$0000,$FFC7,$6900,$8900,$0F00,$F600
	.dc.w	$2AF5,$298A,$3800,$178A,$FFF9,$AA7E,$0000,$AA7F
	.dc.w	$262A,$2629,$3E38,$D817,$EAEA,$B2E9,$03B8,$BD17
	.dc.w	$EACA,$B2CA,$038E,$BD05,$BABA,$6CB9,$00F8,$EF47
	.dc.w	$BA2A,$3A29,$3E38,$C417,$EAAE,$B29B,$0380,$BD7B
	.dc.w	$A82A,$2829,$3838,$D017,$EAAD,$B29A,$0380,$BD7A
	.dc.w	$5F5F,$AAAA,$0000,$AAAA,$FFFF,$AAAA,$0000,$AAAA
	.dc.w	$FFF5,$AA8C,$0003,$AA80,$15DF,$E77B,$F800,$E140
	.dc.w	$FF75,$FF8C,$0003,$0400,$15FF,$E600,$F800,$E000
	.dc.w	$FFBA,$00B9,$00F8,$0047,$BBFF,$3AAA,$3E00,$C4AA
	.dc.w	$FFFC,$003F,$0000,$003F,$9300,$1300,$1F00,$EC00
	.dc.w	$2AFF,$29F5,$3800,$17FF,$55C6,$FFF8,$0000,$FFFF
	.dc.w	$4C2A,$4C29,$7C38,$B017,$EAAE,$F2EE,$03BE,$FD11
	.dc.w	$AE8A,$4ECA,$0F8E,$F105,$BAAB,$7CA7,$00E0,$FF5F
	.dc.w	$AA2A,$CA29,$0E38,$F417,$EAAE,$F29F,$0380,$FD7F
	.dc.w	$A82D,$282C,$383C,$D013,$56AF,$E69D,$0780,$F97F
	.dc.w	$F5F5,$5F5F,$0000,$FFFF,$5555,$FFFF,$0000,$FFFF
	.dc.w	$5575,$FFFC,$0003,$FFF0,$54A4,$A7E0,$F81F,$E180
	.dc.w	$04B5,$00FC,$FF03,$0030,$55FF,$A7FF,$B800,$A1FF
	.dc.w	$FFAB,$FFA6,$00E0,$FF5E,$AB55,$CBFF,$0E00,$F5FF
	.dc.w	$FFE3,$FFFC,$0000,$FFFF,$2600,$2600,$3E00,$D800
	.dc.w	$2A00,$29F5,$3800,$17FF,$AA39,$55C1,$0001,$FFFE
	.dc.w	$982A,$9829,$F838,$6017,$0AAA,$F2A9,$03B8,$FD17
	.dc.w	$0A8A,$F28A,$038E,$FD05,$82A8,$7CA7,$00E0,$FF5F
	.dc.w	$2A2A,$CA29,$0E38,$F417,$0AA0,$F29F,$0380,$FD7F
	.dc.w	$A82A,$2829,$3838,$D017,$EAA0,$B29D,$0380,$BD7F
	.dc.w	$0A0A,$5555,$0000,$FFFF,$AAAA,$5555,$0000,$FFFF
	.dc.w	$AA85,$557C,$0003,$FFF0,$554F,$A6C0,$F83F,$E103
	.dc.w	$FE45,$007C,$FF83,$F810,$5400,$A7FF,$B800,$A1FF
	.dc.w	$00BA,$FFB9,$00F8,$FF47,$BAAA,$3B55,$3E00,$C5FF
	.dc.w	$001C,$FFE0,$0000,$FFFF,$CC00,$CC00,$FC00,$3000
	.dc.w	$2BFF,$280A,$380A,$17F5,$55C6,$0006,$0007,$FFF9
	.dc.w	$302B,$3028,$F038,$C017,$FAAB,$02E8,$03B8,$FD17
	.dc.w	$FA8A,$02EA,$038E,$FD05,$FEAF,$00A0,$00E0,$FF5F
	.dc.w	$EA2B,$0A28,$0E38,$F417,$FABF,$0280,$0380,$FD7F
	.dc.w	$A82D,$282C,$383C,$D013,$56BF,$E682,$0782,$F97D
	.dc.w	$F5F5,$A0A0,$A0A0,$5F5F,$5555,$0000,$0000,$FFFF
	.dc.w	$5573,$000F,$0000,$FFF0,$58D4,$1FCB,$E03F,$0008
	.dc.w	$0523,$FA3F,$FFC0,$0200,$59FF,$1E00,$E000,$01FF
	.dc.w	$FFAB,$00A6,$00E0,$FF5E,$AB55,$CA00,$0E00,$F5FF
	.dc.w	$FFE3,$0003,$0003,$FFFC,$1800,$1800,$F800,$E000
	.dc.w	$280A,$280A,$380A,$17F5,$AA38,$AA38,$AA3F,$55C7
	.dc.w	$E028,$E028,$E038,$0017,$02A8,$02E8,$03F8,$FD17
	.dc.w	$029A,$02FA,$03EE,$FD05,$00A0,$00A0,$00E0,$FF5F
	.dc.w	$0A28,$0A28,$0E38,$F417,$0280,$0280,$0380,$FD7F
	.dc.w	$282A,$2829,$3838,$D017,$EA82,$B282,$0382,$BD7D
	.dc.w	$AAAA,$AAAA,$AAAA,$5555,$AAAA,$AAAA,$AAAA,$5555
	.dc.w	$AA85,$AA8C,$AA83,$5570,$54A0,$A79B,$F87F,$E010
	.dc.w	$00A5,$FB3C,$FFC3,$0100,$5400,$A600,$F800,$E1FF
	.dc.w	$00AB,$00A7,$00E0,$FF5F,$AAAA,$CAAA,$0EAA,$F555
	.dc.w	$001C,$001C,$001F,$FFE3,$7000,$7000,$F000,$8000
	.dc.w	$2FFF,$2FFF,$3FFF,$1000,$FFC3,$FFC3,$FFFF,$003C
	.dc.w	$802F,$802F,$803F,$0010,$FEEF,$FEEF,$FFBF,$0110
	.dc.w	$FEEB,$FEFB,$FF8F,$0104,$FFBF,$FFBF,$FFFF,$0040
	.dc.w	$FA2F,$FA2F,$FE3F,$0410,$FEFF,$FEFF,$FFFF,$0100
	.dc.w	$E82E,$E82E,$F83E,$1011,$AEFF,$4EFF,$0FFF,$F100
	.dc.w	$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000
	.dc.w	$FFF3,$FFFF,$FFF0,$0000,$59A0,$1F9B,$E17F,$0018
	.dc.w	$20B3,$DB3F,$FFD0,$E300,$59FF,$1FFF,$E1FF,$0000
	.dc.w	$FFA8,$FFA7,$FFE0,$005F,$2BFF,$CBFF,$0FFF,$F400
	.dc.w	$FFE1,$FFE1,$FFFF,$001E,$C000,$C000,$C000,$0000
	.dc.w	$2000,$2000,$3FFF,$1FFF,$001E,$001E,$FFFE,$FFE0
	.dc.w	$0020,$0020,$003F,$001F,$00A0,$00E0,$FFFF,$FF1F
	.dc.w	$0088,$00F8,$FFFF,$FF07,$0000,$0000,$FFFF,$FFFF
	.dc.w	$0220,$0220,$FE3F,$FC1F,$0000,$0000,$FFFF,$FFFF
	.dc.w	$082A,$0829,$F838,$F017,$EA00,$B200,$03FF,$BDFF
	.dc.w	$0000,$0000,$FFFF,$FFFF,$0000,$0000,$FFFF,$FFFF
	.dc.w	$0005,$000C,$FFF3,$FFF0,$5424,$A667,$F99B,$E181
	.dc.w	$1485,$ECCC,$FB33,$1030,$5400,$A600,$F9FF,$E1FF
	.dc.w	$00AF,$00A0,$FFE0,$FF5F,$EA00,$0A00,$0FFF,$F5FF
	.dc.w	$000F,$000F,$FFFF,$FFF0,$0000,$0000,$0000,$0000
	.dc.w	$3FFF,$3FFF,$3FFF,$0000,$FFF0,$FFF0,$FFF0,$0000
	.dc.w	$003F,$003F,$003F,$0000,$FFBF,$FFBF,$FFFF,$0000
	.dc.w	$FF9F,$FF9F,$FFEF,$0000,$FFFF,$FFFF,$FFFF,$0000
	.dc.w	$FE3F,$FE3F,$FE3F,$0000,$FFFF,$FFFF,$FFFF,$0000
	.dc.w	$F82E,$F82E,$F83E,$0011,$AEFF,$4EFF,$0FFF,$F100
	.dc.w	$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000
	.dc.w	$FFF3,$FFFF,$FFF0,$0000,$594C,$1FC7,$E13B,$0001
	.dc.w	$0653,$FC7F,$FB90,$1000,$59FF,$1FFF,$E1FF,$0000
	.dc.w	$FFA0,$FFA0,$FFE0,$005F,$0BFF,$0BFF,$0FFF,$F400
	.dc.w	$FFF8,$FFF8,$FFF8,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0001,$1FCF,$0FFE,$0000
	.dc.w	$F000,$FE7F,$0FFE,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$002A,$0029,$0038,$0017,$EA80,$B280,$0380,$BD00
	.dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
	.dc.w	$0005,$000C,$0003,$0000,$5404,$A61F,$F803,$E001
	.dc.w	$0405,$FF0C,$F803,$1000,$5400,$A600,$F800,$E000
	.dc.w	$00BF,$00BF,$00FF,$0040,$FA00,$FA00,$FE00,$0400
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$4CE3,$3C7D,$039E,$0000
	.dc.w	$F8E6,$F7C7,$0F38,$0000,$0000,$8000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0003,$0000,$0000
	.dc.w	$4A2E,$D3AE,$3C3E,$0011,$AE80,$4E80,$0F80,$F100
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0003,$000F,$0000,$0000,$58A4,$1F9F,$E07B,$0018
	.dc.w	$04A3,$FF3F,$FBC0,$E300,$5800,$1E00,$E000,$0000
	.dc.w	$0080,$0080,$00FF,$007F,$0200,$0200,$FE00,$FC00
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$00C0,$3FFB,$3F3F,$0000
	.dc.w	$0060,$1BFF,$FF9F,$0000,$0000,$8000,$8000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0002,$0002,$0000
	.dc.w	$282A,$6CA9,$28B8,$1017,$EA80,$B280,$0380,$BD00
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$1005,$000C,$0003,$0000,$14C0,$E7DF,$F83B,$E008
	.dc.w	$0025,$FF3C,$FBC3,$0200,$1400,$E600,$F800,$E000
	.dc.w	$00FF,$00FF,$00FF,$0000,$FE00,$FE00,$FE00,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0A08,$39FF,$0677,$0002
	.dc.w	$020A,$1FF3,$FDCC,$0800,$0000,$8000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$002A,$4429,$4438,$0017,$EA80,$F280,$0380,$FD00
	.dc.w	$0040,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0004,$000C,$0003,$0000,$A44B,$46C4,$F83B,$4003
	.dc.w	$FA44,$046C,$FB83,$F800,$A400,$4600,$F800,$4000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0004,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0006,$3FF9,$3CEF,$0006
	.dc.w	$EC00,$13FF,$FEE7,$0C00,$0000,$8000,$8000,$0000
	.dc.w	$0010,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$002A,$0029,$0038,$0017,$0A80,$F280,$0380,$FD00
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0002,$0006,$0001,$0000,$4820,$0C64,$F01B,$0000
	.dc.w	$0082,$04C6,$FB01,$0000,$4800,$0C00,$F000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$01E0,$3FFF,$001F,$0000
	.dc.w	$E0F0,$1FFF,$FF00,$0000,$0000,$8000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$002B,$0028,$0038,$0017,$FA80,$0280,$0380,$FD00
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0001,$0003,$0000,$0000,$901B,$983F,$6000,$0000
	.dc.w	$FB01,$FF83,$0000,$0000,$9000,$9800,$6000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0DE3,$33E0,$0C1F,$0C01
	.dc.w	$F8F6,$00F9,$FF06,$F006,$0000,$8000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0028,$0028,$0038,$0017,$0280,$0280,$0380,$FD00
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0001,$0000,$0000,$E000,$F01B,$0000,$0000
	.dc.w	$0000,$FB01,$0000,$0000,$E000,$F000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$00FF,$00FF,$0001
	.dc.w	$0000,$FFE0,$FFE0,$5000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$002F,$002F,$003F,$0010,$FE80,$FE80,$FF80,$0100
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$E000,$0000,$0000
	.dc.w	$0000,$4000,$0000,$0000,$0000,$E000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0053,$00CC,$003F,$000E
	.dc.w	$5940,$A660,$FF80,$0E00,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0020,$0020,$003F,$001F,$0080,$0080,$FF80,$FF00
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$4000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0001,$0000
	.dc.w	$0000,$A000,$F000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$003F,$003F,$003F,$0000,$FF80,$FF80,$FF80,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$4000,$4000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0001,$0001,$0000,$0000
	.dc.w	$5000,$F000,$A000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$4000,$4000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0001,$0000,$0000
	.dc.w	$0000,$5000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0400,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$4000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$4000,$0000,$4000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0800,$0800,$0800,$0080,$0000,$0080,$0080
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$03E0,$7FE0,$001F,$0000
	.dc.w	$FEAA,$0658,$F9E7,$0060,$ABF8,$D300,$3CFF,$3000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$1000,$0000,$3000,$0000
	.dc.w	$0EB7,$0670,$0E10,$01ED,$6B80,$7300,$4380,$BC00
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0800,$3000,$4800,$3000
	.dc.w	$02B7,$0650,$09F0,$006D,$6A00,$5300,$7C80,$B000
	.dc.w	$0080,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$4000,$7000,$0800,$3000
	.dc.w	$0EB7,$0E70,$0610,$01ED,$6B80,$7380,$4300,$BC00
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$3000,$3000,$0000,$0000
	.dc.w	$02AA,$0E58,$01E7,$0060,$AA00,$D380,$3C00,$3000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0008,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0800,$0000,$0000,$0000,$0080,$0000,$0000
	.dc.w	$0001,$0001,$0001,$0000,$4000,$E000,$E000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$000F,$000F,$0007,$0008
	.dc.w	$FFFF,$FFFF,$FFFF,$0000,$FF00,$FF00,$FF00,$00FF
	.dc.w	$0000,$0000,$0000,$FFFF,$1FFF,$0000,$0000,$FFFF
	.dc.w	$FFFC,$0003,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF
	.dc.w	$007F,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
	.dc.w	$F000,$F000,$0000,$F000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0002,$0003,$0003,$0000,$8000,$A000,$A000,$4000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$000C,$000C,$0000,$000C
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$3000,$3000,$0000,$3000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0005,$0007,$0007,$0000,$4000,$2000,$2000,$C000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$000D,$000D,$0000,$000D
	.dc.w	$FFFC,$FFFC,$FFFC,$0003,$001F,$0000,$0000,$FFFF
	.dc.w	$FF00,$00FF,$0000,$FFFF,$07FF,$FFFF,$0000,$FFFF
	.dc.w	$FFF0,$FFFF,$0000,$FFFF,$00FF,$FF00,$0000,$FFFF
	.dc.w	$F800,$0000,$0000,$FFFF,$3FFF,$3FFF,$3FFF,$C000
	.dc.w	$B000,$B000,$0000,$B000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$000A,$000E,$000E,$0001,$C000,$2000,$2000,$C000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$000D,$000D,$0000,$000D
	.dc.w	$FFFC,$FFFC,$7FFC,$8003,$001F,$0000,$0000,$FFFF
	.dc.w	$FF00,$00FF,$0000,$FFFF,$07FF,$FFFF,$0000,$FFFF
	.dc.w	$FFF0,$FFFF,$0000,$FFFF,$00FF,$FF00,$0000,$FFFF
	.dc.w	$F800,$0000,$0000,$FFFF,$3FFF,$3FFF,$3FFE,$C001
	.dc.w	$B000,$B000,$0000,$B000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

	.end
