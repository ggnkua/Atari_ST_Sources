*
*	COCKPIT.S	ST Star-Raiders Cockpit Interior Image Data
*		Copyright 1986 ATARI Corp.
*

*
*	PUBLIC SYMBOLS
*
	.globl	topcock
	.globl	botcock

*
*	COCKPIT Image data
*		Raw Image_Data (just pour and serve)
*

	.data
	.even

topcock:		* Top of Cockpit Image
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$000F,$000F,$000F,$0030,$FFFF,$FFFF,$FFFF,$0000
	.dc.w	$F800,$F900,$F900,$0600,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0001,$0003,$0002,$0001,$FFFF,$FFFF,$0000,$FFFF
	.dc.w	$FFFF,$FFFF,$0000,$FFFF,$8000,$4000,$4000,$0000
	.dc.w	$7FFC,$7FF8,$0000,$7FF8,$000F,$000F,$000F,$0000
	.dc.w	$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000
	.dc.w	$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000
	.dc.w	$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000
	.dc.w	$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000
	.dc.w	$F838,$F820,$F820,$001F,$0000,$0000,$0000,$FFFF
	.dc.w	$0E01,$0303,$0302,$FC01,$FFFF,$FFFF,$0000,$FFFF
	.dc.w	$FFFF,$FFFF,$0000,$FFFF,$83FF,$43FF,$43FF,$0000
	.dc.w	$FC03,$FC07,$FC05,$003A,$FFFF,$FFFF,$FFFF,$0000
	.dc.w	$FFFF,$FFFF,$FFFF,$0000,$C000,$E001,$A001,$5C0E
	.dc.w	$FFFE,$FFFF,$7FFD,$8002,$000F,$000F,$000F,$E000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$7827,$7828,$7820,$001B,$FFFF,$0000,$0000,$FFFF
	.dc.w	$F203,$0B07,$0305,$EC02,$FFFF,$FFFF,$FFFF,$0000
	.dc.w	$FFFF,$FFFF,$FFFF,$0000,$C2A0,$E2A0,$A2A0,$5D5F
	.dc.w	$0036,$03CE,$03CA,$FC34,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$6C0D,$73F3,$53F2,$2C0D
	.dc.w	$FFFF,$8003,$FFFE,$7FFD,$6000,$9FF0,$9FF0,$600F
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$002C,$07E4,$07E0,$781C,$0000,$0000,$0000,$0000
	.dc.w	$1A06,$13CE,$03CA,$1C04,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$6D5F,$7000,$5000,$2FFF
	.dc.w	$FFCC,$03FC,$03D4,$FC28,$0000,$0000,$0000,$0000
	.dc.w	$0000,$003C,$003C,$003C,$33F3,$3FFF,$2BF5,$140A
	.dc.w	$FFEF,$0011,$FFFF,$FFFE,$9FEF,$FFF0,$5FF0,$A00F
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$03A8,$07E4,$07E0,$781C,$0000,$4444,$4444,$4444
	.dc.w	$0ACC,$53DC,$43D4,$5C08,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$315F,$3D5F,$2800,$17FF
	.dc.w	$FC18,$FC38,$0028,$FFD0,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0066,$0066,$0066,$1807,$1C0A,$140B,$0BF5
	.dc.w	$FFEF,$0010,$FFFF,$FFD7,$C000,$A01F,$A010,$5FEF
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$7828,$0466,$0462,$7B9E,$0000,$2222,$AAAA,$AAAA
	.dc.w	$0A18,$3328,$A328,$BCD0,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$1BFF,$1C00,$1400,$0BFF
	.dc.w	$FFD8,$0038,$0028,$FFD0,$0000,$0000,$0000,$0000
	.dc.w	$0000,$006E,$006E,$006E,$1BF6,$1C0A,$140B,$0BF4
	.dc.w	$FFAB,$0010,$FFFF,$FF83,$DFEF,$A01F,$A010,$5FEF
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$03A8,$7C65,$0461,$7B9D,$4000,$1111,$1111,$1111
	.dc.w	$0AD8,$1328,$0328,$1CD0,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$1800,$1EA0,$1400,$0BFF
	.dc.w	$03D8,$03F8,$0028,$FFD0,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0076,$0076,$0076,$1BF6,$1FFA,$140B,$0BF4
	.dc.w	$F793,$A0AA,$5F7D,$5711,$DFEF,$BFFF,$A010,$5FEF
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$7BA8,$7FE4,$0460,$7B9C,$2000,$8888,$8888,$8888
	.dc.w	$0AD8,$93E8,$8328,$9CD0,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$1BFF,$1FFF,$155F,$0AA0
	.dc.w	$FFD8,$FC38,$FC28,$03D0,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0066,$0066,$0066,$1BF6,$1C0B,$140B,$0BF4
	.dc.w	$A6BA,$E5C7,$1A7C,$0238,$DFEF,$A01F,$A010,$5FEF
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$7BA8,$7C64,$0461,$7B9D,$0000,$4444,$5555,$5555
	.dc.w	$0AD8,$5328,$4328,$5CD0,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$1AA0,$1EA0,$1400,$0BFF
	.dc.w	$0018,$0028,$0028,$FFD0,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0066,$0066,$0066,$1807,$140A,$140B,$0BF5
	.dc.w	$047C,$EF83,$B8FE,$007C,$C00F,$A01F,$A010,$5FEF
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0028,$7C64,$0460,$7B9C,$0000,$2222,$2222,$2222
	.dc.w	$0A18,$3328,$2328,$3CD0,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$195F,$16A0,$1400,$0BFF
	.dc.w	$FFEC,$03D4,$03D4,$FC28,$0000,$0000,$0000,$0000
	.dc.w	$0000,$003C,$003C,$003C,$37FB,$2BF5,$2BF5,$140A
	.dc.w	$A8FF,$5701,$FDFF,$A8FE,$BFE0,$5FFF,$5FF0,$A00F
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$7BA8,$07E4,$07E0,$781C,$0000,$0000,$0000,$0000
	.dc.w	$0ACC,$13D4,$03D4,$1C08,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$37FF,$295F,$2800,$17FF
	.dc.w	$FC06,$FFCA,$03CA,$FC34,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$6001,$53F2,$53F2,$2C0D
	.dc.w	$FFFF,$8002,$FFFE,$7FFD,$000F,$9FF0,$9FF0,$600F
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$002F,$07E0,$07E0,$781F,$FFFF,$0000,$0000,$FFFF
	.dc.w	$FA06,$03CA,$03CA,$FC04,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$615F,$5000,$5000,$2FFF
	.dc.w	$FC3B,$003D,$003D,$FC02,$FFFF,$FFFF,$FFFF,$0000
	.dc.w	$FFFF,$FFFF,$FFFF,$0000,$DC0E,$BC0F,$BC0F,$4000
	.dc.w	$FFFE,$7FFD,$7FFD,$8002,$E000,$E000,$E000,$000F
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$7820,$7820,$7820,$001F,$0000,$0000,$0000,$FFFF
	.dc.w	$0203,$0305,$0305,$FC02,$FFFF,$FFFF,$FFFF,$0000
	.dc.w	$FFFF,$FFFF,$FFFF,$0000,$DEA0,$BEA0,$BEA0,$415F
	.dc.w	$FC00,$FC3E,$FC3E,$0001,$0000,$0000,$0000,$FFFF
	.dc.w	$0000,$0000,$0000,$FFFF,$0000,$7C0F,$7C0F,$8000
	.dc.w	$0000,$8003,$8003,$7FFC,$000F,$E00F,$E00F,$0000
	.dc.w	$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000
	.dc.w	$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000
	.dc.w	$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000
	.dc.w	$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000
	.dc.w	$F83F,$F83F,$F83F,$0000,$FFFF,$FFFF,$FFFF,$0000
	.dc.w	$FE00,$FF02,$FF02,$0001,$0000,$0000,$0000,$FFFF
	.dc.w	$0000,$0000,$0000,$FFFF,$02A0,$7FFF,$7FFF,$8000

botcock:		* Cockpit Bottom Image
	.dc.w	$FFF5,$FFFC,$FFFC,$0003,$5FFF,$BFFF,$3FFF,$C000
	.dc.w	$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000
	.dc.w	$FFFF,$FFFF,$FFFF,$0000,$FFE0,$FFFF,$FFEE,$0011
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$8FFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000
	.dc.w	$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000
	.dc.w	$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000
	.dc.w	$FFEA,$0039,$0038,$FFC7,$5FFF,$A000,$2000,$DFFF
	.dc.w	$FFFF,$0000,$0000,$FFFF,$FFFF,$0000,$0000,$FFFF
	.dc.w	$FFFF,$0000,$0000,$FFFF,$E00E,$0036,$0030,$FFCE
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$77FF,$3800,$0800,$77FF,$FFFF,$0000,$0000,$FFFF
	.dc.w	$FFFF,$0000,$0000,$FFFF,$FFFF,$0000,$0000,$FFFF
	.dc.w	$FFFF,$0000,$0000,$FFFF,$FFFF,$0000,$0000,$FFFF
	.dc.w	$FFD4,$FFF2,$0070,$FF8E,$5FFF,$BFFF,$2000,$DFFF
	.dc.w	$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
	.dc.w	$FFFF,$FFFF,$0000,$FFFF,$FFDF,$E03D,$0030,$FFCD
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$FFFF,$EFFF,$8000,$6FFF,$FFFF,$FFFF,$0000,$FFFF
	.dc.w	$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
	.dc.w	$FFFD,$FFFF,$0003,$FFFC,$BFFF,$FFFF,$C000,$3FFF
	.dc.w	$FFA8,$00E4,$00E0,$FF1C,$5FFF,$A000,$2000,$DFFF
	.dc.w	$FFFF,$0000,$0000,$FFFF,$FFFF,$0000,$0000,$FFFF
	.dc.w	$FFFF,$0000,$0000,$FFFF,$E011,$0031,$003E,$FFCF
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$8FFF,$8800,$F000,$7FFF,$FFFF,$0000,$0000,$FFFF
	.dc.w	$FFFF,$0000,$0000,$FFFF,$FFFF,$0000,$0000,$FFFF
	.dc.w	$FFF9,$0005,$0005,$FFFA,$5FFF,$E000,$E000,$1FFF
	.dc.w	$FF50,$FFCA,$FFC0,$0038,$5FFF,$BFFF,$3FFF,$C000
	.dc.w	$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000
	.dc.w	$FFFF,$FFFF,$FFFF,$0000,$FFD1,$FFF0,$FFFE,$000F
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$8FFF,$87FF,$F7FF,$7800,$FFFF,$FFFF,$FFFF,$0000
	.dc.w	$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000
	.dc.w	$FFFE,$FFFC,$FFFC,$0003,$AFFF,$FFFF,$FFFF,$0000
	.dc.w	$02A0,$0394,$0380,$0070,$4AAA,$AAAA,$2AAA,$C000
	.dc.w	$AAAA,$AAAA,$AAAA,$0000,$AAAA,$AAAA,$AAAA,$0000
	.dc.w	$AA00,$AA3F,$AA3F,$0000,$0011,$FFF0,$FFFE,$000F
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$8801,$8001,$F001,$7800,$5511,$3910,$0110,$FE05
	.dc.w	$1110,$5410,$0010,$5540,$542A,$4422,$4422,$381C
	.dc.w	$0555,$04EE,$0404,$03FB,$5000,$7800,$7800,$8000
	.dc.w	$C540,$C728,$C700,$00E0,$5FF7,$BFF5,$3FF4,$C003
	.dc.w	$BFFF,$BFFF,$3FFF,$8000,$D7FE,$D7FE,$D000,$07FE
	.dc.w	$9510,$9537,$9532,$000D,$4011,$7FF0,$7FFE,$800F
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$8D55,$8555,$F555,$7800,$555D,$7D5D,$555D,$AA02
	.dc.w	$DDDC,$7F5D,$555D,$AAA0,$007F,$FFF7,$FFF7,$0008
	.dc.w	$5555,$55F6,$5554,$02AB,$A8C6,$3C06,$3C00,$C0C6
	.dc.w	$2A80,$2E40,$2E00,$C1C0,$400A,$BFE9,$3FE8,$C007
	.dc.w	$C000,$5FFF,$1FFF,$4000,$A70B,$AF07,$A700,$08FF
	.dc.w	$6A10,$6A35,$6A30,$000D,$4011,$7FF0,$7FFE,$800F
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$8AAB,$82AB,$F2AB,$7800,$FFAE,$BBAE,$ABAE,$5401
	.dc.w	$EEEE,$BFAF,$AAAF,$5550,$182A,$27AA,$FFAA,$DB14
	.dc.w	$AFFD,$AEEE,$AEAC,$0153,$5529,$9E09,$1E00,$E129
	.dc.w	$1500,$1C80,$1C00,$6380,$4FEB,$B8E8,$38E8,$C707
	.dc.w	$5FFE,$C001,$0001,$DFFE,$D7FF,$CFFF,$C800,$17FF
	.dc.w	$BF14,$BF31,$3F30,$800D,$4011,$7FF0,$7FFE,$800F
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$8800,$8000,$F000,$7D55,$0002,$2802,$0002,$FF55
	.dc.w	$2222,$0A83,$0003,$FFFC,$187F,$27F7,$FFF7,$DB08
	.dc.w	$5555,$55F6,$5554,$02AB,$2A11,$4F11,$0F01,$7016
	.dc.w	$2A00,$3940,$3800,$0700,$4FE9,$B8E8,$38E8,$C707
	.dc.w	$DFEE,$4011,$0011,$DFFE,$A001,$9801,$9000,$2801
	.dc.w	$3815,$C034,$0030,$FF0D,$4011,$7C30,$7FFE,$83CF
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$8801,$8001,$F001,$7AAA,$5501,$1101,$0101,$FEAA
	.dc.w	$0010,$3F41,$3F01,$C0FE,$002A,$FFAA,$FFAA,$0014
	.dc.w	$AFFD,$AEEE,$AEAC,$0153,$1506,$27A6,$0786,$3868
	.dc.w	$F400,$7280,$7000,$8E00,$4FEC,$B8EC,$38EC,$C703
	.dc.w	$1FEE,$0011,$0011,$DFFE,$E000,$D801,$D000,$2801
	.dc.w	$BF1F,$703E,$0034,$FF0B,$4011,$7831,$7B7E,$834F
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$8800,$8800,$F000,$7D55,$0000,$2800,$0000,$FF55
	.dc.w	$9E88,$BFA0,$A100,$5EFF,$D57F,$D577,$D577,$2808
	.dc.w	$5555,$55F6,$5554,$02AB,$0A8D,$13C9,$03C9,$1C34
	.dc.w	$5810,$7510,$7010,$0C00,$4C17,$BB17,$3BF7,$C700
	.dc.w	$BF82,$807D,$807D,$3FFE,$8000,$9000,$9000,$2801
	.dc.w	$401F,$1E3E,$1E34,$C10B,$5817,$6437,$67F0,$9BCF
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$B800,$BFFF,$87FF,$7800,$0000,$FFF8,$FFF8,$0002
	.dc.w	$525F,$735F,$6D1F,$9EE0,$FFFA,$FFFA,$FFFA,$0004
	.dc.w	$AFFD,$AEEE,$AEAC,$0153,$7552,$09F0,$71F0,$7E02
	.dc.w	$D800,$F400,$F000,$0C00,$4FFB,$B87B,$387B,$C780
	.dc.w	$7FEE,$0011,$0011,$7FFE,$C000,$D000,$D000,$2801
	.dc.w	$811F,$9F3E,$9F34,$4C0B,$400E,$4436,$4470,$804E
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$77FF,$3FFF,$0FFF,$7000,$FFE0,$FFFC,$FFFC,$0001
	.dc.w	$0010,$33B0,$2D30,$5ECF,$000B,$000F,$000F,$FFF0
	.dc.w	$FFFD,$FFFE,$FFFC,$0003,$42A5,$04F4,$78F4,$4701
	.dc.w	$5800,$7400,$7000,$0C00,$4FF8,$B830,$3830,$C7CB
	.dc.w	$7FEE,$0011,$0011,$7FFE,$A7FE,$AFFF,$AFFF,$1000
	.dc.w	$001F,$1F3F,$1F30,$8C0F,$C000,$FF2F,$7F6E,$8041
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$F000,$7FFF,$8FFF,$0008,$001E,$FF96,$FFE8
	.dc.w	$0C10,$3377,$2D30,$9ECF,$0028,$FFEC,$000C,$FFF3
	.dc.w	$00FD,$00FE,$00FC,$FF03,$4151,$0279,$6479,$4380
	.dc.w	$5800,$7401,$7000,$8C01,$CFFB,$3878,$3878,$C783
	.dc.w	$7FFE,$7FF1,$7FF1,$000E,$9000,$97FE,$97FE,$4801
	.dc.w	$011D,$1F3D,$1F3D,$0000,$C000,$FF6F,$FF62,$000D
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$7000,$820F,$0FFF,$FDF0,$006C,$1E1F,$FF93,$E1EC
	.dc.w	$1293,$2137,$2D30,$5ECF,$FFCA,$FFAD,$000D,$FFB2
	.dc.w	$55FD,$AA06,$AA04,$55FB,$00BA,$013E,$223E,$01C0
	.dc.w	$5801,$7402,$7000,$0C03,$4FB8,$78FB,$78D8,$8723
	.dc.w	$7FEE,$4079,$4019,$3FE6,$8FFE,$8FFE,$8FFE,$2000
	.dc.w	$4D10,$5335,$5F30,$0C0D,$4000,$7FEF,$7FE2,$800D
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$F208,$0FFF,$FDF7,$000C,$A07B,$FF91,$5FEA
	.dc.w	$1252,$2D37,$2D31,$9ECE,$0049,$FFEF,$FF8D,$0072
	.dc.w	$AAFD,$FFFE,$AA04,$55FB,$216F,$00BF,$213F,$21C0
	.dc.w	$5802,$7404,$7000,$0C07,$8F20,$D9E0,$D980,$0663
	.dc.w	$0066,$007D,$000D,$0072,$8000,$8000,$8000,$5000
	.dc.w	$8C10,$9235,$9E30,$0D0D,$5800,$67EF,$63E2,$9C0D
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$7000,$E20F,$0FFF,$EDF0,$0064,$1C7B,$FF91,$E3EE
	.dc.w	$8052,$A177,$AD71,$5E8E,$3C4A,$C3EE,$FF8C,$3C73
	.dc.w	$55FD,$5506,$0004,$FFFB,$006F,$003F,$113F,$0040
	.dc.w	$D805,$F409,$F001,$0C0E,$0EBF,$9B7F,$9B00,$04FF
	.dc.w	$FFEA,$FFF7,$0007,$FFF8,$87FE,$87FE,$8000,$27FE
	.dc.w	$4110,$5F35,$5F30,$000D,$4000,$47EF,$47E2,$800D
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$F209,$0FFF,$FDF6,$0002,$0271,$FF91,$FDEE
	.dc.w	$0092,$2DB7,$2DB1,$DE4E,$664A,$99EF,$FF8C,$6673
	.dc.w	$55FD,$FFFE,$00FC,$FF03,$10E8,$0038,$50B8,$50C7
	.dc.w	$580A,$7413,$7003,$8C1C,$4C00,$5E7F,$5E00,$01FF
	.dc.w	$0000,$FFF3,$0003,$FFFC,$870B,$8F07,$8700,$48FF
	.dc.w	$0010,$1335,$1F30,$0C0D,$4000,$7FEF,$7FE2,$800D
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$7000,$83E8,$0FFF,$FC17,$0064,$BC15,$FF95,$43EA
	.dc.w	$D2D2,$FFF7,$FFF1,$0C0E,$6E4B,$91EF,$FF8C,$6E73
	.dc.w	$FFFD,$FFFE,$00FC,$FF03,$006F,$0038,$28B8,$2047
	.dc.w	$D814,$F427,$F006,$0C39,$0800,$9C00,$9C00,$03FF
	.dc.w	$0000,$0001,$0001,$FFFE,$97FF,$CFFF,$C800,$17FF
	.dc.w	$8010,$9235,$1E30,$8C0D,$4000,$7FEF,$7FE2,$800D
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$8000,$0FFF,$FFFF,$0000,$001B,$FF92,$FFED
	.dc.w	$D212,$3F37,$3F31,$CCCE,$764A,$89EF,$FF8C,$7673
	.dc.w	$55FD,$FF06,$0004,$FFFB,$0068,$103F,$54B8,$4047
	.dc.w	$582B,$744C,$700C,$0C73,$0800,$D800,$5800,$87FF
	.dc.w	$0000,$0000,$0000,$FFFF,$A001,$9801,$9000,$2801
	.dc.w	$0110,$9F35,$1F30,$800D,$4000,$7FEF,$7FE2,$800D
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$7FFF,$FFFF,$7FFF,$8000,$FFE3,$FFF7,$FFF4,$000B
	.dc.w	$DED2,$FF37,$3F31,$C0CE,$6648,$99EE,$FF8C,$6673
	.dc.w	$00F9,$55FC,$0004,$FFFB,$006F,$A03F,$2BB8,$8847
	.dc.w	$5850,$7499,$7019,$0CE6,$1000,$DFFF,$9FFF,$4000
	.dc.w	$0000,$FFFF,$FFFF,$0000,$2000,$9801,$9000,$2801
	.dc.w	$F810,$0035,$0030,$FF0D,$5800,$67EF,$63E2,$9C0D
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$FFFF,$7FFF,$8000,$0001,$FFFC,$FFF8,$0007
	.dc.w	$C012,$3F37,$3F31,$C0CE,$664B,$99ED,$FF8D,$6672
	.dc.w	$FFF8,$AA06,$AA02,$55FD,$81E8,$443F,$15B8,$D1C7
	.dc.w	$58AC,$753E,$703E,$0DC1,$11AA,$DFFF,$DFFF,$0000
	.dc.w	$E8C3,$FFFF,$FFFF,$0000,$0000,$9000,$9000,$2801
	.dc.w	$7F10,$7035,$0030,$FF0D,$4000,$47EF,$47E2,$800D
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$7FFF,$FFFF,$7FFF,$8000,$FFE3,$FFFD,$FFFD,$0002
	.dc.w	$FFD2,$FFF7,$FFF1,$000E,$3C48,$C3ED,$FF8D,$3C72
	.dc.w	$00FE,$AAF9,$AAF9,$5506,$406F,$2038,$0A38,$EA47
	.dc.w	$5941,$7674,$7074,$0F83,$113A,$9EC5,$9EC5,$413A
	.dc.w	$C8A2,$375D,$375D,$C8A2,$0000,$9000,$9000,$2801
	.dc.w	$F815,$8030,$8030,$7F0D,$4008,$7FE7,$7FE2,$800D
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$8000,$0FFF,$FFFF,$0008,$001F,$FF97,$FFE8
	.dc.w	$0012,$FFF7,$FFF1,$000E,$004B,$FFEF,$FF8F,$0070
	.dc.w	$FFEA,$FFEA,$FFEA,$0014,$2068,$9038,$8538,$7547
	.dc.w	$5A92,$74F9,$70C8,$0F37,$1000,$9FFF,$98D5,$472A
	.dc.w	$0000,$FFFF,$1131,$EECE,$47FE,$EFFF,$EFFF,$1000
	.dc.w	$7F15,$7F35,$7F31,$800C,$C00D,$FDE2,$7FE2,$820D
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$F227,$0000,$0DD8,$FDD8,$3C6C,$001F,$C393,$C3EC
	.dc.w	$ABD2,$ABF7,$ABF1,$540E,$3C4F,$C3EF,$FF8F,$3C70
	.dc.w	$FFFF,$FFFF,$FFFF,$0000,$106A,$4ABA,$42BA,$3840
	.dc.w	$5D41,$71B3,$7190,$0E6F,$1000,$9FFF,$9FFF,$4000
	.dc.w	$0000,$FFFF,$FFFF,$0000,$2000,$B7FE,$B7FE,$0801
	.dc.w	$001F,$7F3F,$7F35,$000A,$C00D,$F9E2,$7BE2,$820D
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$8368,$7000,$0C97,$FC97,$A20C,$007B,$5D91,$5DEA
	.dc.w	$0092,$00B7,$00B1,$AA0E,$664B,$99EB,$FF8B,$6674
	.dc.w	$82AA,$FFFE,$FFFE,$0000,$8965,$A435,$A035,$1C40
	.dc.w	$5A4B,$7326,$7320,$0CDF,$1FFF,$9FFF,$9FFF,$4000
	.dc.w	$FFFF,$FFFF,$FFFF,$0000,$D7FE,$DFFE,$DFFE,$0000
	.dc.w	$051F,$053F,$0534,$500B,$D80D,$E422,$E7E2,$1BCD
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$F2AF,$6000,$0D50,$ED50,$BC64,$007B,$4391,$43EE
	.dc.w	$0152,$0177,$0171,$540E,$6E4D,$91ED,$FF8D,$6E72
	.dc.w	$7D55,$FFF5,$8355,$7CA8,$44EA,$523A,$503A,$0E40
	.dc.w	$D597,$F7CE,$F7C2,$083D,$4AAA,$CAAA,$CAAA,$0000
	.dc.w	$AAAA,$AAAA,$AAAA,$0000,$AAAA,$AAAA,$AAAA,$0000
	.dc.w	$AA1F,$AA3F,$AA35,$000A,$400D,$4422,$46E2,$82CD
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$8228,$7000,$0DD7,$FDD7,$A002,$0071,$5F91,$5FEE
	.dc.w	$1E92,$1EB7,$1EB1,$A00E,$764E,$89EB,$FF8B,$7674
	.dc.w	$00FE,$FDEE,$7DAE,$8250,$A265,$A935,$A835,$0740
	.dc.w	$DB2B,$3C9E,$3C86,$C379,$1FFF,$9FFF,$9FFF,$4000
	.dc.w	$FFFE,$FFFE,$FFFE,$0001,$7E1E,$7E01,$7E00,$01FF
	.dc.w	$1F10,$FF3F,$003F,$FF00,$400D,$F822,$FBE2,$03CD
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$F228,$0000,$0DD7,$FDD7,$A064,$0015,$5F95,$5FEA
	.dc.w	$C152,$E177,$E171,$1E0E,$664D,$99EE,$FF8E,$6671
	.dc.w	$57D5,$CF75,$C855,$3728,$516A,$54BA,$543A,$03C0
	.dc.w	$D653,$FF3E,$390E,$C6F1,$5000,$9000,$9000,$4FFF
	.dc.w	$0003,$0001,$0001,$FFFE,$4000,$7FFF,$7FFF,$0000
	.dc.w	$010A,$FF38,$FE38,$0107,$800D,$F862,$F862,$000D
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$8000,$0000,$0FFF,$FFFF,$0000,$0012,$FF92,$FFE4
	.dc.w	$1F92,$20B7,$20B1,$DF0E,$664A,$99ED,$FF8D,$6672
	.dc.w	$A1FE,$9D6E,$922E,$6C50,$A8E5,$AA35,$AA35,$01C0
	.dc.w	$FCA3,$027E,$021E,$FDE9,$1000,$97FF,$9000,$4FFF
	.dc.w	$0001,$FFFD,$0001,$FFFE,$4000,$7FFF,$6AA2,$155D
	.dc.w	$011F,$FFE0,$22FF,$DD1F,$C00D,$3FE2,$FFE2,$C00D
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$FFFF,$7FFF,$7FFF,$8000,$FFE1,$FFF4,$FFF4,$0009
	.dc.w	$C152,$3E77,$2071,$DF8E,$3C4A,$C3ED,$FF8D,$3C72
	.dc.w	$A095,$9BF5,$9715,$6B68,$546A,$553A,$553A,$00C0
	.dc.w	$F942,$FCFC,$FC3C,$03DB,$53FF,$D7FF,$D000,$0FFF
	.dc.w	$FFF9,$FFFD,$0001,$FFFE,$5DDD,$6222,$6222,$1DDD
	.dc.w	$9DF0,$6300,$62FF,$9DFF,$7C0D,$03E2,$FBE2,$FC0D
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$8000,$7FFF,$7FFF,$8000,$0003,$FFFB,$FFF8,$0003
	.dc.w	$DD52,$FE77,$2071,$DF8E,$0048,$FFED,$FF8D,$0072
	.dc.w	$A43E,$972E,$93AE,$6B50,$AA25,$AAB5,$AAB5,$0040
	.dc.w	$8285,$89F9,$8879,$7796,$1200,$9600,$9000,$4E00
	.dc.w	$0009,$000D,$0001,$000E,$4000,$6B6E,$6B6E,$1491
	.dc.w	$011F,$29E0,$28FF,$D71F,$C00D,$3FE2,$FFE2,$C00D
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$FFFF,$7FFF,$7FFF,$8000,$FFE3,$FFFE,$FFFE,$0001
	.dc.w	$C553,$3E77,$2070,$DF8F,$FFC8,$FFED,$000D,$FFF2
	.dc.w	$A6BF,$96BF,$95BF,$6840,$552A,$557A,$557A,$0000
	.dc.w	$A542,$53BB,$50F3,$AF4C,$D249,$7649,$7049,$8E00
	.dc.w	$2489,$248D,$2481,$000E,$4000,$7FFF,$7FFF,$0000
	.dc.w	$010A,$FF38,$FE38,$0107,$800D,$FFE2,$FFE2,$000D
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$8000,$0000,$0FFF,$FFFF,$0008,$001E,$FF96,$FFE9
	.dc.w	$1D53,$2277,$2070,$DF8F,$FFC8,$FFEE,$000A,$FFF5
	.dc.w	$5780,$CFFF,$CFFF,$3000,$0000,$FFFF,$FFFF,$0000
	.dc.w	$4AC4,$E737,$61E6,$9ED9,$9249,$F649,$F049,$0E00
	.dc.w	$2489,$248D,$2481,$000E,$47BE,$407D,$4041,$07BC
	.dc.w	$F110,$013F,$003F,$F100,$400D,$FFE2,$FFE2,$000D
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$F000,$01CF,$0FFF,$FE30,$006C,$BE1F,$FF93,$41EC
	.dc.w	$C550,$E277,$E070,$1F8F,$000C,$FFEF,$000D,$FFF2
	.dc.w	$0080,$7DC0,$7DC0,$823F,$3E00,$7F00,$4100,$BEFE
	.dc.w	$B489,$EF6D,$63CD,$9CB2,$52FF,$F6FF,$F0FF,$0E00
	.dc.w	$FFE9,$FFED,$FFE1,$000E,$4701,$40FF,$40BE,$0741
	.dc.w	$7015,$8130,$8030,$710D,$400D,$7FE2,$7FE2,$800D
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$8000,$7228,$0FFF,$FDD7,$000C,$087B,$FF91,$F7EA
	.dc.w	$1550,$F270,$F070,$0F8F,$000E,$000B,$000A,$FFF5
	.dc.w	$7C95,$FEDF,$FEDF,$0120,$2B55,$E7FD,$A0FD,$5F02
	.dc.w	$A812,$FDDF,$679F,$9A60,$D249,$F649,$F049,$0E00
	.dc.w	$2489,$248D,$2481,$000E,$46BE,$4141,$417F,$0680
	.dc.w	$B015,$C130,$4030,$B10D,$580D,$67E2,$63E2,$9C0D
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$F000,$63EF,$0FFF,$EC10,$0064,$087B,$FF91,$F7EE
	.dc.w	$ED5F,$FA7F,$F87F,$0780,$FFFF,$FFFD,$FFFD,$0002
	.dc.w	$030A,$FD5F,$7D5F,$82A0,$BFA8,$41FC,$7E7C,$BF82
	.dc.w	$B025,$E9B7,$6736,$9EC9,$D249,$B649,$B049,$4E00
	.dc.w	$2C89,$248D,$2C81,$080E,$C51F,$C283,$C2FF,$0500
	.dc.w	$1015,$E130,$A030,$510D,$4005,$47E2,$47E2,$800D
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$8000,$7228,$0FFF,$FDD7,$0002,$0871,$FF91,$F7EE
	.dc.w	$AD40,$BA7F,$B87F,$0780,$0001,$FFF0,$FFF0,$000F
	.dc.w	$BB95,$FEDE,$AADE,$5521,$1C15,$E3FD,$FF3D,$1CC2
	.dc.w	$B04B,$EB7F,$667D,$9D82,$D299,$76F8,$3087,$CE00
	.dc.w	$9FE9,$63ED,$F7E1,$740E,$450F,$4687,$46FF,$8100
	.dc.w	$1015,$E134,$A034,$5109,$4000,$7FE2,$7FE2,$800D
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$7000,$0228,$0FFF,$FDD7,$0064,$0815,$FF95,$F7EA
	.dc.w	$4D55,$5A55,$5855,$0780,$5528,$5528,$5528,$2857
	.dc.w	$CD8B,$6F5E,$455E,$BAA1,$08A8,$F77C,$FF3C,$08C2
	.dc.w	$30A3,$EEFA,$E4FA,$1B05,$D249,$B649,$3049,$CE00
	.dc.w	$2C89,$248D,$2C81,$080E,$4477,$46FF,$4687,$8100
	.dc.w	$501F,$A13F,$A038,$5107,$C000,$FC22,$7FE2,$83CD
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0FFF,$FFFF,$0000,$0012,$FF92,$FFE8
	.dc.w	$2D6A,$3A6A,$386A,$8780,$FE04,$EE44,$EE44,$10BB
	.dc.w	$4694,$17DE,$02DE,$FD21,$7755,$883D,$FF3D,$77C2
	.dc.w	$316F,$6DB5,$61B4,$9E4B,$D249,$7649,$7049,$8E00
	.dc.w	$2489,$248D,$2481,$000E,$C463,$46FF,$4683,$8100
	.dc.w	$101F,$A13F,$A035,$510A,$C000,$F822,$F8E2,$00CD
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$7FFF,$7FFF,$7FFF,$8000,$FFE0,$FFF4,$FFF4,$0001
	.dc.w	$0D55,$1A55,$1855,$4780,$542A,$5422,$5422,$295D
	.dc.w	$230A,$0BDE,$015E,$FEA1,$63A8,$9CBC,$FFBC,$6342
	.dc.w	$BAEF,$63BA,$6338,$9CC7,$92FF,$F6FF,$F0FF,$0E00
	.dc.w	$FFE9,$FFED,$FFE1,$000E,$C622,$477F,$4743,$8080
	.dc.w	$301F,$413F,$4035,$B10A,$5800,$6462,$65E2,$998D
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$7FFF,$7FFF,$8000,$0000,$FFF8,$FFF8,$0002
	.dc.w	$2D40,$3A40,$3840,$87AA,$5401,$4441,$4441,$BABE
	.dc.w	$1395,$07DF,$02DF,$FD20,$2255,$5D7D,$7F7D,$A282
	.dc.w	$35EF,$E7B5,$6631,$99CE,$5249,$F649,$F049,$0E00
	.dc.w	$2489,$248D,$2481,$000E,$4700,$C7BE,$47BE,$8041
	.dc.w	$711F,$803F,$8035,$710A,$4000,$4622,$46E2,$80CD
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$35A1,$7DA1,$4DA1,$B040,$5500,$3900,$0100,$FE00
	.dc.w	$0D40,$1A40,$1840,$0780,$502A,$4062,$4062,$381C
	.dc.w	$898A,$83DF,$815F,$7EA0,$80A8,$BEFC,$BEFC,$4102
	.dc.w	$ABEE,$EDBB,$6C33,$93CC,$9249,$B649,$B049,$0E00
	.dc.w	$2489,$248D,$2481,$000E,$47BE,$C3FF,$43FF,$8400
	.dc.w	$F11F,$003F,$0038,$F107,$C000,$FC22,$7FE2,$83CD
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$3307,$7B17,$4B17,$B0C8,$FFFF,$FFFF,$FFFF,$0000
	.dc.w	$FFFF,$FFFF,$FFFF,$0000,$E7FF,$EFFF,$EFFF,$1000
	.dc.w	$4680,$43C0,$42C0,$3D3F,$3E01,$3E01,$3E01,$C1FE
	.dc.w	$B7ED,$FDB7,$FC37,$03C8,$D200,$F600,$F000,$0E00
	.dc.w	$0009,$000D,$0001,$000E,$C780,$C1F7,$41F7,$8600
	.dc.w	$F115,$0035,$0035,$F108,$C000,$F862,$F862,$000D
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$340C,$7958,$4858,$B787,$0000,$0000,$0000,$FFFF
	.dc.w	$0000,$0000,$0000,$FFFF,$3401,$1C01,$1C01,$E3FE
	.dc.w	$2720,$25FF,$257F,$5A91,$0002,$FFFE,$FFFE,$1110
	.dc.w	$A7EB,$7DBC,$7C3C,$83C3,$9257,$3600,$3000,$CE57
	.dc.w	$6C09,$000D,$0001,$6C0E,$C7B6,$C077,$4077,$8780
	.dc.w	$F115,$0030,$0030,$F10D,$4000,$7FE2,$7FE2,$800D
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$30A9,$78BA,$48B8,$B707,$FFFF,$0000,$0000,$FFFF
	.dc.w	$FFFF,$0000,$0000,$FFFF,$9401,$5DFD,$1C01,$E3FE
	.dc.w	$1380,$12DF,$12DF,$2D22,$0001,$FFFD,$FFFD,$2222
	.dc.w	$97E7,$FDBF,$6C38,$93C7,$D200,$3600,$3000,$CE00
	.dc.w	$0009,$000D,$0001,$000E,$47B6,$C077,$4077,$8780
	.dc.w	$F110,$0037,$0032,$F10D,$5800,$67E2,$63E2,$9C0D
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$334B,$7B98,$4B98,$B466,$0000,$FFFF,$0000,$FFFF
	.dc.w	$0000,$FFFF,$0000,$FFFF,$D4F9,$1DF5,$1C01,$63F6
	.dc.w	$0D83,$0D5F,$0D5F,$52A4,$8820,$C7FC,$C45C,$7FE6
	.dc.w	$B7EF,$4DB0,$4C30,$B3CF,$9200,$3600,$3000,$CE6B
	.dc.w	$0009,$000D,$0001,$ADCE,$C780,$4041,$4041,$87B6
	.dc.w	$F110,$0037,$0032,$F10D,$4000,$47E2,$47E2,$800D
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$06AA,$7CB9,$4CB8,$B347,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$5489,$9DFD,$1C71,$E38E
	.dc.w	$0683,$2EDB,$2EDB,$292C,$0471,$8BFD,$888D,$FFFA
	.dc.w	$F7EF,$FDBF,$FC3F,$03C0,$D200,$F600,$F000,$0E00
	.dc.w	$0009,$000D,$0001,$000E,$4780,$4041,$4041,$87B6
	.dc.w	$F110,$0037,$0032,$F10D,$4000,$7FE2,$7FE2,$800D
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$024A,$7959,$4858,$B787,$0000,$0E00,$0E00,$0000
	.dc.w	$0000,$0070,$0070,$0000,$5489,$9DFD,$1C71,$E38E
	.dc.w	$0700,$0759,$0759,$50B7,$E000,$F13C,$F11C,$1FF2
	.dc.w	$57EA,$7DBA,$7C3A,$83C0,$93FF,$B7FF,$B000,$0FFF
	.dc.w	$FFF9,$FFFD,$0001,$FFFE,$47B6,$4041,$4041,$87B6
	.dc.w	$F010,$0037,$0032,$F10D,$4000,$7FE2,$7FE2,$800D
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$052A,$7DB9,$4C38,$B3C7,$0A00,$1B00,$1B00,$0400
	.dc.w	$0050,$00D8,$00D8,$0020,$5489,$9DFD,$1C71,$E38E
	.dc.w	$0781,$0FDB,$0FDB,$2826,$0011,$FFBD,$FFAD,$2272
	.dc.w	$B7E5,$FDB5,$FC35,$03C0,$5000,$77FF,$7000,$0FFF
	.dc.w	$0001,$FFFD,$0001,$FFFE,$C7B6,$C041,$C041,$07B6
	.dc.w	$F010,$0037,$0032,$F10D,$4000,$7FE2,$7FE2,$800D
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$068A,$7FD9,$4E18,$B1E7,$1500,$3180,$3180,$0E00
	.dc.w	$00A8,$018C,$018C,$0070,$5489,$9DFD,$1C71,$E38E
	.dc.w	$0580,$05DD,$05DD,$5226,$0010,$FFFC,$FFCC,$4476
	.dc.w	$0000,$FFF0,$FFF0,$000A,$9000,$B000,$B000,$0FFF
	.dc.w	$0001,$0001,$0001,$FFFE,$4780,$4077,$4041,$07B6
	.dc.w	$F010,$0037,$0032,$F10D,$5808,$67EA,$63EA,$9C05
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$024A,$7AF9,$4A18,$B1E7,$3580,$7BC0,$7BC0,$0400
	.dc.w	$01AC,$03DE,$03DE,$0020,$5489,$9DFD,$1C71,$E38E
	.dc.w	$0780,$0EDD,$0ED9,$292E,$0011,$FFFD,$FFCD,$88BA
	.dc.w	$7FE0,$7FF0,$7FF0,$0005,$5FFF,$7FFF,$7FFF,$0000
	.dc.w	$FFFF,$FFFF,$FFFF,$0000,$47B6,$4077,$4041,$07B6
	.dc.w	$F010,$0037,$0032,$F10D,$400D,$47EF,$47EF,$8000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$B72A,$CF79,$CF18,$30E7,$2486,$7FC6,$7BC4,$0402
	.dc.w	$C124,$C3FE,$43DE,$8020,$5489,$9DFD,$1C71,$E38E
	.dc.w	$0500,$05DD,$0559,$52B7,$0000,$FFBC,$FF9C,$1172
	.dc.w	$4020,$4030,$4030,$3FCA,$8000,$BFFF,$BFFF,$0000
	.dc.w	$0000,$FFFE,$FFFE,$0000,$4780,$4077,$4077,$0780
	.dc.w	$F010,$0037,$0032,$F10D,$400D,$7FEF,$7FEF,$8000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$B08A,$C8B9,$C898,$3767,$0404,$5B47,$5B45,$2080
	.dc.w	$4020,$C2DA,$42DA,$0104,$5489,$9DFD,$1C71,$E38E
	.dc.w	$0781,$0EDE,$0EDA,$2927,$5D51,$7F3D,$7F2D,$A2F2
	.dc.w	$C020,$DFB0,$C030,$3FC5,$5ED5,$40D5,$5ED5,$1E00
	.dc.w	$5569,$5566,$556F,$0006,$4055,$7FC9,$7FC1,$003E
	.dc.w	$001F,$FE3F,$FE30,$010F,$C00D,$FC2F,$7FEF,$83C0
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$B64A,$C9D9,$C858,$37A7,$2EE6,$5B65,$4065,$3B9A
	.dc.w	$CF74,$4EDA,$4E02,$B1DC,$5489,$9DFD,$1C71,$E38E
	.dc.w	$0501,$15DE,$155C,$52A7,$3B10,$7F7C,$7F4C,$C4F6
	.dc.w	$4F23,$59B3,$4030,$B9CB,$F363,$CC60,$7F60,$B31F
	.dc.w	$8FD0,$7FC6,$001F,$FFC0,$DCDD,$7C32,$FC00,$03F3
	.dc.w	$9C1D,$1E3D,$1E3C,$E101,$C00D,$F82F,$FA6F,$0240
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$B7AA,$C9F9,$C838,$37C7,$2A88,$64CB,$60C9,$1F06
	.dc.w	$2154,$A326,$2306,$C0F8,$54BA,$9DF9,$1C78,$E387
	.dc.w	$8781,$8EDE,$8EDC,$292B,$5541,$FFBD,$FF9D,$88EA
	.dc.w	$CF20,$59B7,$4033,$B9C4,$2130,$DE73,$FF0E,$2102
	.dc.w	$64A0,$EBBF,$1C7F,$0810,$5CCD,$FC3E,$FC00,$83FF
	.dc.w	$9D1F,$1F3F,$1F39,$E006,$D00D,$E42F,$E6EF,$12C0
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$B04A,$C9D9,$C858,$37A7,$2A90,$64C3,$60C3,$1F2C
	.dc.w	$1954,$8326,$8306,$6CF8,$54BA,$9DF9,$1C78,$E387
	.dc.w	$C500,$C5DF,$455F,$92B1,$0000,$FFFC,$FFFC,$1112
	.dc.w	$4F2B,$59B7,$4034,$B9CB,$F371,$CC70,$7F70,$B30F
	.dc.w	$C7D0,$3FC6,$001F,$FFC0,$C055,$7FC9,$FFC1,$003E
	.dc.w	$011D,$FF3D,$FF3C,$0001,$C00D,$C42F,$C6EF,$02C0
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$868A,$CED9,$CE98,$3167,$154B,$31DB,$31C3,$0E3C
	.dc.w	$AAA8,$B38C,$838C,$7C70,$54BD,$9DFC,$1C7C,$E383
	.dc.w	$6780,$EEDF,$2EDF,$C922,$0001,$FFFD,$FFFD,$2222
	.dc.w	$C023,$DFBC,$C038,$3FC7,$DED5,$40D5,$5ED5,$9E00
	.dc.w	$5569,$5566,$556F,$0006,$4780,$40F7,$40F7,$0700
	.dc.w	$F11F,$013F,$0130,$F00F,$C00D,$F82F,$7BEF,$83C0
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$870A,$CFD9,$CF18,$30E7,$0E14,$1F13,$1F10,$000C
	.dc.w	$5070,$90F8,$10F8,$6000,$54BA,$9DF9,$1C78,$E387
	.dc.w	$C500,$C5DF,$455F,$92A4,$0000,$FFFC,$FFFC,$4446
	.dc.w	$4027,$4039,$4038,$3FC7,$A800,$FBFF,$3BFF,$C000
	.dc.w	$0000,$FFFF,$FFFF,$0000,$47B6,$C1F7,$C1F7,$0600
	.dc.w	$F11D,$013D,$013D,$F000,$C00D,$F86F,$F86F,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$83CA,$C9D9,$C818,$37E7,$0010,$0E13,$0E13,$000C
	.dc.w	$1000,$9070,$9070,$6000,$54BA,$9DF9,$1C78,$E387
	.dc.w	$8780,$8EDF,$8EDF,$2928,$0001,$FFFD,$FFFD,$888A
	.dc.w	$7FEF,$7FF3,$7FF0,$000F,$0941,$D063,$1060,$ED9F
	.dc.w	$2493,$AEBA,$2082,$DF7D,$4780,$C3F7,$C3F7,$0400
	.dc.w	$F110,$0135,$0130,$F00D,$400D,$7FEF,$7FEF,$8000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$83EA,$CA79,$C878,$3787,$0000,$0000,$0000,$0003
	.dc.w	$0000,$0000,$0000,$8000,$5480,$9DFF,$1C7F,$E380
	.dc.w	$0500,$05DF,$055F,$52B1,$0000,$FFFC,$FFFC,$1112
	.dc.w	$001C,$000F,$0000,$001F,$E341,$335B,$3018,$CBE7
	.dc.w	$2949,$BDDD,$21C1,$DE3E,$4000,$C000,$C000,$0000
	.dc.w	$0110,$0137,$0132,$000D,$400D,$7FEF,$7FEF,$8000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$001F,$001C,$0010,$000F
	.dc.w	$FC00,$1C00,$0400,$F800,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$87CA,$CD99,$C998,$3647,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$54E9,$9DED,$1C61,$E39E
	.dc.w	$0780,$2EDF,$2EDF,$2922,$0001,$FFFD,$FFFD,$2222
	.dc.w	$00F8,$AA9E,$AA80,$007F,$4638,$66AD,$602C,$97D3
	.dc.w	$9492,$D877,$1070,$ED8F,$FFFF,$FFFF,$FFFF,$0000
	.dc.w	$FF10,$FF37,$FF32,$000D,$400D,$7FEF,$7FEF,$8000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0038,$0030,$0027,$0017
	.dc.w	$0E00,$0E00,$F200,$FC00,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$870A,$CB19,$CB18,$3487,$0000,$FFFF,$0000,$FFFF
	.dc.w	$0000,$FFFF,$0000,$FFFF,$54F9,$9DFD,$1C01,$E3FE
	.dc.w	$0500,$05DF,$055F,$52A4,$0000,$FFFC,$FFFC,$4446
	.dc.w	$55E9,$5531,$5501,$00FE,$083C,$C977,$C076,$2F89
	.dc.w	$DD49,$755B,$1558,$E887,$0000,$7FFF,$7FFF,$8000
	.dc.w	$0110,$FF37,$FF32,$000D,$400D,$7FEF,$7FEF,$8000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0038,$0018,$0007,$003F
	.dc.w	$0C00,$0E00,$F000,$FE00,$0000,$0000,$0000,$0000
	.dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
	.dc.w	$B52B,$FC38,$FC38,$0307,$FFFF,$0000,$0000,$FFFF
	.dc.w	$FFFF,$0000,$0000,$FFFF,$D401,$1DFD,$1C01,$E3FE
	.dc.w	$0780,$06DF,$06DF,$2928,$0001,$FFFD,$FFFD,$888A
	.dc.w	$ABF2,$AA63,$AA03,$01FC,$C03A,$E2A9,$E0A9,$1F56
	.dc.w	$6E84,$AE8D,$0E8C,$F153,$A000,$A000,$2000,$CAAA
	.dc.w	$2A10,$2A37,$2A32,$800D,$400D,$7FEF,$7FEF,$8000
	.dc.w	$7FF0,$7FF0,$7FF0,$000F,$00FF,$0000,$0000,$FFFF
	.dc.w	$E003,$1FFF,$0000,$FFFF,$FF98,$FF88,$0007,$FFBF
	.dc.w	$06FF,$00FF,$F000,$FEFF,$F001,$FFFE,$0000,$FFFF
	.dc.w	$FFC0,$0000,$0000,$FFFF,$07FE,$07FE,$07FE,$F800
	.dc.w	$B468,$F878,$F878,$0607,$0000,$0000,$0000,$FFFF
	.dc.w	$0000,$0000,$0000,$FFFF,$1401,$1C01,$1C01,$E3FE
	.dc.w	$0500,$05DF,$055F,$52BF,$0000,$FFFC,$FFFC,$FFFE
	.dc.w	$57AC,$01CF,$000F,$57F0,$147F,$E308,$E108,$1EF7
	.dc.w	$2412,$F806,$8006,$7EB9,$5000,$D000,$1000,$E555
	.dc.w	$5500,$553F,$553F,$0000,$000C,$FFEF,$FFEF,$0000
	.dc.w	$FFF0,$FFF0,$FFF0,$000F,$00FF,$0000,$0000,$FFFF
	.dc.w	$F000,$0FFF,$0000,$FFFF,$FFCF,$FFEF,$002F,$FFD0
	.dc.w	$F9FF,$FBFF,$FA00,$05FF,$F001,$FFFE,$0000,$FFFF
	.dc.w	$FFC0,$0000,$0000,$FFFF,$07FF,$07FF,$07FF,$F800
	.dc.w	$34CF,$F8DF,$F8DF,$0400,$FFFF,$FFFF,$FFFF,$0000
	.dc.w	$FFFF,$FFFF,$FFFF,$0000,$F7FF,$FFFF,$FFFF,$0000
	.dc.w	$0780,$06C0,$06C0,$293F,$0001,$0001,$0001,$FFFE

	.end
