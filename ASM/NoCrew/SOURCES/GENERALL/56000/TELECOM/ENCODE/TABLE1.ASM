     ORG    Y:$0600
TABLE1
     DC     1
     DC     2
     DC     4
     DC     8
     DC     16
     DC     32
     DC     64
     DC     128
     DC     29
     DC     58
     DC     116
     DC     232
     DC     205
     DC     135
     DC     19
     DC     38
     DC     76
     DC     152
     DC     45
     DC     90
     DC     180
     DC     117
     DC     234
     DC     201
     DC     143
     DC     3
     DC     6
     DC     12
     DC     24
     DC     48
     DC     96
     DC     192
     DC     157
     DC     39
     DC     78
     DC     156
     DC     37
     DC     74
     DC     148
     DC     53
     DC     106
     DC     212
     DC     181
     DC     119
     DC     238
     DC     193
     DC     159
     DC     35
     DC     70
     DC     140
     DC     5
     DC     10
     DC     20
     DC     40
     DC     80
     DC     160
     DC     93
     DC     186
     DC     105
     DC     210
     DC     185
     DC     111
     DC     222
     DC     161
     DC     95
     DC     190
     DC     97
     DC     194
     DC     153
     DC     47
     DC     94
     DC     188
     DC     101
     DC     202
     DC     137
     DC     15
     DC     30
     DC     60
     DC     120
     DC     240
     DC     253
     DC     231
     DC     211
     DC     187
     DC     107
     DC     214
     DC     177
     DC     127
     DC     254
     DC     225
     DC     223
     DC     163
     DC     91
     DC     182
     DC     113
     DC     226
     DC     217
     DC     175
     DC     67
     DC     134
     DC     17
     DC     34
     DC     68
     DC     136
     DC     13
     DC     26
     DC     52
     DC     104
     DC     208
     DC     189
     DC     103
     DC     206
     DC     129
     DC     31
     DC     62
     DC     124
     DC     248
     DC     237
     DC     199
     DC     147
     DC     59
     DC     118
     DC     236
     DC     197
     DC     151
     DC     51
     DC     102
     DC     204
     DC     133
     DC     23
     DC     46
     DC     92
     DC     184
     DC     109
     DC     218
     DC     169
     DC     79
     DC     158
     DC     33
     DC     66
     DC     132
     DC     21
     DC     42
     DC     84
     DC     168
     DC     77
     DC     154
     DC     41
     DC     82
     DC     164
     DC     85
     DC     170
     DC     73
     DC     146
     DC     57
     DC     114
     DC     228
     DC     213
     DC     183
     DC     115
     DC     230
     DC     209
     DC     191
     DC     99
     DC     198
     DC     145
     DC     63
     DC     126
     DC     252
     DC     229
     DC     215
     DC     179
     DC     123
     DC     246
     DC     241
     DC     255
     DC     227
     DC     219
     DC     171
     DC     75
     DC     150
     DC     49
     DC     98
     DC     196
     DC     149
     DC     55
     DC     110
     DC     220
     DC     165
     DC     87
     DC     174
     DC     65
     DC     130
     DC     25
     DC     50
     DC     100
     DC     200
     DC     141
     DC     7
     DC     14
     DC     28
     DC     56
     DC     112
     DC     224
     DC     221
     DC     167
     DC     83
     DC     166
     DC     81
     DC     162
     DC     89
     DC     178
     DC     121
     DC     242
     DC     249
     DC     239
     DC     195
     DC     155
     DC     43
     DC     86
     DC     172
     DC     69
     DC     138
     DC     9
     DC     18
     DC     36
     DC     72
     DC     144
     DC     61
     DC     122
     DC     244
     DC     245
     DC     247
     DC     243
     DC     251
     DC     235
     DC     203
     DC     139
     DC     11
     DC     22
     DC     44
     DC     88
     DC     176
     DC     125
     DC     250
     DC     233
     DC     207
     DC     131
     DC     27
     DC     54
     DC     108
     DC     216
     DC     173
     DC     71
     DC     142
     DC     1
     DC     2
     DC     4
     DC     8
     DC     16
     DC     32
     DC     64
     DC     128
     DC     29
     DC     58
     DC     116
     DC     232
     DC     205
     DC     135
     DC     19
     DC     38
     DC     76
     DC     152
     DC     45
     DC     90
     DC     180
     DC     117
     DC     234
     DC     201
     DC     143
     DC     3
     DC     6
     DC     12
     DC     24
     DC     48
     DC     96
     DC     192
     DC     157
     DC     39
     DC     78
     DC     156
     DC     37
     DC     74
     DC     148
     DC     53
     DC     106
     DC     212
     DC     181
     DC     119
     DC     238
     DC     193
     DC     159
     DC     35
     DC     70
     DC     140
     DC     5
     DC     10
     DC     20
     DC     40
     DC     80
     DC     160
     DC     93
     DC     186
     DC     105
     DC     210
     DC     185
     DC     111
     DC     222
     DC     161
     DC     95
     DC     190
     DC     97
     DC     194
     DC     153
     DC     47
     DC     94
     DC     188
     DC     101
     DC     202
     DC     137
     DC     15
     DC     30
     DC     60
     DC     120
     DC     240
     DC     253
     DC     231
     DC     211
     DC     187
     DC     107
     DC     214
     DC     177
     DC     127
     DC     254
     DC     225
     DC     223
     DC     163
     DC     91
     DC     182
     DC     113
     DC     226
     DC     217
     DC     175
     DC     67
     DC     134
     DC     17
     DC     34
     DC     68
     DC     136
     DC     13
     DC     26
     DC     52
     DC     104
     DC     208
     DC     189
     DC     103
     DC     206
     DC     129
     DC     31
     DC     62
     DC     124
     DC     248
     DC     237
     DC     199
     DC     147
     DC     59
     DC     118
     DC     236
     DC     197
     DC     151
     DC     51
     DC     102
     DC     204
     DC     133
     DC     23
     DC     46
     DC     92
     DC     184
     DC     109
     DC     218
     DC     169
     DC     79
     DC     158
     DC     33
     DC     66
     DC     132
     DC     21
     DC     42
     DC     84
     DC     168
     DC     77
     DC     154
     DC     41
     DC     82
     DC     164
     DC     85
     DC     170
     DC     73
     DC     146
     DC     57
     DC     114
     DC     228
     DC     213
     DC     183
     DC     115
     DC     230
     DC     209
     DC     191
     DC     99
     DC     198
     DC     145
     DC     63
     DC     126
     DC     252
     DC     229
     DC     215
     DC     179
     DC     123
     DC     246
     DC     241
     DC     255
     DC     227
     DC     219
     DC     171
     DC     75
     DC     150
     DC     49
     DC     98
     DC     196
     DC     149
     DC     55
     DC     110
     DC     220
     DC     165
     DC     87
     DC     174
     DC     65
     DC     130
     DC     25
     DC     50
     DC     100
     DC     200
     DC     141
     DC     7
     DC     14
     DC     28
     DC     56
     DC     112
     DC     224
     DC     221
     DC     167
     DC     83
     DC     166
     DC     81
     DC     162
     DC     89
     DC     178
     DC     121
     DC     242
     DC     249
     DC     239
     DC     195
     DC     155
     DC     43
     DC     86
     DC     172
     DC     69
     DC     138
     DC     9
     DC     18
     DC     36
     DC     72
     DC     144
     DC     61
     DC     122
     DC     244
     DC     245
     DC     247
     DC     243
     DC     251
     DC     235
     DC     203
     DC     139
     DC     11
     DC     22
     DC     44
     DC     88
     DC     176
     DC     125
     DC     250
     DC     233
     DC     207
     DC     131
     DC     27
     DC     54
     DC     108
     DC     216
     DC     173
     DC     71
     DC     142
