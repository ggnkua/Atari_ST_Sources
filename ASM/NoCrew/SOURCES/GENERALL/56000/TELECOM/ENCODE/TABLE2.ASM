     ORG    Y:$00a0
TABLE2
     DC     0
     DC     0
     DC     1
     DC     25
     DC     2
     DC     50
     DC     26
     DC     198
     DC     3
     DC     223
     DC     51
     DC     238
     DC     27
     DC     104
     DC     199
     DC     75
     DC     4
     DC     100
     DC     224
     DC     14
     DC     52
     DC     141
     DC     239
     DC     129
     DC     28
     DC     193
     DC     105
     DC     248
     DC     200
     DC     8
     DC     76
     DC     113
     DC     5
     DC     138
     DC     101
     DC     47
     DC     225
     DC     36
     DC     15
     DC     33
     DC     53
     DC     147
     DC     142
     DC     218
     DC     240
     DC     18
     DC     130
     DC     69
     DC     29
     DC     181
     DC     194
     DC     125
     DC     106
     DC     39
     DC     249
     DC     185
     DC     201
     DC     154
     DC     9
     DC     120
     DC     77
     DC     228
     DC     114
     DC     166
     DC     6
     DC     191
     DC     139
     DC     98
     DC     102
     DC     221
     DC     48
     DC     253
     DC     226
     DC     152
     DC     37
     DC     179
     DC     16
     DC     145
     DC     34
     DC     136
     DC     54
     DC     208
     DC     148
     DC     206
     DC     143
     DC     150
     DC     219
     DC     189
     DC     241
     DC     210
     DC     19
     DC     92
     DC     131
     DC     56
     DC     70
     DC     64
     DC     30
     DC     66
     DC     182
     DC     163
     DC     195
     DC     72
     DC     126
     DC     110
     DC     107
     DC     58
     DC     40
     DC     84
     DC     250
     DC     133
     DC     186
     DC     61
     DC     202
     DC     94
     DC     155
     DC     159
     DC     10
     DC     21
     DC     121
     DC     43
     DC     78
     DC     212
     DC     229
     DC     172
     DC     115
     DC     243
     DC     167
     DC     87
     DC     7
     DC     112
     DC     192
     DC     247
     DC     140
     DC     128
     DC     99
     DC     13
     DC     103
     DC     74
     DC     222
     DC     237
     DC     49
     DC     197
     DC     254
     DC     24
     DC     227
     DC     165
     DC     153
     DC     119
     DC     38
     DC     184
     DC     180
     DC     124
     DC     17
     DC     68
     DC     146
     DC     217
     DC     35
     DC     32
     DC     137
     DC     46
     DC     55
     DC     63
     DC     209
     DC     91
     DC     149
     DC     188
     DC     207
     DC     205
     DC     144
     DC     135
     DC     151
     DC     178
     DC     220
     DC     252
     DC     190
     DC     97
     DC     242
     DC     86
     DC     211
     DC     171
     DC     20
     DC     42
     DC     93
     DC     158
     DC     132
     DC     60
     DC     57
     DC     83
     DC     71
     DC     109
     DC     65
     DC     162
     DC     31
     DC     45
     DC     67
     DC     216
     DC     183
     DC     123
     DC     164
     DC     118
     DC     196
     DC     23
     DC     73
     DC     236
     DC     127
     DC     12
     DC     111
     DC     246
     DC     108
     DC     161
     DC     59
     DC     82
     DC     41
     DC     157
     DC     85
     DC     170
     DC     251
     DC     96
     DC     134
     DC     177
     DC     187
     DC     204
     DC     62
     DC     90
     DC     203
     DC     89
     DC     95
     DC     176
     DC     156
     DC     169
     DC     160
     DC     81
     DC     11
     DC     245
     DC     22
     DC     235
     DC     122
     DC     117
     DC     44
     DC     215
     DC     79
     DC     174
     DC     213
     DC     233
     DC     230
     DC     231
     DC     173
     DC     232
     DC     116
     DC     214
     DC     244
     DC     234
     DC     168
     DC     80
     DC     88
     DC     175
