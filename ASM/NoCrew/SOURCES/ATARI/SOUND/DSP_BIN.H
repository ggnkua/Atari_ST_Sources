static char dsp_bin[] = {
0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x15, 0x07,
0xff, 0xff, 0x07, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00,
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00,
0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
0x02, 0x0a, 0xf0, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
0x00, 0x00, 0x0c, 0x00, 0x00, 0x02, 0x0b, 0xf0, 0x80, 0x00,
0x00, 0xea, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
0x02, 0x0b, 0xf0, 0x80, 0x00, 0x00, 0xfb, 0x00, 0x00, 0x00,
0x00, 0x00, 0x40, 0x00, 0x00, 0xcb, 0x05, 0x00, 0xbb, 0x08,
0x44, 0x2b, 0x08, 0xf4, 0xbe, 0x00, 0x00, 0x00, 0x08, 0xf4,
0xa0, 0x00, 0x00, 0x01, 0x08, 0xf4, 0xa1, 0x00, 0x00, 0x00,
0x08, 0xf4, 0xa1, 0x00, 0x01, 0xf8, 0x08, 0xf4, 0xac, 0x00,
0x41, 0x00, 0x08, 0xf4, 0xad, 0x00, 0xf8, 0x00, 0x0b, 0xae,
0x24, 0x08, 0xf4, 0xbf, 0x00, 0x30, 0x00, 0x00, 0xfc, 0xb8,
0x0a, 0x70, 0x00, 0x00, 0x00, 0x11, 0x0a, 0x11, 0x80, 0x00,
0x00, 0x5b, 0x0a, 0xa9, 0x81, 0x00, 0x00, 0x5b, 0x44, 0x92,
0x00, 0x08, 0xc4, 0x2b, 0x0a, 0x11, 0x00, 0x0a, 0x10, 0x80,
0x00, 0x00, 0x54, 0x0b, 0xf0, 0x80, 0x00, 0x00, 0x87, 0x56,
0x84, 0x00, 0x20, 0x00, 0x03, 0x0a, 0xf0, 0xaa, 0x00, 0x00,
0x6b, 0x30, 0x2b, 0x00, 0x31, 0x08, 0x00, 0x0b, 0xf0, 0x80,
0x00, 0x00, 0xa5, 0x30, 0x20, 0x00, 0x31, 0x09, 0x00, 0x0b,
0xf0, 0x80, 0x00, 0x00, 0xa5, 0x56, 0x85, 0x00, 0x20, 0x00,
0x03, 0x0a, 0xf0, 0xaa, 0x00, 0x00, 0x77, 0x30, 0x13, 0x00,
0x31, 0x08, 0x00, 0x0b, 0xf0, 0x80, 0x00, 0x00, 0x98, 0x30,
0x14, 0x00, 0x31, 0x09, 0x00, 0x0b, 0xf0, 0x80, 0x00, 0x00,
0x98, 0x56, 0x83, 0x00, 0x20, 0x00, 0x03, 0x0b, 0xf0, 0xa2,
0x00, 0x00, 0xd4, 0x56, 0x82, 0x00, 0x20, 0x00, 0x03, 0x0b,
0xf0, 0xa2, 0x00, 0x00, 0xca, 0x44, 0x88, 0x00, 0x45, 0x89,
0x00, 0x44, 0x0a, 0x00, 0x45, 0x0b, 0x00, 0x0a, 0x10, 0x00,
0x0b, 0xa9, 0xa0, 0x00, 0x00, 0xda, 0x0c, 0x00, 0x54, 0x44,
0x86, 0x00, 0x45, 0x80, 0x00, 0x20, 0x00, 0xa0, 0x20, 0x00,
0x33, 0x20, 0x00, 0x33, 0x20, 0x00, 0x33, 0x20, 0x00, 0x33,
0x56, 0x08, 0x00, 0x44, 0x87, 0x00, 0x45, 0x81, 0x00, 0x20,
0x00, 0xa0, 0x20, 0x00, 0x33, 0x20, 0x00, 0x33, 0x20, 0x00,
0x33, 0x20, 0x00, 0x33, 0x56, 0x09, 0x00, 0x00, 0x00, 0x0c,
0x56, 0xe1, 0x00, 0x57, 0xe0, 0x00, 0x56, 0x60, 0x00, 0x20,
0x00, 0x14, 0x44, 0x85, 0x00, 0x21, 0xc5, 0x00, 0x20, 0x00,
0xa0, 0x57, 0xe1, 0x00, 0x20, 0x00, 0x33, 0x20, 0x00, 0x33,
0x20, 0x00, 0x10, 0x56, 0x61, 0x00, 0x00, 0x00, 0x0c, 0x44,
0xf4, 0x00, 0x0a, 0xaa, 0xaa, 0x45, 0xf8, 0x00, 0x00, 0x00,
0x00, 0x20, 0x00, 0xa0, 0x45, 0xf8, 0x00, 0x38, 0x01, 0x00,
0x46, 0xe0, 0x00, 0x46, 0x68, 0x00, 0x20, 0x00, 0xa8, 0x06,
0x09, 0x80, 0x00, 0x00, 0xb5, 0x45, 0xf8, 0x00, 0x20, 0x00,
0x10, 0x46, 0xe0, 0x00, 0x46, 0x68, 0x00, 0x20, 0x00, 0xa8,
0x45, 0xe1, 0x00, 0x20, 0x00, 0x10, 0x20, 0x00, 0xa8, 0x20,
0x00, 0x10, 0x56, 0x60, 0x00, 0x21, 0xc5, 0x00, 0x44, 0x84,
0x00, 0x20, 0x00, 0xa0, 0x21, 0xc4, 0x00, 0x20, 0x00, 0x33,
0x20, 0x00, 0x33, 0x57, 0xf4, 0x00, 0x7f, 0xff, 0xff, 0x20,
0x00, 0x4c, 0x21, 0xe4, 0x00, 0x45, 0xe1, 0x00, 0x20, 0x00,
0xa8, 0x20, 0x00, 0x10, 0x56, 0x61, 0x00, 0x00, 0x00, 0x0c,
0x44, 0xf4, 0x00, 0x3f, 0xff, 0xff, 0x45, 0x88, 0x00, 0x20,
0x00, 0xa0, 0x45, 0x89, 0x00, 0x20, 0x00, 0xa8, 0x20, 0x00,
0x10, 0x56, 0x08, 0x00, 0x56, 0x09, 0x00, 0x00, 0x00, 0x0c,
0x44, 0x88, 0x00, 0x56, 0x89, 0x00, 0x20, 0x00, 0x44, 0x56,
0x08, 0x00, 0x56, 0x09, 0x00, 0x00, 0x00, 0x0c, 0x08, 0x44,
0x2b, 0x56, 0xf4, 0x00, 0x00, 0x00, 0x7f, 0x20, 0x00, 0x46,
0x21, 0x90, 0x00, 0x0a, 0xc4, 0x27, 0x00, 0x00, 0xe5, 0x0a,
0x11, 0x20, 0x44, 0xe0, 0x00, 0x44, 0x12, 0x00, 0x00, 0x00,
0x0c, 0x56, 0xf4, 0x00, 0xff, 0xff, 0x00, 0x20, 0x00, 0x46,
0x54, 0x60, 0x00, 0x00, 0x00, 0x0c, 0x44, 0x0c, 0x00, 0x45,
0x0d, 0x00, 0x0a, 0x0e, 0x80, 0x00, 0x00, 0xf4, 0x08, 0x45,
0x2f, 0x45, 0x07, 0x00, 0x0a, 0x0e, 0x00, 0x44, 0x8c, 0x00,
0x45, 0x8d, 0x00, 0x00, 0x00, 0x04, 0x08, 0x44, 0x2f, 0x44,
0x06, 0x00, 0x0a, 0x0e, 0x20, 0x44, 0x8c, 0x00, 0x45, 0x8d,
0x00, 0x0a, 0x10, 0x20, 0x00, 0x00, 0x04, 0x44, 0x0c, 0x00,
0x45, 0x0d, 0x00, 0x0a, 0x0f, 0x80, 0x00, 0x01, 0x05, 0x45,
0x8b, 0x00, 0x08, 0xc5, 0x2f, 0x0a, 0x0f, 0x00, 0x44, 0x8c,
0x00, 0x45, 0x8d, 0x00, 0x00, 0x00, 0x04, 0x44, 0x8a, 0x00,
0x08, 0xc4, 0x2f, 0x0a, 0x0f, 0x20, 0x44, 0x8c, 0x00, 0x45,
0x8d, 0x00, 0x00, 0x00, 0x04};
