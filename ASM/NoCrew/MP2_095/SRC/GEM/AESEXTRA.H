/* Extra stuff which should, but isn't always, in AES.H */

#ifndef VA_START
#define VA_START 0x4711
#define AV_STARTED 0x4738
#endif

#ifndef AP_DRAGDROP
#define AP_DRAGDROP 63
#endif

#ifndef DD_OK
#define DD_OK 0
#define DD_NAK 1
#define DD_EXT 2
#define DD_LEN 3
#define DD_TRASH 4
#define DD_PRINTER 5
#define DD_CLIPBOARD 6
#endif


