#define VERSION_TEXT "0.95"
#define VERSION_NUM 95
