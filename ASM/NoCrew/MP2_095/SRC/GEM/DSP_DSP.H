static char dsp_bootstrap[] = {
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x0c,
0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
0x0f, 0x60, 0xf4, 0x00, 0x00, 0x00, 0x4f, 0x61, 0xf4, 0x00,
0x00, 0x7e, 0xa9, 0x06, 0x2f, 0x80, 0x00, 0x00, 0x47, 0x07,
0xd8, 0x84, 0x07, 0x59, 0x84, 0x08, 0xf4, 0xa8, 0x00, 0x00,
0x04, 0x08, 0xf4, 0xbf, 0x00, 0x0c, 0x00, 0x00, 0xfe, 0xb8,
0x0a, 0xf0, 0x80, 0x00, 0x7e, 0xa9, 0x00, 0x00, 0x00, 0x00,
0x7e, 0xa9, 0x00, 0x00, 0x2f, 0x56, 0xf4, 0x00, 0x12, 0x34,
0x56, 0x0a, 0xa9, 0x81, 0x00, 0x7e, 0xab, 0x08, 0xce, 0x2b,
0x0a, 0xa9, 0x80, 0x00, 0x7e, 0xae, 0x08, 0x4e, 0x2b, 0x44,
0xf4, 0x00, 0x00, 0x00, 0x03, 0x44, 0xf4, 0x45, 0x00, 0x00,
0x01, 0x0e, 0xa0, 0x00, 0x0a, 0xa9, 0x80, 0x00, 0x7e, 0xb6,
0x08, 0x50, 0x2b, 0x0a, 0xa9, 0x80, 0x00, 0x7e, 0xb9, 0x08,
0x46, 0x2b, 0x44, 0xf4, 0x45, 0x00, 0x00, 0x02, 0x0a, 0xf0,
0xaa, 0x00, 0x7e, 0xca, 0x20, 0x00, 0x45, 0x0a, 0xf0, 0xaa,
0x00, 0x7e, 0xd1, 0x06, 0xc6, 0x00, 0x00, 0x7e, 0xc7, 0x0a,
0xa9, 0x80, 0x00, 0x7e, 0xc5, 0x08, 0x58, 0x6b, 0x0a, 0xf0,
0x80, 0x00, 0x7e, 0xae, 0x06, 0xc6, 0x00, 0x00, 0x7e, 0xce,
0x0a, 0xa9, 0x80, 0x00, 0x7e, 0xcc, 0x08, 0x58, 0xab, 0x0a,
0xf0, 0x80, 0x00, 0x7e, 0xae, 0x06, 0xc6, 0x00, 0x00, 0x7e,
0xd5, 0x0a, 0xa9, 0x80, 0x00, 0x7e, 0xd3, 0x08, 0x58, 0xeb,
0x0a, 0xf0, 0x80, 0x00, 0x7e, 0xae };
