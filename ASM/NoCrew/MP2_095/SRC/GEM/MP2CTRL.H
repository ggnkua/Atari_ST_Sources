/* Indice du ressource pour MP2CTRL */

#define FORM_CTRL1 0   /* Formulaire/Dialogue */
#define CTRL_FIRST 0   /* BOX dans l'arbre FORM_CTRL1 */
#define CTRL_LOAD 1   /* BOX dans l'arbre FORM_CTRL1 */
#define CTRL_STOP 3   /* BOX dans l'arbre FORM_CTRL1 */
#define CTRL_PLAY 5   /* BOX dans l'arbre FORM_CTRL1 */
#define CTRL_PAUSE 7   /* BOX dans l'arbre FORM_CTRL1 */
#define CTRL_INFO 9   /* BOX dans l'arbre FORM_CTRL1 */
#define CTRL_LOOP 11  /* BOX dans l'arbre FORM_CTRL1 */
#define CTRL_FF  13  /* BOX dans l'arbre FORM_CTRL1 */
#define CTRL_NEXT 15  /* BOX dans l'arbre FORM_CTRL1 */
#define CTRL_PREV 17  /* BOX dans l'arbre FORM_CTRL1 */
#define CTRL_FNAME_BOX 19  /* BOX dans l'arbre FORM_CTRL1 */
#define CTRL_FILENAME 20  /* TEXT dans l'arbre FORM_CTRL1 */
#define CTRL_TIME 21  /* BOX dans l'arbre FORM_CTRL1 */

#define FORM_INFO1 1   /* Formulaire/Dialogue */
#define INFO_FIRST 0   /* BOX dans l'arbre FORM_INFO1 */
#define INFO_VERSION 2   /* TEXT dans l'arbre FORM_INFO1 */

#define FORM_CTRL4 2   /* Formulaire/Dialogue */

#define FORM_INFO4 3   /* Formulaire/Dialogue */
