unsigned char dsp_bootstrap[] = {
0x0c, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
0x00, 0x00, 0x60, 0xf4, 0x00, 0x00, 0x00, 0x4f, 0x61, 0xf4,
0x00, 0x00, 0x7e, 0xa9, 0x06, 0x2a, 0x80, 0x00, 0x00, 0x47,
0x07, 0xd8, 0x84, 0x07, 0x59, 0x84, 0x08, 0xf4, 0xa8, 0x00,
0x00, 0x04, 0x08, 0xf4, 0xbf, 0x00, 0x0c, 0x00, 0x00, 0xfe,
0xb8, 0x0a, 0xf0, 0x80, 0x00, 0x7e, 0xa9, 0x0a, 0xa9, 0x80,
0x00, 0x7e, 0xa9, 0x08, 0x4e, 0x2b, 0x44, 0xf4, 0x00, 0x00,
0x00, 0x03, 0x44, 0xf4, 0x45, 0x00, 0x00, 0x01, 0x0e, 0xa0,
0x00, 0x0a, 0xa9, 0x80, 0x00, 0x7e, 0xb1, 0x08, 0x50, 0x2b,
0x0a, 0xa9, 0x80, 0x00, 0x7e, 0xb4, 0x08, 0x46, 0x2b, 0x44,
0xf4, 0x45, 0x00, 0x00, 0x02, 0x0a, 0xf0, 0xaa, 0x00, 0x7e,
0xc5, 0x20, 0x00, 0x45, 0x0a, 0xf0, 0xaa, 0x00, 0x7e, 0xcc,
0x06, 0xc6, 0x00, 0x00, 0x7e, 0xc2, 0x0a, 0xa9, 0x80, 0x00,
0x7e, 0xc0, 0x08, 0x58, 0x6b, 0x0a, 0xf0, 0x80, 0x00, 0x7e,
0xa9, 0x06, 0xc6, 0x00, 0x00, 0x7e, 0xc9, 0x0a, 0xa9, 0x80,
0x00, 0x7e, 0xc7, 0x08, 0x58, 0xab, 0x0a, 0xf0, 0x80, 0x00,
0x7e, 0xa9, 0x06, 0xc6, 0x00, 0x00, 0x7e, 0xd0, 0x0a, 0xa9,
0x80, 0x00, 0x7e, 0xce, 0x08, 0x58, 0xeb, 0x0a, 0xf0, 0x80,
0x00, 0x7e, 0xa9};
