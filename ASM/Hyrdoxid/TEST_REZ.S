	move	#$20,-(sp)
	trap	#1
	addq	#2,sp
	move	$ffff820e,d0
	move	$ffff8210,d1
	move	#$20,-(sp)
	trap	#1
	addq	#2,sp
	