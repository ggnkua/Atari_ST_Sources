
	BSR	INIT_RAST
	BSR	INSTAL_INTER2

	MOVE	#$2700,SR
	MOVE.B	SAVE_A09,$FFFFA09
	MOVE.B	SAVE_A07,$FFFFA07	
	MOVE.B	SAVE_A1B,$FFFFA1B	
	MOVE.B	SAVE_A21,$FFFFA21	
	MOVE.B	SAVE_A13,$FFFFA13	
	MOVE.L	SAVE_HBL,$120.w
	MOVE.L	SAVE_VBL,$70.W
	MOVE	#$2300,SR

INIT_RAST:
	move.l	$120.w,SAVE_HBL
	MOVE.L	$70.W,SAVE_VBL
	move.b	$ffffa1b,SAVE_A1B
	move.b	$ffffa09,SAVE_A09
	move.b	$ffffa21,SAVE_A21
	move.b	$ffffa07,SAVE_A07
	move.b	$ffffa13,SAVE_A13
	RTS

INSTAL_INTER2:
	MOVE	#$2700,SR
	CLR.B 	$FFFFFA1B.W		STOP TIMER B
	CLR.B 	$FFFFFA07.W		MFP RESET
	CLR.B 	$FFFFFA09.W
	ORI.B 	#1,$FFFFFA07.W		ENABLE TIMER B
	ORI.B 	#1,$FFFFFA13.W
	CLR.B 	$FFFFFA1B.W		STOP TIMER B
	MOVE	#$2300,SR
	RTS

TIMER_B:
	ADD	#$111,$FFFF8242.W
	ADDQ.B	#1,COULOR
	CMPI.B	#7,COULOR
	BNE.S	SUITE11
	CLR.B	COULOR
	CLR.B	$FFFFFA1B.w
	CLR.B	$FFFFFA21.w
	MOVE.L	#TIMER_B2,$120.w
	CLR.B	$FFFFFA1B.w
	MOVE.B	#76-9,$FFFFFA21.w
	MOVE.B	#8,$FFFFA1B
SUITE11	BCLR	#0,$FFFFFA0F.W
	RTE
