	MOVE.W	SR,OLDSR+2
	MOVE.L	A7,OLDUSP+2
	MOVE.L	A7,-(A7)
	MOVE.W	#$20,-(A7)
	TRAP	#1
	MOVE.L	D0,OLDSSP+2
	DC.W	$A000
	DC.W	$A00A
	LEA	PIC+4,A0
	LEA	$FFFF8240.W,A1
	MOVEM.L	(A0),D0-D7
	MOVEM.L	D0-D7,(A1)
	LEA	PIC+128,A0
	MOVE.L	$44E.W,A1
	MOVE.W	#7999,D0
LOOP	MOVE.L	(A0)+,(A1)+
	DBF	D0,LOOP
OLDSSP	MOVE.L	#0,A7
OLDSR	MOVE.W	#0,SR
OLDUSP	MOVE.L	#0,A7
	CLR.W	-(A7)
	TRAP	#1

PIC	INCBIN	LOADSCRN.NEO
