***************************************************************************
* -THE FINK- RETURNS WITH SOME MORE GREAT CODING, THIS CODE WAS RIPPED    *
* OFF THE DEMO CLUB'S CATALOGE MENU AND IMPROVED (IT HAD A REALLY CRAP    *
* SCREEN FLIPPING ROUTINE) - IT'S A FULL-SCREEN, ONE BIT-PLANE, RASTER    *
* SCROLLING TEXT SCROLLER                                                 *
***************************************************************************
L7126E	BSR	SUPER			SUPERVISOR MODE
	MOVE.B	#2,$FFFF820A.W		50Hz SYNC
	BSR	GET_RES			GET RES
	BSR	SET_RES			WAIT FOR VSYNC, SET  TO LOW RES
	BSR	GET_SCR			GET LOG SCREEN BASE
	BSR	GET_PAL			SAVE PALETTE
	BSR	NEW_PAL			NEW PALETTE
	BSR	COP_PIC
	BSR	VSYNC			WAIT FOR VSYNC
	BCLR	#0,$484.W		NO KEYCLICK DURING MUSIC
	MOVEQ	#1,D0
	BSR	MUSIC
	LEA 	L71BCE(PC),A5		HOLDS PALETTE DATA
	MOVE.L	A5,A6
	MOVE.W	#$2700,SR		DISABLE INTERRUPTS
	MOVE.L	$120.W,L28940		SAVE TIMER B ROUTINE
	MOVE.L	$70.W,L28944		SAVE VBL ROUTINE
	MOVE.B	$FFFFFA09.W,L28948
	MOVE.B	$FFFFFA07.W,L2894C
	MOVE.B	$FFFFFA13.W,L28950	SAVE SOME MFP INTERRUPTS
	ANDI.B	#$DF,$FFFFFA09.W	SET TIMER B
	ANDI.B	#$FE,$FFFFFA07.W	SET TIMER A
	MOVE.L	#L71B5A,$120.W		NEW TIMER B ROUTINE
	MOVE.L	#L71B3A,$70.W		NEW VBL ROUTINE
	CLR.B	$FFFFFA1B.W		STOP COUNT
	MOVE.B	#2,$FFFFFA21.W		EVERY 2 SCAN LINES
	MOVE.B	#8,$FFFFFA1B.W		START COUNT
	ORI.B	#1,$FFFFFA07.W
	ORI.B	#1,$FFFFFA13.W
	MOVE.L	$118.W,L2893C		SAVE KEYBOARD VECTOR
	MOVE.W	#$2300,SR		ENABLE INTERRUPTS
	LEA	L71BCE(PC),A5		HOLDS PALETTE DATA
******************************
*START OF MAIN LOOP***********
******************************
L7132E	MOVE.W	#$FFFF,L28916
L71336	TST	L28916
	BNE.S	L71336
	MOVE.B	$FFFFFC02.W,D0		READ KEYBOARD ACIA DATA
	CMP.B	#$39,D0			HAS <SPACE> BEEN PRESSED ?
	BEQ.S	L7138C			YES, SO EXIT PROGRAM
	MOVE.L	L26E5E,D1
	BTST	#0,D1
	BNE.S	L7136C
	CMP.B	#$3B,D0			HAS F1 BEEN PRESSED ?
	BLT.S	L7136C
	CMP.B	#$3C,D0			HAS F2 BEEN PRESSED ?
	BGT.S	L7136C
	SUBI.B	#$3A,D0			D0 IS NOW EITHER 1 0R 2
	EXT.L	D0
	MOVE.W	D0,L26E5C		SAVE D0
L7136C	BSR	SWAP			SWAP SCREENS
	ADDQ.W	#2,A5			GET NEXT COLOUR FROM PALETTE DATA
	TST.W	(A5)			TEST IT
	BPL.S	L7137A			IF IT'S NEGATIVE THEN RESET DATA
	LEA	L71BCE(PC),A5		THE DATA IS NOW RESET
L7137A	
	LEA	L71BCE(PC),A6		PALETTE DATA FOR SCROLLTEXT
	BSR.S	L713F6			DRAW SCROLLER
	BRA	L7132E			BACK TO START OF MAIN LOOP
L7138C	MOVE.W	SR,-(A7)		THE EXIT PROGRAM ROUTINE....
	ORI	#$700,SR
	CLR.B	$FFFFFA1B.W			STOP  COUNT
	MOVE.L	L2893C,$118.W			OLD KEYBOARD VECTOR
	ANDI.B	#$DF,$FFFFFA09.W
	ANDI.B	#$FE,$FFFFFA07.W
	MOVE.L	L28940,$120.W			OLD TIMER B ROUTINE
	MOVE.L	L28944,$70.W			OLD VBL ROUTINE
	MOVE.B	L2894C,$FFFFFA07.W
	MOVE.B	L28948,$FFFFFA09.W
	MOVE.B	L28950,$FFFFFA13.W		OLD MFP INTERRUPTS
	MOVE.W	(A7)+,SR
	BSR	L71B92				CLEAR SOUND CHANNELS
	BSR	L71B18				RESTORE OLD PALETTE
	BSR	L71AC8				WAIT FOR VSYNC, SET OLD
L713E0	BTST	#0,$FFFFFC00.W			REZ AND SCREEN ADDRESS
	BEQ.S	L713EE
	MOVE.B	$FFFFFC02.W,D0			READ KEYBOARD ACIA DATA
	BRA.S	L713E0
L713EE	BSR	L71A90				USER MODE
	CLR.W	-(A7)
	TRAP	#1				EXIT TO DESKTOP
L713F6	
	MOVE.W	L288A2,D5
	EXT.L	D5
	MOVE.L	SCREEN,A0			*********************
	ADDA.W	#2,A0				THE FORTH BIT-PLANE
	ADD.L	D5,A0
	CLR.W	(A0)
	CLR.W	$67C0(A0)
	CLR.W	8(A0)
	CLR.W	$67C8(A0)
	CLR.W	$10(A0)
	CLR.W	$67D0(A0)
	CLR.W	$18(A0)
	CLR.W	$67D8(A0)
	CLR.W	$20(A0)
	CLR.W	$67E0(A0)
	CLR.W	$28(A0)
	CLR.W	$67E8(A0)
	CLR.W	$30(A0)
	CLR.W	$67F0(A0)
	CLR.W	$38(A0)
	CLR.W	$67F8(A0)	
	CLR.W	$40(A0)
	CLR.W	$6800(A0)
	CLR.W	$48(A0)
	CLR.W	$6808(A0)
	CLR.W	$50(A0)
	CLR.W	$6810(A0)
	CLR.W	$58(A0)
	CLR.W	$6818(A0)
	CLR.W	$60(A0)
	CLR.W	$6820(A0)
	CLR.W	$68(A0)
	CLR.W	$6828(A0)
	CLR.W	$70(A0)
	CLR.W	$6830(A0)
	CLR.W	$78(A0)
	CLR.W	$6838(A0)
	CLR.W	$80(A0)
	CLR.W	$6840(A0)
	CLR.W	$88(A0)
	CLR.W	$6848(A0)
	CLR.W	$90(A0)
	CLR.W	$6850(A0)
	CLR.W	$98(A0)
	CLR.W	$6858(A0)
	CLR.W	$A0(A0)
	CLR.W	$6860(A0)
	CLR.W	$A8(A0)
	CLR.W	$6868(A0)
	CLR.W	$B0(A0)
	CLR.W	$6870(A0)
	CLR.W	$B8(A0)
	CLR.W	$6878(A0)
	CLR.W	$C0(A0)
	CLR.W	$6880(A0)
	CLR.W	$C8(A0)
	CLR.W	$6888(A0)
	CLR.W	$D0(A0)
	CLR.W	$6890(A0)
	CLR.W	$D8(A0)
	CLR.W	$6898(A0)
	CLR.W	$E0(A0)
	CLR.W	$68A0(A0)
	CLR.W	$E8(A0)
	CLR.W	$68A8(A0)
	CLR.W	$F0(A0)
	CLR.W	$68B0(A0)
	CLR.W	$F8(A0)
	CLR.W	$68B8(A0)
	CLR.W	$100(A0)
	CLR.W	$68C0(A0)
	CLR.W	$108(A0)
	CLR.W	$68C8(A0)
	CLR.W	$110(A0)
	CLR.W	$68D0(A0)
	CLR.W	$118(A0)
	CLR.W	$68D8(A0)
	CLR.W	$120(A0)
	CLR.W	$68E0(A0)
	CLR.W	$128(A0)
	CLR.W	$68E8(A0)
	CLR.W	$130(A0)
	CLR.W	$68F0(A0)
	CLR.W	$138(A0)
	CLR.W	$68F8(A0)
	CLR.W	$140(A0)
	CLR.W	$6900(A0)
	CLR.W	$148(A0)
	CLR.W	$6908(A0)
	CLR.W	$150(A0)
	CLR.W	$6910(A0)
	CLR.W	$158(A0)
	CLR.W	$6918(A0)
	CLR.W	$160(A0)
	CLR.W	$6920(A0)
	CLR.W	$168(A0)
	CLR.W	$6928(A0)
	CLR.W	$170(A0)
	CLR.W	$6930(A0)
	CLR.W	$178(A0)
	CLR.W	$6938(A0)
	CLR.W	$180(A0)
	CLR.W	$6940(A0)
	CLR.W	$188(A0)
	CLR.W	$6948(A0)
	CLR.W	$190(A0)
	CLR.W	$6950(A0)
	CLR.W	$198(A0)
	CLR.W	$6958(A0)
	CLR.W	$1A0(A0)
	CLR.W	$6960(A0)
	CLR.W	$1A8(A0)
	CLR.W	$6968(A0)
	CLR.W	$1B0(A0)
	CLR.W	$6970(A0)
	CLR.W	$1B8(A0)
	CLR.W	$6978(A0)
	CLR.W	$1C0(A0)
	CLR.W	$6980(A0)
	CLR.W	$1C8(A0)
	CLR.W	$6988(A0)
	CLR.W	$1D0(A0)
	CLR.W	$6990(A0)
	CLR.W	$1D8(A0)
	CLR.W	$6998(A0)
	CLR.W	$1E0(A0)
	CLR.W	$69A0(A0)
	CLR.W	$1E8(A0)
	CLR.W	$69A8(A0)
	CLR.W	$1F0(A0)
	CLR.W	$69B0(A0)
	CLR.W	$1F8(A0)
	CLR.W	$69B8(A0)
	CLR.W	$200(A0)
	CLR.W	$69C0(A0)
	CLR.W	$208(A0)
	CLR.W	$69C8(A0)
	CLR.W	$210(A0)
	CLR.W	$69D0(A0)
	CLR.W	$218(A0)
	CLR.W	$69D8(A0)
	CLR.W	$220(A0)
	CLR.W	$69E0(A0)
	CLR.W	$228(A0)
	CLR.W	$69E8(A0)
	CLR.W	$230(A0)
	CLR.W	$69F0(A0)
	CLR.W	$238(A0)
	CLR.W	$69F8(A0)
	CLR.W	$240(A0)
	CLR.W	$6A00(A0)
	CLR.W	$248(A0)
	CLR.W	$6A08(A0)
	CLR.W	$250(A0)
	CLR.W	$6A10(A0)
	CLR.W	$258(A0)
	CLR.W	$6A18(A0)
	CLR.W	$260(A0)
	CLR.W	$6A20(A0)
	CLR.W	$268(A0)
	CLR.W	$6A28(A0)
	CLR.W	$270(A0)
	CLR.W	$6A30(A0)
	CLR.W	$278(A0)
	CLR.W	$6A38(A0)
	MOVE.L	SCREEN1,A0
	MOVE.L	L288A8,A1			BOUNCE POINTER
	MOVE.W	(A1)+,D0			GET NEXT BOUNCE OFFSET
	MOVE.W	D0,L288A2
	ADD.W	D0,A0
	TST.W	(A1)				IS IT THE END OF THE BOUNCE CODE
	BPL.S	L716A4				IF POSITIVE, NO
	LEA	L288AC,A1			RESET BOUNCE POINTER
L716A4	MOVE.L	A1,L288A8
*********************************
*PLACE TEXT ON SCREEN************
*********************************
	CLR.L	D0
	MOVE.L	L26E60,A2			POINTER TO SCROLL-TEXT
	MOVEA.L	A2,A3				STICK IT HERE
	MOVE.L	L26E5E,D7			HOLDS OFFSET TO HOW FAR ACROSS THE FONT CHAR THE SCROLLER IS
	MOVEQ	#$28,D6				40 DEC-LOOP COUNTER (40*1 BYTE=320(1 SCAN LINE))
L716BA	LEA	L11C9A,A4			BEGINNING ADDR OF FONT
	MOVE.B	(A3)+,D0			NEXT LETTER
	EXT.L	D0				EXTEND IT
	MULU	#$440,D0			MULTIPLY BY 1088 - THE SIZE OF ONE FONT CHARACTER
	ADDA.L	D0,A4				ADD IT TO FONT DATA
	MOVE.L	D7,D0
	MULU	#$22,D0				34 DEC (272/8=34)(ONE LINE OF FONT CHARACTER)
	ADDA.W	D0,A4
L716D2	MOVE.B	(A4)+,D0
	MOVE.B	D0,$0(A0)
	MOVE.B	D0,$A0(A0)
	MOVE.B	D0,$140(A0)
	MOVE.B	D0,$1E0(A0)
	MOVE.B	D0,$280(A0)
	MOVE.B	(A4)+,D0
	MOVE.B	D0,$320(A0)
	MOVE.B	D0,$3C0(A0)
	MOVE.B	D0,$460(A0)
	MOVE.B	D0,$500(A0)
	MOVE.B	D0,$5A0(A0)
	MOVE.B	(A4)+,D0
	MOVE.B	D0,$640(A0)
	MOVE.B	D0,$6E0(A0)
	MOVE.B	D0,$780(A0)
	MOVE.B	D0,$820(A0)
	MOVE.B	D0,$8C0(A0)
	MOVE.B	(A4)+,D0
	MOVE.B	D0,$960(A0)
	MOVE.B	D0,$A00(A0)
	MOVE.B	D0,$AA0(A0)
	MOVE.B	D0,$B40(A0)
	MOVE.B	D0,$BE0(A0)
	MOVE.B	(A4)+,D0
	MOVE.B	D0,$C80(A0)
	MOVE.B	D0,$D20(A0)
	MOVE.B	D0,$DC0(A0)
	MOVE.B	D0,$E60(A0)
	MOVE.B	D0,$F00(A0)
	MOVE.B	(A4)+,D0
	MOVE.B	D0,$FA0(A0)
	MOVE.B	D0,$1040(A0)
	MOVE.B	D0,$10E0(A0)
	MOVE.B	D0,$1180(A0)
	MOVE.B	D0,$1220(A0)
	MOVE.B	(A4)+,D0
	MOVE.B	D0,$12C0(A0)
	MOVE.B	D0,$1360(A0)
	MOVE.B	D0,$1400(A0)
	MOVE.B	D0,$14A0(A0)
	MOVE.B	D0,$1540(A0)
	MOVE.B	(A4)+,D0
	MOVE.B	D0,$15E0(A0)
	MOVE.B	D0,$1680(A0)
	MOVE.B	D0,$1720(A0)
	MOVE.B	D0,$17C0(A0)
	MOVE.B	D0,$1860(A0)
	MOVE.B	(A4)+,D0
	MOVE.B	D0,$1900(A0)
	MOVE.B	D0,$19A0(A0)
	MOVE.B	D0,$1A40(A0)
	MOVE.B	D0,$1AE0(A0)
	MOVE.B	D0,$1B80(A0)
	MOVE.B	(A4)+,D0
	MOVE.B	D0,$1C20(A0)
	MOVE.B	D0,$1CC0(A0)
	MOVE.B	D0,$1D60(A0)
	MOVE.B	D0,$1E00(A0)
	MOVE.B	D0,$1EA0(A0)
	MOVE.B	(A4)+,D0
	MOVE.B	D0,$1F40(A0)
	MOVE.B	D0,$1FE0(A0)
	MOVE.B	D0,$2080(A0)
	MOVE.B	D0,$2120(A0)
	MOVE.B	D0,$21C0(A0)
	MOVE.B	(A4)+,D0
	MOVE.B	D0,$2260(A0)
	MOVE.B	D0,$2300(A0)
	MOVE.B	D0,$23A0(A0)
	MOVE.B	D0,$2440(A0)
	MOVE.B	D0,$24E0(A0)
	MOVE.B	(A4)+,D0
	MOVE.B	D0,$2580(A0)
	MOVE.B	D0,$2620(A0)
	MOVE.B	D0,$26C0(A0)
	MOVE.B	D0,$2760(A0)
	MOVE.B	D0,$2800(A0)
	MOVE.B	(A4)+,D0
	MOVE.B	D0,$28A0(A0)
	MOVE.B	D0,$2940(A0)
	MOVE.B	D0,$29E0(A0)
	MOVE.B	D0,$2A80(A0)
	MOVE.B	D0,$2B20(A0)
	MOVE.B	(A4)+,D0
	MOVE.B	D0,$2BC0(A0)
	MOVE.B	D0,$2C60(A0)
	MOVE.B	D0,$2D00(A0)
	MOVE.B	D0,$2DA0(A0)
	MOVE.B	D0,$2E40(A0)
	MOVE.B	(A4)+,D0
	MOVE.B	D0,$2EE0(A0)
	MOVE.B	D0,$2F80(A0)
	MOVE.B	D0,$3020(A0)
	MOVE.B	D0,$30C0(A0)
	MOVE.B	D0,$3160(A0)
	MOVE.B	(A4)+,D0
	MOVE.B	D0,$3200(A0)
	MOVE.B	D0,$32A0(A0)
	MOVE.B	D0,$3340(A0)
	MOVE.B	D0,$33E0(A0)
	MOVE.B	D0,$3480(A0)
	MOVE.B	(A4)+,D0
	MOVE.B	D0,$3520(A0)
	MOVE.B	D0,$35C0(A0)
	MOVE.B	D0,$3660(A0)
	MOVE.B	D0,$3700(A0)
	MOVE.B	D0,$37A0(A0)
	MOVE.B	(A4)+,D0
	MOVE.B	D0,$3840(A0)
	MOVE.B	D0,$38E0(A0)
	MOVE.B	D0,$3980(A0)
	MOVE.B	D0,$3A20(A0)
	MOVE.B	D0,$3AC0(A0)
	MOVE.B	(A4)+,D0
	MOVE.B	D0,$3B60(A0)
	MOVE.B	D0,$3C00(A0)
	MOVE.B	D0,$3CA0(A0)
	MOVE.B	D0,$3D40(A0)
	MOVE.B	D0,$3DE0(A0)
	MOVE.B	(A4)+,D0
	MOVE.B	D0,$3E80(A0)
	MOVE.B	D0,$3F20(A0)
	MOVE.B	D0,$3FC0(A0)
	MOVE.B	D0,$4060(A0)
	MOVE.B	D0,$4100(A0)
	MOVE.B	(A4)+,D0
	MOVE.B	D0,$41A0(A0)
	MOVE.B	D0,$4240(A0)
	MOVE.B	D0,$42E0(A0)
	MOVE.B	D0,$4380(A0)
	MOVE.B	D0,$4420(A0)
	MOVE.B	(A4)+,D0
	MOVE.B	D0,$44C0(A0)
	MOVE.B	D0,$4560(A0)
	MOVE.B	D0,$4600(A0)
	MOVE.B	D0,$46A0(A0)
	MOVE.B	D0,$4740(A0)
	MOVE.B	(A4)+,D0
	MOVE.B	D0,$47E0(A0)
	MOVE.B	D0,$4880(A0)
	MOVE.B	D0,$4920(A0)
	MOVE.B	D0,$49C0(A0)
	MOVE.B	D0,$4A60(A0)
	MOVE.B	(A4)+,D0
	MOVE.B	D0,$4B00(A0)
	MOVE.B	D0,$4BA0(A0)
	MOVE.B	D0,$4C40(A0)
	MOVE.B	D0,$4CE0(A0)
	MOVE.B	D0,$4D80(A0)
	MOVE.B	(A4)+,D0
	MOVE.B	D0,$4E20(A0)
	MOVE.B	D0,$4EC0(A0)
	MOVE.B	D0,$4F60(A0)
	MOVE.B	D0,$5000(A0)
	MOVE.B	D0,$50A0(A0)
	MOVE.B	(A4)+,D0
	MOVE.B	D0,$5140(A0)
	MOVE.B	D0,$51E0(A0)
	MOVE.B	D0,$5280(A0)
	MOVE.B	D0,$5320(A0)
	MOVE.B	D0,$53C0(A0)
	MOVE.B	(A4)+,D0
	MOVE.B	D0,$5460(A0)
	MOVE.B	D0,$5500(A0)
	MOVE.B	D0,$55A0(A0)
	MOVE.B	D0,$5640(A0)
	MOVE.B	D0,$56E0(A0)
	MOVE.B	(A4)+,D0
	MOVE.B	D0,$5780(A0)
	MOVE.B	D0,$5820(A0)
	MOVE.B	D0,$58C0(A0)
	MOVE.B	D0,$5960(A0)
	MOVE.B	D0,$5A00(A0)
	MOVE.B	(A4)+,D0
	MOVE.B	D0,$5AA0(A0)
	MOVE.B	D0,$5B40(A0)
	MOVE.B	D0,$5BE0(A0)
	MOVE.B	D0,$5C80(A0)
	MOVE.B	D0,$5D20(A0)
	MOVE.B	(A4)+,D0
	MOVE.B	D0,$5DC0(A0)
	MOVE.B	D0,$5E60(A0)
	MOVE.B	D0,$5F00(A0)
	MOVE.B	D0,$5FA0(A0)
	MOVE.B	D0,$6040(A0)
	MOVE.B	(A4)+,D0
	MOVE.B	D0,$60E0(A0)
	MOVE.B	D0,$6180(A0)
	MOVE.B	D0,$6220(A0)
	MOVE.B	D0,$62C0(A0)
	MOVE.B	D0,$6360(A0)
	MOVE.B	(A4)+,D0
	MOVE.B	D0,$6400(A0)
	MOVE.B	D0,$64A0(A0)
	MOVE.B	D0,$6540(A0)
	MOVE.B	D0,$65E0(A0)
	MOVE.B	D0,$6680(A0)
	MOVE.B	(A4)+,D0
	MOVE.B	D0,$6720(A0)
	MOVE.B	D0,$67C0(A0)
	MOVE.B	D0,$6860(A0)
	MOVE.B	D0,$6900(A0)
	MOVE.B	D0,$69A0(A0)			170 LINES DRAWN
	SUBQ.W	#1,D6				NEXT 8 PIXELS
	BEQ.S	L719E6				IS THE SCREEN FULL ?
	ADDQ.W	#1,A0				NEXT BYTE
	MOVE.W	A0,D0
	BTST	#0,D0
	BNE.S	L719CC
	ADDQ.W	#6,A0				NEXT 16 PIXELS
L719CC	ADDQ.L	#1,D7				ADD 1 TO CHR OFFSET
	ANDI.L	#$1F,D7				AND IT
	BNE	L716D2				IS IT THE END OF THE FONT CHR
	TST.B	(A3)				IS TEXT AT END
	CLR.L	D0
	BPL	L716BA				NO
	LEA	L26E64,A3			RESET TEXT
	BRA	L716BA				AND BRANCH BACK
L719E6	MOVE.W	L26E5C,D0	
	ADD.L	D0,L26E5E
	ANDI.L	#$1F,L26E5E
	BNE.S	L71A08
	ADDQ.W	#1,A2
	TST.B	(A2)
	BPL.S	L71A08
	LEA	L26E64,A2
L71A08	MOVE.L	A2,L26E60
	EORI.W	#2,L288A2
	RTS

SUPER	CLR.L	-(A7)
	MOVE.W	#$20,-(A7)			SUPERVISOR MODE
	TRAP	#1
	ADDQ.W	#6,A7
	MOVE.L	D0,L28918			SAVE USER
	RTS
***************************
COP_PIC	
	MOVE.L	L1F13C,A0			PICTURE ADDRESS
	LEA	$60000,A1			SCREEN1 
	LEA	$68000,A2			SCREEN
	MOVE.W	#$1F3F,D0			LOOP COUNTER 8000
PIC2	MOVE.L	(A0),(A1)+
	MOVE.L	(A0)+,(A2)+
	DBF	D0,PIC2
	RTS
*******************************
SWAP	
	TST.W	SWITCH
	BNE.S	TIME
	MOVE.L	#$68000,SCREEN1		SCREEN1= PHYSBASE
	MOVE.L	#$60000,SCREEN		SCREEN= LOGBASE
	MOVE.W	#1,SWITCH
	BRA.S	TIME2
TIME	MOVE.L	#$60000,SCREEN1
	MOVE.L	#$68000,SCREEN
	MOVE.W	#0,SWITCH
TIME2	MOVE.W	#-1,-(SP)
	MOVE.L	SCREEN1,-(SP)
	MOVE.L	SCREEN,-(SP)
	MOVE.W	#5,-(SP)
	TRAP	#14
	ADD.L	#12,SP
	RTS
******************************
***************************
L71A90	MOVE.L	L28918,-(A7)
	MOVE.W	#$20,-(A7)			USER MODE
	TRAP	#1
	ADDQ.W	#6,A7
	RTS
***************************
GET_RES	MOVE.W	#4,-(A7)			GET RESOLUTION
	TRAP	#14
	ADDQ.W	#2,A7
	MOVE.W	D0,L28912			SAVE IT
	RTS
***************************
SET_RES	BSR.S	VSYNC				WAIT FOR VSYNC
	CLR.W	-(A7)				CHANGE TO LOW RES
	PEA	-1.W
	PEA	-1.W
	MOVE.W	#5,-(A7)
	TRAP	#14
	ADDA.W	#$C,A7
	RTS
L71AC8	BSR.S	VSYNC				WAIT FOR VSYNC
	MOVE.W	L28912,-(A7)			OLD RES
	MOVE.L	L28954,-(A7)			OLD PHYS BASE
	MOVE.L	L28954,-(A7)			OLD LOG BASE
	MOVE.W	#5,-(A7)			SET UP SCREEN PARAMETERS
	TRAP	#14
	ADDA.W	#$C,A7
	RTS
***************************
GET_SCR	MOVE.W	#3,-(A7)			GET LOG SCREEN BASE
	TRAP	#14
	ADDQ.W	#2,A7
	MOVE.L	D0,L28954			SAVE IT
	RTS
***************************
GET_PAL	MOVEM.L	$FFFF8240.W,D0-D7		SAVE PALETTE
	MOVEM.L	D0-D7,L2891C
	RTS
***************************
NEW_PAL	MOVEM.L	L11BAE,D0-D7			NEW PALETTE
	MOVEM.L	D0-D7,$FFFF8240.W
	RTS
***************************
L71B18	MOVEM.L	L2891C,D0-D7			OLD PALETTE
	MOVEM.L	D0-D7,$FFFF8240.W
	RTS
***************************
VSYNC	MOVE.W	#$25,-(A7)			WAIT FOR VSYNC
	TRAP	#14
	ADDQ.W	#2,A7
	RTS
***************************
L71B32	BCLR	#6,$FFFFFA11.W			NEW KEYBOARD VECTOR
	RTE
L71B3A	MOVEM.L	D0-A6,-(A7)
	BSR	(MUSIC+8)			PLAY THE MUSIC
	CLR.B	$FFFFFA1B.W			STOP COUNT
	CLR.W	L28916
	MOVE.B	#2,$FFFFFA21.W			EVERY 2 LINES
	MOVE.L	#L71B5A,$120.W			NEW TIMER B ROUTINE
	MOVE.B	#8,$FFFFFA1B.W			START COUNT
	MOVEM.L	(A7)+,D0-A6
	RTE
L71B5A	CLR.B	$FFFFFA1B.W			STOP COUNT
	MOVE.W	(A6)+,$FFFF8250.W
	MOVE.W	(A5),$FFFF824E.W
	MOVE.W	(A5)+,$FFFF825E.W
	TST.W	(A5)
	BPL.S	L71B72
	LEA	L71BCE(PC),A5
L71B72	MOVE.B	#2,$FFFFFA21.W			EVERY 2 LINES
	MOVE.B	#8,$FFFFFA1B.W			START COUNT
	BCLR	#0,$FFFFFA0F.W			END OF INTERRUPTS
	RTE
L71B92	LEA	$FFFF8800.W,A0			CLEAR SOUND CHANNELS
	MOVE.L	#$8080000,(A0)
	MOVE.L	#$9090000,(A0)
	MOVE.L	#$A0A0000,(A0)
	RTS

*	DATA SECTION

L28918	DC.L	0				OLD SP
L71BCE	INCBIN 	'B:\BIG_FINK\PALETTE.DAT'	PALETTE DATA
	DC.W	-1
L28912	DC.W	1				HOLD OLD RES
L28954	DC.L	1				HOLDS OLD LOG SCR BASE
L2891C	DS.W	16				OLD PALETTE
L28940	DC.L	0				OLD TIMER B ROUTINE
L28944	DC.L	0				OLD VBL ROUTINE
L28948	DC.B	0				OLD MFP
L2894C	DC.B	0				OLD MFP
L28950	DC.B	0				OLD MFP
L2893C	DC.L	0				OLD KEYVAL
L28916	DC.W	0				VBL COUNT
L26E5C	DC.W	1				SCROLLER SPEED
L26E5E	DC.L	0				FONT OFFSET
SCREEN1	DC.L	0
SCREEN	DC.L	0
SWITCH	DC.W	0
L26E60	DC.L	L26E64				TEXT POINTER
***************************************************************************
* THE TEXT IS ALL ENCODED INTO HOW FAR THE CHARACTER IS INTO THE FONT DATA*
* SO HERE ARE THE NUMBERS....                                             *
*A=0,B=1,C=2,D=3,E=4,F=5,G=6,H=7,I=8,J=9,K=10,L=11,M=12,N=13,O=14,P=15    *
*R=17,S=18,T=19,U=20,V=21,W=22,X=23,Y=24,Z=25,.=26,,=27,:=28,;=29,1=30    *
*2=31,3=32,4=33,5=34,6=35,7=36,8=37,9=38,08=39,)=40,(=41,-=42,*=243,\=44    *
*!=45,?=46,'=47,@=48,<SPACE>=49                                           *
***************************************************************************
*L26E64	INCBIN	'B:\BIG_FINK\TEXT.DAT'			THE TEXT GOES HERE
L26E64	DC.B	49,49,49,49,49,49,49
	DC.B	42,19,7,4,49,5,8,13,10,42,49,49,49,8,18,49,7,4,17,4
	DC.B	49,49,49,22,8,19,7,49,12,24,49,1,8,6,49,1,14,20,13,2,4
	DC.B	49,18,2,17,14,11,11,4,17,49,49,49,49,8,49,22,4,13,19,49
	DC.B	17,0,18,19,4,17,49,12,0,3,49,22,8,19,7,49,19,7,8,18,49
	DC.B	14,13,4,49,49,49,49,49,49,7,14,15,4,49,24,14,20,49
	DC.B	11,8,10,4,49,19,7,4,49,12,20,18,8,2,49,49,49,8,19,47,18
	DC.B	49,14,13,4,49,14,5,49,19,7,4,49,1,4,18,19,49,8,47,21,4
	DC.B	49,7,4,0,17,3,49,49,49,49,8,49,7,0,2,10,4,3,49,8,19,49
	DC.B	5,17,14,12,49,19,7,4,49,47,18,14,49,22,7,0,19,47,49
	DC.B	3,4,12,14,49,49,49,0,18,49,24,4,19,49,13,14,42,14,13,4
	DC.B	49,7,0,18,49,3,14,13,4,49,0,13,24,49,11,14,6,14,18,49
	DC.B	5,14,17,49,49,42,19,7,4,49,2,4,13,14,1,24,19,4,18,42,49
	DC.B	18,14,49,8,47,12,49,7,0,21,8,13,6,49,19,14,49,3,14,49
	DC.B	12,24,49,14,22,13,49,18,7,8,19,49,6,17,0,15,7,8,2,18,49,49
	DC.B	49,49,49,49,49,49,49,7,4,11,11,14,18,49,19,14,49,19,7,4
	DC.B	49,5,14,11,11,14,22,8,13,6,49,2,14,14,11,49,2,14,3,4,17
	DC.B	18,49,49,49,18,10,20,11,11,49,49,49,17,4,4,18,4,49,49,49
	DC.B	19,7,4,49,22,8,11,11,18,49,49,49,2,17,0,25,24,49,2,7,17,8,18
	DC.B	49,49,49,12,0,17,19,8,13,49,49,49,22,7,8,19,4,49,3,14,21,4
	DC.B	49,49,49,0,13,3,49,11,0,18,19,49,1,20,19,49,1,24,49
	DC.B	13,14,49,12,4,0,13,18,49,11,4,0,18,19,49,49,49,0,11,11
	DC.B	49,12,4,12,1,4,17,18,49,14,5,49,0,17,2,7,0,14,18,49
	DC.B	14,13,49,19,7,4,49,0,12,8,6,0,49,49,49,49,11,4,19,18
	DC.B	49,22,17,0,15,49,49,49
	DC.B	-1
	EVEN
*		"       -THE FINK-    IS HERE   WITH MY BIG BOUNCE SCROLLER
*		"  I WENT RASTER MAD WITH THIS ONE   HOPE YOU LIKE THE MUSIC
*		" IT'S ONE OF THE BEXT I'VE HEARD
L28958	DC.L	0				SECOND SCREEN ADDRESS
L288A2	DC.W	0				????????
MUSIC	INCBIN	'B:\BIG_FINK\FINK.MUS'		THE MUSIC DATA
L288A8	DC.L	L288AC				BOUNCE POINTER
L288AC	INCBIN	'B:\BIG_FINK\BOUNCE.DAT'	BOUNCE CODE
L1F13C	DC.L	PIC+34				MAIN PICTURE GRAPHICS
PIC	INCBIN	'B:\BIG_FINK\BIG_FINK.PI1'
L11BAE	EQU	PIC+2

*	DC.W	$000,$111,$555,$444,$333,$222,$666,$607		NEW PALETTE
*	DC.W	$100,$111,$555,$444,$333,$222,$666,$607
L11C9A	INCBIN	'B:\BIG_FINK\FONT.DAT'			THE 1 BIT-PLANE FONT
	EVEN