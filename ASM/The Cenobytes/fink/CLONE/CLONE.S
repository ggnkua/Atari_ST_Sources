***************************************************************************
* THE CLONE DEMO BY -MENTA-, RIPPED BY -THE FINK-, ALL THE CODE IS HERE   *
* BUT I ONLY GOT THE ROUTINES RUNNING WHICH I WANTED TO USE, IE, THE      *
* MOVING BACKGROUND AND THE SPINNING MAIN SPRITE AND ALL OF THE INTRO     *
* SEQUENCE. THE REST SHOULD ALL RUN TO WITHOUT MUCH BOTHER.....		  *
***************************************************************************
L6A304		MOVE.L	$4(A7),A5 
L6A308		MOVE.L	$C(A5),D0 
L6A30C		ADD.L	$14(A5),D0 
L6A310		ADD.L	$1C(A5),D0 
L6A314		ADDI.L	#$400,D0 
L6A31A		MOVE.L	D0,D1 
L6A31C		ADD.L	A5,D1 
L6A31E		MOVE.L	D1,A7 
L6A320		MOVE.L	D0,-(A7) 
L6A322		PEA	(A5) 
L6A324		CLR.W	-(A7) 
L6A326		MOVE.W	#$4A,-(A7) 		SET DATA ALLOCATIONS
L6A32A		TRAP	#$1 
L6A32C		LEA	$C(A7),A7 

L6A330		CLR.L	-(A7) 
L6A332		MOVE.W	#$20,-(A7)		SUPERVISOR MODE 
L6A336		TRAP	#$1 
L6A338		ADDQ.L	#$6,A7 
L6A33A		MOVE.L	D0,L19096 		SAVE USER

L6A340		MOVE.B	#$12,$FFFFFC02.W 	TURN MOUSE OFF
L6A346		MOVE.L	$44E.W,L19086		GET SCREEN ADDRESS
L6A34E		MOVEM.L	$FFFF8240.W,D0-D7 
L6A354		MOVEM.L	D0-D7,L1905E 		SAVE PALETTE
L6A35C		MOVEM.L	L1369C,D0-D7 
L6A364		MOVEM.L	D0-D7,$FFFF8240.W 	NEW PALETTE
L6A36A		MOVEQ	#$9,D0 			SET UP MUSIC
*L6A36C		LEA	$10754,A0 		
*L6A372		JSR	(A0) 			RUN MUSIC
L6A374		MOVE.L	#L6AE14,$4D2.W 		NEW VBL ROUTINE (JUST PLAYS MUSIC)
L6A37C		CLR.W	-(A7) 			SET LOW RES
L6A37E		PEA	$66000 			NEW PHYS ADDR
L6A384		PEA	$66000 			NEW LOG ADDR
L6A38A		MOVE.W	#$5,-(A7) 		SET SCREEN PARAMETERS
L6A38E		TRAP	#$E 
L6A390		LEA	$C(A7),A7 
L6A394		CLR.W	-(A7) 			SET LOW RES
L6A396		PEA	$5B400 			NEW PHYS ADDR
L6A39C		PEA	$5B400 			NEW LOG ADDR
L6A3A2		MOVE.W	#$5,-(A7) 		SET SCREEN PARAMETERS
L6A3A6		TRAP	#$E 			(AGAIN ?????)
L6A3A8		LEA	$C(A7),A7 

L6A3AC		LEA	$63100,A0 
L6A3B2		LEA	$6DD00,A1 
L6A3B8		MOVE.W	#$57F,D0 		LOOP COUNTER (1408)
L6A3BC		CLR.L	(A0)+ 
L6A3BE		CLR.L	(A1)+ 
L6A3C0		CLR.L	(A0)+			CLEAR SOME MEMORY 
L6A3C2		CLR.L	(A1)+ 			CREATE SOME SPACE
L6A3C4		DBF	D0,L6A3BC 

L6A3C8		MOVE.L	#$5B400,L1908E 
L6A3D2		MOVE.L	#$66000,L19092 
L6A3DC		LEA	L17B9C,A0 		SMILEY GRAPHICS
L6A3E2		LEA	L1942C,A1 		SMILEY DESTINATION
L6A3E8		MOVEQ	#$1F,D0 		LOOP COUNTER (32)
L6A3EA		MOVE.L	(A0)+,D1 
L6A3EC		MOVE.L	D1,(A1)+ 		COPY IT
L6A3EE		MOVE.L	D1,$7C(A1) 		COPY IT AGAIN 124 BYTES LATER
L6A3F2		DBF	D0,L6A3EA 		DO ALL 32 LINES
L6A3F6		LEA	L1942C,A0 		SMILEY DESTINATION
L6A3FC		LEA	$FC(A0),A1 		252 BYTES LATER
L6A400		MOVEQ	#$1F,D1 		LOOP COUNTER (32)
L6A402		MOVEQ	#$3E,D0 		LOOP COUNTER (63)
L6A404		MOVE.L	(A0)+,D2 		COPY SMILEY
L6A406		ROL.L	#$1,D2 			SHIFT IT LEFT 1 BIT
L6A408		MOVE.L	D2,(A1)+ 		COPY IT TO THE NEXT SMILEY POSITION
L6A40A		DBF	D0,L6A404 		COPY 63 LINES OF SMILEY (DRAW 2 IDENTICAL SMILEYS)
L6A40E		DBF	D1,L6A402 		DRAW ANOTHER 32 SMILEYS (EACH SHIFTED ACROSS 1 PIXEL)
L6A412		MOVE.L	#L1369C,L1909A 
L6A41C		MOVE.L	#$13AC2,L19082 
L6A426		MOVE.L	#L14C7A,L1907E 
L6A430		MOVE.L	#$113,$FFFF8240.W 	CHANGE PALETTE
L6A438		MOVE.L	#$2240335,$FFFF8244.W 	CHANGE PALETTE
L6A440		MOVE.L	#$4460557,$FFFF8248.W 	CHANGE PALETTE
L6A448		MOVE.L	#$667030C,$FFFF824C.W 	CHANGE PALETTE
L6A450		CLR.W	$FFFF825E.W 		CHANGE PALETTE
L6A454		LEA	$5B428,A6 
L6A45A		LEA	$6720(A6),A5 
L6A45E		LEA	L184E02,A2 
L6A464		MOVEQ	#$21,D0 
L6A466		MOVE.W	-(A2),$54(A5) 
L6A46A		MOVE.W	(A2),$54(A6) 
L6A46E		MOVE.L	-(A2),$50(A5) 
L6A472		MOVE.L	(A2),$50(A6) 
L6A476		MOVE.W	-(A2),$4C(A5) 
L6A47A		MOVE.W	(A2),$4C(A6) 
L6A47E		MOVE.L	-(A2),$48(A5) 
L6A482		MOVE.L	(A2),$48(A6) 
L6A486		MOVE.W	-(A2),$44(A5) 
L6A48A		MOVE.W	(A2),$44(A6) 
L6A48E		MOVE.L	-(A2),$40(A5) 
L6A492		MOVE.L	(A2),$40(A6) 
L6A496		MOVE.W	-(A2),$3C(A5) 
L6A49A		MOVE.W	(A2),$3C(A6) 
L6A49E		MOVE.L	-(A2),$38(A5) 
L6A4A2		MOVE.L	(A2),$38(A6) 
L6A4A6		MOVE.W	-(A2),$34(A5) 
L6A4AA		MOVE.W	(A2),$34(A6) 
L6A4AE		MOVE.L	-(A2),$30(A5) 
L6A4B2		MOVE.L	(A2),$30(A6) 
L6A4B6		MOVE.W	-(A2),$2C(A5) 
L6A4BA		MOVE.W	(A2),$2C(A6) 
L6A4BE		MOVE.L	-(A2),$28(A5) 
L6A4C2		MOVE.L	(A2),$28(A6) 
L6A4C6		MOVE.W	-(A2),$24(A5) 
L6A4CA		MOVE.W	(A2),$24(A6) 
L6A4CE		MOVE.L	-(A2),$20(A5) 
L6A4D2		MOVE.L	(A2),$20(A6) 
L6A4D6		MOVE.W	-(A2),$1C(A5) 
L6A4DA		MOVE.W	(A2),$1C(A6) 
L6A4DE		MOVE.L	-(A2),$18(A5) 
L6A4E2		MOVE.L	(A2),$18(A6) 
L6A4E6		MOVE.W	-(A2),$14(A5) 
L6A4EA		MOVE.W	(A2),$14(A6) 
L6A4EE		MOVE.L	-(A2),$10(A5) 
L6A4F2		MOVE.L	(A2),$10(A6) 
L6A4F6		MOVE.W	-(A2),$C(A5) 
L6A4FA		MOVE.W	(A2),$C(A6) 
L6A4FE		MOVE.L	-(A2),$8(A5) 
L6A502		MOVE.L	(A2),$8(A6) 
L6A506		MOVE.W	-(A2),$4(A5) 
L6A50A		MOVE.W	(A2),$4(A6) 
L6A50E		MOVE.L	-(A2),$0(A5) 
L6A512		MOVE.L	(A2),$0(A6) 
L6A516		LEA	$FFFFFF60(A5),A5 
L6A51A		LEA	$A0(A6),A6 
L6A51E		DBF	D0,L6A466 
L6A522		MOVE.W	#$25,-(A7) 		WAIT FOR VSYNC
L6A526		TRAP	#$E 
L6A528		ADDQ.L	#$2,A7 
L6A52A		SUBA.L	#$14A0,A6 
L6A530		ADDA.L	#$14A0,A5 
L6A536		CMPA.L	#$5E7E0,A6 
L6A53C		BCS	L6A45E 
L6A540		LEA	$5B400,A6 
L6A546		LEA	$67C0(A6),A5 
L6A54A		MOVEQ	#$31,D4 
L6A54C		MOVEQ	#$9,D5 
L6A54E		CLR.L	(A6)+ 
L6A550		CLR.L	-(A5) 
L6A552		CLR.L	(A6)+ 
L6A554		CLR.L	-(A5) 
L6A556		CLR.L	(A6)+ 
L6A558		CLR.L	-(A5) 
L6A55A		CLR.L	(A6)+ 
L6A55C		CLR.L	-(A5) 
L6A55E		DBF	D5,L6A54E 
L6A562		MOVE.W	#$25,-(A7)		WAIT FOR VSYNC 
L6A566		TRAP	#$E 
L6A568		ADDQ.L	#$2,A7 
L6A56A		DBF	D4,L6A54C 
L6A56E		MOVEQ	#$78,D7 
L6A570		MOVE.W	#$25,-(A7) 		WAIT FOR VSYNC
L6A574		TRAP	#$E 
L6A576		ADDQ.L	#$2,A7 
L6A578		DBF	D7,L6A570 
L6A57C		LEA	$5D218,A6 
L6A582		LEA	$29E0(A6),A5 
L6A586		LEA	L184E0,A2 		LOCATION OF 'MENTA'
L6A58C		MOVEQ	#$21,D6 
L6A58E		MOVEQ	#$6,D0 
L6A590		MOVE.L	(A2),(A5) 
L6A592		MOVE.L	(A2)+,(A6) 
L6A594		MOVE.W	(A2),$4(A5) 
L6A598		MOVE.W	(A2)+,$4(A6) 
L6A59C		MOVE.L	(A2),$8(A5) 
L6A5A0		MOVE.L	(A2)+,$8(A6) 
L6A5A4		MOVE.W	(A2),$C(A5) 
L6A5A8		MOVE.W	(A2)+,$C(A6) 
L6A5AC		LEA	$10(A5),A5 
L6A5B0		LEA	$10(A6),A6 
L6A5B4		DBF	D0,L6A590 
L6A5B8		LEA	$FFFFFEF0(A5),A5 
L6A5BC		LEA	$30(A6),A6 
L6A5C0		MOVE.W	#$25,-(A7) 		WAIT FOR VSYNC
L6A5C4		TRAP	#$E 
L6A5C6		ADDQ.L	#$2,A7 
L6A5C8		MOVE.W	#$25,-(A7) 		WAIT FOR VSYNC
L6A5CC		TRAP	#$E 
L6A5CE		ADDQ.L	#$2,A7 
L6A5D0		DBF	D6,L6A58E 
*L6A5D4		MOVEQ	#$6,D0 
*L6A5D6		LEA	$10754,A0 
*L6A5DC		JSR	(A0) 
L6A5DE		MOVEQ	#$6D,D7 
L6A5E0		MOVE.W	#$25,-(A7) 		WAIT FOR VSYNC
L6A5E4		TRAP	#$E 
L6A5E6		ADDQ.L	#$2,A7 
L6A5E8		DBF	D7,L6A5E0 
L6A5EC		LEA	$5E758,A5 
L6A5F2		MOVEQ	#$21,D5 
L6A5F4		MOVEQ	#$6,D4 
L6A5F6		CLR.L	(A5)+ 
L6A5F8		CLR.L	(A5)+ 
L6A5FA		CLR.L	(A5)+ 
L6A5FC		CLR.L	(A5)+ 
L6A5FE		DBF	D4,L6A5F6 
L6A602		LEA	$30(A5),A5 
L6A606		DBF	D5,L6A5F4 
L6A60A		MOVE.W	#$25,-(A7) 		WAIT FOR VSYNC
L6A60E		TRAP	#$E 
L6A610		ADDQ.L	#$2,A7 
L6A612		LEA	$5D218,A6 
L6A618		LEA	L184E0,A2 		LOCATION OF 'MENTA'
L6A61E		MOVEQ	#$21,D6 
L6A620		MOVEQ	#$6,D0 
L6A622		MOVE.L	(A2)+,(A6) 
L6A624		MOVE.W	(A2)+,$4(A6) 
L6A628		MOVE.L	(A2)+,$8(A6) 
L6A62C		MOVE.W	(A2)+,$C(A6) 
L6A630		LEA	$10(A6),A6 
L6A634		DBF	D0,L6A622 
L6A638		LEA	$30(A6),A6 
L6A63C		DBF	D6,L6A620 
L6A640		MOVEQ	#$6,D0 
L6A642		CLR.L	(A6)+ 
L6A644		CLR.L	(A6)+ 
L6A646		CLR.L	(A6)+ 
L6A648		CLR.L	(A6)+ 
L6A64A		DBF	D0,L6A642 
L6A64E		MOVE.W	#$25,-(A7) 		WAIT FOR VSYNC
L6A652		TRAP	#$E 
L6A654		ADDQ.L	#$2,A7 
L6A656		SUBA.L	#$1650,A6 
L6A65C		CMPA.L	#$5B400,A6 
L6A662		BHI	L6A618 
L6A666		LEA	L1909E,A0 
L6A66C		MOVE.L	$70.W,(A0)+ 		SAVE VBL ROUTINES
L6A670		MOVE.L	$120.W,(A0)+ 		SAVE TIMER B ROUTINES
L6A674		MOVE.B	$FFFFFA07.W,(A0)+ 	SAVE MFP
L6A678		MOVE.B	$FFFFFA09.W,(A0)+ 
L6A67C		MOVE.B	$FFFFFA13.W,(A0)+ 
L6A680		MOVE.B	$FFFFFA1B.W,(A0)+ 
L6A684		MOVE.B	$FFFFFA21.W,(A0)+ 
L6A688		LEA	LB184,A0 
L6A68E		MOVE.L	$118.W,(A0) 		SAVE KEYBOAD VECTOR
L6A692		MOVE.L	#L6B17E,$118.W 		NEW KEYBOARD VECTOR
L6A69A		BCLR	#$5,$FFFFFA09.W 
L6A6A0		BCLR	#$4,$FFFFFA09.W 
L6A6A6		BSET	#$0,$FFFFFA07.W 
L6A6AC		BSET	#$0,$FFFFFA13.W		SET UP MFP 
L6A6B2		PEA	LC387 
L6A6B8		MOVE.W	#$9,-(A7)		PRINT LINE
L6A6BC		TRAP	#$1 
L6A6BE		ADDQ.L	#$6,A7 
L6A6C0		MOVE.W	#$0,D7 
L6A6C4		MOVE.W	D7,$FFFF825E.W 		CHANGE PALETTE REGISTER 16
L6A6C8		ADDI.W	#$888,D7 
L6A6CC		MOVE.W	#$25,-(A7) 		WAIT FOR VSYNC
L6A6D0		TRAP	#$E 
L6A6D2		ADDQ.L	#$2,A7 
L6A6D4		MOVE.W	#$25,-(A7) 		WAIT FOR VSYNC
L6A6D8		TRAP	#$E 
L6A6DA		ADDQ.L	#$2,A7 
L6A6DC		MOVE.W	#$25,-(A7) 		WAIT FOR VSYNC
L6A6E0		TRAP	#$E 
L6A6E2		ADDQ.L	#$2,A7 
L6A6E4		MOVE.W	D7,$FFFF825E.W 		CHANGE PALETTE REGISTER 16
L6A6E8		SUBI.W	#$777,D7 
L6A6EC		MOVE.W	#$25,-(A7) 		WAIT FOR VSYNC
L6A6F0		TRAP	#$E 
L6A6F2		ADDQ.L	#$2,A7 
L6A6F4		MOVE.W	#$25,-(A7) 		WAIT FOR VSYNC
L6A6F8		TRAP	#$E 
L6A6FA		ADDQ.L	#$2,A7 
L6A6FC		MOVE.W	#$25,-(A7) 		WAIT FOR VSYNC
L6A700		TRAP	#$E 
L6A702		ADDQ.L	#$2,A7 
L6A704		CMP.W	#$888,D7 		FADE IN
L6A708		BNE.S	L6A6C4 
L6A70A		MOVEQ	#$62,D7 		LOOP COUNTER (98)
L6A70C		MOVE.W	#$25,-(A7) 		WAIT FOR VSYNC
L6A710		TRAP	#$E 
L6A712		ADDQ.L	#$2,A7 
L6A714		DBF	D7,L6A70C 		KEEP WAITING....
***************************************************************************
* EVERYTHING WORKS ABOVE - BUT NOW THINGS START TO FUCK UP (SHIT,FUCK...) *
***************************************************************************
L6A718		LEA	$5E100,A0 
L6A71E		MOVE.W	#$13F,D7 		LOOP COUNTER (320)
L6A722		CLR.L	$1900(A0) 
L6A726		CLR.L	(A0)+ 
L6A728		DBF	D7,L6A722 

L6A72C		LEA	$5B418,A5 
L6A732		MOVEQ	#$31,D5 		LOOP COUNTER (50)
L6A734		MOVEQ	#$6,D4 			LOOP COUNTER (7)
L6A736		CLR.L	(A5)+ 
L6A738		CLR.L	(A5)+ 
L6A73A		CLR.L	(A5)+ 
L6A73C		CLR.L	(A5)+ 			CLEAR SCREEN
L6A73E		DBF	D4,L6A736 		(STRANGE WAY OF DOING IT)
L6A742		LEA	$30(A5),A5 
L6A746		DBF	D5,L6A734 

*L6A74A		MOVEQ	#$2,D0 			SET UP MUSIC
*L6A74C		LEA	$10754,A0 		
*L6A752		JSR	(A0) 			RUN MUSIC
L6A754		MOVE.L	#6AE26,$4D2.W 		NEW VBL ROUTINE
L6A75C		MOVE.L	#LB188,L1908A 		MOVE TEXT INTO TEXT POINTER
***************************************************************************
* START OF MAIN LOOP                                                      *
***************************************************************************
L6A766		MOVE.L	L1908A,A0 		GET TEXT POINTER
L6A76C		MOVEQ	#$0,D0 
L6A76E		MOVE.B	(A0)+,D0 		GET LETTER
L6A770		BEQ.S	L6A75C 			IF IT'S 00 THEN RESET TEXT
L6A772		MOVE.L	A0,L1908A		SET POINTER TO NEXT LETTER 
L6A778		CMP.B	#$20,D0 		IS IT A <SPACE> ?
L6A77C		BNE.S	L6A786 			NO
L6A77E		LEA	$1369C,A1		THE <SPACE> DATA ADDRESS 
L6A784		BRA.S	L6A794 
L6A786		SUBI.B	#$41,D0			SET OFFSET (A=0,B=1 ETC) 
L6A78A		MULU	#$180,D0 		HOW FAR INTO FONT DATA
L6A78E		LEA	L6C3D4(PC),A1 		THE FONT DATA
L6A792		ADDA.L	D0,A1 			A1 NOW HOLDS CORRECT ADDR
L6A794		NOP
L6A796		LEA	L190AC,A0 
L6A79C		LEA	L1926C,A2 
L6A7A2		LEA	$67498,A3 		SCREEN ADDR OF SCROLLER
L6A7A8		MOVEQ	#$1F,D0			LOOP COUNTER (32) 
L6A7AA		MOVE.B	$1(A3),(A3) 
L6A7AE		MOVE.B	(A1),$1(A3) 
L6A7B2		MOVE.B	$1(A1),(A2) 
L6A7B6		MOVE.B	$6(A1),$1(A2) 
L6A7BC		MOVE.B	$7(A1),$8(A2) 
L6A7C2		MOVE.W	(A1)+,(A0)+ 
L6A7C4		MOVE.B	$3(A3),$2(A3) 
L6A7CA		MOVE.B	(A1),$3(A3) 
L6A7CE		MOVE.B	$1(A1),$2(A2) 
L6A7D4		MOVE.B	$6(A1),$3(A2) 
L6A7DA		MOVE.B	$7(A1),$A(A2) 
L6A7E0		MOVE.W	(A1)+,(A0)+ 
L6A7E2		MOVE.B	$5(A3),$4(A3) 
L6A7E8		MOVE.B	(A1),$5(A3) 
L6A7EC		MOVE.B	$1(A1),$4(A2) 
L6A7F2		MOVE.B	$6(A1),$5(A2) 
L6A7F8		MOVE.B	$7(A1),$C(A2) 
L6A7FE		MOVE.W	(A1)+,(A0)+ 
L6A800		CLR.W	(A0)+ 
L6A802		MOVE.L	(A1)+,(A0)+ 
L6A804		MOVE.W	(A1)+,(A0)+ 
L6A806		LEA	$A0(A3),A3 		NEXT LINE OF SCREEN
L6A80A		LEA	$E(A2),A2 
L6A80E		DBF	D0,L6A7AA 		D0 32 TIMES...
L6A812		MOVEQ	#$4,D2 
***************************************************************************
* THE SCREEN SWOPPING ROUTINE -VERY QUICK ROUTINE                         *
***************************************************************************
L6A814		MOVE.L	L1908E,A4 
L6A81A		MOVE.L	L19092,A5 
L6A820		MOVE.L	A5,L1908E 
L6A826		MOVE.L	A5,$45E.W 		CHANGE SCREEN ADDRESS
L6A82A		MOVE.L	A4,L19092 
***************************************************************************
L6A830		MOVE.W	#$25,-(A7)		WAIT FOR VSYNC 
L6A834		TRAP	#$E 
L6A836		ADDQ.L	#$2,A7 

L6A838		MOVE.L	D2,-(A7) 
L6A83A		BSR	L6A9E6 			MOVING BACKGROUND
L6A83E		BSR	L6A94C 			MOVE SCROLLER
L6A842		BSR	L6AC2C 			BOTTOM BOARDER BARS
L6A846		BSR	L6B0D2 			SPINNING 'MENTA' SYMBOL
L6A84A		NOP
*L6A84C		MOVE.B	$FFFFFC02.W,D0 
*L6A850		CMP.B	#$39,D0 		HAS <SPACE> BEEN PRESSED ?
*L6A854		BEQ	L6A8D2 			YES
*L6A858		CMP.B	#$3A,D0 		HAS <3A BEEN PRESSED ?
*L6A85C		BLE.S	L6A87E 
*L6A85E		CMP.B	#$3D,D0 		HAS >3D BEEN PRESSED ?
*L6A862		BGE.S	L6A87E 
*L6A864		CMP.B	$1905C,D0 		IS THE MUSIC ALREADY PLAYING ?
*L6A86A		BEQ.S	L6A87E 
*L6A86C		MOVE.B	D0,$1905C 		CHANGE MUSIC POINTER
*L6A872		SUBI.B	#$3A,D0 
*L6A876		ANDI.W	#$FF,D0			SET NUMBER TO 1 OR 2 
*L6A87A		BSR	$70754 			RUN NEW MUSIC
L6A87E		MOVE.W	#$60FE,$A84A 
L6A886		MOVE.L	(A7)+,D2 
L6A888		DBF	D2,L6A814 
L6A88C		MOVE.L	#$66000,$1908E 		SCREEN ADDRESS
L6A896		MOVE.L	#$66000,$45E.W 		CHANGE SCREEN ADDRESS
L6A89E		MOVE.L	#$5B400,$19092 		SCREEN ADDRESS

L6A8A8		MOVE.W	#$25,-(A7) 		WAIT FOR VSYNC
L6A8AC		TRAP	#$E 
L6A8AE		ADDQ.L	#$2,A7 

L6A8B0		LEA	$66000,A5 		SCREEN ADDRESS
L6A8B6		BSR	L6A9E6 			MOVING BACKGROUND
L6A8BA		BSR	L6A94C 			MOVE SCROLLER
L6A8BE		BSR	L6AC2C 			BOTTOM BOARDER BARS
L6A8C2		BSR	L6B0D2 			SPINNING 'MENTA' SYMBOL
L6A8C6		MOVE.W	#$60FE,$A794 
L6A8CE		BRA	L6A766
***************************************************************************
* END OF MAIN PROGRAM LOOP - SO LOOP BACK TO START....                    *
***************************************************************************
L6A8D2		LEA	$B184,A0 
L6A8D8		MOVE.L	(A0),$118.W 
L6A8DC		LEA	$1909E,A0 
L6A8E2		MOVE.L	(A0)+,$70.W 
L6A8E6		MOVE.L	(A0)+,$120.W 
L6A8EA		MOVE.B	(A0)+,$FFFFFA07.W 
L6A8EE		MOVE.B	(A0)+,$FFFFFA09.W 
L6A8F2		MOVE.B	(A0)+,$FFFFFA13.W 
L6A8F6		MOVE.B	(A0)+,$FFFFFA1B.W 
L6A8FA		MOVE.B	(A0)+,$FFFFFA21.W 
L6A8FE		MOVE.B	#$8,$FFFFFC02.W 
L6A904		MOVEM.L	$1905E,D0-D7 
L6A90C		MOVEM.L	D0-D7,$FFFF8240.W 
L6A912		CLR.L	$4D2.W 
L6A916		CLR.L	$45E.W 
L6A91A		MOVE.L	$4,A0 
L6A920		JMP	(A0) 
L6A922		MOVE.L	$19096,-(A7) 
L6A928		MOVE.W	#$20,-(A7) 
L6A92C		TRAP	#$1 
L6A92E		ADDQ.L	#$6,A7 
L6A930		MOVE.W	#$0,-(A7) 
L6A934		MOVE.L	$19086,A0 
L6A93A		PEA	(A0) 
L6A93C		PEA	(A0) 
L6A93E		MOVE.W	#$5,-(A7) 
L6A942		TRAP	#$E 
L6A944		LEA	$C(A7),A7 
L6A948		CLR.W	-(A7) 
L6A94A		TRAP	#$1 
L6A94C		LEA	$190AC,A1 
L6A952		MOVE.L	$1908E,A0 
L6A958		CMPA.L	#$66000,A0 
L6A95E		BNE.S	L6A966 
L6A960		LEA	$1926C,A1 
L6A966		LEA	$1400(A0),A0 
L6A96A		MOVEQ	#$1F,D0 
L6A96C		MOVEM.L	$8(A0),D1-D7/A3-A6 
L6A972		MOVEM.L	D1-D7/A3-A6,(A0) 
L6A976		MOVEM.L	D1-D7/A3-A6,$3C00(A0) 
L6A97C		MOVEM.L	$34(A0),D1-D7/A3-A6 
L6A982		MOVEM.L	D1-D7/A3-A6,$2C(A0) 
L6A988		MOVEM.L	D1-D7/A3-A6,$3C2C(A0) 
L6A98E		MOVEM.L	$60(A0),D1-D7/A3-A6 
L6A994		MOVEM.L	D1-D7/A3-A6,$58(A0) 
L6A99A		MOVEM.L	D1-D7/A3-A6,$3C58(A0) 
L6A9A0		MOVEM.L	$8C(A0),D1-D5 
L6A9A6		MOVEM.L	D1-D5,$84(A0) 
L6A9AC		MOVEM.L	D1-D5,$3C84(A0) 
L6A9B2		MOVE.L	(A1)+,D3 
L6A9B4		MOVE.L	D3,$98(A0) 
L6A9B8		MOVE.L	D3,$3C98(A0) 
L6A9BC		MOVE.L	(A1)+,D3 
L6A9BE		MOVE.L	D3,$9C(A0) 
L6A9C2		MOVE.L	D3,$3C9C(A0) 
L6A9C6		MOVE.L	(A1),$FFFFFFF8(A1) 
L6A9CA		CLR.L	(A1)+ 
L6A9CC		MOVE.W	(A1),$FFFFFFF8(A1) 
L6A9D0		CLR.W	(A1)+ 
L6A9D2		LEA	$A0(A0),A0 
L6A9D6		DBF	D0,L6A96C 
L6A9DA		RTS
***************************************************************************
* DRAW SMILEY BACKGROUND                                                  *
***************************************************************************

L6A9DC		MOVE.L	#L1397E,L1909A 		RESET POINTER
L6A9E6		MOVE.L	L1909A,A0 		POINTER TO MOVEMENT DATA
L6A9EC		MOVEQ	#$0,D0 			CLEAR D0
L6A9EE		MOVE.W	(A0)+,D0 		GET MOVEMENT
L6A9F0		BMI.S	L6A9DC			RESET DATA IF AT END
L6A9F2		MOVE.L	A0,L1909A 		SET POINTER TO NEXT WORD
L6A9F8		LEA	L1942C,A0 		SMILEY GRAPHICS
L6A9FE		ADDA.L	D0,A0 			GET CORRECT SMILEY GRAPHICS
L6AA00		LEA	$6(A5),A1 		GET 4TH BIT PLANE OF SCREEN
L6AA04		LEA	$190B2,A3 
L6AA0A		CMPA.L	#$66000,A5 		IS IT SCREEN 2 ?
L6AA10		BNE.S	L6AA18 			NO
L6AA12		LEA	$19272,A3 
L6AA18		MOVE.L	L1907E,A4 		POINTER TO SMILEY SPIN DATA
L6AA1E		CMPI.B	#$FF,(A4) 		IS IT THE END ?
L6AA22		BNE.S	L6AA30 			NO
L6AA24		MOVE.L	#L14C7A,L1907E 		RESET SPIN DATA
L6AA2E		BRA.S	L6AA18 			AND BRANCH BACK...
L6AA30		ADDI.L	#$40,L1907E		ADD 64 
L6AA3A		DIVU	#$FC,D0 		DIVIDE BY 252
L6AA3E		SWAP	D0 			SWAP THE REGISTER HALVES
L6AA40		MOVE.W	D0,D1 
L6AA42		LSR.W	#$2,D0 
L6AA44		CMPA.L	#$151C6,A4 
L6AA4A		BCS	L6AC20 
L6AA4E		CMPA.L	#$15B86,A4 
L6AA54		BGE	L6AC20 
L6AA58		MOVE.W	#$650,LAE48 		CHANGE SMILEY COLOUR
L6AA60		ADDA.W	D0,A4 
L6AA62		MOVEQ	#$1F,D0 		LOOP COUNTER (32)

L6AA64		MOVEQ	#$0,D3 			CLEAR D3
L6AA66		MOVE.B	(A4)+,D3 
L6AA68		CMP.B	#$1,D3 
L6AA6C		BNE.S	L6AA74 
L6AA6E		MOVEQ	#$0,D2 			CLEAR D2
L6AA70		MOVEQ	#$0,D3 			CLEAR D3
L6AA72		BRA.S	L6AA84 			DRAW NOTHING FOR SMILEY GFX
L6AA74		SUB.W	D1,D3 
L6AA76		BPL.S	L6AA7C 
L6AA78		ADDI.W	#$80,D3 
L6AA7C		LEA	$0(A0,D3.W),A5 		GET LINE TO DRAW OF SMILEY GFX
L6AA80		MOVE.W	(A5)+,D2		GET FIRST WORD OF SMILEY 
L6AA82		MOVE.W	(A5)+,D3 		GET SECOND WORD OF SMILEY
L6AA84		MOVE.W	D2,$0(A1) 		FIRST ROW
L6AA88		MOVE.W	D2,$1408(A1) 		32 LINES DOWN
L6AA8C		MOVE.W	D2,$2800(A1) 		64 LINES DOWN
L6AA90		MOVE.W	D2,$3C00(A1) 		96 LINES DOWN
L6AA94		MOVE.W	D2,$6400(A1) 		128 LINES DOWN
L6AA98		MOVE.W	D3,$8(A1) 		SECOND WORD FOR ABOVE ADDR
L6AA9C		MOVE.W	D3,$1410(A1) 
L6AAA0		MOVE.W	D3,$2808(A1) 
L6AAA4		MOVE.W	D3,$3C08(A1) 
L6AAA8		MOVE.W	D3,$6408(A1) 
L6AAAC		MOVE.W	D2,$10(A1) 		SECOND COLUMN, AS ABOVE
L6AAB0		MOVE.W	D2,$1418(A1) 
L6AAB4		MOVE.W	D2,$2810(A1) 
L6AAB8		MOVE.W	D2,$3C10(A1) 
L6AABC		MOVE.W	D2,$6410(A1) 
L6AAC0		MOVE.W	D3,$18(A1) 		SECOND COLUMN, SECOND WORD
L6AAC4		MOVE.W	D3,$1420(A1) 
L6AAC8		MOVE.W	D3,$2818(A1) 
L6AACC		MOVE.W	D3,$3C18(A1) 
L6AAD0		MOVE.W	D3,$6418(A1) 
L6AAD4		MOVE.W	D2,$20(A1) 		THIRD COLUMN, AS ABOVE
L6AAD8		MOVE.W	D2,$1428(A1) 
L6AADC		MOVE.W	D2,$2820(A1) 
L6AAE0		MOVE.W	D2,$3C20(A1) 
L6AAE4		MOVE.W	D2,$6420(A1) 
L6AAE8		MOVE.W	D3,$28(A1) 		THIRD COLUMN, SECOND WORD
L6AAEC		MOVE.W	D3,$1430(A1) 
L6AAF0		MOVE.W	D3,$2828(A1) 
L6AAF4		MOVE.W	D3,$3C28(A1) 
L6AAF8		MOVE.W	D3,$6428(A1) 
L6AAFC		MOVE.W	D2,$30(A1) 		FOURTH COLUMN, AS ABOVE
L6AB00		MOVE.W	D2,$1438(A1) 
L6AB04		MOVE.W	D2,$2830(A1) 
L6AB08		MOVE.W	D2,$3C30(A1) 
L6AB0C		MOVE.W	D2,$6430(A1) 
L6AB10		MOVE.W	D3,$38(A1) 		FOURTH COLUMN, SECOND WORD
L6AB14		MOVE.W	D3,$1440(A1) 
L6AB18		MOVE.W	D3,$2838(A1) 
L6AB1C		MOVE.W	D3,$3C38(A1) 
L6AB20		MOVE.W	D3,$6438(A1) 
L6AB24		MOVE.W	D2,$40(A1) 		FIFTH COLUMN, AS ABOVE
L6AB28		MOVE.W	D2,$1448(A1) 	
L6AB2C		MOVE.W	D2,$2840(A1) 
L6AB30		MOVE.W	D2,$3C40(A1) 
L6AB34		MOVE.W	D2,$6440(A1) 
L6AB38		MOVE.W	D3,$48(A1) 		FIFTH COLUMN, SECOND WORD
L6AB3C		MOVE.W	D3,$1450(A1) 
L6AB40		MOVE.W	D3,$2848(A1) 
L6AB44		MOVE.W	D3,$3C48(A1) 
L6AB48		MOVE.W	D3,$6448(A1) 
L6AB4C		MOVE.W	D2,$50(A1) 		SIXTH COLUMN, AS ABOVE
L6AB50		MOVE.W	D2,$1458(A1) 	
L6AB54		MOVE.W	D2,$2850(A1) 
L6AB58		MOVE.W	D2,$3C50(A1) 
L6AB5C		MOVE.W	D2,$6450(A1) 
L6AB60		MOVE.W	D3,$58(A1) 		SIXTH COLUMN, SECOND WORD
L6AB64		MOVE.W	D3,$1460(A1) 
L6AB68		MOVE.W	D3,$2858(A1) 
L6AB6C		MOVE.W	D3,$3C58(A1) 
L6AB70		MOVE.W	D3,$6458(A1) 
L6AB74		MOVE.W	D2,$60(A1) 		SEVENTH COLUMN, AS ABOVE
L6AB78		MOVE.W	D2,$1468(A1) 
L6AB7C		MOVE.W	D2,$2860(A1) 
L6AB80		MOVE.W	D2,$3C60(A1) 
L6AB84		MOVE.W	D2,$6460(A1) 
L6AB88		MOVE.W	D3,$68(A1) 		SEVENTH COLUMN, SECOND WORD
L6AB8C		MOVE.W	D3,$1470(A1) 
L6AB90		MOVE.W	D3,$2868(A1) 
L6AB94		MOVE.W	D3,$3C68(A1) 
L6AB98		MOVE.W	D3,$6468(A1) 		
L6AB9C		MOVE.W	D2,$70(A1) 		COLUMN 8
L6ABA0		MOVE.W	D2,$1478(A1) 
L6ABA4		MOVE.W	D2,$2870(A1) 
L6ABA8		MOVE.W	D2,$3C70(A1) 
L6ABAC		MOVE.W	D2,$6470(A1) 
L6ABB0		MOVE.W	D3,$78(A1) 		COLUMN 8 - SECOND WORD
L6ABB4		MOVE.W	D3,$1480(A1) 
L6ABB8		MOVE.W	D3,$2878(A1) 
L6ABBC		MOVE.W	D3,$3C78(A1) 
L6ABC0		MOVE.W	D3,$6478(A1) 
L6ABC4		MOVE.W	D2,$80(A1) 		COLUMN 9
L6ABC8		MOVE.W	D2,$1488(A1) 
L6ABCC		MOVE.W	D2,$2880(A1) 
L6ABD0		MOVE.W	D2,$3C80(A1) 
L6ABD4		MOVE.W	D2,$6480(A1) 
L6ABD8		MOVE.W	D3,$88(A1) 		COLUMN 9 - SECOND WORD
L6ABDC		MOVE.W	D3,$1490(A1) 
L6ABE0		MOVE.W	D3,$2888(A1) 
L6ABE4		MOVE.W	D3,$3C88(A1) 
L6ABE8		MOVE.W	D3,$6488(A1) 
L6ABEC		MOVE.W	D2,$90(A1) 		COLUMN 10
L6ABF0		MOVE.W	D2,$1498(A1) 
L6ABF4		MOVE.W	D2,$2890(A1) 
L6ABF8		MOVE.W	D2,$3C90(A1) 
L6ABFC		MOVE.W	D2,$6490(A1) 	
L6AC00		MOVE.W	D3,$98(A1) 		COLUMN 10 - SECOND WORD
L6AC04		MOVE.W	D3,(A3) 
L6AC06		MOVE.W	D3,$2898(A1) 
L6AC0A		MOVE.W	D3,$3C98(A1) 
L6AC0E		MOVE.W	D3,$6498(A1) 
L6AC12		LEA	$E(A3),A3 		NEXT LINE OF SMILEY GFX
L6AC16		LEA	$A0(A1),A1 		NEXT LINE OF EACH SMILEY
L6AC1A		DBF	D0,L6AA64		DO ALL 32 LINES 
L6AC1E		RTS
L6AC20		MOVE.W	#$770,LAE48 
L6AC28		BRA	L6AA60 
***************************************************************************
* BOTTOM BOARDER ROUTINE - DRAWS MUSIC BARS                               *
***************************************************************************
L6AC2C		MOVEM.L	D0-D7/A0-A6,-(A7) 
L6AC30		LEA	$1075C,A0 
L6AC36		JSR	(A0) 
L6AC38		MOVEQ	#$2,D6 
L6AC3A		MOVE.L	$1908E,A6 		SCREEN ADDRESS
L6AC40		LEA	$79E8(A6),A6 		BOTTOM BOARDER
L6AC44		LEA	(A6),A4 		
L6AC46		LEA	(A4),A6 
L6AC48		LEA	$8C(A6),A5 
L6AC4C		MOVE.L	D6,D0 
L6AC4E		ADDQ.B	#$8,D0 
L6AC50		MOVE.B	D0,$FF8800 		GET VOL FOR CHANNEL C
L6AC56		MOVE.B	$FF8800,D0 
L6AC5C		MOVE.L	D0,D1 
L6AC5E		NEG.W	D0 
L6AC60		ADDI.W	#$12,D0 
L6AC64		BTST	#$0,D0 
L6AC68		BNE	L6AD0A 
L6AC6C		LSR.B	#$1,D0 
L6AC6E		SUBQ.B	#$1,D0 
L6AC70		CLR.L	$A0(A6) 
L6AC74		CLR.L	$140(A6) 
L6AC78		CLR.L	$1E0(A6) 
L6AC7C		CLR.L	$280(A6) 
L6AC80		CLR.L	$320(A6) 
L6AC84		CLR.L	$3C0(A6) 
L6AC88		CLR.L	$460(A6) 
L6AC8C		CLR.L	$500(A6) 
L6AC90		CLR.L	$FFFFFF60(A6) 
L6AC94		CLR.L	(A6)+ 
L6AC96		CLR.L	(A6)+ 
L6AC98		CLR.L	-(A5) 
L6AC9A		CLR.L	$A0(A5) 
L6AC9E		CLR.L	$140(A5) 
L6ACA2		CLR.L	$1E0(A5) 
L6ACA6		CLR.L	$280(A5) 
L6ACAA		CLR.L	$320(A5) 
L6ACAE		CLR.L	$3C0(A5) 
L6ACB2		CLR.L	$460(A5) 
L6ACB6		CLR.L	$500(A5) 
L6ACBA		CLR.L	$FFFFFF60(A5) 
L6ACBE		CLR.L	-(A5) 
L6ACC0		DBF	D0,L6AC70 
L6ACC4		TST.B	D1 
L6ACC6		BEQ.S	L6ACFC 
L6ACC8		SUBQ.B	#$1,D1 
L6ACCA		MOVE.L	#$FFFF,D0 
L6ACD0		MOVE.L	D0,$A0(A6) 
L6ACD4		MOVE.L	D0,$140(A6) 
L6ACD8		MOVE.L	D0,$1E0(A6) 
L6ACDC		MOVE.L	D0,$280(A6) 
L6ACE0		MOVE.L	D0,$320(A6) 
L6ACE4		MOVE.L	D0,$3C0(A6) 
L6ACE8		MOVE.L	D0,$460(A6) 
L6ACEC		MOVE.L	D0,$500(A6) 
L6ACF0		MOVE.L	D0,$FFFFFF60(A6) 
L6ACF4		MOVE.L	D0,(A6)+ 
L6ACF6		CLR.L	(A6)+ 
L6ACF8		DBF	D1,L6ACD0 
L6ACFC		LEA	$780(A4),A4 
L6AD00		DBF	D6,L6AC46 
L6AD04		MOVEM.L	(A7)+,D0-D7/A0-A6 
L6AD08		RTS
L6AD0A		SUBQ.B	#$3,D0 
L6AD0C		LSR.B	#$1,D0 
L6AD0E		CLR.L	$A0(A6) 
L6AD12		CLR.L	$140(A6) 
L6AD16		CLR.L	$1E0(A6) 
L6AD1A		CLR.L	$280(A6) 
L6AD1E		CLR.L	$320(A6) 
L6AD22		CLR.L	$3C0(A6) 
L6AD26		CLR.L	$460(A6) 
L6AD2A		CLR.L	$500(A6) 
L6AD2E		CLR.L	$FFFFFF60(A6) 
L6AD32		CLR.L	(A6)+ 
L6AD34		CLR.L	(A6)+ 
L6AD36		CLR.L	-(A5) 
L6AD38		CLR.L	$A0(A5) 
L6AD3C		CLR.L	$140(A5) 
L6AD40		CLR.L	$1E0(A5) 
L6AD44		CLR.L	$280(A5) 
L6AD48		CLR.L	$320(A5) 
L6AD4C		CLR.L	$3C0(A5) 
L6AD50		CLR.L	$460(A5) 
L6AD54		CLR.L	$500(A5) 
L6AD58		CLR.L	$FFFFFF60(A5) 
L6AD5C		CLR.L	-(A5) 
L6AD5E		DBF	D0,L6AD0E 
L6AD62		CLR.W	(A6)+ 
L6AD64		MOVE.W	#$FF,$A0(A6) 
L6AD6A		MOVE.W	#$FF,$140(A6) 
L6AD70		MOVE.W	#$FF,$1E0(A6) 
L6AD76		MOVE.W	#$FF,$280(A6) 
L6AD7C		MOVE.W	#$FF,$320(A6) 
L6AD82		MOVE.W	#$FF,$3C0(A6) 
L6AD88		MOVE.W	#$FF,$460(A6) 
L6AD8E		MOVE.W	#$FF,$500(A6) 
L6AD94		MOVE.W	#$FF,$FFFFFF60(A6) 
L6AD9A		MOVE.W	#$FF,(A6)+ 
L6AD9E		CLR.L	(A6)+ 
L6ADA0		MOVE.W	#$FF00,-(A5) 
L6ADA4		MOVE.W	#$FF00,$140(A5) 
L6ADAA		MOVE.W	#$FF00,$1E0(A5) 
L6ADB0		MOVE.W	#$FF00,$280(A5) 
L6ADB6		MOVE.W	#$FF00,$320(A5) 
L6ADBC		MOVE.W	#$FF00,$3C0(A5) 
L6ADC2		MOVE.W	#$FF00,$460(A5) 
L6ADC8		MOVE.W	#$FF00,$500(A5) 
L6ADCE		MOVE.W	#$FF00,$A0(A5) 
L6ADD4		MOVE.W	#$FF00,$FFFFFF60(A5) 
L6ADDA		SUBQ.B	#$2,D1 
L6ADDC		BMI	L6ACFC 
L6ADE0		MOVE.W	#$FFFF,D0 
L6ADE4		MOVE.L	D0,$A0(A6) 
L6ADE8		MOVE.L	D0,$140(A6) 
L6ADEC		MOVE.L	D0,$1E0(A6) 
L6ADF0		MOVE.L	D0,$280(A6) 
L6ADF4		MOVE.L	D0,$320(A6) 
L6ADF8		MOVE.L	D0,$3C0(A6) 
L6ADFC		MOVE.L	D0,$460(A6) 
L6AE00		MOVE.L	D0,$500(A6) 
L6AE04		MOVE.L	D0,$FFFFFF60(A6) 
L6AE08		MOVE.L	D0,(A6)+ 
L6AE0A		CLR.L	(A6)+ 
L6AE0C		DBF	D1,L6ADE4 
L6AE10		BRA	L6ACFC 
***************************************************************************
* FIRST VBL ROUTINE - DURING INTRO SEQUENCE - JUST PLAYS MUSIC            *
***************************************************************************
L6AE14		MOVEM.L	D0-D7/A0-A6,-(A7) 
*L6AE18		LEA	$1075C,A0 
*L6AE1E		JSR	(A0) 
L6AE20		MOVEM.L	(A7)+,D0-D7/A0-A6 
L6AE24		RTS
***************************************************************************
* SECOND VBL ROUTINE - SETS UP PALETTE AND RUNS TIMER B ROUTINE           *
***************************************************************************
L6AE26		MOVE.L	#$113,$FFFF8240.W 	SET UP PALETTE
L6AE2E		MOVE.L	#$2240335,$FFFF8244.W 
L6AE36		MOVE.L	#$4460557,$FFFF8248.W 
L6AE3E		MOVE.L	#$6670777,$FFFF824C.W 
L6AE46		MOVE.L	#$6500113,$FFFF8250.W 
L6AE4E		MOVE.L	#$2240335,$FFFF8254.W 
L6AE56		MOVE.L	#$4460557,$FFFF8258.W 
L6AE5E		MOVE.L	#$6670777,$FFFF825C.W 
L6AE66		CLR.B	$FFFFFA1B.W 		STOP COUNT
L6AE6A		MOVE.B	#$48,$FFFFFA21.W 	WAIT 72 SCAN LINES
L6AE70		MOVE.L	#L6AE80,$120.W 		NEW TIMER B ROUTINE
L6AE78		MOVE.B	#$8,$FFFFFA1B.W 	START COUNT
L6AE7E		RTS
***************************************************************************
* FIRST TIMER B ROUTINE - SETS UP PALETTE                                 *
***************************************************************************
L6AE80		CLR.B	$FFFFFA1B.W 		STOP COUNT
L6AE84		MOVE.W	#$200,$FFFF8242.W 	SET UP PALETTE
L6AE8A		MOVE.L	#$3100421,$FFFF8244.W 
L6AE92		MOVE.L	#$5320643,$FFFF8248.W 
L6AE9A		MOVE.L	#$7540980,$FFFF824C.W 
L6AEA2		MOVE.W	#$200,$FFFF8252.W 
L6AEA8		MOVE.L	#$3100421,$FFFF8254.W 
L6AEB0		MOVE.L	#$5320643,$FFFF8258.W 
L6AEB8		MOVE.L	#$7540310,$FFFF825C.W 
L6AEC0		MOVE.B	#$32,$FFFFFA21.W 	WAIT 50 SCAN LINES
L6AEC6		MOVE.L	#L6AEDC,$120.W 		NEW TIMER B ROUTINE
L6AECE		MOVE.B	#$8,$FFFFFA1B.W 	START COUNT
L6AED4		BCLR	#$0,$FFFFFA0F.W 	END OF INTERRUPT
L6AEDA		RTE
***************************************************************************
* SECOND TIMER B ROUTINE - SETS UP PALETTE                                *
***************************************************************************
L6AEDC		CLR.B	$FFFFFA1B.W 		STOP COUNT
L6AEE0		MOVE.W	#$203,$FFFF8242.W 	SET UP PALETTE
L6AEE6		MOVE.L	#$3140425,$FFFF8244.W 
L6AEEE		MOVE.L	#$5360647,$FFFF8248.W 
L6AEF6		MOVE.L	#$7570767,$FFFF824C.W 
L6AEFE		MOVE.W	#$203,$FFFF8252.W 
L6AF04		MOVE.L	#$3140425,$FFFF8254.W 
L6AF0C		MOVE.L	#$5360647,$FFFF8258.W 
L6AF14		MOVE.L	#$7570767,$FFFF825C.W 
L6AF1C		MOVE.B	#$48,$FFFFFA21.W 	WAIT 72 SCAN LINES
L6AF22		MOVE.L	#$13670,$140.W 		????????????
L6AF2A		MOVE.L	#L6AF40,$120.W 		NEW TIMER B ROUTINE
L6AF32		MOVE.B	#$8,$FFFFFA1B.W 	START COUNT
L6AF38		BCLR	#$0,$FFFFFA0F.W 	END OF INTERRUPT
L6AF3E		RTE
***************************************************************************
* THIRD TIMER B ROUTINE
***************************************************************************
L6AF40		CLR.B	$FFFFFA1B.W 		STOP COUNT
L6AF44		MOVE.L	A0,-(A7) 
L6AF46		MOVE.L	$140.W,A0 
L6AF4A		MOVE.W	(A0)+,$FFFF8240.W 	SET UP PALETTE
L6AF4E		MOVE.W	$14(A0),$FFFF8244.W 
L6AF54		MOVE.L	A0,$140.W 
L6AF58		MOVE.B	#$1,$FFFFFA21.W 	WAIT 1 SCAN LINE
L6AF5E		CMPI.W	#$EE,(A0) 
L6AF62		BEQ.S	L6AF74 
L6AF64		MOVE.B	#$8,$FFFFFA1B.W 	START COUNT
L6AF6A		MOVE.L	(A7)+,A0 
L6AF6C		BCLR	#$0,$FFFFFA0F.W 	END OF INTERRUPT
L6AF72		RTE
L6AF74		MOVE.L	#$AF96,$120.W 
L6AF7C		ADDQ.L	#$2,$140.W 
L6AF80		MOVE.B	#$1,$FFFFFA21.W 
L6AF86		MOVE.B	#$8,$FFFFFA1B.W 
L6AF8C		MOVE.L	(A7)+,A0 
L6AF8E		BCLR	#$0,$FFFFFA0F.W 
L6AF94		RTE
L6AF96		BCLR	#$1,$FFFF820A.W 
L6AF9C		CLR.B	$FFFFFA1B.W 
L6AFA0		NOP
L6AFA2		BSET	#$1,$FFFF820A.W 
L6AFA8		MOVE.W	#$4E71,$A794 
L6AFB0		MOVE.W	#$4E71,$A84A 
L6AFB8		MOVE.W	#$EE,$FFFF8240.W 
L6AFBE		MOVE.W	#$E,$FFFF8244.W 
L6AFC4		MOVE.B	#$1,$FFFFFA21.W 
L6AFCA		MOVE.L	#$AFE0,$120.W 
L6AFD2		MOVE.B	#$8,$FFFFFA1B.W 
L6AFD8		BCLR	#$0,$FFFFFA0F.W 
L6AFDE		RTE
L6AFE0		MOVE.L	A0,-(A7) 
L6AFE2		MOVE.L	$140.W,A0 
L6AFE6		MOVE.W	(A0)+,$FFFF8240.W 
L6AFEA		MOVE.W	$14(A0),$FFFF8244.W 
L6AFF0		MOVE.L	A0,$140.W 
L6AFF4		CMPI.W	#$2,(A0) 
L6AFF8		BEQ.S	L6B004 
L6AFFA		MOVE.L	(A7)+,A0 
L6AFFC		BCLR	#$0,$FFFFFA0F.W 
L6B002		RTE
L6B004		MOVE.L	#$B030,$120.W 
L6B00C		MOVE.L	#$13670,$140.W 
L6B014		MOVE.B	#$0,$FFFFFA1B.W 
L6B01A		MOVE.B	#$2,$FFFFFA21.W 
L6B020		MOVE.B	#$8,$FFFFFA1B.W 
L6B026		MOVE.L	(A7)+,A0 
L6B028		BCLR	#$0,$FFFFFA0F.W 
L6B02E		RTE
L6B030		CLR.B	$FFFFFA1B.W 
L6B034		MOVE.L	A0,-(A7) 
L6B036		MOVE.L	$140.W,A0 
L6B03A		MOVE.W	(A0)+,$FFFF8240.W 
L6B03E		MOVE.W	$14(A0),$FFFF8244.W 
L6B044		MOVE.L	A0,$140.W 
L6B048		MOVE.B	#$1,$FFFFFA21.W 
L6B04E		CMPI.W	#$2,(A0) 
L6B052		BEQ.S	L6B064 
L6B054		MOVE.B	#$8,$FFFFFA1B.W 
L6B05A		MOVE.L	(A7)+,A0 
L6B05C		BCLR	#$0,$FFFFFA0F.W 
L6B062		RTE
L6B064		MOVE.L	#$B08A,$120.W 
L6B06C		MOVE.L	#$13670,$140.W 
L6B074		MOVE.B	#$2,$FFFFFA21.W 
L6B07A		MOVE.B	#$8,$FFFFFA1B.W 
L6B080		MOVE.L	(A7)+,A0 
L6B082		BCLR	#$0,$FFFFFA0F.W 
L6B088		RTE
L6B08A		CLR.B	$FFFFFA1B.W 
L6B08E		MOVE.L	A0,-(A7) 
L6B090		MOVE.L	$140.W,A0 
L6B094		MOVE.W	(A0)+,$FFFF8240.W 
L6B098		MOVE.W	$14(A0),$FFFF8244.W 
L6B09E		MOVE.L	A0,$140.W 
L6B0A2		MOVE.B	#$1,$FFFFFA21.W 
L6B0A8		CMPI.W	#$2,(A0) 
L6B0AC		BEQ.S	L6B0BE 
L6B0AE		MOVE.B	#$8,$FFFFFA1B.W 
L6B0B4		MOVE.L	(A7)+,A0 
L6B0B6		BCLR	#$0,$FFFFFA0F.W 
L6B0BC		RTE
L6B0BE		MOVE.L	(A7)+,A0 
L6B0C0		BCLR	#$0,$FFFFFA0F.W 
L6B0C6		RTE
L6B0C8		MOVE.L	#$13AC2,$19082 
L6B0D2		MOVE.L	$19082,A0 
L6B0D8		TST.W	(A0) 
L6B0DA		BMI.S	L6B0C8 
L6B0DC		MOVE.W	(A0)+,D0 
L6B0DE		MOVE.L	A0,$19082 
L6B0E4		LEA	$15FFC,A0 
L6B0EA		ADDA.W	D0,A0 
L6B0EC		MOVE.L	$1908E,A1 
L6B0F2		LEA	$3178(A1),A1 
L6B0F6		MOVEQ	#$21,D0 
L6B0F8		MOVEQ	#$0,D1 
L6B0FA		MOVE.W	(A0)+,D1 
L6B0FC		LEA	$184E0,A2 
L6B102		ADDA.L	D1,A2 
L6B104		MOVE.L	(A2)+,$0(A1) 
L6B108		MOVE.W	(A2)+,$4(A1) 
L6B10C		MOVE.L	(A2)+,$8(A1) 
L6B110		MOVE.W	(A2)+,$C(A1) 
L6B114		MOVE.L	(A2)+,$10(A1) 
L6B118		MOVE.W	(A2)+,$14(A1) 
L6B11C		MOVE.L	(A2)+,$18(A1) 
L6B120		MOVE.W	(A2)+,$1C(A1) 
L6B124		MOVE.L	(A2)+,$20(A1) 
L6B128		MOVE.W	(A2)+,$24(A1) 
L6B12C		MOVE.L	(A2)+,$28(A1) 
L6B130		MOVE.W	(A2)+,$2C(A1) 
L6B134		MOVE.L	(A2)+,$30(A1) 
L6B138		MOVE.W	(A2)+,$34(A1) 
L6B13C		MOVE.L	(A2)+,$38(A1) 
L6B140		MOVE.W	(A2)+,$3C(A1) 
L6B144		MOVE.L	(A2)+,$40(A1) 
L6B148		MOVE.W	(A2)+,$44(A1) 
L6B14C		MOVE.L	(A2)+,$48(A1) 
L6B150		MOVE.W	(A2)+,$4C(A1) 
L6B154		MOVE.L	(A2)+,$50(A1) 
L6B158		MOVE.W	(A2)+,$54(A1) 
L6B15C		MOVE.L	(A2)+,$58(A1) 
L6B160		MOVE.W	(A2)+,$5C(A1) 
L6B164		MOVE.L	(A2)+,$60(A1) 
L6B168		MOVE.W	(A2)+,$64(A1) 
L6B16C		MOVE.L	(A2)+,$68(A1) 
L6B170		MOVE.W	(A2)+,$6C(A1) 
L6B174		LEA	$A0(A1),A1 
L6B178		DBF	D0,L6B0FA 
L6B17C		RTS
L6B17E		MOVE.W	#$2500,SR 
L6B182		JMP	$FC281C 

* THE DREADED DATA SECTION (FUCK I HATE THIS BIT !!!!)

L19096	DC.L	0			SUPERVISOR
L19086	DC.L	0			OLD SCREEN ADDRESS
L1905E	DS.W	16			OLD PALETTE
L1369C	DC.W	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
*	DC.W	$000,$113,$224,$335,$446,$557,$667,$304
*	DC.W	$000,$000,$000,$000,$000,$000,$000,$000		NEW PALETTE
L1908E	DC.L	0			SCREEN 1 ADDRESS
L19092	DC.L	0			SCREEN 2 ADDRESS
L17B9C	INCBIN	'SMILEY.DAT'		THE SMILEY GRAFIX
L1942C	DS.B	8588			SMILEY DESTINATION
L1909A	DC.L	0			SMILEY MOVEMENT DATA
L19082	DC.L	0
L1907E	DC.L	0			SPIN DATA POINTER
L1909E	DS.L	5			SAVE MFP ETC HERE
LB184	DC.L	0			SAVE KEYBOARD VECTOR
LC387	DC.B	$1B,$62,$0F,$1B,$59,$25,$32,'says',$1B
	DC.B	$59,$29,$2A,'HELLO STARFIGHTER...',$1B,$59
	DC.B	$2E,$21,'ARE YOU READY TO BE SCARED TO DEATH ?'
L1908A	DC.L	LB188			SCROLL_TEXT POINTER
L190AC	DS.B	448
L1926C	DS.B	448
LAE48	DC.W	0			SMILEY COLOUR
LB188	INCBIN	'S_TEXT.DAT'		THE SCROLL TEXT
L6C3D4	INCBIN	'FONT.DAT'
L184E0	INCBIN	'MENTA.DAT'
CLONE	INCBIN	'CLONE.DAT'
L184E02	EQU	CLONE+2244
L1369C	INCBIN	'S_MOVE1.DAT'
L1397E	INCBIN	'S_MOVE2.DAT'
L14C7A	INCBIN	'SPIN.DAT'