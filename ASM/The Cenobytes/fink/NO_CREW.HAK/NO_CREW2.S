***************************************************************************
* THE NO CREW DEMO RIPPED FROM THE CAREBEARS 'SO WHAT' DEMO BY -THE FINK- *
***************************************************************************
		CLR.L	-(SP)			SUPERVISOR MODE
		MOVE.W	#$20,-(SP)
		TRAP	#1
		ADDQ.L	#6,SP
		MOVE.L	D0,OLDSP
		
*L67FFC		SUBQ.W	#$1,A7 
*L67FFE		MOVE.L	D1,A0 
*L68000		MOVE.L	(A7),$8324 
*L68006		MOVE.L	A7,$8328 

L6800C		MOVEQ	#$1,D0 			SET UP MUSIC 1
L6800E		JSR	MUSIC

L68014		LEA	$2184C,A0 		CLEAR MOST OF THE ST'S 
L6801A		CLR.L	(A0)+ 			MEMORY BECAUSE OF THE
L6801C		CMPA.L	#$80000,A0 		SCREENS
L68022		BLT.S	L6801A 

L68024		LEA	L1F56C,A1 		HOLDS ADDRESSES OF ALL SCREENS
L6802A		MOVE.L	#$2184C,D0 		SCREEN 1
L68030		CLR.B	D0 
L68032		MOVE.L	D0,(A1)+ 	
L68034		ADDI.L	#$7D00,D0 		SCREEN 2	
L6803A		MOVE.L	D0,(A1)+ 
L6803C		ADDI.L	#$7D00,D0 		SCREEN 3
L68042		MOVE.L	D0,(A1)+ 
L68044		ADDI.L	#$7D00,D0 		SCREEN 4
L6804A		MOVE.L	D0,(A1)+ 
L6804C		ADDI.L	#$7D00,D0 		SCREEN 5
L68052		MOVE.L	D0,(A1)+ 
L68054		ADDI.L	#$7D00,D0 		SCREEN 6
L6805A		MOVE.L	D0,(A1)+ 
L6805C		ADDI.L	#$7D00,D0 		SCREEN 7
L68062		MOVE.L	D0,(A1)+ 
L68064		ADDI.L	#$7D00,D0 		SCREEN 8
L6806A		MOVE.L	D0,(A1) 
L6806C		MOVE.W	#$8,L893E 
L68074		LEA	L1F56C,A6		HOLDS ADRESSES OF 8 SCREENS 
L6807A		LEA	L1F56C,A0		HOLDS ADRESSED OF 8 SCREENS 
L68080		LEA	LBA0E,A1		MATRIX GFX 
L68086		MOVE.W	#$7,D0			LOOP COUNTER (8 FOR 8 SCREENS) 

L6808A		MOVE.L	(A0),A2 		GET SCREEN ADDRESS
L6808C		ADDA.L	#$2,A2 			GET 2nd BIT-PLANE
L68092		MOVE.W	#$9,D1 			LOOP COUNTER (10)
L68096		MOVE.W	#$13,D2			LOOP COUNTER (20) 
L6809A		MOVE.W	(A1),(A2) 
L6809C		MOVE.W	$2(A1),$A0(A2) 
L680A2		MOVE.W	$4(A1),$140(A2) 
L680A8		MOVE.W	$6(A1),$1E0(A2) 
L680AE		MOVE.W	$8(A1),$280(A2) 
L680B4		MOVE.W	$A(A1),$320(A2) 
L680BA		MOVE.W	$C(A1),$3C0(A2) 
L680C0		MOVE.W	$E(A1),$460(A2) 
L680C6		MOVE.W	$10(A1),$500(A2) 
L680CC		MOVE.W	$12(A1),$5A0(A2) 
L680D2		MOVE.W	$14(A1),$640(A2) 
L680D8		MOVE.W	$16(A1),$6E0(A2) 
L680DE		MOVE.W	$18(A1),$780(A2) 
L680E4		MOVE.W	$1A(A1),$820(A2) 
L680EA		MOVE.W	$1C(A1),$8C0(A2) 
L680F0		MOVE.W	$1E(A1),$960(A2) 	15 LINES DRAWN
L680F6		ADDA.L	#$8,A2 			NEXT 2nd BIT-PLANE
L680FC		DBF	D2,L6809A 
L68100		ADDA.L	#$960,A2 		15 LINES DOWN
L68106		DBF	D1,L68096 		DRAW 150 LINES OF GFX		
L6810A		ADDA.L	#$20,A1 		NEXT MATRIX GFX
L68110		MOVE.L	(A0)+,A3 		NEXT SCREEN ADDRESS

L68112		LEA	LBB0E,A4		'NO-CREW' LOGO (1 BIT-PLANE) 
L68118		MOVE.W	#$5B3,D3 		LOOP COUNTER (1460)
L6811C		MOVE.W	(A4)+,(A3)		COPY 1 BIT PLANE		 
L6811E		ADDA.L	#$8,A3 			SET UP TO FIRST BIT-PLANE
L68124		DBF	D3,L6811C 		COPY ALL OF GFX
L68128		DBF	D0,L6808A 		COPY GFX ON ALL 8 SCREENS

L6812C		MOVE.L	$20(A6),L893A 		GET FINAL SCREEN ADDRESS

L68134		MOVEM.L	L894E,D0-D5 
L6813C		MOVEM.L	D0-D5,$FFFF8240.W 	NEW PALETTE

L68142		MOVE.L	#$0,A4 
L68148		MOVE.L	#HORIDAT,HORIP		SET UP HORI POINTER
L68152		MOVE.L	#VERTDAT,VERTP 		SET UP VERT POINTER
*L6815C		MOVE.L	#L1BD4A,L8948 		SCROLLTEXT 1
*L68166		MOVE.W	#$5,$894C 
L6816E		LEA	L8966,A5 		PALETTE POINTER
L68174		MOVE.W	#$2700,SR 		DISABLE INTERRUPTS
L68178		MOVEM.L	$FFFFFA00.W,D0-D7 	SAVE OLD MFP REGS
L6817E		MOVEM.L	D0-D7,L8904 
L68186		MOVE.W	#$2300,SR 		ENABLE INTERRUPTS
L6818A		MOVE.L	$120,L8924 		SAVE TIMER B ROUTINES
L68194		MOVE.L	$70,L8928 		SAVE VBL ROUTINES

L6819E		MOVE.B	#$1,$FFFA07		SET UP MFP 
L681A6		CLR.B	$FFFA09 
L681AC		CLR.B	$FFFA15 
L681B2		BSET	#$0,$FFFA13 
L681BA		MOVE.B	#$8,$FFFA1B 		START COUNT
L681C2		MOVE.B	#$5,$FFFA21 		EVERY 5 LINES

L681CA		MOVE.L	#L688B6,$120 		NEW TIMER B
L681D4		MOVE.L	#L688CA,$70 		NEW VBL
*L681DE		MOVE.L	#L1A1EE,L88FC 		SCROLLTEXT 2
*L681E8		MOVE.W	#$4,$8934 
*L681F0		MOVE.L	#$B80,$887E 
***************************************************************************
* START OF MAIN PROGRAM LOOP......					  *
***************************************************************************
L681FA		CMPI.W	#1,L892C 
L68202		BNE.S	L681FA 			WAIT FOR VERTICAL BLANCK

L68204		CLR.W	$FFFF8240.W 		CLEAR BOARDER PAL
L68208		CLR.W	L892C 			CLEAR VBL FLAG (WHY..??)
L6820E		JSR	L6843C 			SHIFT 'NO_CREW' LOGO
*L68214		JSR	L6832C 
*L6821A		JSR	L686E6 
*L68220		MOVE.W	$894C,D1 
*L68226		DBF	D1,L68274 
*L6822A		MOVE.L	L8948,A0 		SCROLLTEXT POINTER 1
*L68230		CLR.L	D0 
*L68232		MOVE.B	(A0),D0 		GET LETTER
*L68234		SUBI.L	#$20,D0 		SO <SPACE> EQUALS ZERO
*L6823A		MULU	#$12C,D0 
*L6823E		LEA	$C69E,A4 
*L68244		ADDA.L	D0,A4 
*L68246		ADDI.L	#$1,L8948 		SET TO NEXT LETTER
*L68250		LEA	L1C5B2,A0 		END OF TEXT ADDRESS
*L68256		CMPA.L	L8948,A0 		IS IT THE END OF TEXT ?
*L6825C		BNE.S	L6826A 			NO, SO SKIP NEXT BIT...
*L6825E		LEA	L1BD4A,A0 
*L68264		MOVE.L	A0,L8948 		RESET POINTER
*L6826A		MOVE.W	#$5,D1 
*L6826E		JMP	L68280 

*L68274		CMP.W	#$0,D1 
*L68278		BNE.S	L68280 
*L6827A		LEA	$1F530,A4 

*L68280		MOVE.W	D1,$894C 
L68286		MOVE.L	(A6),L893A 		SET UP SCREEN POINTER
L6828C		MOVE.L	(A6),D1 
L6828E		LSR.L	#$8,D1 
L68290		MOVE.B	D1,$FFFF8203.W 
L68294		LSR.L	#$8,D1 
L68296		MOVE.B	D1,$FFFF8201.W 
L6829A		ADDA.L	#$4,A6 			POINT TO NEXT SCREEN ADDRESS
L682A0		SUBI.W	#$1,L893E 		NEXT SCREEN NUMBER
L682A8		BNE.S	L682B8 			IS IT THE LAST SCREEN ? YES SO RESET SCREEN POINTER...
L682AA		LEA	L1F56C,A6 		RESET SCREEN POINTER
L682B0		MOVE.W	#$8,L893E 		SET UP SCREEN NUMBER
L682B8		MOVE.B	$FFFFFC02.W,D0 		READ KEYBOARD DATA
*L682BC		CMP.B	L8322,D0 		THE <SPACE> CODE
*L682C2		BNE	L681FA 
*L682B8		BRA	L681FA			*****FINK******
***************************************************************************
* END OF MAIN PROGRAM LOOP....						  *
***************************************************************************
*L682C6		MOVE.B	#$B9,$8322 
L682CE		CMP.B	#$B9,D0 
L682D2		BNE	L681FA 
L682D6		MOVE.W	#$2700,SR 		DISABLE INTERRUPTS
L682DA		MOVEM.L	L8904,D0-D7 		RESTORE OLD MFP
L682E2		MOVEM.L	D0-D7,$FFFFFA00.W 
L682E8		MOVE.W	#$2300,SR 		DISABLE INTERRUPTS
L682EC		MOVE.L	L8924,$120.W 		OLD TIMER B
L682F4		MOVE.L	L8928,$70.W 		OLD VBL
L682FC		CLR.W	$FFFF8246.W 		CHANGE PAL REG

		MOVE.L	OLDSP,-(SP)
		MOVE.W	#$20,-(SP)
		TRAP	#1
		ADDQ.L	#6,SP
		
		CLR.W	-(SP)
		TRAP	#1
		
*L68300		MOVE.L	$8328,A7 
*L68306		MOVE.L	$8324,(A7) 
*L6830C		MOVE.L	$4,A0			THE ADDRESS TO EXIT 
*L68312		JMP	(A0) 			GOOD BYEEEEEEE....
*L68314		RTS

***************************************************************************
* SECOND SUB-ROUTINE FORM MAIN LOOP......				  *
***************************************************************************
L6832C		MOVE.L	(A6),A0 		SCREEN ADDRESS
L6832E		MOVE.L	$893A,A1 
L68334		ADDQ.L	#$4,A0 			GET 3rd BIT-PLANE
L68336		ADDQ.L	#$4,A1 			GET 3rd BIT-PLANE
L68338		MOVE.W	#$3B,D0 		LOOP COUNTER (60)
L6833C		MOVE.B	$1(A1),$0(A0) 
L68342		MOVE.B	$148(A1),$1(A0) 
L68348		MOVE.B	$289(A1),$148(A0) 
L6834E		MOVE.B	$3D0(A1),$289(A0) 
L68354		MOVE.B	$511(A1),$3D0(A0) 
L6835A		MOVE.B	$658(A1),$511(A0) 
L68360		MOVE.B	$799(A1),$658(A0) 
L68366		MOVE.B	$840(A1),$799(A0) 
L6836C		MOVE.B	$8E1(A1),$840(A0) 
L68372		MOVE.B	$988(A1),$8E1(A0) 
L68378		MOVE.B	$989(A1),$988(A0) 
L6837E		MOVE.B	$A30(A1),$989(A0) 
L68384		MOVE.B	$A31(A1),$A30(A0) 
L6838A		MOVE.B	$A38(A1),$A31(A0) 
L68390		MOVE.B	$999(A1),$A38(A0) 
L68396		MOVE.B	$9A0(A1),$999(A0) 
L6839C		MOVE.B	$901(A1),$9A0(A0) 
L683A2		MOVE.B	$868(A1),$901(A0) 
L683A8		MOVE.B	$7C9(A1),$868(A0) 
L683AE		MOVE.B	$730(A1),$7C9(A0) 
L683B4		MOVE.B	$7D1(A1),$730(A0) 
L683BA		MOVE.B	$878(A1),$7D1(A0) 
L683C0		MOVE.B	$919(A1),$878(A0) 
L683C6		MOVE.B	$9C0(A1),$919(A0) 
L683CC		MOVE.B	$9C1(A1),$9C0(A0) 
L683D2		MOVE.B	$A68(A1),$9C1(A0) 
L683D8		MOVE.B	$A69(A1),$A68(A0) 
L683DE		MOVE.B	$A70(A1),$A69(A0) 
L683E4		MOVE.B	$9D1(A1),$A70(A0) 
L683EA		MOVE.B	$9D8(A1),$9D1(A0) 
L683F0		MOVE.B	$939(A1),$9D8(A0) 
L683F6		MOVE.B	$8A0(A1),$939(A0) 
L683FC		MOVE.B	$801(A1),$8A0(A0) 
L68402		MOVE.B	$6C8(A1),$801(A0) 
L68408		MOVE.B	$589(A1),$6C8(A0) 
L6840E		MOVE.B	$450(A1),$589(A0) 
L68414		MOVE.B	$311(A1),$450(A0) 
L6841A		MOVE.B	$1D8(A1),$311(A0) 
L68420		MOVE.B	$99(A1),$1D8(A0) 
L68426		MOVE.B	(A4)+,$99(A1) 
L6842A		ADDA.L	#$A0,A0 		NEXT LINE
L68430		ADDA.L	#$A0,A1 		NEXT LINE
L68436		DBF	D0,L6833C 
L6843A		RTS
***************************************************************************
* FIRST SUB-ROUTINE FROM MAIN LOOP...(MOVING THE 'NO-CREW' LOGO)	  *
***************************************************************************
L6843C		MOVE.L	(A6),A1 		SCREEN ADDRESS
L6843E		ADDA.L	#$6748,A1 		GET TO ADDRESS OF 'NO CREW' LOGO
L68444		MOVE.W	#$7,D0 			LOOP COUNTER (8)
L68448		BSR	L68882 			CLEAR OLD 'NO CREW' LOGO
L6844C		MOVE.L	(A6),A1 		SCREEN ADDRESS
L6844E		ADDA.L	#$7828,A1 		NEXT SCREEN ADDRESS
L68454		MOVE.W	#$7,D0 			LOOP COUNTER (8)
L68458		BSR	L68882 			CLEAR OLD 'NO CREW' LOGO 
L6845C		LEA	L1F58C,A0 		LOGO BUFFER
L68462		LEA	L10CEE,A1 		LOGO
L68468		MOVE.L	A1,A3 
L6846A		ADDA.L	#$8700,A3 		GET CORRECT LOGO
L68470		MOVE.L	HORIP,A2 		GET MOVEMENT POINTER
L68476		ADDQ.L	#$4,A2 			SET TO NEXT MOV DATA
L68478		MOVE.L	A2,HORIP 		AND SET POINTER
L6847E		MOVE.W	#$1A,D0 		LOOP COUNTER (27)
L68482		CMPA.L	#HORIEND,A2 		IS IT THE END OF MOVEMENT DATA ?
L68488		BNE.S	L68494 			NO SO SKIP RESET BIT...
L6848A		MOVE.L	#HORIDAT,HORIP		RESET MOVEMENT DATA 
L68494		MOVE.L	(A2)+,D1 		GET HORIZ MOVEMENT DATA
L68496		MOVEM.L	$0(A1,D1.L),D3-D7 
L6849C		MOVEM.L	D3-D7,(A0) 		BUILD UP BUFFER WITH
L684A0		MOVEM.L	$14(A1,D1.L),D3-D7 	HORIZONTAL WAVE
L684A6		MOVEM.L	D3-D7,$14(A0) 		FROM VARIUS SHIFTED
L684AC		MOVEM.L	$28(A1,D1.L),D3-D7 	LOGO'S (GETTIT ????)
L684B2		MOVEM.L	D3-D7,$28(A0) 
L684B8		MOVEM.L	$3C(A1,D1.L),D3-D7 
L684BE		MOVEM.L	D3-D7,$3C(A0) 
L684C4		ADDA.L	#$50,A0 		
L684CA		ADDA.L	#$50,A1 
L684D0		ADDA.L	#$50,A3 
L684D6		DBF	D0,L68494 

L684DA		LEA	L1F58C,A0 		THE BUFFER NOW HOLDING LOGO
L684E0		MOVE.L	(A6),A1 		GET SCREEN ADDRESS
L684E2		ADDA.L	#$6748,A1 		GET SCR ADDR OF LOGO
L684E8		MOVE.L	VERTP,A2 		GET MOVEMENT POINTER
L684EE		ADDQ.L	#$4,A2 			SET IT TO NEXT DATA
L684F0		MOVE.L	A2,VERTP 		SET UP MOVEMENT POINTER
L684F6		MOVE.W	#$9,D0 			LOOP COUNTER (10)
		
L684FA		CMPA.L	#VERTEND,A2 		IS IT THE END ?
L68500		BNE.S	L6850C 			IF NOT, SKIP NEXT BIT...
L68502		MOVE.L	#VERTDAT,VERTP 		RESET MOVEMENT DATA
*		MOVE.L	VERTP,A2

L6850C		MOVE.L	(A2)+,D1 		GET VERTICAL MOVEMENT DATA
L6850E		MOVE.L	A1,A3 			THE SCREEN ADDRESS
L68510		ADDA.L	D1,A3			ADD MOVEMENT DATA TO IT.. 
L68512		MOVEP.L	$0(A0),D3 
L68516		MOVEP.L	D3,$0(A3) 
L6851A		MOVEP.L	$50(A0),D3 
L6851E		MOVEP.L	D3,$A0(A3) 
L68522		MOVEP.L	$A0(A0),D3 
L68526		MOVEP.L	D3,$140(A3) 
L6852A		MOVEP.L	$F0(A0),D3 
L6852E		MOVEP.L	D3,$1E0(A3) 
L68532		MOVEP.L	$140(A0),D3 
L68536		MOVEP.L	D3,$280(A3) 
L6853A		MOVEP.L	$190(A0),D3 
L6853E		MOVEP.L	D3,$320(A3) 
L68542		MOVEP.L	$1E0(A0),D3 
L68546		MOVEP.L	D3,$3C0(A3) 
L6854A		MOVEP.L	$230(A0),D3 
L6854E		MOVEP.L	D3,$460(A3) 
L68552		MOVEP.L	$280(A0),D3 
L68556		MOVEP.L	D3,$500(A3) 
L6855A		MOVEP.L	$2D0(A0),D3 
L6855E		MOVEP.L	D3,$5A0(A3) 
L68562		MOVEP.L	$320(A0),D3 
L68566		MOVEP.L	D3,$640(A3) 
L6856A		MOVEP.L	$370(A0),D3 
L6856E		MOVEP.L	D3,$6E0(A3) 
L68572		MOVEP.L	$3C0(A0),D3 
L68576		MOVEP.L	D3,$780(A3) 
L6857A		MOVEP.L	$410(A0),D3 
L6857E		MOVEP.L	D3,$820(A3) 
L68582		MOVEP.L	$460(A0),D3 
L68586		MOVEP.L	D3,$8C0(A3) 
L6858A		MOVEP.L	$4B0(A0),D3 
L6858E		MOVEP.L	D3,$960(A3) 
L68592		MOVEP.L	$500(A0),D3 
L68596		MOVEP.L	D3,$A00(A3) 
L6859A		MOVEP.L	$550(A0),D3 
L6859E		MOVEP.L	D3,$AA0(A3) 
L685A2		MOVEP.L	$5A0(A0),D3 
L685A6		MOVEP.L	D3,$B40(A3) 
L685AA		MOVEP.L	$5F0(A0),D3 
L685AE		MOVEP.L	D3,$BE0(A3) 
L685B2		MOVEP.L	$640(A0),D3 
L685B6		MOVEP.L	D3,$C80(A3) 
L685BA		MOVEP.L	$690(A0),D3 
L685BE		MOVEP.L	D3,$D20(A3) 
L685C2		MOVEP.L	$6E0(A0),D3 
L685C6		MOVEP.L	D3,$DC0(A3) 
L685CA		MOVEP.L	$730(A0),D3 
L685CE		MOVEP.L	D3,$E60(A3) 
L685D2		MOVEP.L	$780(A0),D3 
L685D6		MOVEP.L	D3,$F00(A3) 
L685DA		MOVEP.L	$7D0(A0),D3 
L685DE		MOVEP.L	D3,$FA0(A3) 
L685E2		MOVEP.L	$820(A0),D3 
L685E6		MOVEP.L	D3,$1040(A3) 
L685EA		ADDA.L	#$1,A0 			NEXT BYTE
L685F0		ADDA.L	#$1,A1 			NEXT BYTE OF SCREEN
L685F6		MOVE.L	(A2)+,D1 
L685F8		MOVE.L	A1,A3 
L685FA		ADDA.L	D1,A3 
L685FC		MOVEP.L	$0(A0),D3 
L68600		MOVEP.L	D3,$0(A3) 
L68604		MOVEP.L	$50(A0),D3 
L68608		MOVEP.L	D3,$A0(A3) 
L6860C		MOVEP.L	$A0(A0),D3 
L68610		MOVEP.L	D3,$140(A3) 
L68614		MOVEP.L	$F0(A0),D3 
L68618		MOVEP.L	D3,$1E0(A3) 
L6861C		MOVEP.L	$140(A0),D3 
L68620		MOVEP.L	D3,$280(A3) 
L68624		MOVEP.L	$190(A0),D3 
L68628		MOVEP.L	D3,$320(A3) 
L6862C		MOVEP.L	$1E0(A0),D3 
L68630		MOVEP.L	D3,$3C0(A3) 
L68634		MOVEP.L	$230(A0),D3 
L68638		MOVEP.L	D3,$460(A3) 
L6863C		MOVEP.L	$280(A0),D3 
L68640		MOVEP.L	D3,$500(A3) 
L68644		MOVEP.L	$2D0(A0),D3 
L68648		MOVEP.L	D3,$5A0(A3) 
L6864C		MOVEP.L	$320(A0),D3 
L68650		MOVEP.L	D3,$640(A3) 
L68654		MOVEP.L	$370(A0),D3 
L68658		MOVEP.L	D3,$6E0(A3) 
L6865C		MOVEP.L	$3C0(A0),D3 
L68660		MOVEP.L	D3,$780(A3) 
L68664		MOVEP.L	$410(A0),D3 
L68668		MOVEP.L	D3,$820(A3) 
L6866C		MOVEP.L	$460(A0),D3 
L68670		MOVEP.L	D3,$8C0(A3) 
L68674		MOVEP.L	$4B0(A0),D3 
L68678		MOVEP.L	D3,$960(A3) 
L6867C		MOVEP.L	$500(A0),D3 
L68680		MOVEP.L	D3,$A00(A3) 
L68684		MOVEP.L	$550(A0),D3 
L68688		MOVEP.L	D3,$AA0(A3) 
L6868C		MOVEP.L	$5A0(A0),D3 
L68690		MOVEP.L	D3,$B40(A3) 
L68694		MOVEP.L	$5F0(A0),D3 
L68698		MOVEP.L	D3,$BE0(A3) 
L6869C		MOVEP.L	$640(A0),D3 
L686A0		MOVEP.L	D3,$C80(A3) 
L686A4		MOVEP.L	$690(A0),D3 
L686A8		MOVEP.L	D3,$D20(A3) 
L686AC		MOVEP.L	$6E0(A0),D3 
L686B0		MOVEP.L	D3,$DC0(A3) 
L686B4		MOVEP.L	$730(A0),D3 
L686B8		MOVEP.L	D3,$E60(A3) 
L686BC		MOVEP.L	$780(A0),D3 
L686C0		MOVEP.L	D3,$F00(A3) 
L686C4		MOVEP.L	$7D0(A0),D3 
L686C8		MOVEP.L	D3,$FA0(A3) 
L686CC		MOVEP.L	$820(A0),D3 
L686D0		MOVEP.L	D3,$1040(A3) 
L686D4		ADDA.L	#$7,A0 			BACK TO 1st BIT-PLANE
L686DA		ADDA.L	#$7,A1 			BACK TO 1st BIT-PLANE
L686E0		DBF	D0,L6850C 
L686E4		RTS
***************************************************************************
* THIRD SUB-ROUTINE FROM MAIN LOOP...					  *
***************************************************************************
L686E6		MOVE.L	A6,$8900 
L686EC		MOVE.L	(A6),A0 
L686EE		LEA	$333E(A0),A0 
L686F2		MOVE.L	$893A,A1 
L686F8		LEA	$333E(A1),A1 
L686FC		MOVE.L	L88FC,A6 		SCROLLTEXT POINTER 2
L68702		MOVE.L	$887E,A3 
L68708		SUBQ.W	#$1,$8934 
L6870E		BNE.S	L68760 
L68710		LEA	$193EE,A3 
L68716		MOVEQ	#$0,D0 
L68718		MOVE.B	(A6)+,D0 		GET LETTER
L6871A		CMPI.B	#$20,D0 		
L6871E		BNE.S	L68728 
L68720		MOVE.B	#$17,D0 
L68724		BRA	L68754 
L68728		CMPI.B	#$2E,D0 
L6872C		BNE.S	L68736 
L6872E		MOVE.B	#$1A,D0 
L68732		BRA	L68754 
L68736		CMPI.B	#$2C,D0 
L6873A		BNE.S	L68744 
L6873C		MOVE.B	#$1B,D0 
L68740		BRA	L68754 
L68744		CMPI.B	#$21,D0 
L68748		BNE.S	L68750 
L6874A		LEA	$1A1EE,A6 
L68750		SUBI.B	#$41,D0 
L68754		ASL.L	#$7,D0 
L68756		ADDA.L	D0,A3 
L68758		MOVE.W	#$4,$8934 
L68760		MOVE.W	#$1F,D0 
L68764		MOVE.B	$1AE7(A1),$1C26(A0) 
L6876A		MOVE.B	$19AE(A1),$1AE7(A0) 
L68770		MOVE.B	$186F(A1),$19AE(A0) 
L68776		MOVE.B	$1736(A1),$186F(A0) 
L6877C		MOVE.B	$15F7(A1),$1736(A0) 
L68782		MOVE.B	$155E(A1),$15F7(A0) 
L68788		MOVE.B	$14BF(A1),$155E(A0) 
L6878E		MOVE.B	$1426(A1),$14BF(A0) 
L68794		MOVE.B	$1387(A1),$1426(A0) 
L6879A		MOVE.B	$12EE(A1),$1387(A0) 
L687A0		MOVE.B	$124F(A1),$12EE(A0) 
L687A6		MOVE.B	$11B6(A1),$124F(A0) 
L687AC		MOVE.B	$1117(A1),$11B6(A0) 
L687B2		MOVE.B	$107E(A1),$1117(A0) 
L687B8		MOVE.B	$FDF(A1),$107E(A0) 
L687BE		MOVE.B	$F46(A1),$FDF(A0) 
L687C4		MOVE.B	$EA7(A1),$F46(A0) 
L687CA		MOVE.B	$E0E(A1),$EA7(A0) 
L687D0		MOVE.B	$D6F(A1),$E0E(A0) 
L687D6		MOVE.B	$CD6(A1),$D6F(A0) 
L687DC		MOVE.B	$C37(A1),$CD6(A0) 
L687E2		MOVE.B	$B9E(A1),$C37(A0) 
L687E8		MOVE.B	$AFF(A1),$B9E(A0) 
L687EE		MOVE.B	$A66(A1),$AFF(A0) 
L687F4		MOVE.B	$9C7(A1),$A66(A0) 
L687FA		MOVE.B	$92E(A1),$9C7(A0) 
L68800		MOVE.B	$88F(A1),$92E(A0) 
L68806		MOVE.B	$7F6(A1),$88F(A0) 
L6880C		MOVE.B	$757(A1),$7F6(A0) 
L68812		MOVE.B	$6BE(A1),$757(A0) 
L68818		MOVE.B	$57F(A1),$6BE(A0) 
L6881E		MOVE.B	$446(A1),$57F(A0) 
L68824		MOVE.B	$307(A1),$446(A0) 
L6882A		MOVE.B	$1CE(A1),$307(A0) 
L68830		MOVE.B	$8F(A1),$1CE(A0) 
L68836		MOVE.B	$FFFFFF56(A1),$8F(A0) 
L6883C		MOVE.B	$FFFFFE17(A1),$FFFFFF56(A0) 
L68842		MOVE.B	$FFFFFCDE(A1),$FFFFFE17(A0) 
L68848		MOVE.B	$FFFFFB9F(A1),$FFFFFCDE(A0) 
L6884E		MOVE.B	$0(A3),$FFFFFB9F(A1) 
L68854		LEA	$4(A3),A3 
L68858		LEA	$A0(A1),A1 
L6885C		LEA	$A0(A0),A0 
L68860		DBF	D0,L68764 
L68864		SUBA.L	#$7F,A3 
L6886A		MOVE.L	A6,$88FC 		SET POINTER TO NEXT LETTER
L68870		MOVE.L	$8900,A6 
L68876		MOVE.L	A3,$887E 
L6887C		RTS

L6887E		ORI.B	#$F2,D1 
***************************************************************************
* SUB-ROUTINE FROM SECOND SUB-ROUTINE (THE LOGO ANIMATOR)....		  *
***************************************************************************
L68882		CLR.L	(A1)+ 			CLEAR LOGO
L68884		CLR.L	(A1)+ 
L68886		CLR.L	(A1)+ 
L68888		CLR.L	(A1)+ 
L6888A		CLR.L	(A1)+ 
L6888C		CLR.L	(A1)+ 
L6888E		CLR.L	(A1)+ 
L68890		CLR.L	(A1)+ 
L68892		CLR.L	(A1)+ 
L68894		CLR.L	(A1)+ 
L68896		CLR.L	(A1)+ 
L68898		CLR.L	(A1)+ 
L6889A		CLR.L	(A1)+ 
L6889C		CLR.L	(A1)+ 
L6889E		CLR.L	(A1)+ 
L688A0		CLR.L	(A1)+ 
L688A2		CLR.L	(A1)+ 
L688A4		CLR.L	(A1)+ 
L688A6		CLR.L	(A1)+ 
L688A8		CLR.L	(A1)+ 
L688AA		ADDA.L	#$50,A1 		NEXT LINE
L688B0		DBF	D0,L68882 		CLEAR ALL OF LOGO
L688B4		RTS
***************************************************************************
* THE TIMER B  ROUTINE (EVERY 5 LINES).......				  *
***************************************************************************
L688B6		MOVE.W	(A5)+,$FFFF8242.W 
L688BA		MOVE.L	(A5)+,$FFFF8248.W 
L688BE		MOVE.L	(A5)+,$FFFF824C.W 	SET UP PALETTE
L688C2		BCLR	#$0,$FFFFFA0F.W 
L688C8		RTE
***************************************************************************
* THE VBL ROUTINE....							  *
***************************************************************************
L688CA		MOVE.W	#$1,L892C 		SET VBL FLAG
*L688D2		MOVE.L	$FF8248,$7000700 	SET PALETTE
*L688DC		MOVE.L	$FF824C,$7000700 
L688E6		LEA	L8966,A5 		SET UP PALETTE POINTER
L688EC		MOVEM.L	D0-D7/A0-A6,-(A7) 
L688F0		JSR	(MUSIC+8)			PLAY MUSIC
L688F6		MOVEM.L	(A7)+,D0-D7/A0-A6 
L688FA		RTE
***************************************************************************
* THE DATA ALLOCATIONS (SHIT, DON'T YER JUST HATE THEM ????)		  *
***************************************************************************
OLDSP	DC.L	0			SUPERVISOR SHIT
L1F56C	DS.L	8			FOR THE 8 SCREEN ADDRESSES
L893A	DC.L	0			HOLDS FINAL SCREEN ADDRESS
L8322	DC.B	$39			THE EXIT KEYBOARD CODE
LBA0E	INCBIN	'B:\NO_CREW.HAK\MATRIX.DAT'		THE MATRIX GRAFIX
LBB0E	INCBIN	'B:\NO_CREW.HAK\CREW1.DAT'		THE LARGE 1-PLANE GFX
L894E	DC.W	$000,$007,$005,$007,$033,$044,$055,$066
	DC.W	$077,$477,$007,$000,$560,$600,$600,$600		THE NEW PALETTE

L8904	DS.L	7			OLD MFP
L8924	DC.L	0			OLD TIMER B
L8928	DC.L	0			OLD VBL
L892C	DC.W	0			VBL FLAG
L8966	INCBIN	'B:\NO_CREW.HAK\NO_CREW.PAL'		PALETTE POINTER
L1BD4A	DC.B	'SCROLLTEXT 1 GOES HERE'
L1C5B2	DC.B	0			END OF TEXT 1 ADDRESS
L8948	DC.L	0			SCROLLTEXT 1 POINTER
L1A1EE	DC.B	'SCROLLTEXT 2 GOES HERE'
L88FC	DC.L	0			SCROLLTEXT 2 POINTER
L893E	DC.W	0			SCREEN NUMBER (1-8)

HORIP	DC.L	0			HORI POINTER
HORIDAT	INCBIN	'B:\NO_CREW.HAK\HORI.DAT'
HORIEND	DC.L	0			HORI POINTER END
VERTP	DC.L	0			VERT POINTER
VERTDAT	INCBIN	'B:\NO_CREW.HAK\VERT.DAT'	
*	DC.L	-1
VERTEND	DC.L	0			VERT POINTER END
L1F58C	DS.B	2160			LOGO BUFFER
L10CEE	INCBIN	'B:\NO_CREW.HAK\LOGO.DAT'		'NO_CREW' LOGO

MUSIC	INCBIN	'B:\NO_CREW.HAK\FINK.MUS'		THE MUSIC

	EVEN