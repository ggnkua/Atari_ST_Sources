; Macintosh 1984
*
*  NEOchrome V2.27 cut buffer contents (left justified):
*  by Chaos, Inc. of the Delta Force (member of The Union)
*
*    pixels/scanline    = $0140 (bytes/scanline: $00A0)
*  # scanlines (height) = $00C8
*
*  Hardware color pallet  (color 0 to 15):
*
*      $0000,$0FFF,$0000,$0000,$0000,$0000,$0000,$0000
*      $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
*
*
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1200,$0000
		dc.w	$2000,$0000
		dc.w	$6E00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$2000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$A000,$0000
		dc.w	$1200,$0000
		dc.w	$7000,$0000
		dc.w	$9200,$0000
		dc.w	$7800,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$2000,$0000
		dc.w	$C000,$0000
		dc.w	$A000,$0000
		dc.w	$7F00,$0000
		dc.w	$A800,$0000
		dc.w	$9400,$0000
		dc.w	$CC00,$0000
		dc.w	$8000,$0000
		dc.w	$C000,$0000
		dc.w	$6000,$0000
		dc.w	$A800,$0000
		dc.w	$C000,$0000
		dc.w	$A000,$0000
		dc.w	$2400,$0000
		dc.w	$E000,$0000
		dc.w	$6400,$0000
		dc.w	$CD00,$0000
		dc.w	$8000,$0000
		dc.w	$C000,$0000
		dc.w	$6000,$0000
		dc.w	$7000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$2400,$0000
		dc.w	$E000,$0000
		dc.w	$0800,$0000
		dc.w	$6100,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$6000,$0000
		dc.w	$A800,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$FE00,$0000
		dc.w	$7000,$0000
		dc.w	$0800,$0000
		dc.w	$CE00,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$6000,$0000
		dc.w	$2000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$4800,$0000
		dc.w	$3800,$0000
		dc.w	$1300,$0000
		dc.w	$CC00,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$6000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4800,$0000
		dc.w	$3800,$0000
		dc.w	$1480,$0000
		dc.w	$CC00,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$6000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$A800,$0000
		dc.w	$2480,$0000
		dc.w	$CC00,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$6000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7000,$0000
		dc.w	$2300,$0000
		dc.w	$7800,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$2000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$E000,$0000
		dc.w	$FF00,$0000
		dc.w	$F800,$0000
		dc.w	$FF80,$0000
		dc.w	$FF00,$0000
		dc.w	$8000,$0000
		dc.w	$E000,$0000
		dc.w	$E000,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0800,$0000
		dc.w	$7800,$0000
		dc.w	$6000,$0000
		dc.w	$7800,$0000
		dc.w	$FC00,$0000
		dc.w	$0C00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1000,$0000
		dc.w	$CC00,$0000
		dc.w	$E000,$0000
		dc.w	$8C00,$0000
		dc.w	$1800,$0000
		dc.w	$1C00,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1000,$0000
		dc.w	$CC00,$0000
		dc.w	$6000,$0000
		dc.w	$0C00,$0000
		dc.w	$3000,$0000
		dc.w	$2C00,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$2000,$0000
		dc.w	$CC00,$0000
		dc.w	$6000,$0000
		dc.w	$0C00,$0000
		dc.w	$7800,$0000
		dc.w	$4C00,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$2000,$0000
		dc.w	$CC00,$0000
		dc.w	$6000,$0000
		dc.w	$1800,$0000
		dc.w	$0C00,$0000
		dc.w	$8C00,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$CC00,$0000
		dc.w	$6000,$0000
		dc.w	$3000,$0000
		dc.w	$0C00,$0000
		dc.w	$FE00,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$CC00,$0000
		dc.w	$6000,$0000
		dc.w	$6000,$0000
		dc.w	$0C00,$0000
		dc.w	$0C00,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$8000,$0000
		dc.w	$CC00,$0000
		dc.w	$6000,$0000
		dc.w	$C000,$0000
		dc.w	$8C00,$0000
		dc.w	$0C00,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$8000,$0000
		dc.w	$7800,$0000
		dc.w	$6000,$0000
		dc.w	$FC00,$0000
		dc.w	$7800,$0000
		dc.w	$0C00,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$F800,$0000
		dc.w	$C000,$0000
		dc.w	$F800,$0000
		dc.w	$C000,$0000
		dc.w	$F800,$0000
		dc.w	$FC00,$0000
		dc.w	$E000,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FE00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$FC00,$0000
		dc.w	$3800,$0000
		dc.w	$FC00,$0000
		dc.w	$7800,$0000
		dc.w	$7800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$6000,$0000
		dc.w	$0C00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1800,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$0C00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$3000,$0000
		dc.w	$0000,$0000
		dc.w	$6000,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$0C00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$6000,$0000
		dc.w	$FC00,$0000
		dc.w	$3000,$0000
		dc.w	$0C00,$0000
		dc.w	$CC00,$0000
		dc.w	$1800,$0000
		dc.w	$7800,$0000
		dc.w	$CC00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$1800,$0000
		dc.w	$0C00,$0000
		dc.w	$CC00,$0000
		dc.w	$3000,$0000
		dc.w	$CC00,$0000
		dc.w	$7C00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$6000,$0000
		dc.w	$FC00,$0000
		dc.w	$3000,$0000
		dc.w	$0C00,$0000
		dc.w	$CC00,$0000
		dc.w	$3000,$0000
		dc.w	$CC00,$0000
		dc.w	$0C00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3000,$0000
		dc.w	$0000,$0000
		dc.w	$6000,$0000
		dc.w	$8C00,$0000
		dc.w	$CC00,$0000
		dc.w	$3000,$0000
		dc.w	$CC00,$0000
		dc.w	$1800,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$1800,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$7800,$0000
		dc.w	$7800,$0000
		dc.w	$3000,$0000
		dc.w	$7800,$0000
		dc.w	$7000,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$F800,$0000
		dc.w	$FC00,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7800,$0000
		dc.w	$0000,$0000
		dc.w	$7800,$0000
		dc.w	$F800,$0000
		dc.w	$7800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$7800,$0000
		dc.w	$CC00,$0000
		dc.w	$8C00,$0000
		dc.w	$3E00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$C400,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$C400,$0000
		dc.w	$CC00,$0000
		dc.w	$0C00,$0000
		dc.w	$4100,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$CC00,$0000
		dc.w	$1800,$0000
		dc.w	$9C80,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$CC00,$0000
		dc.w	$3000,$0000
		dc.w	$A480,$0000
		dc.w	$FC00,$0000
		dc.w	$F800,$0000
		dc.w	$C000,$0000
		dc.w	$CC00,$0000
		dc.w	$F000,$0000
		dc.w	$F000,$0000
		dc.w	$DC00,$0000
		dc.w	$FC00,$0000
		dc.w	$3000,$0000
		dc.w	$A480,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$0000,$0000
		dc.w	$9B00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$3000,$0000
		dc.w	$4000,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$C400,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$3000,$0000
		dc.w	$3E00,$0000
		dc.w	$CC00,$0000
		dc.w	$F800,$0000
		dc.w	$7800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$C000,$0000
		dc.w	$7800,$0000
		dc.w	$CC00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$FC00,$0000
		dc.w	$FF80,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0C00,$0000
		dc.w	$C600,$0000
		dc.w	$C000,$0000
		dc.w	$8040,$0000
		dc.w	$8200,$0000
		dc.w	$7800,$0000
		dc.w	$F800,$0000
		dc.w	$7800,$0000
		dc.w	$F800,$0000
		dc.w	$C000,$0000
		dc.w	$0C00,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$C0C0,$0000
		dc.w	$C200,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$0C00,$0000
		dc.w	$D800,$0000
		dc.w	$C000,$0000
		dc.w	$E1C0,$0000
		dc.w	$E200,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$0C00,$0000
		dc.w	$F000,$0000
		dc.w	$C000,$0000
		dc.w	$F3C0,$0000
		dc.w	$F200,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$0C00,$0000
		dc.w	$E000,$0000
		dc.w	$C000,$0000
		dc.w	$BEC0,$0000
		dc.w	$BA00,$0000
		dc.w	$CC00,$0000
		dc.w	$F800,$0000
		dc.w	$CC00,$0000
		dc.w	$F800,$0000
		dc.w	$C000,$0000
		dc.w	$CC00,$0000
		dc.w	$F000,$0000
		dc.w	$C000,$0000
		dc.w	$9CC0,$0000
		dc.w	$9E00,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$CC00,$0000
		dc.w	$D800,$0000
		dc.w	$C000,$0000
		dc.w	$88C0,$0000
		dc.w	$8E00,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$80C0,$0000
		dc.w	$8600,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$7800,$0000
		dc.w	$C600,$0000
		dc.w	$F800,$0000
		dc.w	$80C0,$0000
		dc.w	$8200,$0000
		dc.w	$7800,$0000
		dc.w	$C000,$0000
		dc.w	$7800,$0000
		dc.w	$CC00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0C00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$FC00,$0000
		dc.w	$FE00,$0000
		dc.w	$F800,$0000
		dc.w	$FFC0,$0000
		dc.w	$FE00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$E000,$0000
		dc.w	$8000,$0000
		dc.w	$7000,$0000
		dc.w	$FC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CCC0,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$FC00,$0000
		dc.w	$C000,$0000
		dc.w	$8000,$0000
		dc.w	$C800,$0000
		dc.w	$3000,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CCC0,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$0C00,$0000
		dc.w	$C000,$0000
		dc.w	$4000,$0000
		dc.w	$C000,$0000
		dc.w	$3000,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CCC0,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$0C00,$0000
		dc.w	$C000,$0000
		dc.w	$4000,$0000
		dc.w	$E000,$0000
		dc.w	$3000,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CCC0,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$1800,$0000
		dc.w	$C000,$0000
		dc.w	$2000,$0000
		dc.w	$7000,$0000
		dc.w	$3000,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CCC0,$0000
		dc.w	$7800,$0000
		dc.w	$7800,$0000
		dc.w	$3000,$0000
		dc.w	$C000,$0000
		dc.w	$2000,$0000
		dc.w	$3800,$0000
		dc.w	$3000,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CCC0,$0000
		dc.w	$CC00,$0000
		dc.w	$3000,$0000
		dc.w	$6000,$0000
		dc.w	$C000,$0000
		dc.w	$1000,$0000
		dc.w	$1800,$0000
		dc.w	$3000,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CCC0,$0000
		dc.w	$CC00,$0000
		dc.w	$3000,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$1000,$0000
		dc.w	$9800,$0000
		dc.w	$3000,$0000
		dc.w	$CC00,$0000
		dc.w	$C800,$0000
		dc.w	$CC80,$0000
		dc.w	$CC00,$0000
		dc.w	$3000,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$0800,$0000
		dc.w	$7000,$0000
		dc.w	$3000,$0000
		dc.w	$7800,$0000
		dc.w	$F000,$0000
		dc.w	$FF00,$0000
		dc.w	$CC00,$0000
		dc.w	$3000,$0000
		dc.w	$FC00,$0000
		dc.w	$C000,$0000
		dc.w	$0800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$E000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$F800,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FFC0,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$E000,$0000
		dc.w	$F800,$0000
		dc.w	$E000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$6000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$6000,$0000
		dc.w	$5000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0C00,$0000
		dc.w	$0000,$0000
		dc.w	$3800,$0000
		dc.w	$6000,$0000
		dc.w	$8800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0C00,$0000
		dc.w	$0000,$0000
		dc.w	$6000,$0000
		dc.w	$6000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7800,$0000
		dc.w	$F800,$0000
		dc.w	$7000,$0000
		dc.w	$7C00,$0000
		dc.w	$7800,$0000
		dc.w	$F000,$0000
		dc.w	$6000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8C00,$0000
		dc.w	$CC00,$0000
		dc.w	$C800,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$6000,$0000
		dc.w	$6000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7C00,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$6000,$0000
		dc.w	$6000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$CC00,$0000
		dc.w	$FC00,$0000
		dc.w	$6000,$0000
		dc.w	$6000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$6000,$0000
		dc.w	$6000,$0000
		dc.w	$0000,$0000
		dc.w	$FF00,$0000
		dc.w	$0000,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$C800,$0000
		dc.w	$CC00,$0000
		dc.w	$C400,$0000
		dc.w	$6000,$0000
		dc.w	$E000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7C00,$0000
		dc.w	$F800,$0000
		dc.w	$7000,$0000
		dc.w	$7C00,$0000
		dc.w	$7800,$0000
		dc.w	$6000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$E000,$0000
		dc.w	$F800,$0000
		dc.w	$FF00,$0000
		dc.w	$8000,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$F800,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$1800,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7C00,$0000
		dc.w	$F800,$0000
		dc.w	$C000,$0000
		dc.w	$1800,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$FF80,$0000
		dc.w	$F800,$0000
		dc.w	$7800,$0000
		dc.w	$F800,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$1800,$0000
		dc.w	$D800,$0000
		dc.w	$C000,$0000
		dc.w	$CCC0,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$1800,$0000
		dc.w	$F000,$0000
		dc.w	$C000,$0000
		dc.w	$CCC0,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$1800,$0000
		dc.w	$E000,$0000
		dc.w	$C000,$0000
		dc.w	$CCC0,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$1800,$0000
		dc.w	$F000,$0000
		dc.w	$C000,$0000
		dc.w	$CCC0,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$1800,$0000
		dc.w	$D800,$0000
		dc.w	$C000,$0000
		dc.w	$CCC0,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$7C00,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$1800,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$CCC0,$0000
		dc.w	$CC00,$0000
		dc.w	$7800,$0000
		dc.w	$F800,$0000
		dc.w	$0C00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$8C00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$9800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$7800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$C000,$0000
		dc.w	$F800,$0000
		dc.w	$FC00,$0000
		dc.w	$C000,$0000
		dc.w	$FFC0,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$6000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$6000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7C00,$0000
		dc.w	$D800,$0000
		dc.w	$7000,$0000
		dc.w	$F000,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CCC0,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$FC00,$0000
		dc.w	$CC00,$0000
		dc.w	$E000,$0000
		dc.w	$C800,$0000
		dc.w	$6000,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CCC0,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$0C00,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$E000,$0000
		dc.w	$6000,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CCC0,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$1800,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$7000,$0000
		dc.w	$6000,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CCC0,$0000
		dc.w	$7800,$0000
		dc.w	$CC00,$0000
		dc.w	$3000,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$3800,$0000
		dc.w	$6000,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CCC0,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$6000,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$9800,$0000
		dc.w	$6000,$0000
		dc.w	$CC00,$0000
		dc.w	$C800,$0000
		dc.w	$CC80,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$7C00,$0000
		dc.w	$C000,$0000
		dc.w	$7000,$0000
		dc.w	$3000,$0000
		dc.w	$7C00,$0000
		dc.w	$F000,$0000
		dc.w	$FF00,$0000
		dc.w	$CC00,$0000
		dc.w	$7C00,$0000
		dc.w	$FC00,$0000
		dc.w	$0C00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0C00,$0000
		dc.w	$0000,$0000
		dc.w	$0C00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8C00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7800,$0000
		dc.w	$0000,$0000
		dc.w	$FC00,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F000,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FFC0,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$2000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$6400,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$9800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$2000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$E000,$0000
		dc.w	$8000,$0000
		dc.w	$E000,$0000
		dc.w	$FC00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
