; Atari 8-bit
*
*  NEOchrome V2.27 cut buffer contents (left justified):
*  by Chaos, Inc. of the Delta Force (member of The Union)
*
*    pixels/scanline    = $0140 (bytes/scanline: $00A0)
*  # scanlines (height) = $00C8
*
*  Hardware color pallet  (color 0 to 15):
*
*      $0000,$0FFF,$0000,$0000,$0000,$0000,$0000,$0000
*      $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
*
*
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3000,$0000
		dc.w	$0000,$0000
		dc.w	$3800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$CC00,$0000
		dc.w	$6600,$0000
		dc.w	$7C00,$0000
		dc.w	$CC00,$0000
		dc.w	$6C00,$0000
		dc.w	$C000,$0000
		dc.w	$7000,$0000
		dc.w	$E000,$0000
		dc.w	$6600,$0000
		dc.w	$C000,$0000
		dc.w	$CC00,$0000
		dc.w	$FF00,$0000
		dc.w	$C000,$0000
		dc.w	$D800,$0000
		dc.w	$3800,$0000
		dc.w	$C000,$0000
		dc.w	$E000,$0000
		dc.w	$7000,$0000
		dc.w	$3C00,$0000
		dc.w	$C000,$0000
		dc.w	$CC00,$0000
		dc.w	$6600,$0000
		dc.w	$7800,$0000
		dc.w	$3000,$0000
		dc.w	$7000,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$3000,$0000
		dc.w	$FF00,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$6600,$0000
		dc.w	$0C00,$0000
		dc.w	$6000,$0000
		dc.w	$DE00,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$3000,$0000
		dc.w	$3C00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$FF00,$0000
		dc.w	$F800,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$0000,$0000
		dc.w	$E000,$0000
		dc.w	$7000,$0000
		dc.w	$6600,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$6600,$0000
		dc.w	$3000,$0000
		dc.w	$8C00,$0000
		dc.w	$7600,$0000
		dc.w	$0000,$0000
		dc.w	$7000,$0000
		dc.w	$E000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$FC00,$0000
		dc.w	$FF00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FE00,$0000
		dc.w	$C000,$0000
		dc.w	$F000,$0000
		dc.w	$F000,$0000
		dc.w	$FF00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0C00,$0000
		dc.w	$7800,$0000
		dc.w	$3000,$0000
		dc.w	$7800,$0000
		dc.w	$FC00,$0000
		dc.w	$1800,$0000
		dc.w	$3000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1800,$0000
		dc.w	$CC00,$0000
		dc.w	$7000,$0000
		dc.w	$CC00,$0000
		dc.w	$1800,$0000
		dc.w	$3800,$0000
		dc.w	$FC00,$0000
		dc.w	$0000,$0000
		dc.w	$FC00,$0000
		dc.w	$0000,$0000
		dc.w	$3000,$0000
		dc.w	$DC00,$0000
		dc.w	$3000,$0000
		dc.w	$1800,$0000
		dc.w	$3000,$0000
		dc.w	$7800,$0000
		dc.w	$3000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$6000,$0000
		dc.w	$EC00,$0000
		dc.w	$3000,$0000
		dc.w	$3000,$0000
		dc.w	$1800,$0000
		dc.w	$D800,$0000
		dc.w	$3000,$0000
		dc.w	$6000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$CC00,$0000
		dc.w	$3000,$0000
		dc.w	$6000,$0000
		dc.w	$CC00,$0000
		dc.w	$FC00,$0000
		dc.w	$0000,$0000
		dc.w	$6000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$8000,$0000
		dc.w	$7800,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$7800,$0000
		dc.w	$1800,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$FC00,$0000
		dc.w	$E000,$0000
		dc.w	$FC00,$0000
		dc.w	$C000,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1800,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$FC00,$0000
		dc.w	$7800,$0000
		dc.w	$FC00,$0000
		dc.w	$7800,$0000
		dc.w	$7800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3000,$0000
		dc.w	$0000,$0000
		dc.w	$6000,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$0C00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$6000,$0000
		dc.w	$6000,$0000
		dc.w	$FC00,$0000
		dc.w	$3000,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$1800,$0000
		dc.w	$7800,$0000
		dc.w	$7C00,$0000
		dc.w	$C000,$0000
		dc.w	$6000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$1800,$0000
		dc.w	$0C00,$0000
		dc.w	$CC00,$0000
		dc.w	$3000,$0000
		dc.w	$CC00,$0000
		dc.w	$0C00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$6000,$0000
		dc.w	$0000,$0000
		dc.w	$3000,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$6000,$0000
		dc.w	$CC00,$0000
		dc.w	$1800,$0000
		dc.w	$C000,$0000
		dc.w	$6000,$0000
		dc.w	$3000,$0000
		dc.w	$FC00,$0000
		dc.w	$6000,$0000
		dc.w	$7800,$0000
		dc.w	$7800,$0000
		dc.w	$6000,$0000
		dc.w	$7800,$0000
		dc.w	$7000,$0000
		dc.w	$C000,$0000
		dc.w	$6000,$0000
		dc.w	$1800,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$C000,$0000
		dc.w	$E000,$0000
		dc.w	$F800,$0000
		dc.w	$FC00,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7800,$0000
		dc.w	$7800,$0000
		dc.w	$3000,$0000
		dc.w	$F800,$0000
		dc.w	$7800,$0000
		dc.w	$F000,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$7C00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$7800,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$D800,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$CC00,$0000
		dc.w	$1800,$0000
		dc.w	$DC00,$0000
		dc.w	$CC00,$0000
		dc.w	$F800,$0000
		dc.w	$C000,$0000
		dc.w	$CC00,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$C000,$0000
		dc.w	$FC00,$0000
		dc.w	$3000,$0000
		dc.w	$DC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$DC00,$0000
		dc.w	$CC00,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$FC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$D800,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$3000,$0000
		dc.w	$7C00,$0000
		dc.w	$CC00,$0000
		dc.w	$F800,$0000
		dc.w	$7800,$0000
		dc.w	$F000,$0000
		dc.w	$FC00,$0000
		dc.w	$C000,$0000
		dc.w	$7C00,$0000
		dc.w	$CC00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$FC00,$0000
		dc.w	$0C00,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$C600,$0000
		dc.w	$CC00,$0000
		dc.w	$7800,$0000
		dc.w	$F800,$0000
		dc.w	$7800,$0000
		dc.w	$F800,$0000
		dc.w	$3000,$0000
		dc.w	$0C00,$0000
		dc.w	$D800,$0000
		dc.w	$C000,$0000
		dc.w	$EE00,$0000
		dc.w	$EC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$3000,$0000
		dc.w	$0C00,$0000
		dc.w	$F000,$0000
		dc.w	$C000,$0000
		dc.w	$FE00,$0000
		dc.w	$FC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$3000,$0000
		dc.w	$0C00,$0000
		dc.w	$F000,$0000
		dc.w	$C000,$0000
		dc.w	$D600,$0000
		dc.w	$FC00,$0000
		dc.w	$CC00,$0000
		dc.w	$F800,$0000
		dc.w	$CC00,$0000
		dc.w	$F800,$0000
		dc.w	$3000,$0000
		dc.w	$CC00,$0000
		dc.w	$D800,$0000
		dc.w	$C000,$0000
		dc.w	$C600,$0000
		dc.w	$DC00,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$D800,$0000
		dc.w	$D800,$0000
		dc.w	$FC00,$0000
		dc.w	$7800,$0000
		dc.w	$CC00,$0000
		dc.w	$FC00,$0000
		dc.w	$C600,$0000
		dc.w	$CC00,$0000
		dc.w	$7800,$0000
		dc.w	$C000,$0000
		dc.w	$6C00,$0000
		dc.w	$CC00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FE00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7800,$0000
		dc.w	$FC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$C600,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$FC00,$0000
		dc.w	$F000,$0000
		dc.w	$8000,$0000
		dc.w	$C000,$0000
		dc.w	$3000,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$C600,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$1800,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$7800,$0000
		dc.w	$3000,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$D600,$0000
		dc.w	$7800,$0000
		dc.w	$7800,$0000
		dc.w	$3000,$0000
		dc.w	$C000,$0000
		dc.w	$6000,$0000
		dc.w	$0C00,$0000
		dc.w	$3000,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$FE00,$0000
		dc.w	$7800,$0000
		dc.w	$3000,$0000
		dc.w	$6000,$0000
		dc.w	$C000,$0000
		dc.w	$3000,$0000
		dc.w	$0C00,$0000
		dc.w	$3000,$0000
		dc.w	$CC00,$0000
		dc.w	$7800,$0000
		dc.w	$EE00,$0000
		dc.w	$CC00,$0000
		dc.w	$3000,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$1800,$0000
		dc.w	$7800,$0000
		dc.w	$3000,$0000
		dc.w	$FC00,$0000
		dc.w	$3000,$0000
		dc.w	$C600,$0000
		dc.w	$CC00,$0000
		dc.w	$3000,$0000
		dc.w	$FC00,$0000
		dc.w	$F000,$0000
		dc.w	$0C00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FE00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$F000,$0000
		dc.w	$FC00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$F000,$0000
		dc.w	$1000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0C00,$0000
		dc.w	$0000,$0000
		dc.w	$3800,$0000
		dc.w	$3000,$0000
		dc.w	$3800,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$7800,$0000
		dc.w	$C000,$0000
		dc.w	$7800,$0000
		dc.w	$0C00,$0000
		dc.w	$7800,$0000
		dc.w	$6000,$0000
		dc.w	$3000,$0000
		dc.w	$6C00,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0C00,$0000
		dc.w	$F800,$0000
		dc.w	$C000,$0000
		dc.w	$7C00,$0000
		dc.w	$CC00,$0000
		dc.w	$F800,$0000
		dc.w	$3000,$0000
		dc.w	$C600,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7C00,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$CC00,$0000
		dc.w	$FC00,$0000
		dc.w	$6000,$0000
		dc.w	$3000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$6000,$0000
		dc.w	$F000,$0000
		dc.w	$0000,$0000
		dc.w	$FF00,$0000
		dc.w	$0000,$0000
		dc.w	$7C00,$0000
		dc.w	$F800,$0000
		dc.w	$7800,$0000
		dc.w	$7C00,$0000
		dc.w	$7800,$0000
		dc.w	$6000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$F000,$0000
		dc.w	$FE00,$0000
		dc.w	$FF00,$0000
		dc.w	$C000,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$F800,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$6000,$0000
		dc.w	$1800,$0000
		dc.w	$C000,$0000
		dc.w	$E000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7C00,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$6000,$0000
		dc.w	$CC00,$0000
		dc.w	$F800,$0000
		dc.w	$7800,$0000
		dc.w	$F800,$0000
		dc.w	$CC00,$0000
		dc.w	$F800,$0000
		dc.w	$E000,$0000
		dc.w	$1800,$0000
		dc.w	$D800,$0000
		dc.w	$6000,$0000
		dc.w	$FE00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$6000,$0000
		dc.w	$1800,$0000
		dc.w	$F000,$0000
		dc.w	$6000,$0000
		dc.w	$FE00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$7C00,$0000
		dc.w	$CC00,$0000
		dc.w	$6000,$0000
		dc.w	$1800,$0000
		dc.w	$D800,$0000
		dc.w	$6000,$0000
		dc.w	$D600,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$F800,$0000
		dc.w	$0C00,$0000
		dc.w	$CC00,$0000
		dc.w	$F000,$0000
		dc.w	$1800,$0000
		dc.w	$CC00,$0000
		dc.w	$F000,$0000
		dc.w	$C600,$0000
		dc.w	$CC00,$0000
		dc.w	$7800,$0000
		dc.w	$C000,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$F000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$F000,$0000
		dc.w	$F800,$0000
		dc.w	$FC00,$0000
		dc.w	$F000,$0000
		dc.w	$FE00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7C00,$0000
		dc.w	$F800,$0000
		dc.w	$7C00,$0000
		dc.w	$FC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$C600,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$FC00,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$3000,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$D600,$0000
		dc.w	$7800,$0000
		dc.w	$CC00,$0000
		dc.w	$1800,$0000
		dc.w	$CC00,$0000
		dc.w	$C000,$0000
		dc.w	$7800,$0000
		dc.w	$3000,$0000
		dc.w	$CC00,$0000
		dc.w	$CC00,$0000
		dc.w	$FE00,$0000
		dc.w	$3000,$0000
		dc.w	$CC00,$0000
		dc.w	$3000,$0000
		dc.w	$7C00,$0000
		dc.w	$C000,$0000
		dc.w	$0C00,$0000
		dc.w	$3000,$0000
		dc.w	$CC00,$0000
		dc.w	$7800,$0000
		dc.w	$7C00,$0000
		dc.w	$7800,$0000
		dc.w	$7C00,$0000
		dc.w	$6000,$0000
		dc.w	$0C00,$0000
		dc.w	$C000,$0000
		dc.w	$F800,$0000
		dc.w	$1C00,$0000
		dc.w	$7C00,$0000
		dc.w	$3000,$0000
		dc.w	$6C00,$0000
		dc.w	$CC00,$0000
		dc.w	$1800,$0000
		dc.w	$FC00,$0000
		dc.w	$0C00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$F000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FE00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
