; MV Boli
*
*  NEOchrome V2.27 cut buffer contents (left justified):
*  by Chaos, Inc. of the Delta Force (member of The Union)
*
*    pixels/scanline    = $0140 (bytes/scanline: $00A0)
*  # scanlines (height) = $00C8
*
*  Hardware color pallet  (color 0 to 15):
*
*      $0000,$0FFF,$0000,$0000,$0000,$0000,$0000,$0000
*      $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
*
*
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1000,$0000
		dc.w	$4800,$0000
		dc.w	$1200,$0000
		dc.w	$0400,$0000
		dc.w	$3100,$0000
		dc.w	$1C00,$0000
		dc.w	$4000,$0000
		dc.w	$0C00,$0000
		dc.w	$0800,$0000
		dc.w	$2000,$0000
		dc.w	$1000,$0000
		dc.w	$9000,$0000
		dc.w	$1200,$0000
		dc.w	$1E00,$0000
		dc.w	$5200,$0000
		dc.w	$2200,$0000
		dc.w	$4000,$0000
		dc.w	$1000,$0000
		dc.w	$0400,$0000
		dc.w	$F000,$0000
		dc.w	$2000,$0000
		dc.w	$9000,$0000
		dc.w	$7E00,$0000
		dc.w	$2800,$0000
		dc.w	$6400,$0000
		dc.w	$2400,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$0400,$0000
		dc.w	$F000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$2400,$0000
		dc.w	$3000,$0000
		dc.w	$0800,$0000
		dc.w	$3800,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0400,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$2400,$0000
		dc.w	$1800,$0000
		dc.w	$1000,$0000
		dc.w	$5100,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0400,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$FE00,$0000
		dc.w	$1400,$0000
		dc.w	$2600,$0000
		dc.w	$8A00,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4800,$0000
		dc.w	$F800,$0000
		dc.w	$4A00,$0000
		dc.w	$8C00,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0800,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$4800,$0000
		dc.w	$2000,$0000
		dc.w	$8C00,$0000
		dc.w	$7300,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$1000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$F000,$0000
		dc.w	$F800,$0000
		dc.w	$FE00,$0000
		dc.w	$FE00,$0000
		dc.w	$FF00,$0000
		dc.w	$FF00,$0000
		dc.w	$C000,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$F000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0200,$0000
		dc.w	$1C00,$0000
		dc.w	$7000,$0000
		dc.w	$1C00,$0000
		dc.w	$1C00,$0000
		dc.w	$1200,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0400,$0000
		dc.w	$2200,$0000
		dc.w	$2000,$0000
		dc.w	$2200,$0000
		dc.w	$2200,$0000
		dc.w	$2200,$0000
		dc.w	$1000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0800,$0000
		dc.w	$4200,$0000
		dc.w	$2000,$0000
		dc.w	$0200,$0000
		dc.w	$0200,$0000
		dc.w	$4400,$0000
		dc.w	$1000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1000,$0000
		dc.w	$4200,$0000
		dc.w	$4000,$0000
		dc.w	$0200,$0000
		dc.w	$1C00,$0000
		dc.w	$8400,$0000
		dc.w	$FC00,$0000
		dc.w	$0000,$0000
		dc.w	$F000,$0000
		dc.w	$0000,$0000
		dc.w	$2000,$0000
		dc.w	$8400,$0000
		dc.w	$4000,$0000
		dc.w	$0C00,$0000
		dc.w	$0400,$0000
		dc.w	$FE00,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$8400,$0000
		dc.w	$4000,$0000
		dc.w	$3000,$0000
		dc.w	$0400,$0000
		dc.w	$0800,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$8800,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$8800,$0000
		dc.w	$0800,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$7000,$0000
		dc.w	$8000,$0000
		dc.w	$FE00,$0000
		dc.w	$7000,$0000
		dc.w	$0800,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$FC00,$0000
		dc.w	$C000,$0000
		dc.w	$F000,$0000
		dc.w	$8000,$0000
		dc.w	$FE00,$0000
		dc.w	$FE00,$0000
		dc.w	$F000,$0000
		dc.w	$FE00,$0000
		dc.w	$FE00,$0000
		dc.w	$FE00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1E00,$0000
		dc.w	$1800,$0000
		dc.w	$FC00,$0000
		dc.w	$3800,$0000
		dc.w	$3800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1000,$0000
		dc.w	$2400,$0000
		dc.w	$0800,$0000
		dc.w	$4600,$0000
		dc.w	$4400,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$2000,$0000
		dc.w	$4000,$0000
		dc.w	$1000,$0000
		dc.w	$4800,$0000
		dc.w	$4400,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0C00,$0000
		dc.w	$0000,$0000
		dc.w	$6000,$0000
		dc.w	$3800,$0000
		dc.w	$B000,$0000
		dc.w	$2000,$0000
		dc.w	$3000,$0000
		dc.w	$4C00,$0000
		dc.w	$4000,$0000
		dc.w	$2000,$0000
		dc.w	$3000,$0000
		dc.w	$F800,$0000
		dc.w	$1800,$0000
		dc.w	$0400,$0000
		dc.w	$C800,$0000
		dc.w	$4000,$0000
		dc.w	$5000,$0000
		dc.w	$3800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0C00,$0000
		dc.w	$0400,$0000
		dc.w	$8800,$0000
		dc.w	$4000,$0000
		dc.w	$8800,$0000
		dc.w	$0800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$6000,$0000
		dc.w	$F800,$0000
		dc.w	$3000,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$8000,$0000
		dc.w	$8800,$0000
		dc.w	$1000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1800,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$7000,$0000
		dc.w	$7000,$0000
		dc.w	$8000,$0000
		dc.w	$7000,$0000
		dc.w	$E000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$FE00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FE00,$0000
		dc.w	$FC00,$0000
		dc.w	$C000,$0000
		dc.w	$E000,$0000
		dc.w	$FC00,$0000
		dc.w	$0000,$0000
		dc.w	$FC00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7800,$0000
		dc.w	$0F80,$0000
		dc.w	$0E00,$0000
		dc.w	$1E00,$0000
		dc.w	$1C00,$0000
		dc.w	$7C00,$0000
		dc.w	$3F00,$0000
		dc.w	$3E00,$0000
		dc.w	$0E00,$0000
		dc.w	$2100,$0000
		dc.w	$C800,$0000
		dc.w	$30C0,$0000
		dc.w	$1200,$0000
		dc.w	$2200,$0000
		dc.w	$3400,$0000
		dc.w	$3200,$0000
		dc.w	$2000,$0000
		dc.w	$6000,$0000
		dc.w	$1200,$0000
		dc.w	$2100,$0000
		dc.w	$1800,$0000
		dc.w	$6E40,$0000
		dc.w	$2200,$0000
		dc.w	$2600,$0000
		dc.w	$6000,$0000
		dc.w	$2100,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$2000,$0000
		dc.w	$2200,$0000
		dc.w	$2000,$0000
		dc.w	$5AC0,$0000
		dc.w	$6200,$0000
		dc.w	$5800,$0000
		dc.w	$4000,$0000
		dc.w	$2100,$0000
		dc.w	$4C00,$0000
		dc.w	$4000,$0000
		dc.w	$4600,$0000
		dc.w	$4200,$0000
		dc.w	$C000,$0000
		dc.w	$A580,$0000
		dc.w	$7E00,$0000
		dc.w	$7800,$0000
		dc.w	$8000,$0000
		dc.w	$2100,$0000
		dc.w	$7000,$0000
		dc.w	$7800,$0000
		dc.w	$9A00,$0000
		dc.w	$4E00,$0000
		dc.w	$8000,$0000
		dc.w	$BE00,$0000
		dc.w	$C200,$0000
		dc.w	$4400,$0000
		dc.w	$8000,$0000
		dc.w	$4200,$0000
		dc.w	$8000,$0000
		dc.w	$C000,$0000
		dc.w	$8400,$0000
		dc.w	$7400,$0000
		dc.w	$0000,$0000
		dc.w	$8100,$0000
		dc.w	$8400,$0000
		dc.w	$8C00,$0000
		dc.w	$8C00,$0000
		dc.w	$5C00,$0000
		dc.w	$8C00,$0000
		dc.w	$8000,$0000
		dc.w	$8C00,$0000
		dc.w	$8400,$0000
		dc.w	$8000,$0000
		dc.w	$C600,$0000
		dc.w	$8400,$0000
		dc.w	$F000,$0000
		dc.w	$7800,$0000
		dc.w	$F000,$0000
		dc.w	$F000,$0000
		dc.w	$8000,$0000
		dc.w	$7000,$0000
		dc.w	$8400,$0000
		dc.w	$0000,$0000
		dc.w	$7800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$F800,$0000
		dc.w	$FFC0,$0000
		dc.w	$FE00,$0000
		dc.w	$FE00,$0000
		dc.w	$FC00,$0000
		dc.w	$FF00,$0000
		dc.w	$FF00,$0000
		dc.w	$FE00,$0000
		dc.w	$FE00,$0000
		dc.w	$FF00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0080,$0000
		dc.w	$0000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$2000,$0000
		dc.w	$0300,$0000
		dc.w	$4200,$0000
		dc.w	$2000,$0000
		dc.w	$0880,$0000
		dc.w	$2080,$0000
		dc.w	$1E00,$0000
		dc.w	$7C00,$0000
		dc.w	$1E00,$0000
		dc.w	$3C00,$0000
		dc.w	$2000,$0000
		dc.w	$0E00,$0000
		dc.w	$4400,$0000
		dc.w	$4000,$0000
		dc.w	$3980,$0000
		dc.w	$3080,$0000
		dc.w	$3100,$0000
		dc.w	$2200,$0000
		dc.w	$3100,$0000
		dc.w	$2200,$0000
		dc.w	$4000,$0000
		dc.w	$0200,$0000
		dc.w	$4800,$0000
		dc.w	$4000,$0000
		dc.w	$2A80,$0000
		dc.w	$5100,$0000
		dc.w	$6100,$0000
		dc.w	$4200,$0000
		dc.w	$4100,$0000
		dc.w	$4600,$0000
		dc.w	$4000,$0000
		dc.w	$0200,$0000
		dc.w	$5000,$0000
		dc.w	$4000,$0000
		dc.w	$4C80,$0000
		dc.w	$5100,$0000
		dc.w	$4100,$0000
		dc.w	$4C00,$0000
		dc.w	$8100,$0000
		dc.w	$4C00,$0000
		dc.w	$4000,$0000
		dc.w	$0200,$0000
		dc.w	$F800,$0000
		dc.w	$4000,$0000
		dc.w	$4D00,$0000
		dc.w	$4900,$0000
		dc.w	$8300,$0000
		dc.w	$7000,$0000
		dc.w	$9200,$0000
		dc.w	$7800,$0000
		dc.w	$8000,$0000
		dc.w	$0400,$0000
		dc.w	$8400,$0000
		dc.w	$8400,$0000
		dc.w	$5900,$0000
		dc.w	$4A00,$0000
		dc.w	$8200,$0000
		dc.w	$8000,$0000
		dc.w	$9400,$0000
		dc.w	$CC00,$0000
		dc.w	$8000,$0000
		dc.w	$8400,$0000
		dc.w	$8200,$0000
		dc.w	$9800,$0000
		dc.w	$9100,$0000
		dc.w	$8600,$0000
		dc.w	$8C00,$0000
		dc.w	$8000,$0000
		dc.w	$7800,$0000
		dc.w	$8600,$0000
		dc.w	$8000,$0000
		dc.w	$C800,$0000
		dc.w	$8200,$0000
		dc.w	$E000,$0000
		dc.w	$9100,$0000
		dc.w	$8600,$0000
		dc.w	$7800,$0000
		dc.w	$8000,$0000
		dc.w	$0800,$0000
		dc.w	$8200,$0000
		dc.w	$0000,$0000
		dc.w	$7000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0C00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$E000,$0000
		dc.w	$FF00,$0000
		dc.w	$FE00,$0000
		dc.w	$FC00,$0000
		dc.w	$FF80,$0000
		dc.w	$FF80,$0000
		dc.w	$FF00,$0000
		dc.w	$FE00,$0000
		dc.w	$FF00,$0000
		dc.w	$FE00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0E00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0040,$0000
		dc.w	$0000,$0000
		dc.w	$0200,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3000,$0000
		dc.w	$3E00,$0000
		dc.w	$0200,$0000
		dc.w	$8400,$0000
		dc.w	$2040,$0000
		dc.w	$1080,$0000
		dc.w	$4200,$0000
		dc.w	$0F00,$0000
		dc.w	$1C00,$0000
		dc.w	$8000,$0000
		dc.w	$6000,$0000
		dc.w	$F000,$0000
		dc.w	$4200,$0000
		dc.w	$8400,$0000
		dc.w	$6040,$0000
		dc.w	$1100,$0000
		dc.w	$4400,$0000
		dc.w	$3300,$0000
		dc.w	$2000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$1000,$0000
		dc.w	$4200,$0000
		dc.w	$8800,$0000
		dc.w	$4480,$0000
		dc.w	$0A00,$0000
		dc.w	$2400,$0000
		dc.w	$0600,$0000
		dc.w	$2000,$0000
		dc.w	$4000,$0000
		dc.w	$7C00,$0000
		dc.w	$1000,$0000
		dc.w	$4400,$0000
		dc.w	$8800,$0000
		dc.w	$4880,$0000
		dc.w	$0C00,$0000
		dc.w	$2800,$0000
		dc.w	$0C00,$0000
		dc.w	$2000,$0000
		dc.w	$4000,$0000
		dc.w	$0400,$0000
		dc.w	$1000,$0000
		dc.w	$8400,$0000
		dc.w	$9000,$0000
		dc.w	$8880,$0000
		dc.w	$0800,$0000
		dc.w	$3000,$0000
		dc.w	$1000,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$0C00,$0000
		dc.w	$2000,$0000
		dc.w	$8800,$0000
		dc.w	$9000,$0000
		dc.w	$9900,$0000
		dc.w	$1400,$0000
		dc.w	$2000,$0000
		dc.w	$2200,$0000
		dc.w	$4000,$0000
		dc.w	$2000,$0000
		dc.w	$1800,$0000
		dc.w	$2000,$0000
		dc.w	$9800,$0000
		dc.w	$A000,$0000
		dc.w	$AB00,$0000
		dc.w	$6600,$0000
		dc.w	$2000,$0000
		dc.w	$4C00,$0000
		dc.w	$4000,$0000
		dc.w	$2000,$0000
		dc.w	$F000,$0000
		dc.w	$2000,$0000
		dc.w	$E000,$0000
		dc.w	$4000,$0000
		dc.w	$C600,$0000
		dc.w	$8200,$0000
		dc.w	$4000,$0000
		dc.w	$F000,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$E000,$0000
		dc.w	$0000,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FE00,$0000
		dc.w	$F800,$0000
		dc.w	$FFC0,$0000
		dc.w	$FF80,$0000
		dc.w	$FC00,$0000
		dc.w	$FF00,$0000
		dc.w	$FC00,$0000
		dc.w	$E000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1C00,$0000
		dc.w	$3000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0400,$0000
		dc.w	$0000,$0000
		dc.w	$3800,$0000
		dc.w	$0400,$0000
		dc.w	$7000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0400,$0000
		dc.w	$0000,$0000
		dc.w	$2800,$0000
		dc.w	$0800,$0000
		dc.w	$5000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0800,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0800,$0000
		dc.w	$8800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3800,$0000
		dc.w	$7800,$0000
		dc.w	$3000,$0000
		dc.w	$3800,$0000
		dc.w	$3000,$0000
		dc.w	$4000,$0000
		dc.w	$0800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4800,$0000
		dc.w	$4800,$0000
		dc.w	$4000,$0000
		dc.w	$4800,$0000
		dc.w	$5000,$0000
		dc.w	$E000,$0000
		dc.w	$0800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$9000,$0000
		dc.w	$8800,$0000
		dc.w	$8000,$0000
		dc.w	$8800,$0000
		dc.w	$E000,$0000
		dc.w	$8000,$0000
		dc.w	$1000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$B000,$0000
		dc.w	$9000,$0000
		dc.w	$9000,$0000
		dc.w	$9800,$0000
		dc.w	$9000,$0000
		dc.w	$8000,$0000
		dc.w	$1000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$D000,$0000
		dc.w	$E000,$0000
		dc.w	$E000,$0000
		dc.w	$E800,$0000
		dc.w	$E000,$0000
		dc.w	$8000,$0000
		dc.w	$1000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$E000,$0000
		dc.w	$0000,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$FC00,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$C000,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F000,$0000
		dc.w	$FC00,$0000
		dc.w	$F000,$0000
		dc.w	$F000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$2000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$2000,$0000
		dc.w	$4000,$0000
		dc.w	$1000,$0000
		dc.w	$2000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4800,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3000,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$1000,$0000
		dc.w	$5000,$0000
		dc.w	$4000,$0000
		dc.w	$5B00,$0000
		dc.w	$5800,$0000
		dc.w	$3800,$0000
		dc.w	$7800,$0000
		dc.w	$5000,$0000
		dc.w	$5800,$0000
		dc.w	$4000,$0000
		dc.w	$1000,$0000
		dc.w	$6000,$0000
		dc.w	$4000,$0000
		dc.w	$6D00,$0000
		dc.w	$6800,$0000
		dc.w	$4800,$0000
		dc.w	$6800,$0000
		dc.w	$B000,$0000
		dc.w	$E800,$0000
		dc.w	$8000,$0000
		dc.w	$1000,$0000
		dc.w	$D000,$0000
		dc.w	$8000,$0000
		dc.w	$4900,$0000
		dc.w	$4800,$0000
		dc.w	$8800,$0000
		dc.w	$4800,$0000
		dc.w	$D000,$0000
		dc.w	$D000,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$9000,$0000
		dc.w	$8000,$0000
		dc.w	$9100,$0000
		dc.w	$9000,$0000
		dc.w	$9000,$0000
		dc.w	$5000,$0000
		dc.w	$1000,$0000
		dc.w	$9000,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$9000,$0000
		dc.w	$8000,$0000
		dc.w	$9200,$0000
		dc.w	$9000,$0000
		dc.w	$E000,$0000
		dc.w	$6000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$6000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$F000,$0000
		dc.w	$F800,$0000
		dc.w	$C000,$0000
		dc.w	$F000,$0000
		dc.w	$F800,$0000
		dc.w	$C000,$0000
		dc.w	$FF00,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0800,$0000
		dc.w	$7800,$0000
		dc.w	$3000,$0000
		dc.w	$3800,$0000
		dc.w	$4C00,$0000
		dc.w	$8800,$0000
		dc.w	$8100,$0000
		dc.w	$2400,$0000
		dc.w	$6400,$0000
		dc.w	$7800,$0000
		dc.w	$3800,$0000
		dc.w	$4800,$0000
		dc.w	$4000,$0000
		dc.w	$E000,$0000
		dc.w	$8800,$0000
		dc.w	$9000,$0000
		dc.w	$8A00,$0000
		dc.w	$1800,$0000
		dc.w	$4800,$0000
		dc.w	$1000,$0000
		dc.w	$4800,$0000
		dc.w	$8000,$0000
		dc.w	$6000,$0000
		dc.w	$4000,$0000
		dc.w	$8800,$0000
		dc.w	$9000,$0000
		dc.w	$9A00,$0000
		dc.w	$1000,$0000
		dc.w	$5800,$0000
		dc.w	$2000,$0000
		dc.w	$9000,$0000
		dc.w	$8000,$0000
		dc.w	$1000,$0000
		dc.w	$4800,$0000
		dc.w	$9800,$0000
		dc.w	$6000,$0000
		dc.w	$AC00,$0000
		dc.w	$7800,$0000
		dc.w	$6800,$0000
		dc.w	$4800,$0000
		dc.w	$F000,$0000
		dc.w	$8000,$0000
		dc.w	$E000,$0000
		dc.w	$7000,$0000
		dc.w	$E800,$0000
		dc.w	$4000,$0000
		dc.w	$CC00,$0000
		dc.w	$8800,$0000
		dc.w	$1000,$0000
		dc.w	$F000,$0000
		dc.w	$1000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$1000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F000,$0000
		dc.w	$F800,$0000
		dc.w	$FC00,$0000
		dc.w	$F800,$0000
		dc.w	$FF00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0200,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0600,$0000
		dc.w	$0A00,$0000
		dc.w	$0A00,$0000
		dc.w	$1400,$0000
		dc.w	$0C00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0A00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0C00,$0000
		dc.w	$0000,$0000
		dc.w	$0C00,$0000
		dc.w	$1000,$0000
		dc.w	$3000,$0000
		dc.w	$0E00,$0000
		dc.w	$0E00,$0000
		dc.w	$1E00,$0000
		dc.w	$0200,$0000
		dc.w	$3F00,$0000
		dc.w	$1400,$0000
		dc.w	$0000,$0000
		dc.w	$1000,$0000
		dc.w	$1000,$0000
		dc.w	$0800,$0000
		dc.w	$1200,$0000
		dc.w	$1200,$0000
		dc.w	$3100,$0000
		dc.w	$4200,$0000
		dc.w	$2000,$0000
		dc.w	$1800,$0000
		dc.w	$2800,$0000
		dc.w	$1000,$0000
		dc.w	$2000,$0000
		dc.w	$0800,$0000
		dc.w	$2200,$0000
		dc.w	$2200,$0000
		dc.w	$6100,$0000
		dc.w	$4200,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$2000,$0000
		dc.w	$2000,$0000
		dc.w	$1000,$0000
		dc.w	$6200,$0000
		dc.w	$6200,$0000
		dc.w	$4100,$0000
		dc.w	$4400,$0000
		dc.w	$4C00,$0000
		dc.w	$3800,$0000
		dc.w	$3800,$0000
		dc.w	$C000,$0000
		dc.w	$4000,$0000
		dc.w	$1000,$0000
		dc.w	$7E00,$0000
		dc.w	$7E00,$0000
		dc.w	$8300,$0000
		dc.w	$8400,$0000
		dc.w	$7000,$0000
		dc.w	$4800,$0000
		dc.w	$4800,$0000
		dc.w	$2000,$0000
		dc.w	$4000,$0000
		dc.w	$0C00,$0000
		dc.w	$C200,$0000
		dc.w	$C200,$0000
		dc.w	$8200,$0000
		dc.w	$8800,$0000
		dc.w	$8000,$0000
		dc.w	$9000,$0000
		dc.w	$9000,$0000
		dc.w	$2000,$0000
		dc.w	$4000,$0000
		dc.w	$1000,$0000
		dc.w	$8400,$0000
		dc.w	$8400,$0000
		dc.w	$8C00,$0000
		dc.w	$9800,$0000
		dc.w	$8C00,$0000
		dc.w	$B000,$0000
		dc.w	$B000,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$8400,$0000
		dc.w	$8400,$0000
		dc.w	$7800,$0000
		dc.w	$E000,$0000
		dc.w	$F000,$0000
		dc.w	$D000,$0000
		dc.w	$D000,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3000,$0000
		dc.w	$8000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$FC00,$0000
		dc.w	$F000,$0000
		dc.w	$FC00,$0000
		dc.w	$FE00,$0000
		dc.w	$FE00,$0000
		dc.w	$FF00,$0000
		dc.w	$FE00,$0000
		dc.w	$FE00,$0000
		dc.w	$FC00,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$2800,$0000
		dc.w	$2800,$0000
		dc.w	$3000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3800,$0000
		dc.w	$4C00,$0000
		dc.w	$3000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4800,$0000
		dc.w	$8800,$0000
		dc.w	$5000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$E000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$9000,$0000
		dc.w	$9800,$0000
		dc.w	$9000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$E000,$0000
		dc.w	$E800,$0000
		dc.w	$E000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$F800,$0000
		dc.w	$FC00,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
