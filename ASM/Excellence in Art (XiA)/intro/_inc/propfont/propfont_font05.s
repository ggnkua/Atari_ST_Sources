; Palatino Linotype
*
*  NEOchrome V2.27 cut buffer contents (left justified):
*  by Chaos, Inc. of the Delta Force (member of The Union)
*
*    pixels/scanline    = $0140 (bytes/scanline: $00A0)
*  # scanlines (height) = $00C8
*
*  Hardware color pallet  (color 0 to 15):
*
*      $0000,$0FFF,$0000,$0000,$0000,$0000,$0000,$0000
*      $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
*
*
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$5000,$0000
		dc.w	$5000,$0000
		dc.w	$7000,$0000
		dc.w	$6200,$0000
		dc.w	$3000,$0000
		dc.w	$4000,$0000
		dc.w	$2000,$0000
		dc.w	$8000,$0000
		dc.w	$A000,$0000
		dc.w	$8000,$0000
		dc.w	$5000,$0000
		dc.w	$5000,$0000
		dc.w	$A800,$0000
		dc.w	$9400,$0000
		dc.w	$5000,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$7000,$0000
		dc.w	$8000,$0000
		dc.w	$A000,$0000
		dc.w	$F800,$0000
		dc.w	$A000,$0000
		dc.w	$9800,$0000
		dc.w	$5000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$A000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$5000,$0000
		dc.w	$E000,$0000
		dc.w	$6800,$0000
		dc.w	$6700,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$2000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$A000,$0000
		dc.w	$3800,$0000
		dc.w	$1600,$0000
		dc.w	$A200,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$F000,$0000
		dc.w	$2800,$0000
		dc.w	$1900,$0000
		dc.w	$9200,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$A000,$0000
		dc.w	$A800,$0000
		dc.w	$2900,$0000
		dc.w	$8C00,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$A000,$0000
		dc.w	$7000,$0000
		dc.w	$4600,$0000
		dc.w	$7700,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$2000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$F000,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$FF00,$0000
		dc.w	$FF00,$0000
		dc.w	$C000,$0000
		dc.w	$E000,$0000
		dc.w	$E000,$0000
		dc.w	$F000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1000,$0000
		dc.w	$7000,$0000
		dc.w	$6000,$0000
		dc.w	$7000,$0000
		dc.w	$7000,$0000
		dc.w	$1000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1000,$0000
		dc.w	$8800,$0000
		dc.w	$A000,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$3000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$2000,$0000
		dc.w	$8800,$0000
		dc.w	$2000,$0000
		dc.w	$0800,$0000
		dc.w	$0800,$0000
		dc.w	$5000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$2000,$0000
		dc.w	$8800,$0000
		dc.w	$2000,$0000
		dc.w	$0800,$0000
		dc.w	$7000,$0000
		dc.w	$5000,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$8800,$0000
		dc.w	$2000,$0000
		dc.w	$1000,$0000
		dc.w	$0800,$0000
		dc.w	$9000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$E000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$8800,$0000
		dc.w	$2000,$0000
		dc.w	$2000,$0000
		dc.w	$0800,$0000
		dc.w	$F800,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$8800,$0000
		dc.w	$2000,$0000
		dc.w	$4000,$0000
		dc.w	$8800,$0000
		dc.w	$1000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$7000,$0000
		dc.w	$7000,$0000
		dc.w	$F800,$0000
		dc.w	$F000,$0000
		dc.w	$3800,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$F800,$0000
		dc.w	$C000,$0000
		dc.w	$E000,$0000
		dc.w	$8000,$0000
		dc.w	$F000,$0000
		dc.w	$F800,$0000
		dc.w	$F000,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7800,$0000
		dc.w	$3000,$0000
		dc.w	$F800,$0000
		dc.w	$7000,$0000
		dc.w	$7000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$1000,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1800,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$7000,$0000
		dc.w	$B000,$0000
		dc.w	$1000,$0000
		dc.w	$7000,$0000
		dc.w	$9800,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$6000,$0000
		dc.w	$F800,$0000
		dc.w	$3000,$0000
		dc.w	$4800,$0000
		dc.w	$C800,$0000
		dc.w	$2000,$0000
		dc.w	$8800,$0000
		dc.w	$6800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0800,$0000
		dc.w	$0800,$0000
		dc.w	$8800,$0000
		dc.w	$2000,$0000
		dc.w	$8800,$0000
		dc.w	$0800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$6000,$0000
		dc.w	$F800,$0000
		dc.w	$3000,$0000
		dc.w	$8800,$0000
		dc.w	$8800,$0000
		dc.w	$4000,$0000
		dc.w	$8800,$0000
		dc.w	$1000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1800,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$7000,$0000
		dc.w	$7000,$0000
		dc.w	$4000,$0000
		dc.w	$7000,$0000
		dc.w	$6000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$8000,$0000
		dc.w	$C000,$0000
		dc.w	$FC00,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$E000,$0000
		dc.w	$0000,$0000
		dc.w	$0800,$0000
		dc.w	$F800,$0000
		dc.w	$3C00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$3E00,$0000
		dc.w	$E380,$0000
		dc.w	$9000,$0000
		dc.w	$3C00,$0000
		dc.w	$0800,$0000
		dc.w	$4400,$0000
		dc.w	$4400,$0000
		dc.w	$4200,$0000
		dc.w	$4400,$0000
		dc.w	$4400,$0000
		dc.w	$4200,$0000
		dc.w	$4100,$0000
		dc.w	$1000,$0000
		dc.w	$4200,$0000
		dc.w	$1400,$0000
		dc.w	$4400,$0000
		dc.w	$8000,$0000
		dc.w	$4100,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$4100,$0000
		dc.w	$2000,$0000
		dc.w	$9A00,$0000
		dc.w	$1400,$0000
		dc.w	$7800,$0000
		dc.w	$8000,$0000
		dc.w	$4100,$0000
		dc.w	$7800,$0000
		dc.w	$7800,$0000
		dc.w	$8000,$0000
		dc.w	$7F00,$0000
		dc.w	$4000,$0000
		dc.w	$AA00,$0000
		dc.w	$2200,$0000
		dc.w	$4400,$0000
		dc.w	$8000,$0000
		dc.w	$4100,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$8700,$0000
		dc.w	$4100,$0000
		dc.w	$4000,$0000
		dc.w	$BC00,$0000
		dc.w	$3E00,$0000
		dc.w	$4400,$0000
		dc.w	$8000,$0000
		dc.w	$4100,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$8200,$0000
		dc.w	$4100,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$4100,$0000
		dc.w	$4400,$0000
		dc.w	$4400,$0000
		dc.w	$4200,$0000
		dc.w	$4400,$0000
		dc.w	$4000,$0000
		dc.w	$4200,$0000
		dc.w	$4100,$0000
		dc.w	$4000,$0000
		dc.w	$7C00,$0000
		dc.w	$E380,$0000
		dc.w	$F800,$0000
		dc.w	$3800,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$E000,$0000
		dc.w	$3C00,$0000
		dc.w	$E380,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$F000,$0000
		dc.w	$FE00,$0000
		dc.w	$FF80,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FF00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FF00,$0000
		dc.w	$FF80,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$E000,$0000
		dc.w	$E000,$0000
		dc.w	$E300,$0000
		dc.w	$E000,$0000
		dc.w	$E0E0,$0000
		dc.w	$C380,$0000
		dc.w	$3800,$0000
		dc.w	$F800,$0000
		dc.w	$3800,$0000
		dc.w	$F800,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$4400,$0000
		dc.w	$4000,$0000
		dc.w	$60C0,$0000
		dc.w	$6100,$0000
		dc.w	$4400,$0000
		dc.w	$4400,$0000
		dc.w	$4400,$0000
		dc.w	$4400,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$4800,$0000
		dc.w	$4000,$0000
		dc.w	$5140,$0000
		dc.w	$5100,$0000
		dc.w	$8200,$0000
		dc.w	$4400,$0000
		dc.w	$8200,$0000
		dc.w	$4400,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$5000,$0000
		dc.w	$4000,$0000
		dc.w	$5140,$0000
		dc.w	$4900,$0000
		dc.w	$8200,$0000
		dc.w	$4400,$0000
		dc.w	$8200,$0000
		dc.w	$4800,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$7000,$0000
		dc.w	$4000,$0000
		dc.w	$4A40,$0000
		dc.w	$4900,$0000
		dc.w	$8200,$0000
		dc.w	$5800,$0000
		dc.w	$8200,$0000
		dc.w	$5000,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$4800,$0000
		dc.w	$4000,$0000
		dc.w	$4A40,$0000
		dc.w	$4500,$0000
		dc.w	$8200,$0000
		dc.w	$4000,$0000
		dc.w	$8200,$0000
		dc.w	$4800,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$4400,$0000
		dc.w	$4400,$0000
		dc.w	$4440,$0000
		dc.w	$4300,$0000
		dc.w	$4400,$0000
		dc.w	$4000,$0000
		dc.w	$4400,$0000
		dc.w	$4400,$0000
		dc.w	$E000,$0000
		dc.w	$4000,$0000
		dc.w	$E300,$0000
		dc.w	$FC00,$0000
		dc.w	$E4E0,$0000
		dc.w	$E100,$0000
		dc.w	$3800,$0000
		dc.w	$E000,$0000
		dc.w	$3800,$0000
		dc.w	$E600,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4E00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$E000,$0000
		dc.w	$E000,$0000
		dc.w	$FF00,$0000
		dc.w	$FC00,$0000
		dc.w	$FFE0,$0000
		dc.w	$FF80,$0000
		dc.w	$FE00,$0000
		dc.w	$FC00,$0000
		dc.w	$FE00,$0000
		dc.w	$FE00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7800,$0000
		dc.w	$FE00,$0000
		dc.w	$E700,$0000
		dc.w	$E380,$0000
		dc.w	$E4E0,$0000
		dc.w	$C600,$0000
		dc.w	$C200,$0000
		dc.w	$FC00,$0000
		dc.w	$C000,$0000
		dc.w	$8000,$0000
		dc.w	$8800,$0000
		dc.w	$9200,$0000
		dc.w	$4200,$0000
		dc.w	$4100,$0000
		dc.w	$4440,$0000
		dc.w	$4400,$0000
		dc.w	$4400,$0000
		dc.w	$8800,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$1000,$0000
		dc.w	$4200,$0000
		dc.w	$2200,$0000
		dc.w	$4440,$0000
		dc.w	$2800,$0000
		dc.w	$2800,$0000
		dc.w	$1000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$7000,$0000
		dc.w	$1000,$0000
		dc.w	$4200,$0000
		dc.w	$2200,$0000
		dc.w	$2A80,$0000
		dc.w	$1000,$0000
		dc.w	$2800,$0000
		dc.w	$1000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$0800,$0000
		dc.w	$1000,$0000
		dc.w	$4200,$0000
		dc.w	$1400,$0000
		dc.w	$2A80,$0000
		dc.w	$1000,$0000
		dc.w	$1000,$0000
		dc.w	$2000,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$0800,$0000
		dc.w	$1000,$0000
		dc.w	$4200,$0000
		dc.w	$1400,$0000
		dc.w	$2A80,$0000
		dc.w	$2800,$0000
		dc.w	$1000,$0000
		dc.w	$2000,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$8800,$0000
		dc.w	$1000,$0000
		dc.w	$4200,$0000
		dc.w	$0800,$0000
		dc.w	$1100,$0000
		dc.w	$4400,$0000
		dc.w	$1000,$0000
		dc.w	$4400,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$F000,$0000
		dc.w	$3800,$0000
		dc.w	$3C00,$0000
		dc.w	$0800,$0000
		dc.w	$1100,$0000
		dc.w	$C600,$0000
		dc.w	$3800,$0000
		dc.w	$FC00,$0000
		dc.w	$8000,$0000
		dc.w	$1000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$1000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$F800,$0000
		dc.w	$FE00,$0000
		dc.w	$FF00,$0000
		dc.w	$FF00,$0000
		dc.w	$FFC0,$0000
		dc.w	$FE00,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$C000,$0000
		dc.w	$F000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$3000,$0000
		dc.w	$0000,$0000
		dc.w	$3000,$0000
		dc.w	$4000,$0000
		dc.w	$5000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$1000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$5000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$1000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$8800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$6000,$0000
		dc.w	$7000,$0000
		dc.w	$7000,$0000
		dc.w	$7000,$0000
		dc.w	$6000,$0000
		dc.w	$E000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1000,$0000
		dc.w	$4800,$0000
		dc.w	$9000,$0000
		dc.w	$9000,$0000
		dc.w	$9000,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7000,$0000
		dc.w	$4800,$0000
		dc.w	$8000,$0000
		dc.w	$9000,$0000
		dc.w	$F000,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$9000,$0000
		dc.w	$4800,$0000
		dc.w	$8000,$0000
		dc.w	$9000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7800,$0000
		dc.w	$7000,$0000
		dc.w	$7000,$0000
		dc.w	$7800,$0000
		dc.w	$7000,$0000
		dc.w	$E000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$FC00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$F800,$0000
		dc.w	$FC00,$0000
		dc.w	$C000,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$F000,$0000
		dc.w	$F800,$0000
		dc.w	$F000,$0000
		dc.w	$F000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7800,$0000
		dc.w	$7000,$0000
		dc.w	$C000,$0000
		dc.w	$C000,$0000
		dc.w	$4800,$0000
		dc.w	$4000,$0000
		dc.w	$F600,$0000
		dc.w	$F000,$0000
		dc.w	$7000,$0000
		dc.w	$F000,$0000
		dc.w	$9000,$0000
		dc.w	$4800,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$5000,$0000
		dc.w	$4000,$0000
		dc.w	$4900,$0000
		dc.w	$4800,$0000
		dc.w	$8800,$0000
		dc.w	$4800,$0000
		dc.w	$9000,$0000
		dc.w	$4800,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$6000,$0000
		dc.w	$4000,$0000
		dc.w	$4900,$0000
		dc.w	$4800,$0000
		dc.w	$8800,$0000
		dc.w	$4800,$0000
		dc.w	$6000,$0000
		dc.w	$4800,$0000
		dc.w	$4000,$0000
		dc.w	$4000,$0000
		dc.w	$5000,$0000
		dc.w	$4000,$0000
		dc.w	$4900,$0000
		dc.w	$4800,$0000
		dc.w	$8800,$0000
		dc.w	$4800,$0000
		dc.w	$8000,$0000
		dc.w	$EC00,$0000
		dc.w	$E000,$0000
		dc.w	$4000,$0000
		dc.w	$CC00,$0000
		dc.w	$E000,$0000
		dc.w	$FD80,$0000
		dc.w	$EC00,$0000
		dc.w	$7000,$0000
		dc.w	$7000,$0000
		dc.w	$7800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$8800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$F000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$E000,$0000
		dc.w	$F800,$0000
		dc.w	$FC00,$0000
		dc.w	$E000,$0000
		dc.w	$C000,$0000
		dc.w	$FC00,$0000
		dc.w	$E000,$0000
		dc.w	$FF80,$0000
		dc.w	$FC00,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7000,$0000
		dc.w	$D000,$0000
		dc.w	$6000,$0000
		dc.w	$E000,$0000
		dc.w	$D800,$0000
		dc.w	$EE00,$0000
		dc.w	$EB80,$0000
		dc.w	$C800,$0000
		dc.w	$EE00,$0000
		dc.w	$F800,$0000
		dc.w	$9000,$0000
		dc.w	$6000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$4800,$0000
		dc.w	$4400,$0000
		dc.w	$4900,$0000
		dc.w	$5000,$0000
		dc.w	$4400,$0000
		dc.w	$9000,$0000
		dc.w	$9000,$0000
		dc.w	$4000,$0000
		dc.w	$E000,$0000
		dc.w	$4000,$0000
		dc.w	$4800,$0000
		dc.w	$2800,$0000
		dc.w	$5500,$0000
		dc.w	$2000,$0000
		dc.w	$2800,$0000
		dc.w	$2000,$0000
		dc.w	$9000,$0000
		dc.w	$4000,$0000
		dc.w	$2000,$0000
		dc.w	$4000,$0000
		dc.w	$4800,$0000
		dc.w	$2800,$0000
		dc.w	$5500,$0000
		dc.w	$5000,$0000
		dc.w	$2800,$0000
		dc.w	$4800,$0000
		dc.w	$7000,$0000
		dc.w	$E000,$0000
		dc.w	$C000,$0000
		dc.w	$6000,$0000
		dc.w	$3C00,$0000
		dc.w	$1000,$0000
		dc.w	$2200,$0000
		dc.w	$9800,$0000
		dc.w	$1000,$0000
		dc.w	$F800,$0000
		dc.w	$1000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1000,$0000
		dc.w	$0000,$0000
		dc.w	$1000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1000,$0000
		dc.w	$0000,$0000
		dc.w	$3800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$6000,$0000
		dc.w	$0000,$0000
		dc.w	$F800,$0000
		dc.w	$F000,$0000
		dc.w	$E000,$0000
		dc.w	$E000,$0000
		dc.w	$FC00,$0000
		dc.w	$FC00,$0000
		dc.w	$FF80,$0000
		dc.w	$F800,$0000
		dc.w	$FE00,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1400,$0000
		dc.w	$1200,$0000
		dc.w	$4800,$0000
		dc.w	$2400,$0000
		dc.w	$1000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$6000,$0000
		dc.w	$8000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0800,$0000
		dc.w	$3800,$0000
		dc.w	$E700,$0000
		dc.w	$FC00,$0000
		dc.w	$5000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$0800,$0000
		dc.w	$0800,$0000
		dc.w	$4400,$0000
		dc.w	$4200,$0000
		dc.w	$4400,$0000
		dc.w	$2000,$0000
		dc.w	$9000,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$1400,$0000
		dc.w	$1400,$0000
		dc.w	$8200,$0000
		dc.w	$4200,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$1400,$0000
		dc.w	$1400,$0000
		dc.w	$8200,$0000
		dc.w	$4200,$0000
		dc.w	$7800,$0000
		dc.w	$6000,$0000
		dc.w	$6000,$0000
		dc.w	$8000,$0000
		dc.w	$8000,$0000
		dc.w	$2000,$0000
		dc.w	$2200,$0000
		dc.w	$2200,$0000
		dc.w	$8200,$0000
		dc.w	$4200,$0000
		dc.w	$4000,$0000
		dc.w	$1000,$0000
		dc.w	$1000,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$3E00,$0000
		dc.w	$3E00,$0000
		dc.w	$8200,$0000
		dc.w	$4200,$0000
		dc.w	$4000,$0000
		dc.w	$7000,$0000
		dc.w	$7000,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$4100,$0000
		dc.w	$4100,$0000
		dc.w	$4400,$0000
		dc.w	$4200,$0000
		dc.w	$4400,$0000
		dc.w	$9000,$0000
		dc.w	$9000,$0000
		dc.w	$4000,$0000
		dc.w	$8000,$0000
		dc.w	$4000,$0000
		dc.w	$E380,$0000
		dc.w	$E380,$0000
		dc.w	$3800,$0000
		dc.w	$3C00,$0000
		dc.w	$FC00,$0000
		dc.w	$7800,$0000
		dc.w	$7800,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$4000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$6000,$0000
		dc.w	$0000,$0000
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$E000,$0000
		dc.w	$8000,$0000
		dc.w	$E000,$0000
		dc.w	$FF80,$0000
		dc.w	$FF80,$0000
		dc.w	$FE00,$0000
		dc.w	$FE00,$0000
		dc.w	$FC00,$0000
		dc.w	$F800,$0000
		dc.w	$F800,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$9000,$0000
		dc.w	$4800,$0000
		dc.w	$2000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7000,$0000
		dc.w	$D800,$0000
		dc.w	$6000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8800,$0000
		dc.w	$4800,$0000
		dc.w	$9000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8800,$0000
		dc.w	$4800,$0000
		dc.w	$F000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8800,$0000
		dc.w	$4800,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7000,$0000
		dc.w	$3C00,$0000
		dc.w	$7000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$F800,$0000
		dc.w	$FC00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$F000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
