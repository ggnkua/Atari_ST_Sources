;set a0 to screen base
;set a6 to sprite curb start base
;modifies d0-d7/a0-a4
;sprite curb format:
;number_of_deletes  ; table of 16xn stripes to erase
;delete1.w,dellen1.w ;repeated number_of_deletes times
; [...]
;number_of_shift15.w
;offset_1.w   ;repeated number_of_shift15 times
;offset_2.w   ;distance to next sprite in screen coords
; [...]
;number_of_shift14.w
;offset_1.w   ;repeated number_of_shift14 times
; [...]
; ... until shift 0

writesprite:      ; bsr here with a0 & a6 set


	lea clearcode,a2
	moveq.l #0,d2
	move.l a0,a1
	 bra clearcode
delsprite_l:
	 move.l d2,200*160(a1)
	 move.l d2,199*160(a1)
	 move.l d2,198*160(a1)
	 move.l d2,197*160(a1)
	 move.l d2,196*160(a1)
	 move.l d2,195*160(a1)
	 move.l d2,194*160(a1)
	 move.l d2,193*160(a1)
	 move.l d2,192*160(a1)
	 move.l d2,191*160(a1)
	 move.l d2,190*160(a1)
	 move.l d2,189*160(a1)
	 move.l d2,188*160(a1)
	 move.l d2,187*160(a1)
	 move.l d2,186*160(a1)
	 move.l d2,185*160(a1)
	 move.l d2,184*160(a1)
	 move.l d2,183*160(a1)
	 move.l d2,182*160(a1)
	 move.l d2,181*160(a1)
	 move.l d2,180*160(a1)
	 move.l d2,179*160(a1)
	 move.l d2,178*160(a1)
	 move.l d2,177*160(a1)
	 move.l d2,176*160(a1)
	 move.l d2,175*160(a1)
	 move.l d2,174*160(a1)
	 move.l d2,173*160(a1)
	 move.l d2,172*160(a1)
	 move.l d2,171*160(a1)
	 move.l d2,170*160(a1)
	 move.l d2,169*160(a1)
	 move.l d2,168*160(a1)
	 move.l d2,167*160(a1)
	 move.l d2,166*160(a1)
	 move.l d2,165*160(a1)
	 move.l d2,164*160(a1)
	 move.l d2,163*160(a1)
	 move.l d2,162*160(a1)
	 move.l d2,161*160(a1)
	 move.l d2,160*160(a1)
	 move.l d2,159*160(a1)
	 move.l d2,158*160(a1)
	 move.l d2,157*160(a1)
	 move.l d2,156*160(a1)
	 move.l d2,155*160(a1)
	 move.l d2,154*160(a1)
	 move.l d2,153*160(a1)
	 move.l d2,152*160(a1)
	 move.l d2,151*160(a1)
	 move.l d2,150*160(a1)
	 move.l d2,149*160(a1)
	 move.l d2,148*160(a1)
	 move.l d2,147*160(a1)
	 move.l d2,146*160(a1)
	 move.l d2,145*160(a1)
	 move.l d2,144*160(a1)
	 move.l d2,143*160(a1)
	 move.l d2,142*160(a1)
	 move.l d2,141*160(a1)
	 move.l d2,140*160(a1)
	 move.l d2,139*160(a1)
	 move.l d2,138*160(a1)
	 move.l d2,137*160(a1)
	 move.l d2,136*160(a1)
	 move.l d2,135*160(a1)
	 move.l d2,134*160(a1)
	 move.l d2,133*160(a1)
	 move.l d2,132*160(a1)
	 move.l d2,131*160(a1)
	 move.l d2,130*160(a1)
	 move.l d2,129*160(a1)
	 move.l d2,128*160(a1)
	 move.l d2,127*160(a1)
	 move.l d2,126*160(a1)
	 move.l d2,125*160(a1)
	 move.l d2,124*160(a1)
	 move.l d2,123*160(a1)
	 move.l d2,122*160(a1)
	 move.l d2,121*160(a1)
	 move.l d2,120*160(a1)
	 move.l d2,119*160(a1)
	 move.l d2,118*160(a1)
	 move.l d2,117*160(a1)
	 move.l d2,116*160(a1)
	 move.l d2,115*160(a1)
	 move.l d2,114*160(a1)
	 move.l d2,113*160(a1)
	 move.l d2,112*160(a1)
	 move.l d2,111*160(a1)
	 move.l d2,110*160(a1)
	 move.l d2,109*160(a1)
	 move.l d2,108*160(a1)
	 move.l d2,107*160(a1)
	 move.l d2,106*160(a1)
	 move.l d2,105*160(a1)
	 move.l d2,104*160(a1)
	 move.l d2,103*160(a1)
	 move.l d2,102*160(a1)
	 move.l d2,101*160(a1)
	 move.l d2,100*160(a1)
	 move.l d2,99*160(a1)
	 move.l d2,98*160(a1)
	 move.l d2,97*160(a1)
	 move.l d2,96*160(a1)
	 move.l d2,95*160(a1)
	 move.l d2,94*160(a1)
	 move.l d2,93*160(a1)
	 move.l d2,92*160(a1)
	 move.l d2,91*160(a1)
	 move.l d2,90*160(a1)
	 move.l d2,89*160(a1)
	 move.l d2,88*160(a1)
	 move.l d2,87*160(a1)
	 move.l d2,86*160(a1)
	 move.l d2,85*160(a1)
	 move.l d2,84*160(a1)
	 move.l d2,83*160(a1)
	 move.l d2,82*160(a1)
	 move.l d2,81*160(a1)
	 move.l d2,80*160(a1)
	 move.l d2,79*160(a1)
	 move.l d2,78*160(a1)
	 move.l d2,77*160(a1)
	 move.l d2,76*160(a1)
	 move.l d2,75*160(a1)
	 move.l d2,74*160(a1)
	 move.l d2,73*160(a1)
	 move.l d2,72*160(a1)
	 move.l d2,71*160(a1)
	 move.l d2,70*160(a1)
	 move.l d2,69*160(a1)
	 move.l d2,68*160(a1)
	 move.l d2,67*160(a1)
	 move.l d2,66*160(a1)
	 move.l d2,65*160(a1)
	 move.l d2,64*160(a1)
	 move.l d2,63*160(a1)
	 move.l d2,62*160(a1)
	 move.l d2,61*160(a1)
	 move.l d2,60*160(a1)
	 move.l d2,59*160(a1)
	 move.l d2,58*160(a1)
	 move.l d2,57*160(a1)
	 move.l d2,56*160(a1)
	 move.l d2,55*160(a1)
	 move.l d2,54*160(a1)
	 move.l d2,53*160(a1)
	 move.l d2,52*160(a1)
	 move.l d2,51*160(a1)
	 move.l d2,50*160(a1)
	 move.l d2,49*160(a1)
	 move.l d2,48*160(a1)
	 move.l d2,47*160(a1)
	 move.l d2,46*160(a1)
	 move.l d2,45*160(a1)
	 move.l d2,44*160(a1)
	 move.l d2,43*160(a1)
	 move.l d2,42*160(a1)
	 move.l d2,41*160(a1)
	 move.l d2,40*160(a1)
	 move.l d2,39*160(a1)
	 move.l d2,38*160(a1)
	 move.l d2,37*160(a1)
	 move.l d2,36*160(a1)
	 move.l d2,35*160(a1)
	 move.l d2,34*160(a1)
	 move.l d2,33*160(a1)
	 move.l d2,32*160(a1)
	 move.l d2,31*160(a1)
	 move.l d2,30*160(a1)
	 move.l d2,29*160(a1)
	 move.l d2,28*160(a1)
	 move.l d2,27*160(a1)
	 move.l d2,26*160(a1)
	 move.l d2,25*160(a1)
	 move.l d2,24*160(a1)
	 move.l d2,23*160(a1)
	 move.l d2,22*160(a1)
	 move.l d2,21*160(a1)
	 move.l d2,20*160(a1)
	 move.l d2,19*160(a1)
	 move.l d2,18*160(a1)
	 move.l d2,17*160(a1)
	 move.l d2,16*160(a1)
	 move.l d2,15*160(a1)
	 move.l d2,14*160(a1)
	 move.l d2,13*160(a1)
	 move.l d2,12*160(a1)
	 move.l d2,11*160(a1)
	 move.l d2,10*160(a1)
	 move.l d2,9*160(a1)
	 move.l d2,8*160(a1)
	 move.l d2,7*160(a1)
	 move.l d2,6*160(a1)
	 move.l d2,5*160(a1)
	 move.l d2,4*160(a1)
	 move.l d2,3*160(a1)
	 move.l d2,2*160(a1)
	 move.l d2,1*160(a1)
	 move.l d2,(a1)
clearcode:
	 adda.w (a6)+,a1
	 adda.w (a6)+,a2
	 jmp (a2)
	ifeq colors
	move.w #$000,$ffff8240.w
	endc
	 add.w #1120,a0
;Shift 15
;Needs  8 registers REGS: x
;d0=00000000000000000000111111000000
;d1=00000000000000000011111111110000
;d2=00000000000000000111111111111000
;d3=00000000000000001111111111111100
;d4=11111111111111000011100000000000
;d5=00000000000000000000000000000001
;a1=11111111111111100111110000000000
;a2=10001111111111101111111000000000

;a0 offset for shift 15: 1120
	movem.l writesprite15_d,d0-d5/a1-a2
	move.w (a6)+,d7
	 bmi.s noMv_15
writesprite15_ml:
	 adda.w (a6)+,a0
	   move.w d0,0008-1120(a0) ; 0000111111000000
	   move.w d0,2408-1120(a0) ; 0000111111000000
	   move.w d1,0168-1120(a0) ; 0011111111110000
	   move.w d1,2248-1120(a0) ; 0011111111110000
	   move.w d2,0328-1120(a0) ; 0111111111111000
	   move.w d2,2088-1120(a0) ; 0111111111111000
	   move.w d3,0488-1120(a0) ; 1111111111111100
	   move.w d3,1928-1120(a0) ; 1111111111111100
	   move.l d4,0648-1120(a0) ; 11111111111111000011100000000000
	   move.l d4,1768-1120(a0) ; 11111111111111000011100000000000
	   move.w d5,0800-1120(a0) ; 0000000000000001
	   move.w d5,1600-1120(a0) ; 0000000000000001
	   move.l a1,0808-1120(a0) ; 11111111111111100111110000000000
	   move.l a1,1608-1120(a0) ; 11111111111111100111110000000000
	   move.w d5,0960-1120(a0) ; 0000000000000001
	   move.w d5,1440-1120(a0) ; 0000000000000001
	   move.l a2,0968-1120(a0) ; 10001111111111101111111000000000
	   move.l a2,1448-1120(a0) ; 10001111111111101111111000000000
	   move.w d5,(a0)          ; 0000000000000001
	   move.w d5,1280-1120(a0) ; 0000000000000001
	   move.l a2,1128-1120(a0) ; 10001111111111101111111000000000
	   move.l a2,1288-1120(a0) ; 10001111111111101111111000000000
writesprite15_ms:
	 dbra d7,writesprite15_ml
noMv_15:
	move.w (a6)+,d7
	bmi.s noOr
writesprite15_l:
	 adda.w (a6)+,a0
	   or.w d0,0008-1120(a0) ; 0000111111000000
	   or.w d0,2408-1120(a0) ; 0000111111000000
	   or.w d1,0168-1120(a0) ; 0011111111110000
	   or.w d1,2248-1120(a0) ; 0011111111110000
	   or.w d2,0328-1120(a0) ; 0111111111111000
	   or.w d2,2088-1120(a0) ; 0111111111111000
	   or.w d3,0488-1120(a0) ; 1111111111111100
	   or.w d3,1928-1120(a0) ; 1111111111111100
	   or.l d4,0648-1120(a0) ; 11111111111111000011100000000000
	   or.l d4,1768-1120(a0) ; 11111111111111000011100000000000
	   or.w d5,0800-1120(a0) ; 0000000000000001
	   or.w d5,1600-1120(a0) ; 0000000000000001
	   or.w d5,0960-1120(a0) ; 0000000000000001
	   or.w d5,1440-1120(a0) ; 0000000000000001
	   or.w d5,(a0)          ; 0000000000000001
	   or.w d5,1280-1120(a0) ; 0000000000000001
	 move.l a2,d6
	   or.l d6,0968-1120(a0) ; 10001111111111101111111000000000
	   or.l d6,1448-1120(a0) ; 10001111111111101111111000000000
	   or.l d6,1128-1120(a0) ; 10001111111111101111111000000000
	   or.l d6,1288-1120(a0) ; 10001111111111101111111000000000
	 move.l a1,d6
	   or.l d6,0808-1120(a0) ; 11111111111111100111110000000000
	   or.l d6,1608-1120(a0) ; 11111111111111100111110000000000
writesprite15_s:
	 dbra d7,writesprite15_l
noOr:
;Shift 14
;Needs  9 registers REGS: xx
;d0=00000000000000000001111110000000
;d1=00000000000000000111111111100000
;d2=00000000000000001111111111110000
;d3=00000000000000001111111111111000
;d4=11111111111110000111000000000000
;d5=00000000000000000000000000000011
;a1=11111111111111001111100000000000
;a2=00000000000000110000000000000001
;a3=00011111111111001111110000000000

;a0 offset for shift 14: 1120
	movem.l writesprite14_d,d0-d5/a1-a3
	move.w (a6)+,d7
	 bmi.s noMv_14
writesprite14_ml:
	 adda.w (a6)+,a0
	   move.w d0,0008-1120(a0) ; 0001111110000000
	   move.w d0,2408-1120(a0) ; 0001111110000000
	   move.w d1,0168-1120(a0) ; 0111111111100000
	   move.w d1,2248-1120(a0) ; 0111111111100000
	   move.w d2,0328-1120(a0) ; 1111111111110000
	   move.w d2,2088-1120(a0) ; 1111111111110000
	   move.w a2,0480-1120(a0) ; 0000000000000001
	   move.w a2,1920-1120(a0) ; 0000000000000001
	   move.w d3,0488-1120(a0) ; 1111111111111000
	   move.w d3,1928-1120(a0) ; 1111111111111000
	   move.w a2,0640-1120(a0) ; 0000000000000001
	   move.w a2,1760-1120(a0) ; 0000000000000001
	   move.l d4,0648-1120(a0) ; 11111111111110000111000000000000
	   move.l d4,1768-1120(a0) ; 11111111111110000111000000000000
	   move.w d5,0800-1120(a0) ; 0000000000000011
	   move.w d5,1600-1120(a0) ; 0000000000000011
	   move.l a1,0808-1120(a0) ; 11111111111111001111100000000000
	   move.l a1,1608-1120(a0) ; 11111111111111001111100000000000
	   move.l a2,0960-1120(a0) ; 00000000000000110000000000000001
	   move.l a2,1440-1120(a0) ; 00000000000000110000000000000001
	   move.l a3,0968-1120(a0) ; 00011111111111001111110000000000
	   move.l a3,1448-1120(a0) ; 00011111111111001111110000000000
	   move.l a2,(a0)          ; 00000000000000110000000000000001
	   move.l a2,1280-1120(a0) ; 00000000000000110000000000000001
	   move.l a3,1128-1120(a0) ; 00011111111111001111110000000000
	   move.l a3,1288-1120(a0) ; 00011111111111001111110000000000
writesprite14_ms:
	 dbra d7,writesprite14_ml
noMv_14:
	move.w (a6)+,d7
writesprite14_l:
	 adda.w (a6)+,a0
	   or.w d0,0008-1120(a0) ; 0001111110000000
	   or.w d0,2408-1120(a0) ; 0001111110000000
	   or.w d1,0168-1120(a0) ; 0111111111100000
	   or.w d1,2248-1120(a0) ; 0111111111100000
	   or.w d2,0328-1120(a0) ; 1111111111110000
	   or.w d2,2088-1120(a0) ; 1111111111110000
	   or.w d3,0488-1120(a0) ; 1111111111111000
	   or.w d3,1928-1120(a0) ; 1111111111111000
	   or.l d4,0648-1120(a0) ; 11111111111110000111000000000000
	   or.l d4,1768-1120(a0) ; 11111111111110000111000000000000
	   or.w d5,0800-1120(a0) ; 0000000000000011
	   or.w d5,1600-1120(a0) ; 0000000000000011
	 move.l a2,d6
	   or.w d6,0480-1120(a0) ; 0000000000000001
	   or.w d6,1920-1120(a0) ; 0000000000000001
	   or.w d6,0640-1120(a0) ; 0000000000000001
	   or.w d6,1760-1120(a0) ; 0000000000000001
	   or.l d6,0960-1120(a0) ; 00000000000000110000000000000001
	   or.l d6,1440-1120(a0) ; 00000000000000110000000000000001
	   or.l d6,(a0)          ; 00000000000000110000000000000001
	   or.l d6,1280-1120(a0) ; 00000000000000110000000000000001
	 move.l a1,d6
	   or.l d6,0808-1120(a0) ; 11111111111111001111100000000000
	   or.l d6,1608-1120(a0) ; 11111111111111001111100000000000
	 move.l a3,d6
	   or.l d6,0968-1120(a0) ; 00011111111111001111110000000000
	   or.l d6,1448-1120(a0) ; 00011111111111001111110000000000
	   or.l d6,1128-1120(a0) ; 00011111111111001111110000000000
	   or.l d6,1288-1120(a0) ; 00011111111111001111110000000000
writesprite14_s:
	 dbra d7,writesprite14_l
;Shift 13
;Needs  9 registers REGS: xx
;d0=00000000000000000000000000111111
;d1=00000000000000001111111111000000
;d2=00000000000000001111111111100000
;d3=00000000000000001111111111110000
;d4=11111111111100001110000000000000
;d5=00000000000001110000000000000001
;a1=11111111111110001111000000000000
;a2=00000000000001100000000000000011
;a3=00111111111110001111100000000000

;a0 offset for shift 13: 1120
	movem.l writesprite13_d,d0-d5/a1-a3
	move.w (a6)+,d7
	 bmi.s noMv_13
writesprite13_ml:
	 adda.w (a6)+,a0
	   move.b d0,0008-1120(a0) ; 00111111
	   move.b d0,2408-1120(a0) ; 00111111
	   move.w d1,0168-1120(a0) ; 1111111111000000
	   move.w d1,2248-1120(a0) ; 1111111111000000
	   move.w d5,0320-1120(a0) ; 0000000000000001
	   move.w d5,2080-1120(a0) ; 0000000000000001
	   move.w d2,0328-1120(a0) ; 1111111111100000
	   move.w d2,2088-1120(a0) ; 1111111111100000
	   move.w a2,0480-1120(a0) ; 0000000000000011
	   move.w a2,1920-1120(a0) ; 0000000000000011
	   move.w d3,0488-1120(a0) ; 1111111111110000
	   move.w d3,1928-1120(a0) ; 1111111111110000
	   move.w a2,0640-1120(a0) ; 0000000000000011
	   move.w a2,1760-1120(a0) ; 0000000000000011
	   move.l d4,0648-1120(a0) ; 11111111111100001110000000000000
	   move.l d4,1768-1120(a0) ; 11111111111100001110000000000000
	   move.l d5,0800-1120(a0) ; 00000000000001110000000000000001
	   move.l d5,1600-1120(a0) ; 00000000000001110000000000000001
	   move.l a1,0808-1120(a0) ; 11111111111110001111000000000000
	   move.l a1,1608-1120(a0) ; 11111111111110001111000000000000
	   move.l a2,0960-1120(a0) ; 00000000000001100000000000000011
	   move.l a2,1440-1120(a0) ; 00000000000001100000000000000011
	   move.l a3,0968-1120(a0) ; 00111111111110001111100000000000
	   move.l a3,1448-1120(a0) ; 00111111111110001111100000000000
	   move.l a2,(a0)          ; 00000000000001100000000000000011
	   move.l a2,1280-1120(a0) ; 00000000000001100000000000000011
	   move.l a3,1128-1120(a0) ; 00111111111110001111100000000000
	   move.l a3,1288-1120(a0) ; 00111111111110001111100000000000
writesprite13_ms:
	 dbra d7,writesprite13_ml
noMv_13:
	move.w (a6)+,d7
writesprite13_l:
	 adda.w (a6)+,a0
	   or.b d0,0008-1120(a0) ; 00111111
	   or.b d0,2408-1120(a0) ; 00111111
	   or.w d1,0168-1120(a0) ; 1111111111000000
	   or.w d1,2248-1120(a0) ; 1111111111000000
	   or.w d5,0320-1120(a0) ; 0000000000000001
	   or.w d5,2080-1120(a0) ; 0000000000000001
	   or.w d2,0328-1120(a0) ; 1111111111100000
	   or.w d2,2088-1120(a0) ; 1111111111100000
	   or.w d3,0488-1120(a0) ; 1111111111110000
	   or.w d3,1928-1120(a0) ; 1111111111110000
	   or.l d4,0648-1120(a0) ; 11111111111100001110000000000000
	   or.l d4,1768-1120(a0) ; 11111111111100001110000000000000
	   or.l d5,0800-1120(a0) ; 00000000000001110000000000000001
	   or.l d5,1600-1120(a0) ; 00000000000001110000000000000001
	 move.l a2,d6
	   or.w d6,0480-1120(a0) ; 0000000000000011
	   or.w d6,1920-1120(a0) ; 0000000000000011
	   or.w d6,0640-1120(a0) ; 0000000000000011
	   or.w d6,1760-1120(a0) ; 0000000000000011
	   or.l d6,0960-1120(a0) ; 00000000000001100000000000000011
	   or.l d6,1440-1120(a0) ; 00000000000001100000000000000011
	   or.l d6,(a0)          ; 00000000000001100000000000000011
	   or.l d6,1280-1120(a0) ; 00000000000001100000000000000011
	 move.l a1,d6
	   or.l d6,0808-1120(a0) ; 11111111111110001111000000000000
	   or.l d6,1608-1120(a0) ; 11111111111110001111000000000000
	 move.l a3,d6
	   or.l d6,0968-1120(a0) ; 00111111111110001111100000000000
	   or.l d6,1448-1120(a0) ; 00111111111110001111100000000000
	   or.l d6,1128-1120(a0) ; 00111111111110001111100000000000
	   or.l d6,1288-1120(a0) ; 00111111111110001111100000000000
writesprite13_s:
	 dbra d7,writesprite13_l
;Shift 12
;Needs 10 registers REGS: xxx
;d0=00000000000000000000000001111110
;d1=00000000000000001111111110000000
;d2=00000000000000001111111111000000
;d3=00000000000000001111111111100000
;d4=00000000000001110000000000000001
;d5=11111111111000001100000000000000
;a1=00000000000011110000000000000011
;a2=11111111111100001110000000000000
;a3=00000000000011000000000000000111
;a4=01111111111100001111000000000000

;a0 offset for shift 12: 1120
	movem.l writesprite12_d,d0-d5/a1-a4
	move.w (a6)+,d7
	 bmi.s noMv_12
writesprite12_ml:
	 adda.w (a6)+,a0
	   move.b d0,0008-1120(a0) ; 01111110
	   move.b d0,2408-1120(a0) ; 01111110
	   move.w d4,0160-1120(a0) ; 0000000000000001
	   move.w d4,2240-1120(a0) ; 0000000000000001
	   move.w d1,0168-1120(a0) ; 1111111110000000
	   move.w d1,2248-1120(a0) ; 1111111110000000
	   move.w a1,0320-1120(a0) ; 0000000000000011
	   move.w a1,2080-1120(a0) ; 0000000000000011
	   move.w d2,0328-1120(a0) ; 1111111111000000
	   move.w d2,2088-1120(a0) ; 1111111111000000
	   move.w a3,0480-1120(a0) ; 0000000000000111
	   move.w a3,1920-1120(a0) ; 0000000000000111
	   move.w d3,0488-1120(a0) ; 1111111111100000
	   move.w d3,1928-1120(a0) ; 1111111111100000
	   move.l d4,0640-1120(a0) ; 00000000000001110000000000000001
	   move.l d4,1760-1120(a0) ; 00000000000001110000000000000001
	   move.l d5,0648-1120(a0) ; 11111111111000001100000000000000
	   move.l d5,1768-1120(a0) ; 11111111111000001100000000000000
	   move.l a1,0800-1120(a0) ; 00000000000011110000000000000011
	   move.l a1,1600-1120(a0) ; 00000000000011110000000000000011
	   move.l a2,0808-1120(a0) ; 11111111111100001110000000000000
	   move.l a2,1608-1120(a0) ; 11111111111100001110000000000000
	   move.l a3,0960-1120(a0) ; 00000000000011000000000000000111
	   move.l a3,1440-1120(a0) ; 00000000000011000000000000000111
	   move.l a4,0968-1120(a0) ; 01111111111100001111000000000000
	   move.l a4,1448-1120(a0) ; 01111111111100001111000000000000
	   move.l a3,(a0)          ; 00000000000011000000000000000111
	   move.l a3,1280-1120(a0) ; 00000000000011000000000000000111
	   move.l a4,1128-1120(a0) ; 01111111111100001111000000000000
	   move.l a4,1288-1120(a0) ; 01111111111100001111000000000000
writesprite12_ms:
	 dbra d7,writesprite12_ml
noMv_12:
	move.w (a6)+,d7
writesprite12_l:
	 adda.w (a6)+,a0
	   or.b d0,0008-1120(a0) ; 01111110
	   or.b d0,2408-1120(a0) ; 01111110
	   or.w d4,0160-1120(a0) ; 0000000000000001
	   or.w d4,2240-1120(a0) ; 0000000000000001
	   or.w d1,0168-1120(a0) ; 1111111110000000
	   or.w d1,2248-1120(a0) ; 1111111110000000
	   or.w d2,0328-1120(a0) ; 1111111111000000
	   or.w d2,2088-1120(a0) ; 1111111111000000
	   or.w d3,0488-1120(a0) ; 1111111111100000
	   or.w d3,1928-1120(a0) ; 1111111111100000
	   or.l d4,0640-1120(a0) ; 00000000000001110000000000000001
	   or.l d4,1760-1120(a0) ; 00000000000001110000000000000001
	   or.l d5,0648-1120(a0) ; 11111111111000001100000000000000
	   or.l d5,1768-1120(a0) ; 11111111111000001100000000000000
	 move.l a4,d6
	   or.l d6,0968-1120(a0) ; 01111111111100001111000000000000
	   or.l d6,1448-1120(a0) ; 01111111111100001111000000000000
	   or.l d6,1128-1120(a0) ; 01111111111100001111000000000000
	   or.l d6,1288-1120(a0) ; 01111111111100001111000000000000
	 move.l a2,d6
	   or.l d6,0808-1120(a0) ; 11111111111100001110000000000000
	   or.l d6,1608-1120(a0) ; 11111111111100001110000000000000
	 move.l a1,d6
	   or.w d6,0320-1120(a0) ; 0000000000000011
	   or.w d6,2080-1120(a0) ; 0000000000000011
	   or.l d6,0800-1120(a0) ; 00000000000011110000000000000011
	   or.l d6,1600-1120(a0) ; 00000000000011110000000000000011
	 move.l a3,d6
	   or.w d6,0480-1120(a0) ; 0000000000000111
	   or.w d6,1920-1120(a0) ; 0000000000000111
	   or.l d6,0960-1120(a0) ; 00000000000011000000000000000111
	   or.l d6,1440-1120(a0) ; 00000000000011000000000000000111
	   or.l d6,(a0)          ; 00000000000011000000000000000111
	   or.l d6,1280-1120(a0) ; 00000000000011000000000000000111
writesprite12_s:
	 dbra d7,writesprite12_l
;Shift 11
;Needs 10 registers REGS: xxx
;d0=00000000000000000000000011111100
;d1=00000000000000000000000011111111
;d2=00000000000000001111111110000000
;d3=00000000000000001111111111000000
;d4=00000000000011110000000000000011
;d5=11111111110000001000000000000000
;a1=00000000000111110000000000000111
;a2=11111111111000001100000000000000
;a3=00000000000110000000000000001111
;a4=11111111111000001110000000000000

;a0 offset for shift 11: 1120
	movem.l writesprite11_d,d0-d5/a1-a4
	move.w (a6)+,d7
	 bmi.s noMv_11
writesprite11_ml:
	 adda.w (a6)+,a0
	   move.b d0,0008-1120(a0) ; 11111100
	   move.b d0,2408-1120(a0) ; 11111100
	   move.w d4,0160-1120(a0) ; 0000000000000011
	   move.w d4,2240-1120(a0) ; 0000000000000011
	 move.b d1,0168-1120(a0) ; 11111111
	 move.b d1,2248-1120(a0) ; 11111111
	   move.w a1,0320-1120(a0) ; 0000000000000111
	   move.w a1,2080-1120(a0) ; 0000000000000111
	   move.w d2,0328-1120(a0) ; 1111111110000000
	   move.w d2,2088-1120(a0) ; 1111111110000000
	   move.w a3,0480-1120(a0) ; 0000000000001111
	   move.w a3,1920-1120(a0) ; 0000000000001111
	   move.w d3,0488-1120(a0) ; 1111111111000000
	   move.w d3,1928-1120(a0) ; 1111111111000000
	   move.l d4,0640-1120(a0) ; 00000000000011110000000000000011
	   move.l d4,1760-1120(a0) ; 00000000000011110000000000000011
	   move.l d5,0648-1120(a0) ; 11111111110000001000000000000000
	   move.l d5,1768-1120(a0) ; 11111111110000001000000000000000
	   move.l a1,0800-1120(a0) ; 00000000000111110000000000000111
	   move.l a1,1600-1120(a0) ; 00000000000111110000000000000111
	   move.l a2,0808-1120(a0) ; 11111111111000001100000000000000
	   move.l a2,1608-1120(a0) ; 11111111111000001100000000000000
	   move.l a3,0960-1120(a0) ; 00000000000110000000000000001111
	   move.l a3,1440-1120(a0) ; 00000000000110000000000000001111
	   move.l a4,0968-1120(a0) ; 11111111111000001110000000000000
	   move.l a4,1448-1120(a0) ; 11111111111000001110000000000000
	   move.l a3,(a0)          ; 00000000000110000000000000001111
	   move.l a3,1280-1120(a0) ; 00000000000110000000000000001111
	   move.l a4,1128-1120(a0) ; 11111111111000001110000000000000
	   move.l a4,1288-1120(a0) ; 11111111111000001110000000000000
writesprite11_ms:
	 dbra d7,writesprite11_ml
noMv_11:
	move.w (a6)+,d7
writesprite11_l:
	 adda.w (a6)+,a0
	   or.b d0,0008-1120(a0) ; 11111100
	   or.b d0,2408-1120(a0) ; 11111100
	   or.w d4,0160-1120(a0) ; 0000000000000011
	   or.w d4,2240-1120(a0) ; 0000000000000011
	 move.b d1,0168-1120(a0) ; 11111111
	 move.b d1,2248-1120(a0) ; 11111111
	   or.w d2,0328-1120(a0) ; 1111111110000000
	   or.w d2,2088-1120(a0) ; 1111111110000000
	   or.w d3,0488-1120(a0) ; 1111111111000000
	   or.w d3,1928-1120(a0) ; 1111111111000000
	   or.l d4,0640-1120(a0) ; 00000000000011110000000000000011
	   or.l d4,1760-1120(a0) ; 00000000000011110000000000000011
	   or.l d5,0648-1120(a0) ; 11111111110000001000000000000000
	   or.l d5,1768-1120(a0) ; 11111111110000001000000000000000
	 move.l a4,d6
	   or.l d6,0968-1120(a0) ; 11111111111000001110000000000000
	   or.l d6,1448-1120(a0) ; 11111111111000001110000000000000
	   or.l d6,1128-1120(a0) ; 11111111111000001110000000000000
	   or.l d6,1288-1120(a0) ; 11111111111000001110000000000000
	 move.l a2,d6
	   or.l d6,0808-1120(a0) ; 11111111111000001100000000000000
	   or.l d6,1608-1120(a0) ; 11111111111000001100000000000000
	 move.l a1,d6
	   or.w d6,0320-1120(a0) ; 0000000000000111
	   or.w d6,2080-1120(a0) ; 0000000000000111
	   or.l d6,0800-1120(a0) ; 00000000000111110000000000000111
	   or.l d6,1600-1120(a0) ; 00000000000111110000000000000111
	 move.l a3,d6
	   or.w d6,0480-1120(a0) ; 0000000000001111
	   or.w d6,1920-1120(a0) ; 0000000000001111
	   or.l d6,0960-1120(a0) ; 00000000000110000000000000001111
	   or.l d6,1440-1120(a0) ; 00000000000110000000000000001111
	   or.l d6,(a0)          ; 00000000000110000000000000001111
	   or.l d6,1280-1120(a0) ; 00000000000110000000000000001111
writesprite11_s:
	 dbra d7,writesprite11_l
;Shift 10
;Needs  9 registers REGS: xx
;d0=00000000000000000000000011111000
;d1=00000000000000000000000011111110
;d2=00000000000000000000000011111111
;d3=00000000000000001111111110000000
;d4=00000000000111110000000000000111
;d5=00000000001111110000000000001111
;a1=11111111110000001000000000000000
;a2=00000000001100010000000000011111
;a3=11111111110000001100000000000000

;a0 offset for shift 10: 1120
	movem.l writesprite10_d,d0-d5/a1-a3
	move.w (a6)+,d7
	 bmi noMv_10
writesprite10_ml:
	 adda.w (a6)+,a0
	 bset.b d0,0001-1120(a0) ;         00000001
	 bset.b d0,2401-1120(a0) ;         00000001
	   move.b d0,0008-1120(a0) ; 11111000
	   move.b d0,2408-1120(a0) ; 11111000
	   move.w d4,0160-1120(a0) ; 0000000000000111
	   move.w d4,2240-1120(a0) ; 0000000000000111
	   move.b d1,0168-1120(a0) ; 11111110
	   move.b d1,2248-1120(a0) ; 11111110
	   move.w d5,0320-1120(a0) ; 0000000000001111
	   move.w d5,2080-1120(a0) ; 0000000000001111
	 move.b d2,0328-1120(a0) ; 11111111
	 move.b d2,2088-1120(a0) ; 11111111
	   move.w a2,0480-1120(a0) ; 0000000000011111
	   move.w a2,1920-1120(a0) ; 0000000000011111
	   move.w d3,0488-1120(a0) ; 1111111110000000
	   move.w d3,1928-1120(a0) ; 1111111110000000
	   move.l d4,0640-1120(a0) ; 00000000000111110000000000000111
	   move.l d4,1760-1120(a0) ; 00000000000111110000000000000111
	   move.w d3,0648-1120(a0) ; 1111111110000000
	   move.w d3,1768-1120(a0) ; 1111111110000000
	   move.l d5,0800-1120(a0) ; 00000000001111110000000000001111
	   move.l d5,1600-1120(a0) ; 00000000001111110000000000001111
	   move.l a1,0808-1120(a0) ; 11111111110000001000000000000000
	   move.l a1,1608-1120(a0) ; 11111111110000001000000000000000
	   move.l a2,0960-1120(a0) ; 00000000001100010000000000011111
	   move.l a2,1440-1120(a0) ; 00000000001100010000000000011111
	   move.l a3,0968-1120(a0) ; 11111111110000001100000000000000
	   move.l a3,1448-1120(a0) ; 11111111110000001100000000000000
	   move.l a2,(a0)          ; 00000000001100010000000000011111
	   move.l a2,1280-1120(a0) ; 00000000001100010000000000011111
	   move.l a3,1128-1120(a0) ; 11111111110000001100000000000000
	   move.l a3,1288-1120(a0) ; 11111111110000001100000000000000
writesprite10_ms:
	 dbra d7,writesprite10_ml
noMv_10:
	move.w (a6)+,d7
writesprite10_l:
	 adda.w (a6)+,a0
	 bset.b d0,0001-1120(a0) ;         00000001
	 bset.b d0,2401-1120(a0) ;         00000001
	   or.b d0,0008-1120(a0) ; 11111000
	   or.b d0,2408-1120(a0) ; 11111000
	   or.w d4,0160-1120(a0) ; 0000000000000111
	   or.w d4,2240-1120(a0) ; 0000000000000111
	   or.b d1,0168-1120(a0) ; 11111110
	   or.b d1,2248-1120(a0) ; 11111110
	   or.w d5,0320-1120(a0) ; 0000000000001111
	   or.w d5,2080-1120(a0) ; 0000000000001111
	 move.b d2,0328-1120(a0) ; 11111111
	 move.b d2,2088-1120(a0) ; 11111111
	   or.w d3,0488-1120(a0) ; 1111111110000000
	   or.w d3,1928-1120(a0) ; 1111111110000000
	   or.l d4,0640-1120(a0) ; 00000000000111110000000000000111
	   or.l d4,1760-1120(a0) ; 00000000000111110000000000000111
	   or.w d3,0648-1120(a0) ; 1111111110000000
	   or.w d3,1768-1120(a0) ; 1111111110000000
	   or.l d5,0800-1120(a0) ; 00000000001111110000000000001111
	   or.l d5,1600-1120(a0) ; 00000000001111110000000000001111
	 move.l a2,d6
	   or.w d6,0480-1120(a0) ; 0000000000011111
	   or.w d6,1920-1120(a0) ; 0000000000011111
	   or.l d6,0960-1120(a0) ; 00000000001100010000000000011111
	   or.l d6,1440-1120(a0) ; 00000000001100010000000000011111
	   or.l d6,(a0)          ; 00000000001100010000000000011111
	   or.l d6,1280-1120(a0) ; 00000000001100010000000000011111
	 move.l a1,d6
	   or.l d6,0808-1120(a0) ; 11111111110000001000000000000000
	   or.l d6,1608-1120(a0) ; 11111111110000001000000000000000
	 move.l a3,d6
	   or.l d6,0968-1120(a0) ; 11111111110000001100000000000000
	   or.l d6,1448-1120(a0) ; 11111111110000001100000000000000
	   or.l d6,1128-1120(a0) ; 11111111110000001100000000000000
	   or.l d6,1288-1120(a0) ; 11111111110000001100000000000000
writesprite10_s:
	 dbra d7,writesprite10_l
;Shift 9
;Needs 11 registers REGS: xxxx
;d0=00000000000000000000000000000011
;d1=00000000000000000000000011110000
;d2=00000000000000000000000000001111
;d3=00000000000000000000000011111100
;d4=00000000000000000000000011111110
;d5=00000000000000000000000011111111
;a1=00000000001111110000000000001110
;a2=00000000011111110000000000011111
;a3=00000000000000001111111110000000
;a4=00000000011000110000000000111111
;a5=11111111100000001000000000000000

;a0 offset for shift 9: 1120
	movem.l writesprite9_d,d0-d5/a1-a5
	move.w (a6)+,d7
	 bmi noMv_9
writesprite9_ml:
	 adda.w (a6)+,a0
	   move.w d0,0000-1120(a0) ; 0000000000000011
	   move.w d0,2400-1120(a0) ; 0000000000000011
	   move.b d1,0008-1120(a0) ; 11110000
	   move.b d1,2408-1120(a0) ; 11110000
	   move.w d2,0160-1120(a0) ; 0000000000001111
	   move.w d2,2240-1120(a0) ; 0000000000001111
	   move.b d3,0168-1120(a0) ; 11111100
	   move.b d3,2248-1120(a0) ; 11111100
	   move.w a2,0320-1120(a0) ; 0000000000011111
	   move.w a2,2080-1120(a0) ; 0000000000011111
	   move.b d4,0328-1120(a0) ; 11111110
	   move.b d4,2088-1120(a0) ; 11111110
	   move.w a4,0480-1120(a0) ; 0000000000111111
	   move.w a4,1920-1120(a0) ; 0000000000111111
	 move.b d5,0488-1120(a0) ; 11111111
	 move.b d5,1928-1120(a0) ; 11111111
	   move.l a1,0640-1120(a0) ; 00000000001111110000000000001110
	   move.l a1,1760-1120(a0) ; 00000000001111110000000000001110
	 move.b d5,0648-1120(a0) ; 11111111
	 move.b d5,1768-1120(a0) ; 11111111
	   move.l a2,0800-1120(a0) ; 00000000011111110000000000011111
	   move.l a2,1600-1120(a0) ; 00000000011111110000000000011111
	   move.w a3,0808-1120(a0) ; 1111111110000000
	   move.w a3,1608-1120(a0) ; 1111111110000000
	   move.l a4,0960-1120(a0) ; 00000000011000110000000000111111
	   move.l a4,1440-1120(a0) ; 00000000011000110000000000111111
	   move.l a5,0968-1120(a0) ; 11111111100000001000000000000000
	   move.l a5,1448-1120(a0) ; 11111111100000001000000000000000
	   move.l a4,(a0)          ; 00000000011000110000000000111111
	   move.l a4,1280-1120(a0) ; 00000000011000110000000000111111
	   move.l a5,1128-1120(a0) ; 11111111100000001000000000000000
	   move.l a5,1288-1120(a0) ; 11111111100000001000000000000000
writesprite9_ms:
	 dbra d7,writesprite9_ml
noMv_9:
	move.w (a6)+,d7
writesprite9_l:
	 adda.w (a6)+,a0
	   or.w d0,0000-1120(a0) ; 0000000000000011
	   or.w d0,2400-1120(a0) ; 0000000000000011
	   or.b d1,0008-1120(a0) ; 11110000
	   or.b d1,2408-1120(a0) ; 11110000
	   or.w d2,0160-1120(a0) ; 0000000000001111
	   or.w d2,2240-1120(a0) ; 0000000000001111
	   or.b d3,0168-1120(a0) ; 11111100
	   or.b d3,2248-1120(a0) ; 11111100
	   or.b d4,0328-1120(a0) ; 11111110
	   or.b d4,2088-1120(a0) ; 11111110
	 move.b d5,0488-1120(a0) ; 11111111
	 move.b d5,1928-1120(a0) ; 11111111
	 move.b d5,0648-1120(a0) ; 11111111
	 move.b d5,1768-1120(a0) ; 11111111
	 move.l a4,d6
	   or.w d6,0480-1120(a0) ; 0000000000111111
	   or.w d6,1920-1120(a0) ; 0000000000111111
	   or.l d6,0960-1120(a0) ; 00000000011000110000000000111111
	   or.l d6,1440-1120(a0) ; 00000000011000110000000000111111
	   or.l d6,(a0)          ; 00000000011000110000000000111111
	   or.l d6,1280-1120(a0) ; 00000000011000110000000000111111
	 move.l a2,d6
	   or.w d6,0320-1120(a0) ; 0000000000011111
	   or.w d6,2080-1120(a0) ; 0000000000011111
	   or.l d6,0800-1120(a0) ; 00000000011111110000000000011111
	   or.l d6,1600-1120(a0) ; 00000000011111110000000000011111
	 move.l a5,d6
	   or.l d6,0968-1120(a0) ; 11111111100000001000000000000000
	   or.l d6,1448-1120(a0) ; 11111111100000001000000000000000
	   or.l d6,1128-1120(a0) ; 11111111100000001000000000000000
	   or.l d6,1288-1120(a0) ; 11111111100000001000000000000000
	 move.l a1,d6
	   or.l d6,0640-1120(a0) ; 00000000001111110000000000001110
	   or.l d6,1760-1120(a0) ; 00000000001111110000000000001110
	 move.l a3,d6
	   or.w d6,0808-1120(a0) ; 1111111110000000
	   or.w d6,1608-1120(a0) ; 1111111110000000
writesprite9_s:
	 dbra d7,writesprite9_l
;Shift 8
;Needs 11 registers REGS: xxxx
;d0=00000000000000000000000000000111
;d1=00000000000000000000000011100000
;d2=00000000000000000000000000011111
;d3=00000000000000000000000011111000
;d4=00000000000000000000000000111111
;d5=00000000000000000000000011111100
;a1=00000000000000000000000011111110
;a2=00000000011111110000000000011100
;a3=00000000111111110000000000111110
;a4=00000000000000000000000011111111
;a5=00000000110001110000000001111111

;a0 offset for shift 8: 1120
	movem.l writesprite8_d,d0-d5/a1-a5
	move.w (a6)+,d7
; JUST DON'T DO THIS MOVE
writesprite8_l:
	 adda.w (a6)+,a0
	   or.w d0,0000-1120(a0) ; 0000000000000111
	   or.w d0,2400-1120(a0) ; 0000000000000111
	   or.b d1,0008-1120(a0) ; 11100000
	   or.b d1,2408-1120(a0) ; 11100000
	   or.w d2,0160-1120(a0) ; 0000000000011111
	   or.w d2,2240-1120(a0) ; 0000000000011111
	   or.b d3,0168-1120(a0) ; 11111000
	   or.b d3,2248-1120(a0) ; 11111000
	   or.w d4,0320-1120(a0) ; 0000000000111111
	   or.w d4,2080-1120(a0) ; 0000000000111111
	   or.b d5,0328-1120(a0) ; 11111100
	   or.b d5,2088-1120(a0) ; 11111100
	 move.l a4,d6
	 move.b d6,0808-1120(a0) ; 11111111
	 move.b d6,1608-1120(a0) ; 11111111
	 move.b d6,0968-1120(a0) ; 11111111
	 move.b d6,1448-1120(a0) ; 11111111
	 move.b d6,1128-1120(a0) ; 11111111
	 move.b d6,1288-1120(a0) ; 11111111
	 move.l a2,d6
	   or.l d6,0640-1120(a0) ; 00000000011111110000000000011100
	   or.l d6,1760-1120(a0) ; 00000000011111110000000000011100
	 move.l a5,d6
	   or.w d6,0480-1120(a0) ; 0000000001111111
	   or.w d6,1920-1120(a0) ; 0000000001111111
	   or.l d6,0960-1120(a0) ; 00000000110001110000000001111111
	   or.l d6,1440-1120(a0) ; 00000000110001110000000001111111
	   or.l d6,(a0)          ; 00000000110001110000000001111111
	   or.l d6,1280-1120(a0) ; 00000000110001110000000001111111
	 move.l a1,d6
	   or.b d6,0488-1120(a0) ; 11111110
	   or.b d6,1928-1120(a0) ; 11111110
	   or.b d6,0648-1120(a0) ; 11111110
	   or.b d6,1768-1120(a0) ; 11111110
	 move.l a3,d6
	   or.l d6,0800-1120(a0) ; 00000000111111110000000000111110
	   or.l d6,1600-1120(a0) ; 00000000111111110000000000111110
writesprite8_s:
	 dbra d7,writesprite8_l
;Shift 7
;Needs 11 registers REGS: xxxx
;d0=00000000000000000000000000001111
;d1=00000000000000000000000011000000
;d2=00000000000000000000000000111111
;d3=00000000000000000000000011110000
;d4=00000000000000000000000001111111
;d5=00000000000000000000000011111000
;a1=00000000000000000000000011111111
;a2=00000000000000000000000011111100
;a3=00000000111111110000000000111000
;a4=00000001111111110000000001111100
;a5=00000001100011110000000011111110

;a0 offset for shift 7: 1120
	movem.l writesprite7_d,d0-d5/a1-a5
	move.w (a6)+,d7
; JUST DON'T DO THIS MOVE
writesprite7_l:
	 adda.w (a6)+,a0
	   or.w d0,0000-1120(a0) ; 0000000000001111
	   or.w d0,2400-1120(a0) ; 0000000000001111
	   or.b d1,0008-1120(a0) ; 11000000
	   or.b d1,2408-1120(a0) ; 11000000
	   or.w d2,0160-1120(a0) ; 0000000000111111
	   or.w d2,2240-1120(a0) ; 0000000000111111
	   or.b d3,0168-1120(a0) ; 11110000
	   or.b d3,2248-1120(a0) ; 11110000
	   or.w d4,0320-1120(a0) ; 0000000001111111
	   or.w d4,2080-1120(a0) ; 0000000001111111
	   or.b d5,0328-1120(a0) ; 11111000
	   or.b d5,2088-1120(a0) ; 11111000
	 move.l a4,d6
	   or.l d6,0800-1120(a0) ; 00000001111111110000000001111100
	   or.l d6,1600-1120(a0) ; 00000001111111110000000001111100
	 move.l a2,d6
	   or.b d6,0488-1120(a0) ; 11111100
	   or.b d6,1928-1120(a0) ; 11111100
	   or.b d6,0648-1120(a0) ; 11111100
	   or.b d6,1768-1120(a0) ; 11111100
	 move.l a5,d6
	   or.b d6,0808-1120(a0) ; 11111110
	   or.b d6,1608-1120(a0) ; 11111110
	   or.l d6,0960-1120(a0) ; 00000001100011110000000011111110
	   or.l d6,1440-1120(a0) ; 00000001100011110000000011111110
	   or.b d6,0968-1120(a0) ; 11111110
	   or.b d6,1448-1120(a0) ; 11111110
	   or.l d6,(a0)          ; 00000001100011110000000011111110
	   or.l d6,1280-1120(a0) ; 00000001100011110000000011111110
	   or.b d6,1128-1120(a0) ; 11111110
	   or.b d6,1288-1120(a0) ; 11111110
	 move.l a1,d6
	 move.b d6,0481-1120(a0) ;         11111111
	 move.b d6,1921-1120(a0) ;         11111111
	 move.l a3,d6
	   or.l d6,0640-1120(a0) ; 00000000111111110000000000111000
	   or.l d6,1760-1120(a0) ; 00000000111111110000000000111000
writesprite7_s:
	 dbra d7,writesprite7_l
;Shift 6
;Needs  8 registers REGS: x
;d0=00000000000000000000000000011111
;d1=00000000000000000000000001111111
;d2=00000000000000000000000011100000
;d3=00000000000000000000000011110000
;d4=00000000000000000000000111111111
;d5=00000001111111110000000001110000
;a1=00000011111111110000000011111000
;a2=00000011000111110000000111111100

;a0 offset for shift 6: 1120
	movem.l writesprite6_d,d0-d5/a1-a2
	move.w (a6)+,d7
; JUST DON'T DO THIS MOVE
writesprite6_l:
	 adda.w (a6)+,a0
	   or.w d0,0000-1120(a0) ; 0000000000011111
	   or.w d0,2400-1120(a0) ; 0000000000011111
	 bset.b d0,0008-1120(a0) ; 10000000
	 bset.b d0,2408-1120(a0) ; 10000000
	   or.w d1,0160-1120(a0) ; 0000000001111111
	   or.w d1,2240-1120(a0) ; 0000000001111111
	   or.b d2,0168-1120(a0) ; 11100000
	   or.b d2,2248-1120(a0) ; 11100000
	 move.b d4,0321-1120(a0) ;         11111111
	 move.b d4,2081-1120(a0) ;         11111111
	   or.b d3,0328-1120(a0) ; 11110000
	   or.b d3,2088-1120(a0) ; 11110000
	   or.w d4,0480-1120(a0) ; 0000000111111111
	   or.w d4,1920-1120(a0) ; 0000000111111111
	   or.l d5,0640-1120(a0) ; 00000001111111110000000001110000
	   or.l d5,1760-1120(a0) ; 00000001111111110000000001110000
	 move.l a2,d6
	   or.b d6,0808-1120(a0) ; 11111100
	   or.b d6,1608-1120(a0) ; 11111100
	   or.l d6,0960-1120(a0) ; 00000011000111110000000111111100
	   or.l d6,1440-1120(a0) ; 00000011000111110000000111111100
	   or.b d6,0968-1120(a0) ; 11111100
	   or.b d6,1448-1120(a0) ; 11111100
	   or.l d6,(a0)          ; 00000011000111110000000111111100
	   or.l d6,1280-1120(a0) ; 00000011000111110000000111111100
	   or.b d6,1128-1120(a0) ; 11111100
	   or.b d6,1288-1120(a0) ; 11111100
	 move.l a1,d6
	   or.b d6,0488-1120(a0) ; 11111000
	   or.b d6,1928-1120(a0) ; 11111000
	   or.b d6,0648-1120(a0) ; 11111000
	   or.b d6,1768-1120(a0) ; 11111000
	   or.l d6,0800-1120(a0) ; 00000011111111110000000011111000
	   or.l d6,1600-1120(a0) ; 00000011111111110000000011111000
writesprite6_s:
	 dbra d7,writesprite6_l
;Shift 5
;Needs  7 registers
;d0=00000000000000000000000000111111
;d1=00000000000000000000000011000000
;d2=00000000000000000000000111111111
;d3=00000000000000000000001111111111
;d4=00000011111111110000000011100000
;d5=00000111111111110000000111110000
;d6=00000110001111110000001111111000

;a0 offset for shift 5: 1120
	movem.l writesprite5_d,d0-d6
	move.w (a6)+,d7
; JUST DON'T DO THIS MOVE
writesprite5_l:
	 adda.w (a6)+,a0
	   or.w d0,0000-1120(a0) ; 0000000000111111
	   or.w d0,2400-1120(a0) ; 0000000000111111
	 move.b d3,0161-1120(a0) ;         11111111
	 move.b d3,2241-1120(a0) ;         11111111
	   or.b d1,0168-1120(a0) ; 11000000
	   or.b d1,2248-1120(a0) ; 11000000
	   or.w d2,0320-1120(a0) ; 0000000111111111
	   or.w d2,2080-1120(a0) ; 0000000111111111
	   or.b d4,0328-1120(a0) ; 11100000
	   or.b d4,2088-1120(a0) ; 11100000
	   or.w d3,0480-1120(a0) ; 0000001111111111
	   or.w d3,1920-1120(a0) ; 0000001111111111
	   or.b d5,0488-1120(a0) ; 11110000
	   or.b d5,1928-1120(a0) ; 11110000
	   or.l d4,0640-1120(a0) ; 00000011111111110000000011100000
	   or.l d4,1760-1120(a0) ; 00000011111111110000000011100000
	   or.b d5,0648-1120(a0) ; 11110000
	   or.b d5,1768-1120(a0) ; 11110000
	   or.l d5,0800-1120(a0) ; 00000111111111110000000111110000
	   or.l d5,1600-1120(a0) ; 00000111111111110000000111110000
	   or.b d6,0808-1120(a0) ; 11111000
	   or.b d6,1608-1120(a0) ; 11111000
	   or.l d6,0960-1120(a0) ; 00000110001111110000001111111000
	   or.l d6,1440-1120(a0) ; 00000110001111110000001111111000
	   or.b d6,0968-1120(a0) ; 11111000
	   or.b d6,1448-1120(a0) ; 11111000
	   or.l d6,(a0)          ; 00000110001111110000001111111000
	   or.l d6,1280-1120(a0) ; 00000110001111110000001111111000
	   or.b d6,1128-1120(a0) ; 11111000
	   or.b d6,1288-1120(a0) ; 11111000
writesprite5_s:
	 dbra d7,writesprite5_l
;Shift 4
;Needs  7 registers
;d0=00000000000000000000000001111110
;d1=00000000000000000000000111111111
;d2=00000000000000000000001111111111
;d3=00000000000000000000011111111111
;d4=00000111111111110000000111000000
;d5=00001111111111110000001111100000
;d6=00001100011111110000011111110000

;a0 offset for shift 4: 1120
	movem.l writesprite4_d,d0-d6
	move.w (a6)+,d7
; JUST DON'T DO THIS MOVE
writesprite4_l:
	 adda.w (a6)+,a0
	   or.w d0,0000-1120(a0) ; 0000000001111110
	   or.w d0,2400-1120(a0) ; 0000000001111110
	   or.w d1,0160-1120(a0) ; 0000000111111111
	   or.w d1,2240-1120(a0) ; 0000000111111111
	 bset.b d1,0168-1120(a0) ; 10000000
	 bset.b d1,2248-1120(a0) ; 10000000
	   or.w d2,0320-1120(a0) ; 0000001111111111
	   or.w d2,2080-1120(a0) ; 0000001111111111
	   or.b d4,0328-1120(a0) ; 11000000
	   or.b d4,2088-1120(a0) ; 11000000
	   or.w d3,0480-1120(a0) ; 0000011111111111
	   or.w d3,1920-1120(a0) ; 0000011111111111
	   or.b d5,0488-1120(a0) ; 11100000
	   or.b d5,1928-1120(a0) ; 11100000
	   or.l d4,0640-1120(a0) ; 00000111111111110000000111000000
	   or.l d4,1760-1120(a0) ; 00000111111111110000000111000000
	   or.b d5,0648-1120(a0) ; 11100000
	   or.b d5,1768-1120(a0) ; 11100000
	   or.l d5,0800-1120(a0) ; 00001111111111110000001111100000
	   or.l d5,1600-1120(a0) ; 00001111111111110000001111100000
	   or.b d6,0808-1120(a0) ; 11110000
	   or.b d6,1608-1120(a0) ; 11110000
	   or.l d6,0960-1120(a0) ; 00001100011111110000011111110000
	   or.l d6,1440-1120(a0) ; 00001100011111110000011111110000
	   or.b d6,0968-1120(a0) ; 11110000
	   or.b d6,1448-1120(a0) ; 11110000
	   or.l d6,(a0)          ; 00001100011111110000011111110000
	   or.l d6,1280-1120(a0) ; 00001100011111110000011111110000
	   or.b d6,1128-1120(a0) ; 11110000
	   or.b d6,1288-1120(a0) ; 11110000
writesprite4_s:
	 dbra d7,writesprite4_l
;Shift 3
;Needs  7 registers
;d0=00000000000000000000000011111100
;d1=00000000000000000000001111111111
;d2=00000000000000000000011111111111
;d3=00000000000000000000111111111111
;d4=00001111111111110000001110000000
;d5=00011111111111110000011111000000
;d6=00011000111111110000111111100000

;a0 offset for shift 3: 1120
	movem.l writesprite3_d,d0-d6
	move.w (a6)+,d7
; JUST DON'T DO THIS MOVE
writesprite3_l:
	 adda.w (a6)+,a0
	   or.w d0,0000-1120(a0) ; 0000000011111100
	   or.w d0,2400-1120(a0) ; 0000000011111100
	   or.w d1,0160-1120(a0) ; 0000001111111111
	   or.w d1,2240-1120(a0) ; 0000001111111111
	   or.w d2,0320-1120(a0) ; 0000011111111111
	   or.w d2,2080-1120(a0) ; 0000011111111111
	   or.b d4,0328-1120(a0) ; 10000000
	   or.b d4,2088-1120(a0) ; 10000000
	   or.w d3,0480-1120(a0) ; 0000111111111111
	   or.w d3,1920-1120(a0) ; 0000111111111111
	   or.b d5,0488-1120(a0) ; 11000000
	   or.b d5,1928-1120(a0) ; 11000000
	   or.l d4,0640-1120(a0) ; 00001111111111110000001110000000
	   or.l d4,1760-1120(a0) ; 00001111111111110000001110000000
	   or.b d5,0648-1120(a0) ; 11000000
	   or.b d5,1768-1120(a0) ; 11000000
	   or.l d5,0800-1120(a0) ; 00011111111111110000011111000000
	   or.l d5,1600-1120(a0) ; 00011111111111110000011111000000
	   or.b d6,0808-1120(a0) ; 11100000
	   or.b d6,1608-1120(a0) ; 11100000
	   or.l d6,0960-1120(a0) ; 00011000111111110000111111100000
	   or.l d6,1440-1120(a0) ; 00011000111111110000111111100000
	   or.b d6,0968-1120(a0) ; 11100000
	   or.b d6,1448-1120(a0) ; 11100000
	   or.l d6,(a0)          ; 00011000111111110000111111100000
	   or.l d6,1280-1120(a0) ; 00011000111111110000111111100000
	   or.b d6,1128-1120(a0) ; 11100000
	   or.b d6,1288-1120(a0) ; 11100000
writesprite3_s:
	 dbra d7,writesprite3_l
;Shift 2
;Needs  7 registers
;d0=00000000000000000000000111111000
;d1=00000000000000000000011111111110
;d2=00000000000000000000111111111111
;d3=00000000000000000001111111111111
;d4=00011111111111110000011100000000
;d5=00111111111111110000111110000000
;d6=00110001111111110001111111000000

;a0 offset for shift 2: 1120
	movem.l writesprite2_d,d0-d6
	move.w (a6)+,d7
; JUST DON'T DO THIS MOVE
writesprite2_l:
	 adda.w (a6)+,a0
	   or.w d0,0000-1120(a0) ; 0000000111111000
	   or.w d0,2400-1120(a0) ; 0000000111111000
	   or.w d1,0160-1120(a0) ; 0000011111111110
	   or.w d1,2240-1120(a0) ; 0000011111111110
	   or.w d2,0320-1120(a0) ; 0000111111111111
	   or.w d2,2080-1120(a0) ; 0000111111111111
	   or.w d3,0480-1120(a0) ; 0001111111111111
	   or.w d3,1920-1120(a0) ; 0001111111111111
	   or.b d5,0488-1120(a0) ; 10000000
	   or.b d5,1928-1120(a0) ; 10000000
	   or.l d4,0640-1120(a0) ; 00011111111111110000011100000000
	   or.l d4,1760-1120(a0) ; 00011111111111110000011100000000
	   or.b d5,0648-1120(a0) ; 10000000
	   or.b d5,1768-1120(a0) ; 10000000
	   or.l d5,0800-1120(a0) ; 00111111111111110000111110000000
	   or.l d5,1600-1120(a0) ; 00111111111111110000111110000000
	   or.b d6,0808-1120(a0) ; 11000000
	   or.b d6,1608-1120(a0) ; 11000000
	   or.l d6,0960-1120(a0) ; 00110001111111110001111111000000
	   or.l d6,1440-1120(a0) ; 00110001111111110001111111000000
	   or.b d6,0968-1120(a0) ; 11000000
	   or.b d6,1448-1120(a0) ; 11000000
	   or.l d6,(a0)          ; 00110001111111110001111111000000
	   or.l d6,1280-1120(a0) ; 00110001111111110001111111000000
	   or.b d6,1128-1120(a0) ; 11000000
	   or.b d6,1288-1120(a0) ; 11000000
writesprite2_s:
	 dbra d7,writesprite2_l
;Shift 1
;Needs  7 registers
;d0=00000000000000000000001111110000
;d1=00000000000000000000111111111100
;d2=00000000000000000001111111111110
;d3=00000000000000000011111111111111
;d4=00111111111111110000111000000000
;d5=01111111111111110001111100000000
;d6=01100011111111110011111110000000

;a0 offset for shift 1: 1120
	movem.l writesprite1_d,d0-d6
	move.w (a6)+,d7
; JUST DON'T DO THIS MOVE
writesprite1_l:
	 adda.w (a6)+,a0
	   or.w d0,0000-1120(a0) ; 0000001111110000
	   or.w d0,2400-1120(a0) ; 0000001111110000
	   or.w d1,0160-1120(a0) ; 0000111111111100
	   or.w d1,2240-1120(a0) ; 0000111111111100
	   or.w d2,0320-1120(a0) ; 0001111111111110
	   or.w d2,2080-1120(a0) ; 0001111111111110
	   or.w d3,0480-1120(a0) ; 0011111111111111
	   or.w d3,1920-1120(a0) ; 0011111111111111
	   or.l d4,0640-1120(a0) ; 00111111111111110000111000000000
	   or.l d4,1760-1120(a0) ; 00111111111111110000111000000000
	   or.l d5,0800-1120(a0) ; 01111111111111110001111100000000
	   or.l d5,1600-1120(a0) ; 01111111111111110001111100000000
	   or.b d6,0808-1120(a0) ; 10000000
	   or.b d6,1608-1120(a0) ; 10000000
	   or.l d6,0960-1120(a0) ; 01100011111111110011111110000000
	   or.l d6,1440-1120(a0) ; 01100011111111110011111110000000
	   or.b d6,0968-1120(a0) ; 10000000
	   or.b d6,1448-1120(a0) ; 10000000
	   or.l d6,(a0)          ; 01100011111111110011111110000000
	   or.l d6,1280-1120(a0) ; 01100011111111110011111110000000
	   or.b d6,1128-1120(a0) ; 10000000
	   or.b d6,1288-1120(a0) ; 10000000
writesprite1_s:
	 dbra d7,writesprite1_l
;Shift 0
;Needs  7 registers
;d0=00000000000000000000011111100000
;d1=00000000000000000001111111111000
;d2=00000000000000000011111111111100
;d3=00000000000000000111111111111110
;d4=01111111111111100001110000000000
;d5=11111111111111110011111000000000
;d6=11000111111111110111111100000000

;a0 offset for shift 0: 1120
	movem.l writesprite0_d,d0-d6
	move.w (a6)+,d7
	 bmi.s noMv_0
writesprite0_ml:
	 adda.w (a6)+,a0
	   move.w d0,0000-1120(a0) ; 0000011111100000
	   move.w d0,2400-1120(a0) ; 0000011111100000
	   move.w d1,0160-1120(a0) ; 0001111111111000
	   move.w d1,2240-1120(a0) ; 0001111111111000
	   move.w d2,0320-1120(a0) ; 0011111111111100
	   move.w d2,2080-1120(a0) ; 0011111111111100
	   move.w d3,0480-1120(a0) ; 0111111111111110
	   move.w d3,1920-1120(a0) ; 0111111111111110
	   move.l d4,0640-1120(a0) ; 01111111111111100001110000000000
	   move.l d4,1760-1120(a0) ; 01111111111111100001110000000000
	   move.l d5,0800-1120(a0) ; 11111111111111110011111000000000
	   move.l d5,1600-1120(a0) ; 11111111111111110011111000000000
	   move.l d6,0960-1120(a0) ; 11000111111111110111111100000000
	   move.l d6,1440-1120(a0) ; 11000111111111110111111100000000
	   move.l d6,(a0)          ; 11000111111111110111111100000000
	   move.l d6,1280-1120(a0) ; 11000111111111110111111100000000
writesprite0_ms:
	 dbra d7,writesprite0_ml
noMv_0:
	move.w (a6)+,d7
writesprite0_l:
	 adda.w (a6)+,a0
	   or.w d0,0000-1120(a0) ; 0000011111100000
	   or.w d0,2400-1120(a0) ; 0000011111100000
	   or.w d1,0160-1120(a0) ; 0001111111111000
	   or.w d1,2240-1120(a0) ; 0001111111111000
	   or.w d2,0320-1120(a0) ; 0011111111111100
	   or.w d2,2080-1120(a0) ; 0011111111111100
	   or.w d3,0480-1120(a0) ; 0111111111111110
	   or.w d3,1920-1120(a0) ; 0111111111111110
	   or.l d4,0640-1120(a0) ; 01111111111111100001110000000000
	   or.l d4,1760-1120(a0) ; 01111111111111100001110000000000
	   or.l d5,0800-1120(a0) ; 11111111111111110011111000000000
	   or.l d5,1600-1120(a0) ; 11111111111111110011111000000000
	   or.l d6,0960-1120(a0) ; 11000111111111110111111100000000
	   or.l d6,1440-1120(a0) ; 11000111111111110111111100000000
	   or.l d6,(a0)          ; 11000111111111110111111100000000
	   or.l d6,1280-1120(a0) ; 11000111111111110111111100000000
writesprite0_s:
	 dbra d7,writesprite0_l
	rts
writesprite15_d:
	dc.l %00000000000000000000111111000000
	dc.l %00000000000000000011111111110000
	dc.l %00000000000000000111111111111000
	dc.l %00000000000000001111111111111100
	dc.l %11111111111111000011100000000000
	dc.l %00000000000000000000000000000001
	dc.l %11111111111111100111110000000000
	dc.l %10001111111111101111111000000000
writesprite14_d:
	dc.l %00000000000000000001111110000000
	dc.l %00000000000000000111111111100000
	dc.l %00000000000000001111111111110000
	dc.l %00000000000000001111111111111000
	dc.l %11111111111110000111000000000000
	dc.l %00000000000000000000000000000011
	dc.l %11111111111111001111100000000000
	dc.l %00000000000000110000000000000001
	dc.l %00011111111111001111110000000000
writesprite13_d:
	dc.l %00000000000000000000000000111111
	dc.l %00000000000000001111111111000000
	dc.l %00000000000000001111111111100000
	dc.l %00000000000000001111111111110000
	dc.l %11111111111100001110000000000000
	dc.l %00000000000001110000000000000001
	dc.l %11111111111110001111000000000000
	dc.l %00000000000001100000000000000011
	dc.l %00111111111110001111100000000000
writesprite12_d:
	dc.l %00000000000000000000000001111110
	dc.l %00000000000000001111111110000000
	dc.l %00000000000000001111111111000000
	dc.l %00000000000000001111111111100000
	dc.l %00000000000001110000000000000001
	dc.l %11111111111000001100000000000000
	dc.l %00000000000011110000000000000011
	dc.l %11111111111100001110000000000000
	dc.l %00000000000011000000000000000111
	dc.l %01111111111100001111000000000000
writesprite11_d:
	dc.l %00000000000000000000000011111100
	dc.l %00000000000000000000000011111111
	dc.l %00000000000000001111111110000000
	dc.l %00000000000000001111111111000000
	dc.l %00000000000011110000000000000011
	dc.l %11111111110000001000000000000000
	dc.l %00000000000111110000000000000111
	dc.l %11111111111000001100000000000000
	dc.l %00000000000110000000000000001111
	dc.l %11111111111000001110000000000000
writesprite10_d:
	dc.l %00000000000000000000000011111000
	dc.l %00000000000000000000000011111110
	dc.l %00000000000000000000000011111111
	dc.l %00000000000000001111111110000000
	dc.l %00000000000111110000000000000111
	dc.l %00000000001111110000000000001111
	dc.l %11111111110000001000000000000000
	dc.l %00000000001100010000000000011111
	dc.l %11111111110000001100000000000000
writesprite9_d:
	dc.l %00000000000000000000000000000011
	dc.l %00000000000000000000000011110000
	dc.l %00000000000000000000000000001111
	dc.l %00000000000000000000000011111100
	dc.l %00000000000000000000000011111110
	dc.l %00000000000000000000000011111111
	dc.l %00000000001111110000000000001110
	dc.l %00000000011111110000000000011111
	dc.l %00000000000000001111111110000000
	dc.l %00000000011000110000000000111111
	dc.l %11111111100000001000000000000000
writesprite8_d:
	dc.l %00000000000000000000000000000111
	dc.l %00000000000000000000000011100000
	dc.l %00000000000000000000000000011111
	dc.l %00000000000000000000000011111000
	dc.l %00000000000000000000000000111111
	dc.l %00000000000000000000000011111100
	dc.l %00000000000000000000000011111110
	dc.l %00000000011111110000000000011100
	dc.l %00000000111111110000000000111110
	dc.l %00000000000000000000000011111111
	dc.l %00000000110001110000000001111111
writesprite7_d:
	dc.l %00000000000000000000000000001111
	dc.l %00000000000000000000000011000000
	dc.l %00000000000000000000000000111111
	dc.l %00000000000000000000000011110000
	dc.l %00000000000000000000000001111111
	dc.l %00000000000000000000000011111000
	dc.l %00000000000000000000000011111111
	dc.l %00000000000000000000000011111100
	dc.l %00000000111111110000000000111000
	dc.l %00000001111111110000000001111100
	dc.l %00000001100011110000000011111110
writesprite6_d:
	dc.l %00000000000000000000000000011111
	dc.l %00000000000000000000000001111111
	dc.l %00000000000000000000000011100000
	dc.l %00000000000000000000000011110000
	dc.l %00000000000000000000000111111111
	dc.l %00000001111111110000000001110000
	dc.l %00000011111111110000000011111000
	dc.l %00000011000111110000000111111100
writesprite5_d:
	dc.l %00000000000000000000000000111111
	dc.l %00000000000000000000000011000000
	dc.l %00000000000000000000000111111111
	dc.l %00000000000000000000001111111111
	dc.l %00000011111111110000000011100000
	dc.l %00000111111111110000000111110000
	dc.l %00000110001111110000001111111000
writesprite4_d:
	dc.l %00000000000000000000000001111110
	dc.l %00000000000000000000000111111111
	dc.l %00000000000000000000001111111111
	dc.l %00000000000000000000011111111111
	dc.l %00000111111111110000000111000000
	dc.l %00001111111111110000001111100000
	dc.l %00001100011111110000011111110000
writesprite3_d:
	dc.l %00000000000000000000000011111100
	dc.l %00000000000000000000001111111111
	dc.l %00000000000000000000011111111111
	dc.l %00000000000000000000111111111111
	dc.l %00001111111111110000001110000000
	dc.l %00011111111111110000011111000000
	dc.l %00011000111111110000111111100000
writesprite2_d:
	dc.l %00000000000000000000000111111000
	dc.l %00000000000000000000011111111110
	dc.l %00000000000000000000111111111111
	dc.l %00000000000000000001111111111111
	dc.l %00011111111111110000011100000000
	dc.l %00111111111111110000111110000000
	dc.l %00110001111111110001111111000000
writesprite1_d:
	dc.l %00000000000000000000001111110000
	dc.l %00000000000000000000111111111100
	dc.l %00000000000000000001111111111110
	dc.l %00000000000000000011111111111111
	dc.l %00111111111111110000111000000000
	dc.l %01111111111111110001111100000000
	dc.l %01100011111111110011111110000000
writesprite0_d:
	dc.l %00000000000000000000011111100000
	dc.l %00000000000000000001111111111000
	dc.l %00000000000000000011111111111100
	dc.l %00000000000000000111111111111110
	dc.l %01111111111111100001110000000000
	dc.l %11111111111111110011111000000000
	dc.l %11000111111111110111111100000000

