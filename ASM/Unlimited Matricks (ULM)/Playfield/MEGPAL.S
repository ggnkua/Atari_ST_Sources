
 dc.w $0707,$0707,$0607,$0607,$0507,$0507,$0407,$0407
 dc.w $0307,$0307,$0207,$0207,$0107,$0107,$0007,$0007
 dc.w $0017,$0017,$0027,$0027,$0037,$0037,$0047,$0047
 dc.w $0057,$0057,$0067,$0067,$0077,$0077,$0076,$0076
 dc.w $0075,$0075,$0074,$0074,$0073,$0073,$0072,$0072
 dc.w $0071,$0071,$0070,$0070,$0170,$0170,$0270,$0270
 dc.w $0370,$0370,$0470,$0470,$0570,$0570,$0670,$0670
 dc.w $0770,$0770,$0760,$0760,$0750,$0750,$0740,$0740
 dc.w $0730,$0730,$0720,$0720,$0710,$0710,$0700,$0700
 dc.w $0701,$0701,$0702,$0702,$0703,$0703,$0704,$0704
 dc.w $0705,$0705,$0706,$0706,$0707,$0707,$0617,$0617
 dc.w $0527,$0527,$0427,$0427,$0337,$0337,$0247,$0247
 dc.w $0257,$0257,$0167,$0167,$0077,$0077,$0176,$0176
 dc.w $0275,$0275,$0274,$0274,$0373,$0373,$0472,$0472
 dc.w $0572,$0572,$0671,$0671,$0770,$0770,$0761,$0761
 dc.w $0752,$0752,$0742,$0742,$0733,$0733,$0724,$0724
 dc.w $0725,$0725,$0716,$0716,$0707,$0707,$0616,$0616
 dc.w $0525,$0525,$0434,$0434,$0343,$0343,$0252,$0252
 dc.w $0161,$0161,$0070,$0070,$0160,$0160,$0250,$0250
 dc.w $0340,$0340,$0430,$0430,$0520,$0520,$0610,$0610
 dc.w $0700,$0700,$0611,$0611,$0522,$0522,$0433,$0433
 dc.w $0344,$0344,$0255,$0255,$0166,$0166,$0077,$0077
 dc.w $0176,$0176,$0275,$0275,$0374,$0374,$0473,$0473
 dc.w $0572,$0572,$0671,$0671,$0770,$0770,$0661,$0661
 dc.w $0552,$0552,$0443,$0443,$0334,$0334,$0225,$0225
 dc.w $0116,$0116,$0007,$0007,$0016,$0016,$0025,$0025
 dc.w $0034,$0034,$0043,$0043,$0052,$0052,$0061,$0061
 dc.w $0070,$0070,$0170,$0170,$0271,$0271,$0371,$0371
 dc.w $0472,$0472,$0572,$0572,$0673,$0673,$0773,$0773
 dc.w $0763,$0763,$0752,$0752,$0742,$0742,$0731,$0731
 dc.w $0721,$0721,$0710,$0710,$0700,$0700,$0701,$0701
 dc.w $0712,$0712,$0713,$0713,$0724,$0724,$0725,$0725
 dc.w $0736,$0736,$0737,$0737,$0637,$0637,$0527,$0527
 dc.w $0427,$0427,$0317,$0317,$0217,$0217,$0107,$0107
 dc.w $0007,$0007,$0017,$0017,$0127,$0127,$0137,$0137
 dc.w $0247,$0247,$0257,$0257,$0367,$0367,$0377,$0377
 dc.w $0376,$0376,$0275,$0275,$0274,$0274,$0173,$0173
 dc.w $0172,$0172,$0071,$0071,$0070,$0070,$0161,$0161
 dc.w $0252,$0252,$0343,$0343,$0434,$0434,$0525,$0525
 dc.w $0616,$0616,$0707,$0707,$FFFF,$FFFF
