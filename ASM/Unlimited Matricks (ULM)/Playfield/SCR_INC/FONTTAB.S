	dc.l	font+0,1152/2
	dc.l	font+1152/2,1152/2
	dc.l	font+2304/2,1152/2
	dc.l	font+3456/2,1152/2
	dc.l	font+4608/2,1152/2
	dc.l	font+5760/2,1152/2
	dc.l	font+6912/2,1152/2
	dc.l	font+8064/2,1152/2
	dc.l	font+9216/2,576/2
	dc.l	font+9792/2,960/2
	dc.l	font+10752/2,1152/2
	dc.l	font+11904/2,1152/2
	dc.l	font+13056/2,1152/2
	dc.l	font+14208/2,1152/2
	dc.l	font+15360/2,1152/2
	dc.l	font+16512/2,1152/2
	dc.l	font+17664/2,1152/2
	dc.l	font+18816/2,1152/2
	dc.l	font+19968/2,1152/2
	dc.l	font+21120/2,1152/2
	dc.l	font+22272/2,1152/2
	dc.l	font+23424/2,1152/2
	dc.l	font+24576/2,1152/2
	dc.l	font+25728/2,1152/2
	dc.l	font+26880/2,1152/2
	dc.l	font+28032/2,1152/2
	dc.l	font+29184/2,960/2
	dc.l	font+30144/2,768/2
	dc.l	font+30912/2,960/2
	dc.l	font+31872/2,960/2
	dc.l	font+32832/2,1152/2
	dc.l	font+33984/2,960/2
	dc.l	font+34944/2,960/2
	dc.l	font+35904/2,960/2
	dc.l	font+36864/2,960/2
	dc.l	font+37824/2,960/2
	dc.l	font+38784/2,192/2
	dc.l	font+38976/2,384/2
	dc.l	font+39360/2,960/2
	dc.l	font+40320/2,384/2
	dc.l	font+40704/2,576/2
	dc.l	font+41280/2,576/2
	dc.l	font+41856/2,384/2
	dc.l	font+42240/2,768/2
	dc.l	font+43008/2,384/2
	dc.l	font+43392/2,768/2
	dc.l	font+44160/2,384/2
	dc.l	font+44544/2,768/2
	dc.l	font+45312/2,1920/2
;	number of characters : 49
