
 dc.b 136,136,136,136,136,136,136,136,96,16,0,0,28,120,136,96,56,80,136,20
 dc.b 32,52,0,44,44,96,136,20,56,80,52,12,136,32,76,136,128,128,128,136
 dc.b 88,0,72,52,124,76,136,32,76,136,20,80,52,136,44,56,56,40,32,52
 dc.b 24,136,72,56,136,56,20,76,16,52,136,0,76,136,76,28,16,136,72,0
 dc.b 48,16,136,72,8,68,16,16,52,136,132,132,132,136,136,96,56,80,136,0
 dc.b 68,16,136,60,68,56,4,0,4,44,96,136,52,56,88,136,84,16,68,96
 dc.b 136,28,0,60,60,96,136,76,56,136,72,16,16,136,0,44,44,136,76,28
 dc.b 16,72,16,136,72,60,68,32,76,16,72,136,0,20,76,16,68,136,96,56
 dc.b 80,68,136,84,16,68,96,136,44,56,52,24,136,64,80,16,72,76,136,20
 dc.b 56,68,136,76,28,16,136,72,8,68,16,16,52,136,88,28,32,8,28,136
 dc.b 32,72,136,12,32,20,20,32,8,80,44,76,136,76,56,136,16,52,76,16
 dc.b 68,112,112,112,136,136,56,40,120,136,52,56,88,136,76,28,0,76,136,16
 dc.b 84,16,68,96,4,56,12,96,136,32,72,136,28,16,68,16,120,136,32,136
 dc.b 8,0,52,136,76,16,44,44,136,96,56,80,136,76,28,0,76,136,76,28
 dc.b 32,72,136,32,72,136,0,52,56,76,28,16,68,136,20,80,44,44,72,8
 dc.b 68,16,16,52,136,4,96,136,48,16,120,136,76,28,16,136,20,0,76,16
 dc.b 112,112,112,136,136,136,136,0,44,44,136,24,68,0,60,28,32,92,136,88
 dc.b 16,68,16,136,12,56,52,16,136,4,96,136,76,96,68,16,48,136,56,20
 dc.b 136,76,28,16,136,68,16,72,60,16,8,76,0,4,44,16,72,112,112,112
 dc.b 136,136,136,76,28,16,136,48,80,72,32,8,136,32,72,136,20,68,56,48
 dc.b 136,48,0,12,136,48,0,92,136,56,20,136,76,16,92,112,112,112,136,136
 dc.b 136,136,32,76,124,72,136,56,52,16,136,56,20,136,48,96,136,56,44,12
 dc.b 16,72,76,136,72,8,68,16,16,52,72,120,136,4,80,76,136,32,136,76
 dc.b 28,32,52,40,136,32,76,124,72,136,72,76,32,44,44,136,84,16,68,96
 dc.b 136,24,56,56,12,112,136,32,76,136,88,0,72,136,8,56,12,16,12,136
 dc.b 0,20,76,16,68,136,76,28,16,136,60,0,68,76,96,136,32,52,136,48
 dc.b 0,68,72,16,32,44,44,16,72,136,88,28,16,52,136,32,136,0,52,12
 dc.b 136,24,80,52,72,76,32,8,40,136,72,76,0,96,16,12,136,72,56,48
 dc.b 16,136,48,56,68,16,136,12,0,96,72,136,0,76,136,20,80,68,96,124
 dc.b 72,136,28,56,48,16,136,76,56,136,28,16,44,60,136,28,32,48,136,8
 dc.b 44,16,0,52,32,52,24,136,80,60,136,28,32,72,136,28,56,80,72,16
 dc.b 136,4,16,20,56,68,16,136,28,32,72,136,48,56,76,28,16,68,136,88
 dc.b 0,72,136,8,56,48,32,52,24,136,4,0,8,40,112,136,136,136,136,96
 dc.b 16,0,28,120,136,76,28,32,72,136,16,84,16,52,32,52,24,136,32,136
 dc.b 88,32,44,44,136,44,16,0,84,16,136,44,80,92,16,48,4,56,80,68
 dc.b 24,136,76,56,136,24,56,136,76,56,136,76,28,16,136,72,76,136,52,16
 dc.b 88,72,136,32,52,76,16,68,52,0,76,32,56,52,0,44,136,8,28,68
 dc.b 32,72,76,48,0,72,136,8,56,12,32,52,24,136,8,56,52,20,16,68
 dc.b 16,52,8,16,136,32,52,136,28,56,44,44,0,52,12,136,88,28,16,68
 dc.b 16,136,88,16,136,88,32,44,44,136,28,0,84,16,136,0,136,24,68,16
 dc.b 0,76,136,76,32,48,16,112,136,0,72,136,76,28,16,136,32,52,84,32
 dc.b 76,0,76,32,56,52,136,72,0,96,72,120,136,32,76,136,88,32,44,44
 dc.b 136,4,16,136,76,28,16,136,28,56,76,76,16,72,76,136,76,28,32,52
 dc.b 24,136,72,32,52,8,16,136,76,28,16,136,72,80,48,48,16,68,136,0
 dc.b 52,12,136,32,136,76,28,32,52,40,136,76,28,32,72,136,32,72,136,76
 dc.b 68,80,16,136,0,52,12,136,16,84,16,68,96,4,56,12,96,136,88,28
 dc.b 56,136,88,56,52,124,76,136,4,16,136,76,28,16,68,16,136,88,32,44
 dc.b 44,136,72,80,68,16,44,96,136,48,32,72,72,136,72,56,48,16,76,28
 dc.b 32,52,24,112,112,112,136,0,52,96,88,0,96,120,136,32,124,48,136,44
 dc.b 56,56,40,32,52,24,136,20,56,68,88,0,68,12,136,76,56,136,48,16
 dc.b 16,76,136,76,28,16,136,44,56,72,76,136,4,56,96,72,136,0,24,0
 dc.b 32,52,112,112,112,136,32,136,48,16,76,136,76,28,16,48,136,76,28,16
 dc.b 136,20,32,68,72,76,136,76,32,48,16,136,76,28,32,72,136,96,16,0
 dc.b 68,136,0,76,136,76,28,0,44,32,56,52,136,88,28,16,68,16,136,76
 dc.b 28,16,96,136,20,32,52,32,72,28,16,12,136,76,28,16,32,68,136,84
 dc.b 16,68,96,136,4,68,32,44,44,136,44,32,20,16,124,72,136,0,136,4
 dc.b 32,76,8,28,136,12,16,48,56,136,88,28,32,8,28,136,32,72,136,72
 dc.b 80,68,16,44,96,136,56,52,16,136,56,20,136,76,28,16,136,4,16,72
 dc.b 76,136,12,16,48,56,72,136,16,84,16,68,112,112,112,136,136,136,136,32
 dc.b 136,88,32,44,44,136,52,56,88,136,28,0,84,16,136,76,56,136,72,76
 dc.b 56,60,136,88,68,32,76,32,52,24,136,84,16,68,96,136,72,56,56,52
 dc.b 120,136,0,72,136,32,136,72,76,32,44,44,136,28,0,84,16,136,52,56
 dc.b 136,12,80,76,8,28,136,48,56,52,16,96,120,136,32,136,28,0,84,16
 dc.b 136,76,56,136,4,0,8,40,80,60,136,48,96,136,28,0,68,12,12,32
 dc.b 72,40,120,136,32,136,28,0,84,16,136,76,56,136,60,80,76,136,48,96
 dc.b 136,8,44,56,76,28,16,72,136,32,52,136,48,96,136,4,0,24,120,136
 dc.b 32,136,28,0,84,16,136,76,56,136,76,0,40,16,136,0,136,4,0,76
 dc.b 28,120,136,32,136,28,0,84,16,136,76,56,136,60,80,76,136,76,28,32
 dc.b 72,136,72,8,68,56,44,44,76,16,92,76,136,32,52,136,76,28,16,136
 dc.b 72,8,68,16,16,52,120,136,32,136,28,0,84,16,136,76,56,136,60,80
 dc.b 76,136,48,96,136,8,56,48,60,80,76,16,68,72,136,0,52,12,136,48
 dc.b 56,52,32,76,56,68,72,136,32,52,136,72,56,48,16,136,4,56,92,16
 dc.b 72,136,0,52,12,136,32,136,28,0,84,16,136,76,56,136,12,56,136,72
 dc.b 56,48,16,136,56,76,28,16,68,136,76,28,32,52,24,72,136,88,28,32
 dc.b 8,28,136,0,68,16,52,124,76,136,76,28,0,76,136,32,48,60,56,68
 dc.b 76,0,52,76,120,136,72,56,136,32,136,12,56,52,124,76,136,48,16,52
 dc.b 76,32,56,52,136,76,28,16,48,112,112,112,112,136,96,56,80,136,72,80
 dc.b 68,16,44,96,136,88,56,52,12,16,68,136,88,28,96,136,32,136,76,16
 dc.b 44,44,136,96,56,80,136,0,44,44,136,76,28,32,72,136,8,68,0,60
 dc.b 112,112,112,136,32,136,12,56,52,124,76,136,40,52,56,88,112,136,60,68
 dc.b 56,4,0,4,44,96,136,4,16,8,0,80,72,16,136,32,136,28,0,84
 dc.b 16,136,52,56,136,56,76,28,16,68,136,32,12,16,0,72,136,0,52,12
 dc.b 136,4,16,8,0,80,72,16,136,32,136,12,56,136,52,56,76,136,88,0
 dc.b 52,76,136,76,28,32,72,136,72,8,68,56,44,44,136,76,56,136,4,16
 dc.b 136,84,16,68,96,136,72,28,56,68,76,112,112,112,136,136,12,32,12,136
 dc.b 96,56,80,136,0,44,68,16,0,12,96,136,40,52,56,88,120,136,76,28
 dc.b 0,76,136,32,76,136,32,72,136,60,56,72,72,32,4,44,16,136,76,56
 dc.b 136,88,68,32,76,16,136,72,8,68,56,44,44,76,16,92,76,72,136,0
 dc.b 20,76,16,68,136,96,56,80,136,28,0,84,16,136,16,0,76,16,52,136
 dc.b 72,56,48,16,76,28,32,52,24,112,112,112,136,32,20,136,52,56,76,120
 dc.b 136,96,56,80,136,0,68,16,136,60,68,56,4,0,4,44,96,136,8,56
 dc.b 48,60,44,16,76,16,44,96,136,48,0,12,136,0,52,12,136,76,28,0
 dc.b 76,124,72,136,0,44,72,56,136,88,28,96,136,96,56,80,136,72,76,32
 dc.b 44,44,136,68,16,0,12,136,76,28,32,72,136,72,28,32,76,112,112,112
 dc.b 136,136,136,136,136,136,0,68,16,136,96,56,80,136,72,76,32,44,44,136
 dc.b 76,28,16,68,16,136,132,132,132,136,136,136,136,136,32,136,0,48,136,72
 dc.b 76,32,44,44,136,28,16,68,16,136,128,128,128,136,136,136,136,136,76,28
 dc.b 16,68,16,136,32,72,136,0,136,28,32,12,12,16,52,136,48,80,72,32
 dc.b 8,136,32,52,136,76,28,32,72,136,72,8,68,16,16,52,136,128,128,128
 dc.b 136,136,136,96,56,80,136,28,0,84,16,136,76,56,136,16,52,76,16,68
 dc.b 136,136,136,32,136,136,136,136,76,28,16,52,136,136,136,136,112,136,136,136
 dc.b 136,76,28,16,52,136,136,136,136,0,136,136,136,136,76,28,16,52,136,136
 dc.b 136,136,48,136,136,136,136,76,28,16,52,136,136,136,136,112,136,136,136,136
 dc.b 76,28,16,52,136,136,136,136,48,136,136,136,136,76,28,16,52,136,136,136
 dc.b 136,0,136,136,136,136,76,28,16,52,136,136,136,136,12,136,136,136,136,76
 dc.b 28,16,52,136,136,136,136,128,128,128,136,136,136,136,0,52,12,136,0,44
 dc.b 44,136,76,28,32,72,136,76,28,68,16,16,136,76,32,48,16,72,136,0
 dc.b 52,12,136,12,56,136,52,56,76,136,60,0,80,72,16,136,76,56,56,136
 dc.b 44,56,52,24,136,4,16,76,88,16,16,52,136,60,80,72,28,32,52,24
 dc.b 136,76,28,16,136,40,16,96,72,112,112,112,136,136,136,136,32,20,136,52
 dc.b 56,76,28,32,52,24,136,28,0,60,60,16,52,72,120,136,32,76,124,72
 dc.b 136,52,56,76,136,48,96,136,20,0,80,44,76,112,112,112,136,136,136,136
 dc.b 136,136,136,0,52,96,88,0,96,136,32,76,136,88,0,72,136,36,80,72
 dc.b 76,136,0,136,36,56,40,16,136,88,28,32,8,28,136,88,56,68,40,72
 dc.b 136,56,52,44,96,136,88,32,76,28,136,60,16,56,60,44,16,136,88,28
 dc.b 56,136,0,68,16,136,48,0,12,136,128,128,128,136,56,68,136,12,56,136
 dc.b 96,56,80,136,76,96,60,16,136,32,52,136,32,112,0,48,112,48,0,12
 dc.b 128,128,128,136,0,52,12,136,76,28,32,72,136,76,28,68,16,16,136,76
 dc.b 32,48,16,72,136,88,28,16,52,136,96,56,80,136,0,68,16,52,124,76
 dc.b 136,48,0,12,136,132,132,132,132,136,136,136,136,136,136,88,16,44,44,120
 dc.b 136,52,56,88,136,76,28,16,136,72,8,68,56,44,44,32,52,24,136,32
 dc.b 72,136,44,56,52,24,136,16,52,56,80,24,28,120,136,0,52,96,88,0
 dc.b 96,136,32,124,48,136,68,16,0,44,44,96,136,56,80,76,136,56,20,136
 dc.b 32,12,16,0,72,136,0,52,12,136,72,56,136,76,28,16,136,56,52,44
 dc.b 96,136,76,28,32,52,24,136,32,136,8,0,52,136,12,56,136,32,72,136
 dc.b 76,56,136,44,16,76,136,76,28,32,72,136,72,8,68,56,44,44,136,4
 dc.b 16,24,32,52,136,20,68,56,48,136,76,28,16,136,4,16,24,32,52,52
 dc.b 32,52,24,112,112,112,112,112,112,112,136,136,136,136,136,136,136,136,136,136
 dc.b 136,136,136,136
