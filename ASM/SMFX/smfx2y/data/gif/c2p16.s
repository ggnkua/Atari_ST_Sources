	dc.b	24,24,36,36,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,40,40,36,36,36,36,36,36,36,40,48,40,40,36,36,36,36,40,48,48,16,48,48,48,40,16,12,48,48,48,48,40,40,40,48,0,0,0,0
	dc.b	28,28,28,28,28,24,24,36,36,40,48,48,48,48,48,48,16,16,16,48,48,48,48,48,48,48,48,48,40,40,40,40,40,36,36,40,36,40,48,40,40,40,40,36,36,36,40,48,48,16,16,48,48,48,40,40,48,48,48,48,48,48,48,48,0,0,0,0
	dc.b	28,24,24,24,24,36,36,24,36,36,36,36,40,40,48,48,16,16,16,16,16,16,16,16,48,48,48,48,48,48,48,48,40,48,40,40,40,48,48,40,40,40,40,40,36,36,40,40,16,16,16,48,48,48,48,48,40,40,52,52,16,48,48,48,0,0,0,0
	dc.b	24,24,24,36,36,36,36,36,40,40,40,36,36,36,36,36,36,40,40,52,52,60,60,12,12,12,16,16,48,48,48,48,48,48,48,48,48,40,36,40,40,40,40,40,36,36,40,40,16,16,16,48,48,48,48,48,40,40,36,36,36,36,36,36,0,0,0,0
	dc.b	48,40,40,36,36,36,36,36,36,36,40,40,40,40,36,36,36,36,36,36,36,36,36,36,40,40,40,52,52,52,16,48,48,48,40,40,36,36,36,36,40,40,48,40,40,36,36,36,52,12,12,16,48,48,48,40,40,40,40,36,36,36,24,24,0,0,0,0
	dc.b	40,40,48,48,48,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,36,36,36,36,40,36,24,28,24,40,40,36,40,40,40,40,40,40,36,36,36,12,12,16,48,48,48,48,40,36,36,36,36,36,36,24,0,0,0,0
	dc.b	40,40,36,36,36,40,40,40,48,48,48,40,40,40,40,40,40,40,40,40,40,40,40,36,36,36,40,36,36,36,36,36,36,36,24,24,24,36,40,48,48,48,48,40,40,40,40,36,36,52,12,16,48,48,48,48,40,40,36,36,36,36,36,24,0,0,0,0
	dc.b	36,36,36,36,36,36,40,40,40,40,48,48,40,40,40,40,40,40,40,40,48,48,48,48,40,40,48,40,40,40,40,40,36,36,24,24,24,24,24,40,48,48,48,40,40,40,40,36,36,36,60,12,48,48,48,48,48,40,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,40,40,40,40,40,48,36,36,36,40,40,48,48,48,48,48,48,48,48,48,48,48,40,40,36,36,36,36,36,24,24,24,24,36,36,48,48,48,40,40,36,40,36,36,52,4,16,48,48,40,40,40,40,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,40,40,48,40,48,48,36,36,36,40,40,40,40,40,40,40,40,40,36,36,40,40,40,40,36,36,36,36,36,36,36,36,36,24,28,40,48,48,48,48,40,40,36,36,36,12,16,48,48,48,40,40,40,36,36,36,36,36,0,0,0,0
	dc.b	36,36,40,40,40,40,40,40,40,40,48,48,36,24,24,24,24,24,24,24,24,24,24,24,24,24,24,24,24,36,36,36,40,36,36,36,36,36,24,28,28,36,40,48,48,48,40,40,40,36,36,44,12,48,48,48,40,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,40,40,40,40,40,40,48,48,48,48,48,36,24,24,24,24,24,24,24,36,24,28,28,24,24,28,28,28,28,28,28,24,24,36,36,24,24,28,28,24,36,36,40,48,40,40,40,36,40,36,36,52,48,48,48,48,40,36,40,40,36,36,36,0,0,0,0
	dc.b	40,40,40,48,48,48,48,48,48,48,48,40,40,36,36,24,36,36,36,36,36,36,24,28,24,28,28,28,28,28,28,28,28,28,28,24,24,24,24,28,28,24,24,36,48,48,40,40,36,40,36,36,40,48,48,48,48,40,40,36,36,40,40,36,0,0,0,0
	dc.b	40,48,48,48,48,48,16,16,12,52,40,36,36,36,40,36,36,36,36,36,36,36,36,24,24,24,28,28,28,28,28,28,28,28,28,28,28,28,28,32,32,28,24,24,48,48,40,40,40,40,40,40,36,40,40,48,48,40,40,40,40,40,40,40,0,0,0,0
	dc.b	48,48,48,48,48,16,12,12,52,36,36,36,36,40,40,36,36,36,40,40,36,36,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,32,28,24,24,28,40,48,36,36,36,36,36,36,24,24,24,36,40,48,48,48,48,48,48,40,0,0,0,0
	dc.b	48,16,48,16,16,12,12,36,36,36,40,36,48,40,48,40,40,40,36,36,28,28,28,28,28,28,28,28,28,28,28,28,28,32,28,28,28,28,28,32,28,24,24,28,36,40,36,36,36,24,24,24,24,24,36,36,24,36,40,40,40,40,40,36,0,0,0,0
	dc.b	16,16,12,4,12,52,40,36,40,40,40,40,40,48,48,40,40,36,28,28,24,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,28,28,28,28,32,24,28,28,24,40,40,36,36,24,24,24,24,24,40,36,36,36,40,40,40,36,36,36,0,0,0,0
	dc.b	16,12,12,12,52,40,40,40,40,40,40,48,48,48,40,36,24,24,24,28,28,32,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,24,36,36,36,36,24,24,24,24,40,48,40,40,40,40,40,40,36,36,36,0,0,0,0
	dc.b	12,12,52,40,36,40,40,40,48,48,48,48,48,40,36,36,24,24,28,32,32,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,24,36,24,24,24,24,24,36,40,48,48,40,40,40,40,36,40,36,36,36,0,0,0,0
	dc.b	16,40,36,40,40,40,40,40,48,48,48,48,48,36,24,24,24,28,28,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,24,24,28,28,28,28,24,36,48,48,40,48,40,40,36,36,40,36,36,36,0,0,0,0
	dc.b	40,36,36,40,40,40,40,40,40,48,48,48,40,24,28,28,28,28,24,24,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,28,28,24,24,24,36,48,48,48,40,40,40,40,40,36,36,36,40,16,0,0,0,0
	dc.b	36,36,40,40,40,40,48,40,48,48,48,40,36,24,24,24,24,24,36,24,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,32,32,32,28,24,24,24,36,40,48,48,48,48,40,40,40,36,36,40,16,12,16,0,0,0,0
	dc.b	36,36,40,40,40,40,40,40,40,48,40,24,24,24,36,36,36,36,36,24,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,24,24,24,40,40,48,48,40,40,48,36,36,36,36,40,12,12,12,48,0,0,0,0
	dc.b	40,36,40,40,40,40,40,36,36,40,36,24,24,36,36,36,36,36,40,36,28,28,24,32,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,28,28,24,24,28,24,36,40,48,48,40,40,40,36,40,36,36,40,52,4,12,16,16,16,0,0,0,0
	dc.b	40,40,48,40,40,40,36,36,36,36,24,24,24,36,36,36,36,36,36,24,28,24,28,32,32,28,28,28,28,32,32,28,28,28,28,28,28,28,28,28,28,28,28,28,24,40,40,40,40,40,40,40,40,40,36,36,36,12,12,16,48,48,48,48,0,0,0,0
	dc.b	48,48,48,48,48,48,48,40,40,36,24,24,36,36,36,36,36,36,40,36,28,24,28,28,32,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,24,36,36,36,36,36,40,40,40,36,36,36,36,44,12,12,16,48,48,48,48,48,0,0,0,0
	dc.b	40,40,40,40,40,40,48,48,48,40,40,36,40,36,40,40,40,40,48,40,24,24,28,32,32,28,24,24,28,28,28,28,32,28,28,28,28,28,24,24,36,36,36,36,36,36,36,36,36,40,40,36,36,36,52,16,16,16,48,48,48,48,48,40,0,0,0,0
	dc.b	40,40,40,36,40,40,40,48,48,48,48,40,36,36,40,40,48,48,48,40,36,24,28,28,24,24,24,24,24,28,28,28,28,28,28,28,28,28,28,24,24,24,36,36,24,24,24,24,24,36,36,36,40,40,48,48,48,48,48,40,40,40,40,36,0,0,0,0
	dc.b	36,36,36,40,40,40,40,48,48,48,16,52,36,36,40,36,40,40,48,48,40,36,24,24,28,28,24,36,36,36,24,24,28,28,28,28,28,28,24,24,28,28,24,36,24,24,24,24,24,24,24,36,48,48,48,48,48,40,40,40,36,40,36,36,0,0,0,0
	dc.b	36,36,36,36,40,40,40,40,48,48,16,12,52,36,40,40,40,48,48,48,48,40,36,28,28,24,36,36,36,36,36,36,36,36,36,24,24,24,24,24,24,24,28,24,24,24,24,24,24,24,24,36,48,48,40,40,40,40,40,40,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,40,40,48,48,48,48,12,12,36,36,40,40,48,40,48,48,48,40,28,24,36,36,36,36,36,36,36,36,36,40,40,40,40,40,40,40,40,40,40,40,40,40,40,36,36,36,36,48,48,40,40,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,40,40,48,48,48,48,12,4,40,40,36,40,40,48,40,48,48,48,36,24,24,24,24,36,36,36,36,36,40,40,48,48,48,48,48,48,48,48,48,48,48,40,40,48,36,36,40,48,40,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,40,48,40,48,48,48,16,12,12,36,40,40,40,40,48,48,48,48,48,40,24,24,24,24,36,36,36,40,40,40,40,40,40,40,48,48,48,48,48,40,40,40,40,40,40,36,40,48,48,40,40,40,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,36,36,36,36,40,40,48,48,48,48,16,12,4,52,36,40,40,48,48,48,48,48,48,48,40,24,24,24,24,36,40,36,36,36,36,40,40,40,40,40,40,40,40,40,40,40,48,48,40,40,40,40,48,48,48,40,40,40,36,36,40,40,36,0,0,0,0
	dc.b	24,36,36,36,36,40,40,48,48,48,48,16,12,4,12,40,36,40,40,40,40,48,48,40,40,40,36,24,28,24,36,40,36,36,36,36,36,36,36,40,36,36,36,36,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,36,0,0,0,0
	dc.b	36,36,36,36,40,40,40,40,48,48,48,16,16,12,4,52,36,40,40,40,40,48,48,40,36,36,36,36,36,40,48,48,16,16,52,52,52,40,40,40,40,36,36,36,36,36,36,36,36,36,40,40,40,40,36,36,36,36,36,36,40,40,40,40,0,0,0,0
	dc.b	40,52,36,36,36,40,40,48,48,48,48,48,16,16,16,16,40,40,40,40,40,40,48,40,36,40,40,40,48,48,48,48,48,48,48,16,16,12,12,12,12,12,12,52,52,40,40,36,36,36,36,36,36,36,36,40,36,36,36,36,24,36,36,24,0,0,0,0
	dc.b	48,16,16,16,52,52,40,48,48,48,48,48,16,16,16,16,48,40,36,40,40,40,40,40,40,48,48,40,40,40,40,40,48,48,48,48,48,48,48,16,16,16,16,16,16,16,16,16,48,48,48,40,36,36,36,36,36,36,36,24,24,24,24,24,0,0,0,0
	dc.b	48,48,48,48,16,16,16,16,48,48,48,48,16,16,16,16,48,40,36,40,40,40,40,40,48,40,40,40,36,36,40,40,40,40,40,48,48,48,48,48,48,48,48,48,16,16,16,16,48,48,48,48,48,48,40,40,36,24,28,28,28,28,32,32,0,0,0,0
	dc.b	40,16,60,16,16,16,16,16,12,16,48,48,48,16,16,48,48,40,36,40,40,40,40,40,48,40,36,36,40,36,36,36,36,36,36,40,48,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,36,36,36,24,0,0,0,0
	dc.b	24,24,36,36,36,40,40,48,48,48,48,48,48,48,48,16,48,48,48,48,48,48,48,48,48,48,40,40,40,40,40,36,40,36,36,40,36,36,40,48,48,40,36,36,36,36,40,48,48,16,16,48,48,48,48,48,48,48,48,48,48,48,48,48,0,0,0,0
	dc.b	32,28,28,28,28,24,24,36,40,40,48,48,48,48,48,16,16,16,16,16,48,48,48,48,48,48,48,48,48,40,40,40,40,40,40,40,40,40,48,40,48,40,40,40,36,36,40,48,48,16,16,48,48,48,48,40,40,40,40,16,16,16,48,48,0,0,0,0
	dc.b	24,36,36,36,36,36,36,36,36,36,36,40,40,40,48,48,16,16,16,12,12,12,16,12,16,16,48,48,48,48,48,40,48,40,48,40,40,48,48,48,40,40,40,40,36,36,40,40,16,16,16,48,48,48,48,40,40,40,36,36,36,36,40,40,0,0,0,0
	dc.b	24,24,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,40,52,52,52,12,12,12,12,16,16,48,48,48,48,48,48,48,40,36,36,36,40,40,40,40,36,36,36,36,16,12,16,48,48,48,48,48,40,40,40,36,36,24,24,24,0,0,0,0
	dc.b	40,40,40,40,36,36,36,36,40,40,40,36,40,40,36,36,40,36,36,36,36,36,36,36,40,36,36,40,44,52,40,40,48,48,40,36,36,36,36,36,36,40,48,40,40,40,40,36,40,12,12,16,48,48,48,48,40,40,36,36,36,36,36,24,0,0,0,0
	dc.b	40,40,48,40,40,40,40,40,40,40,48,40,40,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,40,24,28,24,36,40,40,40,40,48,40,40,40,36,36,36,12,4,12,16,48,48,48,40,40,36,36,36,36,36,24,0,0,0,0
	dc.b	36,36,36,36,40,40,40,40,40,48,48,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,36,36,36,36,40,36,36,24,24,24,36,48,40,48,48,40,40,40,40,40,36,40,12,12,16,48,48,48,40,40,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,40,40,40,40,48,48,40,36,36,40,40,40,40,48,48,48,48,48,48,48,40,40,40,40,40,40,40,40,36,24,24,24,24,28,36,48,48,48,48,48,40,40,40,40,36,60,4,16,48,48,48,40,40,40,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,40,40,40,40,40,48,48,36,36,36,40,40,40,48,48,48,48,48,48,48,48,48,48,48,40,40,36,36,36,36,36,36,24,24,24,36,40,48,48,48,40,40,36,40,36,36,4,12,48,48,40,40,40,40,40,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,40,40,40,40,48,48,48,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,36,36,36,36,24,36,36,36,28,24,40,48,48,48,40,40,40,36,36,44,12,48,48,48,40,40,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,40,40,40,40,40,40,48,48,48,40,36,24,24,24,24,24,24,36,36,24,24,28,24,24,24,28,28,24,24,36,36,36,40,36,36,36,24,28,28,24,36,16,48,48,40,40,40,36,36,36,12,16,48,48,40,40,36,36,36,36,36,36,0,0,0,0
	dc.b	40,40,40,40,40,40,48,48,48,48,48,48,36,36,24,24,24,36,24,24,24,24,24,28,28,28,24,24,24,28,28,28,28,24,36,36,36,24,28,28,24,36,36,36,48,48,48,40,36,36,36,36,40,48,48,48,48,40,40,36,36,36,36,36,0,0,0,0
	dc.b	40,40,40,48,48,48,48,48,48,16,48,40,36,40,36,24,24,36,36,36,36,36,24,24,24,28,28,32,28,28,28,28,28,28,28,28,24,24,24,24,28,24,36,24,40,48,40,40,40,36,36,36,36,48,48,48,48,40,40,36,36,36,40,40,0,0,0,0
	dc.b	40,48,48,48,48,48,16,16,12,52,36,36,36,40,40,36,36,36,36,36,40,36,36,24,24,24,28,32,32,28,28,28,28,28,28,28,28,28,28,28,32,24,24,28,40,48,40,40,40,40,40,36,36,40,40,40,48,48,40,40,40,40,40,40,0,0,0,0
	dc.b	48,48,48,48,16,12,12,12,40,36,36,40,40,40,48,40,36,40,40,40,36,24,28,28,28,28,28,28,28,28,28,32,28,28,28,28,28,28,28,32,32,24,24,28,36,48,40,36,36,36,36,36,24,24,24,36,40,40,40,48,48,48,48,40,0,0,0,0
	dc.b	16,48,48,16,12,4,12,36,36,36,40,40,40,40,48,40,40,40,36,24,28,28,28,28,28,28,28,28,28,28,28,28,28,32,32,28,28,28,28,32,28,28,24,28,24,48,40,40,36,36,24,24,24,24,24,36,24,36,36,40,40,40,40,40,0,0,0,0
	dc.b	12,16,12,4,12,52,36,40,36,40,40,40,48,48,48,40,36,24,28,28,28,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,28,24,28,28,24,40,40,36,36,24,24,24,24,28,36,40,36,36,40,40,40,36,36,36,0,0,0,0
	dc.b	16,4,4,12,40,36,40,40,40,48,48,48,48,48,48,36,24,24,24,24,28,28,28,32,28,28,28,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,24,36,36,36,36,36,24,24,24,36,40,40,40,40,40,40,40,40,36,36,0,0,0,0
	dc.b	12,12,52,40,40,40,40,40,48,48,48,48,16,40,36,24,24,24,28,32,32,32,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,24,36,24,24,24,24,24,24,36,48,48,48,40,40,40,36,36,40,36,36,0,0,0,0
	dc.b	52,40,36,40,40,40,40,48,48,48,48,48,16,36,24,24,24,24,28,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,24,24,24,28,28,28,24,36,40,48,40,48,40,40,40,36,36,36,36,36,0,0,0,0
	dc.b	36,36,40,40,40,40,40,40,48,48,48,16,36,24,28,28,28,24,24,24,24,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,32,28,32,28,28,28,28,28,28,24,24,28,36,40,48,48,48,40,40,40,40,40,36,36,40,16,0,0,0,0
	dc.b	36,36,40,40,40,48,48,40,48,48,48,36,24,36,36,36,24,36,36,24,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,32,28,28,24,24,24,36,40,48,48,48,40,40,40,40,40,36,40,52,12,12,0,0,0,0
	dc.b	36,36,40,40,40,48,40,40,40,48,36,24,24,24,36,36,36,36,36,24,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,24,24,24,24,36,48,48,48,48,40,40,40,40,40,36,36,12,4,12,12,0,0,0,0
	dc.b	40,40,40,48,40,40,36,40,40,36,24,24,36,24,24,36,36,40,40,24,28,28,28,32,28,28,28,28,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,24,28,24,24,36,40,48,48,48,40,36,40,40,36,36,40,12,12,16,16,16,0,0,0,0
	dc.b	40,40,40,48,40,36,36,24,36,24,24,24,36,24,36,36,36,36,40,24,28,24,28,28,28,28,28,28,28,28,32,28,28,28,28,28,28,28,28,28,28,28,28,28,24,36,40,40,40,40,40,40,40,40,36,36,36,52,12,12,16,48,48,16,0,0,0,0
	dc.b	40,48,48,48,48,48,40,40,36,24,24,36,36,36,36,36,36,36,40,36,28,24,28,32,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,24,36,40,40,36,36,40,40,40,36,40,36,36,36,16,12,16,48,48,48,48,48,0,0,0,0
	dc.b	48,40,40,40,40,48,48,48,40,40,40,40,40,40,40,40,40,40,48,36,28,24,28,32,28,28,24,24,28,28,28,28,28,28,28,32,32,28,24,24,24,36,36,36,36,36,36,36,36,40,40,36,36,36,44,12,16,16,48,48,48,48,48,40,0,0,0,0
	dc.b	40,40,40,40,40,40,48,48,48,48,48,36,36,36,40,40,48,48,48,40,24,24,24,28,24,24,36,36,28,28,28,28,28,28,28,28,28,28,24,24,24,36,36,36,36,36,36,24,36,36,36,36,36,40,16,48,48,48,48,40,40,40,40,40,0,0,0,0
	dc.b	36,36,40,40,40,40,40,48,48,48,16,52,36,36,40,40,48,40,48,48,36,36,24,24,28,24,24,36,36,36,24,28,28,28,28,28,24,24,24,24,28,24,24,24,24,24,24,24,24,24,24,36,48,48,48,40,48,40,40,40,40,40,36,36,0,0,0,0
	dc.b	36,36,36,36,40,40,40,48,48,48,16,12,36,36,40,40,40,40,48,48,40,36,24,28,28,24,36,36,40,36,36,40,36,24,24,24,24,24,24,24,28,28,24,24,24,24,24,24,24,24,24,36,48,48,40,40,40,36,36,36,40,36,36,24,0,0,0,0
	dc.b	36,36,36,40,40,40,40,40,48,48,16,12,52,36,40,40,40,48,48,48,48,40,24,28,36,36,36,36,36,36,36,36,40,40,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,48,48,40,40,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,40,40,48,48,48,16,12,4,36,36,40,40,48,40,48,48,48,40,36,24,24,24,36,24,36,36,36,36,40,40,48,48,48,48,48,48,48,48,48,48,48,40,40,40,36,36,36,48,48,40,40,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,40,40,48,48,48,48,12,4,12,36,40,40,40,40,48,48,48,48,48,24,24,24,24,36,36,36,40,40,40,40,40,40,40,48,48,48,48,48,48,48,40,40,40,40,40,40,40,40,48,40,40,40,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,40,40,48,48,48,48,16,12,4,40,40,40,40,40,40,48,48,48,48,40,36,24,24,24,36,36,40,36,36,36,40,40,40,40,40,40,40,40,40,40,40,40,40,48,40,40,40,40,48,48,40,40,40,40,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,40,36,36,40,48,48,48,16,16,12,4,12,40,40,40,40,40,48,48,40,40,40,36,36,24,28,36,40,36,36,36,36,36,36,36,36,36,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,0,0,0,0
	dc.b	36,36,36,40,40,36,40,40,48,48,48,16,16,12,12,40,40,40,40,40,40,48,40,40,36,36,36,36,36,40,48,48,16,52,40,40,36,36,40,40,36,36,36,36,36,36,40,40,36,36,40,40,40,40,40,40,36,36,36,36,40,40,40,40,0,0,0,0
	dc.b	24,24,36,36,40,40,40,48,48,48,48,48,12,12,12,16,40,40,40,40,40,48,40,40,36,36,40,40,48,48,48,48,48,48,16,16,12,12,12,12,60,60,52,52,40,40,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,24,24,24,0,0,0,0
	dc.b	52,52,44,36,36,40,40,40,48,48,48,48,16,16,16,16,40,40,40,40,40,40,48,40,40,48,48,40,40,40,40,40,48,48,48,48,48,48,16,16,12,12,12,12,16,12,16,16,48,48,40,40,40,36,36,36,36,36,36,36,36,36,36,24,0,0,0,0
	dc.b	48,16,12,12,60,12,16,40,48,48,48,48,16,12,16,16,48,40,40,40,40,40,48,48,48,40,40,36,40,40,40,36,40,40,40,48,48,48,48,48,48,48,48,48,16,16,16,16,16,48,48,48,48,40,40,40,36,24,24,28,28,28,28,32,0,0,0,0
	dc.b	16,16,16,16,12,12,16,16,48,48,48,48,16,16,16,48,48,40,40,40,40,40,40,40,48,40,40,40,36,36,36,40,36,40,40,40,48,40,48,48,48,48,48,48,48,48,48,48,16,16,48,48,48,48,48,48,40,40,40,40,36,36,24,24,0,0,0,0
	dc.b	24,24,36,36,36,36,40,48,48,48,48,48,16,48,48,16,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,36,36,36,36,40,36,40,48,48,40,36,40,40,36,40,48,48,16,16,48,48,48,48,40,40,40,52,16,16,48,48,48,0,0,0,0
	dc.b	28,28,28,24,24,24,24,36,36,40,48,48,48,48,48,16,12,16,16,16,16,16,48,48,48,48,48,48,48,40,40,40,40,40,40,40,40,48,48,40,40,40,40,40,40,36,40,40,48,16,16,48,48,48,48,48,40,36,36,36,36,44,52,52,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,40,40,40,40,40,40,52,16,16,12,12,12,12,12,12,16,48,48,48,48,48,40,48,40,40,48,48,48,40,40,40,40,48,40,40,36,36,40,16,16,16,16,48,48,48,48,40,40,40,36,24,24,24,36,0,0,0,0
	dc.b	36,24,24,24,36,36,36,36,40,36,36,36,36,36,36,36,40,40,36,40,40,52,52,52,52,52,52,12,12,16,48,48,48,48,48,40,40,36,36,36,36,40,40,40,40,40,40,36,52,12,12,16,48,48,48,40,40,40,40,36,36,36,36,24,0,0,0,0
	dc.b	40,40,40,40,36,36,36,36,40,40,40,40,40,40,36,36,40,36,36,36,36,36,36,36,40,36,36,36,36,40,40,40,40,40,40,36,24,36,36,36,40,40,40,40,40,40,40,40,36,12,12,16,16,48,48,48,40,36,36,36,36,36,36,24,0,0,0,0
	dc.b	48,48,48,40,40,40,40,48,40,40,48,40,40,40,40,48,40,40,40,40,40,40,40,40,36,36,40,36,36,36,36,36,36,40,36,24,28,24,36,40,40,40,40,40,40,40,40,40,36,52,4,12,48,48,48,48,40,40,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,40,40,48,48,48,48,48,48,40,36,40,48,48,48,48,48,48,48,40,40,40,40,48,40,40,36,36,36,36,40,36,36,36,24,24,24,36,40,48,48,48,48,40,40,40,40,36,12,4,16,48,48,48,40,40,40,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,40,40,40,48,48,48,40,36,36,40,40,40,40,40,48,48,48,48,48,48,48,48,40,40,40,48,40,40,36,36,36,24,24,24,24,40,48,48,48,48,40,40,40,40,36,52,4,16,48,48,48,40,40,40,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,40,40,40,40,40,48,40,36,36,36,40,48,40,48,48,48,48,48,48,48,48,48,48,48,48,40,36,36,36,36,36,36,24,24,24,36,44,48,48,48,48,40,40,36,36,36,60,12,16,48,48,40,40,40,40,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,40,40,40,40,48,48,40,36,24,36,36,36,36,36,36,36,24,24,24,24,24,24,36,36,36,36,40,40,36,36,36,36,36,36,24,24,24,36,16,48,48,40,40,40,36,36,36,12,16,48,48,48,40,40,36,36,36,36,36,0,0,0,0
	dc.b	36,36,40,40,40,40,40,40,48,48,48,40,36,24,24,24,24,24,24,24,24,36,24,28,24,24,24,24,24,28,24,24,36,36,40,40,36,36,36,24,28,28,36,44,48,48,40,40,40,36,36,36,52,16,48,48,40,40,36,36,36,36,36,36,0,0,0,0
	dc.b	40,40,40,40,40,48,48,48,48,48,48,40,36,36,36,24,36,36,36,24,36,36,24,28,28,24,24,28,24,28,28,28,28,24,36,36,36,24,28,28,28,24,36,24,48,48,40,40,40,36,36,36,36,16,48,48,40,40,40,36,36,36,40,36,0,0,0,0
	dc.b	40,40,40,48,48,48,48,48,16,16,40,36,40,40,40,36,36,36,36,36,36,36,36,24,24,24,28,28,28,28,28,28,28,28,28,24,24,36,24,28,24,24,36,24,40,48,40,40,40,36,36,36,36,40,48,48,48,48,48,40,40,40,40,40,0,0,0,0
	dc.b	48,48,48,48,48,16,16,12,52,40,36,36,36,40,40,36,36,36,40,40,40,36,36,36,36,24,28,32,32,28,28,28,28,28,32,28,28,24,28,28,28,24,24,28,24,48,48,48,40,40,40,40,36,36,40,40,48,48,48,40,40,40,40,48,0,0,0,0
	dc.b	48,48,48,48,16,12,12,52,36,36,36,40,40,40,48,40,40,36,40,40,36,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,32,32,32,24,24,28,28,48,48,40,36,36,36,36,36,36,24,24,40,40,40,40,48,48,48,48,0,0,0,0
	dc.b	48,48,16,12,4,12,52,36,36,40,40,40,48,40,48,40,48,40,36,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,24,28,28,48,40,40,36,36,36,24,24,24,24,36,36,36,36,36,40,40,40,36,0,0,0,0
	dc.b	16,16,4,4,12,40,36,40,40,40,40,48,48,48,48,40,36,24,28,28,24,24,28,28,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,28,24,24,28,24,40,40,36,36,36,36,24,24,24,24,40,36,36,36,40,40,40,36,36,0,0,0,0
	dc.b	12,4,12,52,36,40,40,40,48,40,48,48,48,48,36,24,24,24,24,24,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,24,36,40,36,36,36,24,24,24,24,40,40,40,40,40,40,40,40,36,36,0,0,0,0
	dc.b	4,60,40,40,40,40,48,40,40,48,48,48,16,36,24,36,24,24,28,32,32,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,24,36,36,36,36,36,24,24,24,36,48,48,48,40,40,40,40,36,36,36,0,0,0,0
	dc.b	52,40,36,40,40,40,40,48,48,48,48,48,36,24,24,24,24,24,28,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,36,36,24,28,24,24,24,24,40,48,48,48,40,40,40,40,40,36,36,36,0,0,0,0
	dc.b	36,40,40,40,40,40,48,48,48,48,48,40,36,24,24,28,28,24,24,24,24,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,28,28,24,28,28,24,36,48,48,48,48,40,40,40,40,36,36,40,40,0,0,0,0
	dc.b	36,40,40,40,48,48,40,48,48,48,40,24,24,36,36,36,36,36,36,24,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,32,32,28,24,24,24,24,36,48,48,48,48,40,40,40,40,40,36,40,52,12,0,0,0,0
	dc.b	36,40,40,48,48,40,40,40,48,40,24,24,36,36,36,36,36,40,36,24,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,24,24,24,24,24,36,48,48,48,48,40,40,40,40,36,36,52,12,12,16,0,0,0,0
	dc.b	40,40,40,40,40,40,40,36,40,36,24,24,24,36,36,36,36,40,40,24,28,24,24,28,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,28,24,24,24,24,28,28,36,40,48,48,40,40,40,40,40,40,36,40,12,4,12,16,48,0,0,0,0
	dc.b	48,40,40,40,36,36,36,36,36,24,24,24,36,36,36,36,36,40,40,28,28,24,24,28,32,28,28,28,28,28,32,28,28,28,28,28,28,28,28,28,28,28,28,28,24,36,36,40,40,40,48,40,36,40,40,36,36,52,12,4,12,48,48,48,0,0,0,0
	dc.b	48,48,48,48,48,40,40,36,24,24,36,36,36,36,36,36,40,40,40,24,28,24,28,32,32,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,36,36,36,36,40,40,40,40,36,40,36,36,36,52,12,12,16,48,48,48,40,0,0,0,0
	dc.b	48,40,40,40,40,48,48,48,40,40,40,40,40,40,40,40,40,40,40,36,24,24,28,28,28,28,24,24,28,28,28,28,28,28,28,32,32,28,24,36,36,36,40,36,36,36,36,36,36,40,40,36,36,36,36,52,16,16,48,48,48,48,40,48,0,0,0,0
	dc.b	40,40,40,40,40,48,48,48,48,48,40,36,40,36,40,48,40,48,48,36,24,24,24,24,24,24,36,36,28,28,28,28,24,28,28,28,28,28,24,24,24,36,36,36,36,24,36,36,36,36,40,36,36,40,48,48,48,48,48,40,40,40,40,40,0,0,0,0
	dc.b	36,40,40,40,40,40,40,40,48,48,16,36,36,40,36,40,48,48,48,40,24,36,24,28,24,24,36,36,36,36,24,28,28,28,24,24,24,24,24,24,28,24,36,36,36,24,24,24,24,24,36,36,40,48,48,48,48,48,40,40,40,40,36,36,0,0,0,0
	dc.b	36,36,36,36,36,40,48,48,48,48,12,60,36,40,40,40,48,40,48,48,40,36,28,28,24,36,36,40,40,40,40,36,24,24,24,24,24,24,24,28,28,24,24,24,24,24,24,24,24,24,24,24,40,48,48,48,40,40,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,40,40,40,48,48,48,48,12,4,36,36,40,40,40,40,48,48,48,40,28,24,24,36,36,36,36,36,36,40,40,40,36,36,36,24,24,24,24,24,24,36,36,36,36,36,36,36,24,36,40,48,40,40,40,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,40,40,40,40,48,48,48,12,4,16,36,36,40,40,48,48,48,48,48,36,36,24,36,36,36,36,36,36,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,36,36,36,40,48,48,40,40,36,36,36,36,36,36,24,0,0,0,0
	dc.b	36,36,36,36,40,40,40,48,48,48,16,12,4,52,40,40,40,48,48,48,48,48,48,40,24,28,24,36,36,36,36,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,40,40,40,36,40,36,36,48,48,40,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,36,36,36,36,40,40,48,48,48,48,12,4,60,36,40,40,40,40,48,48,48,48,40,40,24,24,36,36,36,40,40,40,40,36,36,40,40,48,48,40,40,40,40,48,48,40,40,48,48,40,36,36,48,48,40,40,40,40,40,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,40,40,48,48,48,48,16,12,4,52,40,40,40,40,48,48,48,48,48,40,36,24,24,24,36,40,36,36,36,36,36,40,36,36,36,40,40,40,40,40,40,40,40,40,40,40,40,40,40,48,40,48,40,40,40,40,48,48,40,0,0,0,0
	dc.b	36,36,36,36,36,40,40,48,48,48,48,16,12,4,12,40,40,40,40,48,48,48,40,40,36,36,36,24,24,40,40,40,40,40,36,36,36,36,36,40,36,36,36,36,40,40,40,36,36,36,40,40,40,40,40,40,36,36,36,36,40,40,40,40,0,0,0,0
	dc.b	36,36,36,36,40,40,40,40,48,48,48,16,16,12,12,52,40,40,40,40,48,48,40,36,36,36,36,40,40,48,48,48,48,48,16,12,12,12,52,52,52,52,52,40,40,40,40,40,40,36,36,40,40,36,36,40,40,36,36,36,24,24,36,36,0,0,0,0
	dc.b	36,36,36,36,40,40,40,48,48,48,48,48,16,12,12,16,40,40,40,40,40,48,40,40,40,40,48,48,48,48,48,48,40,48,48,48,48,48,16,16,12,12,12,12,12,16,16,16,48,40,40,40,40,36,36,40,36,40,40,40,36,36,36,36,0,0,0,0
	dc.b	16,12,52,40,40,44,40,48,48,48,48,48,16,12,16,16,40,40,40,40,40,48,40,48,40,48,48,40,40,40,40,40,40,40,40,48,48,48,48,48,48,48,16,16,16,16,16,16,16,48,48,48,48,40,40,40,36,24,24,28,28,28,28,28,0,0,0,0
	dc.b	16,12,12,4,4,20,60,48,40,48,48,48,16,12,12,48,48,40,40,40,40,40,40,48,48,48,40,36,36,40,36,36,36,40,40,40,48,48,48,48,48,48,48,48,48,48,48,16,16,48,16,16,48,48,48,48,48,40,36,36,36,36,24,28,0,0,0,0
	dc.b	24,24,24,36,36,40,40,48,48,48,48,48,16,16,16,16,16,16,48,48,48,48,48,48,48,48,48,40,40,40,40,40,40,36,36,40,40,40,40,48,48,40,40,40,40,36,40,48,48,16,16,48,48,48,48,48,40,36,36,36,36,44,52,52,0,0,0,0
	dc.b	28,24,24,24,24,24,36,36,40,40,40,48,48,48,16,12,12,12,12,12,16,16,16,48,48,48,48,48,48,48,40,40,40,40,48,40,40,48,48,40,36,40,40,40,40,40,40,40,16,16,16,48,48,48,48,48,40,40,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,40,40,40,36,36,40,40,40,40,40,40,52,16,16,12,12,12,12,12,16,16,16,48,48,48,48,48,48,48,48,48,48,40,36,36,36,40,40,40,40,40,40,40,16,12,16,16,48,48,48,40,40,40,40,36,36,36,24,24,0,0,0,0
	dc.b	24,24,24,36,36,36,36,36,40,40,40,40,36,40,40,40,40,40,36,36,36,40,52,52,52,52,52,12,16,16,48,48,48,48,48,40,40,36,36,36,36,40,40,40,40,40,40,36,40,12,12,16,16,48,48,48,40,40,36,36,36,36,36,24,0,0,0,0
	dc.b	40,40,40,40,36,36,36,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,36,40,36,36,36,36,36,40,40,36,40,40,36,28,24,36,36,36,40,48,48,40,40,40,40,36,52,4,12,16,48,48,48,48,40,36,36,36,36,36,36,0,0,0,0
	dc.b	48,40,40,40,40,40,40,48,48,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,36,36,36,36,36,40,36,36,24,24,36,40,40,48,48,48,48,40,40,40,40,36,12,4,16,48,48,48,40,40,36,36,36,36,36,36,0,0,0,0
	dc.b	40,36,36,40,40,48,48,40,48,48,40,36,36,40,40,48,40,48,48,48,48,40,40,40,40,40,40,40,40,40,40,36,40,40,36,36,36,24,24,36,48,48,48,40,40,40,40,40,40,36,52,4,12,48,48,48,40,40,40,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,40,40,40,48,48,40,36,36,36,36,40,40,40,48,48,48,48,48,48,48,48,48,48,48,40,48,40,40,36,36,36,24,24,24,24,36,40,48,48,48,48,48,40,36,40,40,12,12,16,48,48,40,48,40,40,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,40,40,48,48,48,36,36,36,36,36,40,40,48,48,40,48,40,40,40,40,40,48,48,48,40,40,36,36,36,36,36,36,24,24,24,36,16,48,48,48,48,40,40,40,36,52,4,16,48,48,48,40,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,40,40,40,40,40,40,48,48,36,24,24,24,36,24,24,24,24,24,36,24,28,24,24,24,24,24,36,36,40,40,40,36,36,36,36,24,36,36,24,24,16,48,48,40,40,40,40,36,36,60,12,48,48,40,40,36,40,40,36,36,36,0,0,0,0
	dc.b	36,40,40,40,40,40,40,48,48,48,48,40,36,36,24,24,24,24,24,24,36,36,24,28,28,24,24,24,28,28,28,24,36,36,40,40,36,36,36,36,24,28,28,36,48,48,40,40,40,40,40,36,40,12,48,48,48,40,40,36,36,36,36,36,0,0,0,0
	dc.b	40,40,40,40,40,48,48,48,48,48,48,40,36,36,36,36,36,36,36,36,36,36,24,24,24,24,24,24,24,24,28,28,28,24,24,36,36,36,24,24,28,28,24,24,44,48,48,48,40,36,40,36,36,52,48,48,48,48,40,36,36,36,40,40,0,0,0,0
	dc.b	40,48,40,48,48,48,48,48,16,40,40,36,36,40,36,36,36,36,36,36,36,36,36,36,24,24,28,28,28,28,28,24,28,28,28,24,36,36,24,24,28,24,36,24,24,48,48,48,40,36,40,36,36,36,40,48,48,48,48,40,36,36,40,40,0,0,0,0
	dc.b	40,48,48,48,16,16,16,12,52,40,36,36,36,40,40,40,36,36,40,40,40,36,36,36,36,24,28,32,32,28,28,28,28,28,28,28,28,28,28,28,28,24,36,28,28,48,48,40,48,40,40,40,40,40,40,40,40,48,48,48,40,40,40,48,0,0,0,0
	dc.b	48,48,48,16,12,4,12,36,36,36,40,40,40,48,48,48,40,40,40,36,36,24,28,28,28,28,28,28,28,28,28,28,32,28,28,28,28,32,32,28,28,24,36,28,28,40,48,40,36,36,36,36,36,36,36,24,36,36,40,40,40,48,48,48,0,0,0,0
	dc.b	48,16,16,12,4,12,40,40,40,40,40,40,40,48,48,40,40,36,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,28,28,36,48,40,36,36,24,36,24,24,24,24,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	16,12,4,4,52,40,40,40,48,40,40,40,48,48,48,36,24,28,28,28,24,24,28,28,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,32,24,24,28,28,40,48,40,36,36,24,24,36,24,24,36,36,36,36,36,40,40,40,40,0,0,0,0
	dc.b	12,4,12,40,36,40,40,40,48,48,48,48,48,40,24,28,24,24,24,28,28,28,28,32,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,24,28,28,24,36,40,36,36,36,24,24,24,24,36,48,40,40,40,40,40,40,40,36,0,0,0,0
	dc.b	12,16,40,40,40,40,48,40,48,48,48,48,52,36,24,24,24,24,24,28,32,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,24,36,36,36,36,36,36,24,24,36,40,40,40,40,40,40,40,40,36,36,0,0,0,0
	dc.b	40,40,40,40,48,48,48,48,48,48,48,40,24,28,28,28,28,24,24,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,24,24,24,24,28,24,24,24,36,40,48,48,48,40,40,40,40,40,36,36,0,0,0,0
	dc.b	40,40,40,40,40,40,40,48,48,48,40,36,36,36,36,24,24,24,36,24,24,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,24,24,28,28,28,28,24,52,48,48,48,48,40,40,40,36,36,40,40,0,0,0,0
	dc.b	40,40,40,40,48,48,40,48,48,40,36,24,36,36,36,36,36,36,36,24,24,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,32,32,32,24,24,24,24,24,24,52,48,48,48,40,40,40,40,40,36,40,52,12,0,0,0,0
	dc.b	36,40,48,40,40,48,40,40,48,36,24,24,36,36,36,36,40,40,36,24,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,32,28,28,28,24,24,24,24,24,36,40,48,48,40,40,40,36,40,40,36,40,12,12,12,0,0,0,0
	dc.b	40,40,40,40,40,36,36,36,36,24,24,36,36,36,36,36,36,40,36,24,28,24,28,28,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,28,24,24,24,28,28,28,24,36,48,48,48,48,40,40,40,40,36,40,52,60,4,16,48,0,0,0,0
	dc.b	40,40,36,36,36,36,36,36,24,24,36,24,36,36,36,36,40,48,36,28,28,24,28,32,32,28,28,28,28,28,28,32,28,28,28,32,28,28,28,28,28,28,28,28,28,24,36,40,40,48,48,40,40,40,40,40,36,36,12,4,12,16,48,48,0,0,0,0
	dc.b	48,48,48,48,40,40,36,36,36,36,36,36,36,36,40,40,36,40,36,28,28,24,28,32,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,36,36,40,40,36,40,48,40,40,40,36,36,36,36,12,12,16,48,48,48,48,0,0,0,0
	dc.b	40,48,48,48,48,48,48,40,40,40,36,40,40,40,40,40,40,40,40,28,28,24,28,28,24,28,28,24,28,28,28,24,28,28,28,32,32,28,24,36,36,36,36,40,40,40,36,36,36,40,36,36,36,36,36,52,12,16,16,48,48,48,48,40,0,0,0,0
	dc.b	40,40,40,40,40,48,48,48,48,40,40,36,40,40,40,48,48,48,40,24,24,24,24,24,24,24,36,36,24,28,28,28,24,28,28,28,28,24,24,24,36,36,36,36,36,36,36,36,36,40,36,36,36,36,40,16,48,48,48,48,40,40,40,40,0,0,0,0
	dc.b	40,40,40,40,40,40,40,48,48,48,52,36,36,40,40,40,48,48,48,36,24,24,28,28,24,24,36,36,36,24,24,28,28,28,24,24,24,24,24,24,24,24,36,36,36,36,36,36,24,36,36,36,36,48,48,48,48,48,40,40,40,40,40,36,0,0,0,0
	dc.b	36,36,40,40,40,40,48,48,48,48,12,40,36,40,40,40,40,48,48,48,36,24,28,24,36,36,36,36,40,40,40,36,24,24,28,24,24,24,28,28,28,24,36,24,24,24,24,24,24,24,36,36,40,48,48,40,48,40,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,40,36,40,40,48,48,48,48,12,60,36,40,40,48,48,40,48,48,52,36,24,36,36,36,36,36,36,36,40,40,40,36,36,24,24,24,24,24,28,24,36,24,24,24,24,36,36,24,24,36,36,48,48,40,40,40,40,36,36,40,36,36,0,0,0,0
	dc.b	36,36,36,40,40,40,40,48,48,48,12,4,52,40,40,48,48,40,48,48,48,16,36,24,24,24,36,36,36,36,36,40,40,48,48,48,48,48,40,40,40,40,48,40,40,48,48,40,40,36,36,36,36,48,40,48,40,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,40,40,48,48,48,16,4,12,40,40,40,40,48,48,48,48,48,40,36,24,36,24,36,36,36,36,40,40,48,48,48,40,48,48,48,48,48,48,48,48,48,40,40,40,36,36,36,36,40,48,40,40,40,40,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,40,40,48,48,48,16,12,4,52,36,40,40,40,48,48,48,48,48,40,24,24,24,36,36,36,40,40,36,40,40,40,40,40,40,40,48,40,48,48,48,48,48,48,48,40,40,36,36,40,48,40,40,40,40,40,36,36,36,40,0,0,0,0
	dc.b	36,36,36,36,40,40,48,48,48,48,48,12,4,4,40,40,40,40,48,48,48,48,40,48,40,36,24,24,36,40,36,36,36,36,36,36,36,40,40,40,40,40,40,40,40,40,40,40,48,48,48,40,40,40,40,40,48,40,40,40,40,40,48,48,0,0,0,0
	dc.b	36,36,36,36,36,40,48,48,48,48,16,16,12,4,52,40,40,40,40,48,48,40,40,36,36,36,36,24,36,36,40,40,40,40,40,36,36,36,36,36,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,36,36,36,40,40,40,40,0,0,0,0
	dc.b	36,36,36,36,40,40,40,40,48,48,16,16,12,4,4,40,40,40,40,40,40,48,48,36,36,24,36,36,40,48,48,48,48,48,16,12,60,52,52,52,40,40,40,40,40,40,40,40,36,40,40,40,40,40,40,40,40,40,36,36,24,24,24,24,0,0,0,0
	dc.b	36,36,36,36,40,40,40,40,48,48,48,16,16,12,12,16,40,40,40,40,48,48,48,36,36,36,48,48,48,48,48,48,48,48,48,48,48,16,16,12,4,4,4,12,12,16,16,16,40,40,40,40,40,40,40,36,40,40,40,40,40,40,36,36,0,0,0,0
	dc.b	36,36,36,36,40,40,40,40,48,48,48,48,16,12,16,16,40,40,40,40,40,48,40,36,40,48,48,40,48,40,40,36,48,48,48,48,48,48,48,48,16,16,16,16,12,12,12,16,12,16,48,48,48,48,40,40,36,36,24,24,24,24,24,28,0,0,0,0
	dc.b	60,20,20,60,44,44,52,40,48,48,48,48,16,12,16,16,48,40,40,40,40,40,40,48,40,48,40,40,36,36,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,16,16,16,16,16,16,48,48,48,48,48,40,36,36,36,36,24,24,0,0,0,0
	dc.b	24,24,24,24,36,40,48,48,48,48,48,16,48,16,12,16,16,16,16,48,48,48,48,48,48,48,48,48,40,40,40,40,40,40,40,40,40,48,48,48,40,40,40,40,40,36,40,40,48,16,16,48,48,48,48,48,40,40,36,36,36,24,24,24,0,0,0,0
	dc.b	24,24,36,36,36,36,36,36,36,40,48,48,48,16,16,16,16,16,12,12,12,12,16,16,48,48,48,48,48,48,48,40,48,48,40,40,48,48,48,40,36,40,40,40,40,40,40,40,16,12,12,16,48,48,48,48,40,40,40,36,36,36,24,24,0,0,0,0
	dc.b	36,36,36,40,40,40,40,40,40,40,40,40,40,40,40,40,40,52,52,12,12,12,4,12,12,16,16,16,48,48,48,48,48,48,48,48,48,40,36,24,36,40,40,48,40,40,40,40,40,12,12,12,48,48,48,40,40,40,40,36,36,36,36,24,0,0,0,0
	dc.b	24,24,24,36,36,40,40,40,48,40,40,40,40,40,40,40,40,40,40,36,36,36,40,40,40,52,52,52,52,16,48,48,48,48,48,40,36,36,36,36,36,36,40,40,40,40,40,40,36,12,4,12,16,48,48,48,40,40,36,36,36,36,36,36,0,0,0,0
	dc.b	48,48,40,40,36,36,40,40,40,40,48,48,40,40,40,40,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,36,36,36,40,36,24,24,36,36,36,40,48,48,40,40,40,40,36,52,4,12,16,48,48,48,40,40,36,36,36,36,36,36,0,0,0,0
	dc.b	40,48,40,40,40,40,48,48,40,40,40,40,40,40,40,40,48,40,40,40,40,40,48,48,40,40,40,40,36,36,36,36,36,40,40,36,24,24,24,36,48,48,48,48,40,40,40,40,40,36,60,4,16,48,48,48,48,40,40,36,36,36,36,36,0,0,0,0
	dc.b	40,36,36,40,40,40,40,40,48,48,36,36,36,40,40,40,48,48,48,48,48,48,48,48,40,48,48,40,40,40,40,40,40,40,36,36,36,36,24,24,40,40,48,48,48,48,40,40,40,40,40,4,12,16,48,48,48,40,40,40,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,40,40,48,48,48,36,24,36,36,36,40,40,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,36,36,36,24,36,36,24,24,36,16,48,48,48,40,40,40,40,36,52,4,16,48,48,40,40,40,40,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,40,40,40,48,48,40,24,36,36,36,36,36,40,36,40,40,40,40,36,40,40,40,40,48,48,40,36,40,36,36,36,36,36,24,24,24,36,52,16,48,48,40,48,40,36,36,36,4,12,48,48,48,48,40,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,40,40,40,48,48,40,36,36,24,24,24,24,24,24,24,24,24,36,28,28,24,24,28,28,24,36,40,40,40,40,36,36,36,36,36,36,24,24,52,16,48,48,48,48,40,36,36,44,12,48,48,48,40,40,36,36,36,36,36,0,0,0,0
	dc.b	40,40,40,40,40,40,48,48,48,48,40,40,36,36,24,24,24,24,36,36,36,36,36,24,28,24,24,24,28,28,28,28,24,36,40,36,36,36,36,36,36,24,28,24,52,48,48,40,48,36,36,36,36,16,48,48,48,48,40,36,36,36,36,36,0,0,0,0
	dc.b	40,36,40,40,48,48,48,48,48,48,40,36,40,40,36,36,36,36,36,36,36,36,36,24,28,24,24,24,24,24,28,28,28,28,24,36,36,36,24,24,24,28,24,24,24,16,48,40,40,36,36,40,36,40,48,48,48,48,40,36,36,40,40,40,0,0,0,0
	dc.b	40,40,48,48,48,48,48,16,16,40,36,36,36,40,40,36,36,36,36,36,36,36,36,24,36,24,24,28,28,28,28,24,28,28,28,28,24,36,36,24,28,24,36,24,28,52,48,48,48,40,40,36,36,36,40,48,48,48,40,40,40,40,40,40,0,0,0,0
	dc.b	48,48,48,48,16,12,12,12,36,40,36,36,36,40,40,40,36,40,40,40,40,36,36,36,24,28,28,28,32,32,28,28,24,28,28,28,28,28,28,28,28,24,36,28,28,36,48,48,40,40,40,40,36,36,36,40,40,48,48,48,48,48,48,48,0,0,0,0
	dc.b	48,48,48,16,12,4,12,36,36,40,40,48,40,40,48,40,40,40,40,36,24,24,24,28,24,28,28,28,28,28,28,32,28,28,28,28,28,28,28,32,28,24,36,28,28,36,48,48,40,40,36,36,36,36,36,36,24,36,36,36,40,40,40,48,0,0,0,0
	dc.b	48,16,12,4,4,52,36,40,40,40,40,48,48,48,48,48,40,36,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,32,28,24,24,28,28,24,48,40,36,36,36,24,36,24,24,28,24,36,24,24,24,36,36,36,0,0,0,0
	dc.b	16,12,4,60,40,40,40,40,48,48,48,48,48,48,40,24,28,28,28,24,24,28,24,28,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,28,24,24,28,28,36,48,40,40,36,36,36,36,24,24,24,40,36,36,36,36,40,40,36,0,0,0,0
	dc.b	12,4,60,36,40,40,40,40,48,48,48,48,16,36,24,28,24,24,24,28,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,36,40,40,36,36,24,36,24,28,24,40,40,36,40,40,40,40,40,40,0,0,0,0
	dc.b	12,52,40,40,48,48,40,48,48,48,48,16,36,24,28,24,24,24,24,28,32,28,32,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,24,36,36,36,36,24,24,24,24,24,36,48,40,40,48,48,40,40,40,36,0,0,0,0
	dc.b	40,40,40,40,48,48,48,48,48,48,16,40,24,28,24,24,28,24,24,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,32,28,28,24,36,24,36,36,36,36,24,24,40,48,48,48,48,48,40,40,40,40,36,0,0,0,0
	dc.b	40,40,40,40,48,48,48,48,48,48,40,36,36,36,36,36,24,36,36,24,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,24,24,28,28,24,28,24,40,48,48,48,48,48,48,40,40,40,40,40,0,0,0,0
	dc.b	40,40,40,40,48,48,48,48,48,36,24,24,36,36,36,36,36,36,36,36,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,32,28,24,24,24,24,28,24,36,48,48,48,48,40,40,40,40,36,40,52,12,0,0,0,0
	dc.b	40,48,48,48,40,40,40,40,40,24,24,36,36,36,36,36,40,40,36,24,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,24,24,24,24,24,24,36,48,48,48,40,48,40,40,40,36,40,52,12,12,0,0,0,0
	dc.b	40,40,40,40,36,36,36,40,24,24,24,36,36,36,36,40,40,48,36,24,28,28,24,28,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,28,24,24,24,24,28,28,28,24,40,48,48,48,48,40,40,40,36,36,40,60,4,12,16,0,0,0,0
	dc.b	40,40,36,36,24,36,36,36,24,36,36,36,36,36,36,36,40,48,24,28,28,28,24,28,28,28,28,28,28,28,28,32,28,28,28,28,28,28,28,28,28,28,28,28,28,28,36,36,40,48,48,40,40,40,40,40,36,36,52,4,12,16,48,48,0,0,0,0
	dc.b	40,48,40,40,40,36,36,24,36,36,36,36,36,40,40,40,40,40,36,28,28,24,28,28,32,28,28,28,28,28,28,28,32,28,28,28,28,28,28,28,28,24,24,24,36,40,40,40,40,48,40,40,40,40,40,36,36,12,12,16,16,48,48,48,0,0,0,0
	dc.b	48,48,48,48,48,48,40,40,40,40,40,40,40,40,40,48,40,48,36,28,24,36,28,28,24,28,28,24,24,28,28,24,28,28,28,32,28,28,24,24,36,36,36,40,40,40,40,36,40,40,40,36,36,36,36,36,12,16,16,48,48,48,48,40,0,0,0,0
	dc.b	40,40,40,40,40,48,48,48,48,40,36,36,40,40,48,48,48,48,40,28,24,36,24,24,24,36,36,24,28,28,28,28,24,24,28,28,28,24,36,36,24,36,40,36,36,36,36,36,36,40,40,36,36,36,40,16,48,48,48,48,48,40,40,36,0,0,0,0
	dc.b	40,40,40,40,40,40,48,48,48,16,40,36,40,40,40,40,48,48,16,36,24,24,24,24,24,36,36,40,36,24,28,28,24,24,28,24,24,36,24,24,36,36,36,36,36,36,36,36,36,36,40,40,36,40,48,48,48,48,40,40,40,40,40,40,0,0,0,0
	dc.b	36,40,40,40,40,40,48,48,48,16,12,36,36,40,40,40,48,48,48,52,24,28,24,24,36,36,36,40,40,40,36,24,28,28,28,28,24,24,24,28,24,36,36,24,24,36,24,24,24,24,36,36,36,40,48,48,48,40,40,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,40,48,48,48,16,12,52,36,40,40,40,48,48,48,16,40,24,24,36,36,36,36,36,36,40,40,40,40,36,36,24,28,28,28,24,28,24,36,24,24,24,24,24,24,24,24,36,36,40,48,40,40,40,40,40,36,36,36,36,0,0,0,0
	dc.b	36,36,40,40,40,40,48,48,48,16,12,4,36,40,40,40,48,48,48,48,48,36,36,24,36,24,36,36,36,36,36,40,40,40,48,48,40,40,40,40,40,40,40,40,36,40,36,36,36,36,36,36,24,40,48,48,40,40,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,40,48,40,48,48,48,48,12,4,52,40,48,40,40,48,48,48,48,48,40,24,24,36,36,36,36,36,36,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,36,36,36,24,36,48,48,40,40,40,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,40,48,48,48,48,16,12,4,40,40,40,40,48,48,48,48,48,40,36,24,24,24,36,36,40,40,40,40,40,40,40,40,40,48,48,48,48,48,48,48,48,40,40,40,40,40,36,36,36,40,48,48,40,40,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,40,48,48,48,48,16,12,4,60,36,40,40,48,48,48,48,48,48,40,36,24,24,36,36,36,36,36,36,36,36,40,40,40,40,40,40,48,40,48,48,48,48,40,48,48,40,40,40,40,40,40,48,48,48,40,40,40,40,40,0,0,0,0
	dc.b	36,36,36,36,40,40,48,48,48,48,16,12,4,4,52,40,40,40,40,48,48,48,40,36,36,36,24,24,36,40,36,36,36,36,36,36,36,36,40,40,40,40,40,40,40,40,40,40,40,48,40,40,40,40,40,48,40,40,36,36,40,40,40,48,0,0,0,0
	dc.b	36,36,36,40,40,40,40,48,48,48,16,16,12,4,12,40,40,40,48,48,48,48,40,36,36,24,24,36,40,40,48,48,48,16,16,52,52,52,52,40,40,40,40,36,36,40,40,40,40,40,40,40,40,40,40,48,40,40,36,36,36,24,24,24,0,0,0,0
	dc.b	24,36,36,36,40,40,40,48,48,48,48,16,16,12,12,40,40,40,40,40,48,48,40,36,36,24,36,48,48,48,48,48,48,48,48,48,16,12,12,12,12,12,12,12,12,16,52,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,36,36,0,0,0,0
	dc.b	36,36,36,36,44,52,40,48,48,48,48,48,16,12,12,16,40,40,40,40,48,48,40,40,36,40,48,48,48,48,40,40,40,40,48,48,48,48,48,48,16,16,16,12,12,12,12,12,12,16,48,48,40,48,40,40,36,36,36,36,36,36,24,24,0,0,0,0
	dc.b	36,44,44,44,44,52,52,48,48,48,48,48,16,12,12,16,40,40,40,40,40,48,40,40,48,48,40,40,36,36,36,40,40,40,40,40,48,48,48,48,48,48,48,48,48,16,16,16,12,16,16,16,48,48,48,48,48,40,40,36,36,24,24,24,0,0,0,0
	dc.b	24,24,24,36,36,40,40,48,48,48,48,48,16,16,16,16,16,16,16,16,48,48,48,48,48,48,48,48,40,40,40,40,40,36,40,40,40,48,48,40,36,36,48,40,40,40,36,48,16,16,16,16,48,48,48,48,40,40,40,36,36,24,24,24,0,0,0,0
	dc.b	36,36,36,36,36,36,40,40,40,40,40,48,48,16,16,16,12,12,12,12,12,12,12,16,48,48,48,48,48,48,48,40,48,48,40,48,48,48,40,36,36,40,40,48,48,40,40,40,16,12,12,16,48,48,48,48,40,40,36,36,36,36,24,24,0,0,0,0
	dc.b	36,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,52,52,12,12,12,12,12,12,12,16,16,48,48,48,48,48,48,48,40,40,24,28,36,40,40,48,40,40,40,36,40,12,12,12,16,48,48,48,40,40,36,36,36,36,36,24,0,0,0,0
	dc.b	24,24,24,36,36,40,40,40,48,40,40,40,40,40,40,40,40,40,36,36,36,36,36,36,40,40,40,52,52,52,40,40,48,40,40,40,36,24,36,36,36,36,40,48,40,40,40,40,36,52,4,12,16,48,48,48,48,40,36,36,36,36,36,36,0,0,0,0
	dc.b	48,40,40,36,36,36,40,40,40,40,48,48,48,40,40,40,40,40,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,36,40,40,24,24,36,36,40,40,40,48,48,48,40,40,40,40,4,4,16,48,48,48,48,40,40,36,36,36,36,36,0,0,0,0
	dc.b	40,40,40,48,48,48,48,48,40,36,36,40,40,40,40,48,40,48,48,48,48,40,40,40,40,40,40,40,40,40,36,36,36,36,40,36,24,24,24,24,40,48,48,48,48,48,48,40,40,36,52,4,12,48,48,48,40,40,40,40,36,36,36,36,0,0,0,0
	dc.b	40,40,40,40,40,40,48,48,48,40,24,36,36,36,40,40,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,40,40,40,36,36,36,36,24,24,36,40,48,48,48,48,48,40,40,36,36,12,12,16,48,48,40,40,40,40,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,40,40,40,48,40,28,24,36,36,36,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,36,36,36,36,36,36,24,24,24,52,16,48,48,48,40,40,40,40,40,4,12,48,48,48,40,40,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,40,40,48,48,48,36,24,36,36,24,36,36,36,36,36,36,36,40,36,36,36,36,36,40,40,40,40,40,36,36,36,36,36,36,24,24,24,36,52,16,48,48,40,40,40,40,36,60,12,48,48,40,40,40,36,36,36,36,36,0,0,0,0
	dc.b	40,40,36,36,40,40,40,48,48,48,40,36,36,24,24,36,24,24,24,24,24,24,36,24,28,28,28,28,28,28,36,36,48,40,40,40,36,36,36,36,24,36,24,36,16,48,48,48,40,40,40,36,36,12,16,48,48,48,40,36,36,36,36,36,0,0,0,0
	dc.b	40,40,40,40,40,40,48,48,48,48,40,40,40,36,36,24,36,36,36,36,24,36,36,36,28,28,24,24,24,28,28,32,28,36,36,40,40,36,36,36,24,24,28,28,36,16,48,48,40,40,40,36,36,52,16,48,48,40,40,40,36,36,36,36,0,0,0,0
	dc.b	36,40,40,48,48,48,48,48,48,40,36,36,40,40,40,36,36,36,36,36,36,36,36,36,24,24,24,24,24,24,24,28,28,28,24,36,36,36,36,24,24,28,28,24,24,52,48,48,40,40,40,36,36,36,40,48,48,48,40,40,40,36,40,40,0,0,0,0
	dc.b	40,40,48,48,48,48,48,16,16,40,36,40,36,40,48,36,36,36,36,36,36,40,36,36,36,24,24,28,28,28,28,24,24,28,28,28,24,24,24,24,24,28,24,24,28,36,48,48,48,40,40,36,36,36,36,40,48,48,48,40,40,40,40,40,0,0,0,0
	dc.b	48,48,48,48,16,16,12,12,40,36,36,40,40,40,48,40,40,40,40,40,40,40,36,36,24,24,28,28,32,32,28,28,28,28,28,28,28,28,28,24,28,24,36,24,28,24,48,48,48,40,40,40,36,36,36,40,40,40,48,48,48,48,48,48,0,0,0,0
	dc.b	48,48,16,16,12,12,52,36,40,40,40,40,48,48,48,40,40,40,36,36,24,24,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,32,28,24,36,28,32,24,48,40,40,40,40,36,36,36,40,36,24,24,24,24,36,36,40,40,0,0,0,0
	dc.b	48,16,12,4,60,40,36,40,40,40,40,48,48,48,48,40,36,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,32,28,28,28,28,28,28,28,28,24,36,28,28,24,48,48,40,36,36,36,36,36,36,24,24,24,24,24,24,36,36,36,0,0,0,0
	dc.b	16,4,4,52,40,40,40,40,40,48,48,48,48,40,36,24,28,28,28,24,24,24,24,28,28,28,28,28,32,32,32,32,32,32,32,28,28,28,28,28,28,24,24,28,28,24,40,48,40,36,36,36,24,24,24,24,36,36,36,36,36,36,36,40,0,0,0,0
	dc.b	4,4,52,40,40,40,48,40,48,48,48,16,52,24,24,24,24,24,24,24,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,24,36,48,40,40,36,36,24,24,24,24,36,40,36,36,40,48,40,40,48,0,0,0,0
	dc.b	60,52,40,40,40,48,48,48,48,48,48,16,36,28,28,24,24,24,24,28,32,28,32,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,24,36,36,36,36,36,24,36,24,24,24,40,48,40,40,48,48,40,40,40,0,0,0,0
	dc.b	40,40,48,40,40,48,48,48,48,48,16,36,24,24,24,24,24,24,36,28,32,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,36,36,36,36,36,36,36,24,24,40,48,48,48,40,40,48,40,36,36,0,0,0,0
	dc.b	40,40,40,48,48,40,48,48,48,40,36,24,36,36,36,36,36,24,36,24,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,32,28,24,24,24,24,24,24,24,36,40,48,48,48,48,48,40,40,40,40,40,0,0,0,0
	dc.b	40,40,40,48,48,48,40,48,48,36,24,36,36,36,36,40,36,36,36,24,24,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,24,24,28,28,28,28,24,40,48,48,48,48,48,48,40,40,40,40,12,0,0,0,0
	dc.b	48,40,40,40,40,40,40,40,36,24,24,36,36,36,36,40,36,40,36,24,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,28,28,28,32,28,28,24,24,24,24,24,28,24,40,48,48,40,48,40,40,40,40,40,52,12,4,0,0,0,0
	dc.b	40,40,40,36,36,36,36,36,24,24,36,36,36,36,36,40,40,40,36,24,28,24,24,28,28,28,28,28,28,32,32,32,32,32,32,32,28,28,28,28,28,24,24,24,24,28,28,28,24,36,48,48,48,48,48,40,40,40,40,40,52,4,4,16,0,0,0,0
	dc.b	36,36,36,24,24,36,36,24,24,36,36,36,36,36,36,36,40,40,28,28,24,24,24,28,32,28,28,28,28,28,28,32,28,28,28,28,28,28,28,28,28,28,28,28,32,28,24,36,40,48,48,48,40,40,40,40,36,36,40,12,4,12,16,48,0,0,0,0
	dc.b	40,40,36,24,36,36,36,36,36,40,40,40,40,40,40,40,40,40,28,28,24,24,24,32,32,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,24,36,36,40,40,40,48,40,48,40,40,36,36,36,52,12,12,16,48,48,48,0,0,0,0
	dc.b	48,48,48,48,48,48,40,40,40,36,40,40,40,40,48,40,40,48,24,28,24,24,24,28,24,28,28,28,28,28,28,28,28,28,32,32,28,28,24,24,36,36,40,40,40,40,40,36,40,40,40,36,40,36,36,36,52,12,16,48,48,48,48,48,0,0,0,0
	dc.b	40,40,40,48,48,48,48,48,40,36,36,36,40,40,48,48,48,48,24,24,24,24,24,24,24,24,24,24,28,28,24,24,24,28,28,28,28,24,36,36,36,36,40,36,36,36,36,36,36,40,36,36,36,36,40,40,16,48,48,48,48,40,40,40,0,0,0,0
	dc.b	48,40,36,40,40,48,48,48,48,16,36,40,36,40,40,48,48,48,40,24,24,28,24,24,36,36,36,36,36,24,28,28,28,24,24,24,24,24,24,24,36,36,36,36,36,36,36,36,36,40,40,40,36,36,40,48,48,48,48,48,40,40,40,36,0,0,0,0
	dc.b	36,40,36,40,40,40,48,48,48,16,52,36,36,40,48,40,48,48,16,44,28,28,24,24,36,40,40,40,40,40,36,28,32,28,28,24,24,24,24,28,36,36,36,36,36,36,36,24,24,36,36,40,36,40,48,48,48,48,40,36,40,40,36,40,0,0,0,0
	dc.b	36,40,40,40,40,40,48,48,48,16,12,36,36,40,48,40,48,48,48,16,36,24,36,36,36,36,36,40,40,40,48,40,40,36,28,28,28,24,28,28,24,24,24,24,24,24,24,24,36,24,24,36,36,40,48,40,40,40,40,36,36,36,36,36,0,0,0,0
	dc.b	36,36,40,40,40,40,48,48,48,16,4,12,36,48,40,48,48,48,48,48,16,36,24,24,36,36,36,36,36,36,36,40,40,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,24,24,24,36,48,48,48,40,36,36,36,40,36,36,0,0,0,0
	dc.b	36,36,36,40,40,40,40,48,48,16,12,4,40,40,40,40,40,48,48,48,48,40,36,28,24,36,36,36,36,36,36,40,48,40,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,36,36,36,24,24,40,48,40,40,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,40,40,40,40,48,48,48,12,4,12,40,40,40,48,48,48,48,48,48,40,36,24,24,36,36,36,36,40,40,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,40,36,36,36,36,40,48,48,48,40,40,40,40,36,36,0,0,0,0
	dc.b	36,36,36,36,40,40,48,48,48,48,16,12,4,52,40,40,40,48,48,48,48,48,48,40,36,24,24,36,36,40,36,36,36,36,40,40,40,40,40,40,48,40,40,40,48,48,48,48,48,40,40,48,40,36,36,40,48,40,40,40,40,40,40,40,0,0,0,0
	dc.b	36,36,36,36,40,40,40,48,48,48,16,12,4,4,40,40,40,40,48,48,48,40,40,36,36,36,24,24,40,40,36,36,36,36,36,36,36,36,40,40,40,40,40,40,40,40,40,40,40,40,40,40,48,40,40,40,40,40,36,36,36,40,40,40,0,0,0,0
	dc.b	36,36,36,40,40,40,40,48,48,48,16,12,12,4,52,40,48,40,48,48,48,48,40,36,36,24,24,36,40,40,40,48,40,40,52,52,52,52,40,40,40,40,36,36,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,36,36,24,24,24,0,0,0,0
	dc.b	36,36,36,40,40,40,40,48,48,48,48,16,12,4,4,40,40,40,48,48,48,40,40,36,24,24,24,40,48,48,48,48,48,48,48,16,16,16,12,12,12,12,12,60,16,52,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,36,36,0,0,0,0
	dc.b	36,36,36,40,40,40,40,48,48,48,48,16,12,12,4,16,40,40,40,48,48,40,40,36,24,36,40,48,48,40,40,48,40,48,48,48,48,48,48,48,16,16,12,12,4,12,12,12,12,16,16,48,48,48,40,40,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,44,44,44,44,52,16,40,48,48,48,48,16,12,12,16,40,40,40,40,40,48,40,36,40,48,48,40,40,40,40,40,40,40,40,40,40,48,48,48,48,48,48,48,16,16,16,12,12,16,16,16,16,16,48,48,48,40,40,36,24,24,24,24,0,0,0,0
	dc.b	24,24,24,36,36,40,40,48,48,48,48,16,16,16,16,12,16,16,16,16,16,48,48,48,48,48,48,48,48,40,40,40,40,40,40,40,48,48,48,36,36,36,40,40,48,40,40,40,16,16,12,16,48,48,48,48,40,40,40,36,36,36,24,24,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,40,40,40,48,48,16,16,12,12,12,4,4,4,12,16,16,48,48,48,48,48,48,48,40,48,48,48,48,48,48,36,24,24,36,40,40,40,40,40,40,16,12,12,16,48,48,48,40,40,40,36,36,36,36,36,24,0,0,0,0
	dc.b	36,36,40,48,48,40,40,40,40,40,40,40,40,40,40,40,40,40,40,52,52,60,60,60,12,12,12,12,16,48,48,48,48,48,48,48,40,36,24,24,24,36,40,48,40,40,40,40,40,12,12,12,16,48,48,40,40,40,36,36,36,36,36,36,0,0,0,0
	dc.b	24,36,36,36,36,40,40,48,40,40,40,40,48,40,40,40,40,40,40,40,36,36,36,36,40,36,40,52,52,40,40,40,40,36,40,40,36,24,24,40,36,36,40,48,48,48,40,40,40,52,4,12,16,48,48,48,48,40,36,36,36,36,36,36,0,0,0,0
	dc.b	48,40,40,36,36,40,40,40,40,40,40,40,40,48,40,40,40,40,48,48,40,40,40,40,40,40,40,36,36,36,36,36,36,36,36,40,36,24,24,36,40,40,40,48,48,40,48,48,40,36,60,4,12,48,48,48,48,40,40,36,36,36,36,36,0,0,0,0
	dc.b	40,40,40,48,48,48,48,48,36,36,36,36,40,40,40,40,48,48,48,48,48,40,40,40,40,40,40,40,40,40,40,40,36,40,40,40,36,36,24,24,36,40,48,48,48,48,48,40,40,40,40,4,12,16,48,48,48,40,40,40,36,36,36,36,0,0,0,0
	dc.b	40,40,40,40,48,48,48,48,40,36,24,24,36,36,36,40,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,40,36,40,40,36,24,36,36,24,24,40,48,48,48,48,48,40,40,40,36,52,12,12,48,48,48,40,40,40,36,36,36,36,0,0,0,0
	dc.b	36,36,40,40,40,40,48,40,48,36,28,24,36,36,36,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,48,40,36,36,36,36,36,24,24,24,44,16,48,48,48,48,40,40,36,40,12,12,16,48,48,48,40,40,36,36,36,36,0,0,0,0
	dc.b	36,40,40,36,36,40,40,48,48,40,36,24,24,36,36,24,36,36,36,36,36,36,36,36,24,24,24,24,36,40,40,40,40,36,36,36,36,36,36,36,24,24,24,52,12,48,48,48,40,40,36,36,52,12,16,48,48,40,40,36,36,36,36,36,0,0,0,0
	dc.b	40,36,36,40,40,40,40,48,48,16,40,36,36,36,24,36,24,24,24,24,24,24,36,36,28,28,24,24,28,28,28,24,40,40,48,40,36,36,36,36,36,36,36,36,52,16,48,40,40,40,40,36,36,60,12,48,48,48,40,36,36,36,36,40,0,0,0,0
	dc.b	40,40,40,40,40,40,48,48,48,40,36,40,40,40,36,36,36,36,36,36,36,36,36,36,24,28,28,24,24,28,28,28,28,24,40,40,36,36,40,36,36,36,24,28,24,52,48,48,48,40,40,40,36,36,16,48,48,40,40,40,40,36,36,36,0,0,0,0
	dc.b	40,40,40,48,48,48,48,48,48,40,36,36,40,40,40,36,36,36,36,36,36,36,36,36,24,24,24,24,24,24,24,28,28,28,24,36,36,36,36,36,24,24,28,28,24,24,16,48,48,40,36,40,36,36,40,48,48,48,48,40,40,40,40,40,0,0,0,0
	dc.b	48,40,48,48,48,48,16,16,40,36,36,40,36,40,40,36,36,36,36,40,40,40,36,36,36,36,24,28,28,28,24,24,24,28,28,28,28,24,36,24,24,24,24,24,24,28,52,48,48,48,40,36,36,36,36,36,40,48,48,48,48,40,40,40,0,0,0,0
	dc.b	48,48,48,48,16,12,12,52,36,36,40,40,40,48,48,40,40,40,40,40,40,36,36,24,24,28,32,32,32,32,28,28,28,28,28,28,28,28,28,24,24,24,36,28,28,28,52,48,40,48,40,40,36,40,40,36,40,40,40,40,40,48,48,48,0,0,0,0
	dc.b	48,48,16,12,4,12,52,36,40,40,48,40,40,48,48,48,48,40,36,24,24,24,24,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,32,32,28,24,36,24,28,28,40,48,40,40,40,40,36,36,40,36,36,36,24,24,28,24,36,36,0,0,0,0
	dc.b	16,12,4,4,16,40,40,40,48,40,40,48,48,48,48,36,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,32,28,28,32,28,28,28,28,28,24,36,28,28,28,52,48,40,36,36,36,36,36,24,24,24,24,24,24,24,24,36,36,0,0,0,0
	dc.b	12,4,4,52,40,40,40,40,48,48,48,48,48,40,24,28,28,24,28,24,24,24,24,28,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,28,24,28,28,28,24,40,48,40,40,36,36,24,24,24,24,24,36,36,36,36,36,40,40,0,0,0,0
	dc.b	4,12,40,40,40,40,40,48,48,48,48,16,44,24,24,28,24,36,24,24,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,28,28,28,28,24,28,28,28,24,40,40,40,40,36,36,36,24,24,24,36,40,40,36,36,40,40,40,0,0,0,0
	dc.b	52,40,40,40,48,48,48,48,48,48,16,40,24,24,28,28,28,24,24,28,28,32,32,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,24,40,40,36,36,36,24,24,24,24,36,40,40,40,48,48,48,40,40,0,0,0,0
	dc.b	40,40,40,40,48,48,48,48,48,16,40,24,24,36,36,24,24,24,36,28,32,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,24,36,36,36,36,36,36,24,24,40,48,48,48,40,48,48,40,40,40,0,0,0,0
	dc.b	48,40,40,48,48,48,48,48,48,40,24,24,36,36,36,36,36,36,36,28,28,28,28,32,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,32,28,36,24,24,24,24,24,24,24,40,48,48,48,48,48,40,40,40,40,36,0,0,0,0
	dc.b	40,40,48,48,48,40,40,48,40,24,24,36,36,36,36,36,40,36,24,24,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,24,24,24,24,28,28,28,24,40,48,48,48,48,48,48,48,40,40,40,52,0,0,0,0
	dc.b	48,48,48,40,40,40,40,36,24,36,36,36,36,36,36,36,48,40,36,24,28,28,28,24,28,28,28,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,24,24,24,24,24,24,24,36,16,48,48,48,40,40,40,40,40,40,12,4,0,0,0,0
	dc.b	40,40,36,36,36,36,36,36,24,36,36,36,36,36,40,40,40,40,24,28,28,24,24,28,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,28,24,24,24,24,24,24,28,28,24,40,48,48,48,40,40,48,40,36,40,52,12,4,12,0,0,0,0
	dc.b	36,36,24,24,24,24,24,24,24,36,36,36,36,36,36,40,40,40,28,28,28,24,24,28,28,28,28,28,28,28,28,32,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,36,40,48,48,40,40,40,40,36,36,40,16,4,12,16,48,0,0,0,0
	dc.b	40,36,24,24,24,36,36,36,40,40,40,40,40,40,40,40,40,40,28,28,24,36,24,28,32,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,24,36,40,48,40,48,48,40,40,40,36,36,36,36,12,4,12,16,48,48,0,0,0,0
	dc.b	48,48,48,48,48,48,40,40,36,36,40,40,40,48,48,48,48,40,28,28,24,24,24,24,24,28,28,28,24,28,28,28,28,28,28,32,32,28,28,24,24,36,36,40,40,40,40,40,40,48,40,36,36,40,36,36,36,12,12,48,48,48,48,48,0,0,0,0
	dc.b	40,40,48,48,48,48,48,40,40,36,36,40,40,40,48,48,48,40,28,24,24,24,24,24,36,36,24,28,28,28,28,24,24,24,28,28,28,36,36,36,36,36,40,40,36,36,36,36,36,40,40,36,36,36,36,40,16,48,48,48,40,40,40,40,0,0,0,0
	dc.b	40,40,40,40,40,48,48,48,48,40,36,40,40,40,48,48,48,48,36,24,28,28,24,36,36,36,40,36,36,24,28,28,28,24,24,24,24,24,24,24,36,36,36,36,36,36,36,36,36,40,40,40,36,36,40,48,48,48,48,48,40,40,40,36,0,0,0,0
	dc.b	40,40,40,40,40,48,48,48,48,12,40,36,40,40,48,48,48,48,52,24,28,24,36,36,36,40,40,40,40,36,24,28,28,28,28,24,24,24,24,24,36,36,36,36,36,36,36,36,36,36,36,40,40,36,40,48,48,40,40,40,40,40,40,36,0,0,0,0
	dc.b	36,36,36,40,40,40,48,48,48,16,60,40,40,40,40,48,48,48,16,40,36,36,36,36,36,36,36,40,40,48,40,40,24,24,28,28,24,28,28,28,36,36,24,24,24,36,36,36,24,24,36,36,36,40,48,48,48,40,40,40,36,36,36,40,0,0,0,0
	dc.b	36,36,40,40,40,40,48,48,48,16,4,52,40,40,40,48,48,48,48,16,52,24,24,36,36,36,36,36,36,36,40,40,40,48,40,36,24,24,24,24,36,36,36,36,24,24,24,24,24,36,36,24,24,36,40,48,48,40,40,36,36,36,36,36,0,0,0,0
	dc.b	36,36,40,40,40,48,48,48,48,16,12,4,40,40,40,40,48,48,48,48,48,36,24,24,36,36,36,36,36,36,40,48,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,36,36,36,24,28,24,48,48,40,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,40,40,40,48,48,48,16,12,4,12,40,48,48,48,48,48,48,48,48,40,24,36,36,36,36,36,40,40,36,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,40,40,36,36,36,36,24,24,40,48,48,40,40,40,40,36,36,0,0,0,0
	dc.b	36,36,36,40,40,40,48,48,48,48,12,4,4,40,40,48,48,48,48,48,48,48,40,36,36,24,36,36,36,40,36,36,36,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,40,48,40,40,36,36,36,36,40,48,48,48,40,40,40,40,0,0,0,0
	dc.b	36,36,36,36,40,40,48,48,48,48,16,12,4,12,40,40,40,48,48,48,48,40,40,36,36,24,24,36,40,36,36,36,36,36,36,36,36,40,40,40,40,40,48,48,40,40,48,40,40,48,40,40,40,40,40,40,40,40,40,36,36,36,40,40,0,0,0,0
	dc.b	36,36,36,36,36,40,48,48,48,48,16,12,4,4,16,40,40,40,48,48,48,40,36,36,36,24,24,36,40,40,40,40,40,40,40,52,44,40,36,36,36,36,40,40,40,40,40,40,48,48,48,48,40,40,40,40,48,40,40,36,36,36,24,24,0,0,0,0
	dc.b	36,36,36,40,36,40,48,48,48,48,16,16,12,4,12,40,48,40,48,48,48,40,36,24,24,24,36,40,48,48,40,48,48,48,48,16,12,12,12,12,12,12,52,52,52,40,40,40,40,40,40,40,40,40,40,40,40,40,40,48,40,40,36,36,0,0,0,0
	dc.b	36,36,40,40,40,40,40,40,48,48,48,16,16,12,4,16,48,40,48,48,40,40,36,36,28,24,40,48,48,48,40,48,40,48,48,48,48,48,48,16,12,12,12,4,4,4,12,12,12,16,16,48,40,40,48,40,40,40,40,36,36,36,36,36,0,0,0,0
	dc.b	24,44,44,44,52,12,16,40,48,48,48,16,12,12,12,16,40,40,40,48,48,40,36,36,36,48,48,48,40,36,40,40,40,40,48,48,48,48,48,48,48,48,16,16,16,16,16,16,12,12,16,16,16,48,48,48,48,40,40,40,36,24,24,24,0,0,0,0
	dc.b	24,24,24,36,36,40,48,48,48,48,16,16,16,16,12,12,12,12,16,12,16,16,48,48,48,48,48,48,48,48,40,40,40,40,40,40,48,48,40,24,24,36,40,40,40,40,40,40,12,12,12,16,48,48,48,40,40,40,36,40,36,36,24,24,0,0,0,0
	dc.b	40,40,40,40,40,40,40,40,40,40,40,40,48,16,16,12,12,12,4,4,4,4,12,16,16,16,16,48,48,48,48,48,48,48,48,48,48,40,36,24,24,36,36,40,48,40,40,40,40,12,12,16,16,48,48,48,40,40,36,36,36,36,36,36,0,0,0,0
	dc.b	36,40,40,40,48,40,40,40,48,40,40,40,40,40,40,40,40,40,40,40,40,52,52,52,60,60,12,12,16,16,48,48,48,40,40,40,40,36,24,36,36,36,36,40,48,40,40,40,40,12,4,12,16,48,48,48,40,40,36,36,36,36,36,36,0,0,0,0
	dc.b	24,36,36,36,40,40,40,48,48,40,48,48,48,48,40,40,40,40,40,40,40,36,36,36,40,40,40,40,40,36,36,36,36,36,36,36,36,24,24,36,40,40,36,40,48,48,40,40,40,40,4,4,12,48,48,48,48,40,40,36,36,36,36,36,0,0,0,0
	dc.b	40,40,36,40,40,40,40,36,36,40,40,40,40,48,48,48,40,40,40,48,40,48,48,48,40,40,40,36,36,36,36,36,36,36,36,40,36,36,24,24,40,40,40,48,48,48,40,40,40,40,52,4,12,16,48,48,48,40,40,40,36,36,36,36,0,0,0,0
	dc.b	48,40,40,48,48,48,40,40,36,36,36,36,36,40,40,48,48,48,48,48,48,48,48,48,40,40,40,40,40,40,40,36,40,40,40,40,36,36,24,24,24,40,48,48,48,48,48,48,40,40,36,12,4,16,48,48,48,40,40,40,40,36,36,36,0,0,0,0
	dc.b	40,40,40,48,40,48,48,48,36,28,28,24,36,36,36,36,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,40,40,36,36,36,36,36,24,36,40,48,48,48,48,48,40,40,36,40,4,12,16,48,48,40,40,40,40,36,36,36,0,0,0,0
	dc.b	36,36,36,40,40,40,48,48,48,24,28,24,36,36,36,40,40,40,40,40,40,40,16,16,40,48,48,48,48,48,48,48,40,40,36,36,36,36,36,36,36,24,36,52,16,48,48,40,40,40,40,36,52,4,16,48,48,48,40,40,36,36,36,36,0,0,0,0
	dc.b	40,40,36,40,40,40,40,48,48,40,36,36,24,36,36,24,24,24,24,24,24,24,36,36,24,24,24,24,24,36,40,40,40,40,36,36,36,36,36,36,24,36,24,36,12,16,48,48,40,40,40,40,40,12,16,48,48,48,40,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,40,40,40,48,48,48,40,40,40,36,36,24,36,36,36,36,36,36,36,36,36,24,24,24,28,28,28,28,24,36,40,48,40,40,36,36,36,36,36,24,36,44,12,48,48,48,48,40,40,36,52,12,48,48,48,48,40,40,36,40,40,0,0,0,0
	dc.b	36,40,40,40,40,48,48,48,48,36,36,40,40,40,36,36,36,36,36,36,36,36,36,36,36,28,28,24,24,28,28,28,28,24,36,40,40,40,36,36,36,36,24,24,24,52,16,48,48,48,40,40,36,36,16,48,48,48,40,40,40,36,36,40,0,0,0,0
	dc.b	40,40,48,40,48,48,48,48,40,36,36,36,40,40,40,36,36,36,36,36,36,36,36,36,36,24,24,24,24,24,24,28,28,28,28,24,24,36,36,24,24,24,28,28,28,24,16,48,48,40,40,40,40,36,36,40,48,48,48,48,48,40,40,40,0,0,0,0
	dc.b	48,40,48,48,48,48,16,16,36,36,40,40,40,48,40,36,36,36,40,40,40,40,36,36,36,36,24,24,28,28,24,24,24,28,28,28,28,28,24,24,24,24,24,28,24,28,44,48,48,40,40,36,36,36,36,36,40,48,48,48,48,48,40,48,0,0,0,0
	dc.b	48,48,16,16,16,12,16,36,36,40,40,40,40,48,48,40,40,40,40,40,40,36,24,28,28,28,28,28,32,32,28,28,28,28,28,28,28,28,28,36,24,24,36,24,28,28,24,48,48,48,48,40,40,40,40,36,36,40,40,40,40,40,48,48,0,0,0,0
	dc.b	48,48,12,4,4,52,40,40,40,40,40,48,48,48,48,40,40,36,36,24,24,24,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,32,32,28,24,36,24,28,28,24,48,48,40,40,40,40,40,40,40,36,36,36,24,28,28,24,24,0,0,0,0
	dc.b	16,12,4,12,40,40,40,40,48,48,40,48,48,48,40,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,32,28,28,28,28,28,28,32,28,24,36,28,28,28,44,48,40,40,36,36,36,36,36,24,24,24,24,36,24,24,36,36,0,0,0,0
	dc.b	12,4,60,40,40,40,40,40,48,48,48,48,48,36,28,28,28,24,24,24,24,24,24,28,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,28,24,28,28,28,24,36,48,48,40,36,36,36,36,24,24,24,36,36,36,36,36,36,40,0,0,0,0
	dc.b	4,16,40,40,40,40,48,48,48,48,16,52,24,28,24,24,24,24,24,24,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,24,28,28,36,48,40,36,36,36,36,24,24,24,36,36,36,36,40,40,40,40,0,0,0,0
	dc.b	16,40,48,48,48,48,48,48,48,16,16,36,24,24,24,28,24,24,24,24,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,24,36,40,40,36,36,36,24,24,24,36,48,48,40,40,48,40,40,40,0,0,0,0
	dc.b	40,40,40,48,48,48,48,48,48,52,36,24,36,36,36,24,24,24,36,24,32,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,32,28,24,36,36,40,36,36,36,24,24,36,40,48,48,40,48,48,40,40,40,0,0,0,0
	dc.b	48,40,48,48,48,48,48,48,40,36,24,24,36,36,36,40,36,36,24,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,24,24,24,36,36,36,36,24,36,40,48,48,48,48,48,40,48,40,40,0,0,0,0
	dc.b	40,40,48,48,48,40,40,48,36,36,36,36,36,36,36,36,40,40,24,28,24,24,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,32,28,24,24,24,24,28,24,24,24,36,16,48,48,48,48,48,40,40,48,40,52,0,0,0,0
	dc.b	48,40,40,40,36,40,36,36,24,36,36,36,36,36,36,36,40,36,24,24,28,28,24,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,24,24,24,24,28,28,28,36,40,48,48,48,48,40,40,40,40,40,16,4,0,0,0,0
	dc.b	40,40,36,36,36,36,36,24,36,36,36,36,36,36,40,40,48,40,24,28,24,24,24,28,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,28,28,24,24,24,24,28,28,28,28,36,16,48,48,48,48,40,40,40,40,40,60,4,12,0,0,0,0
	dc.b	36,36,24,24,24,36,24,24,36,36,36,36,36,36,40,40,48,36,28,28,24,24,24,28,28,28,28,28,28,28,28,32,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,40,48,48,48,40,48,40,40,40,40,40,4,4,12,48,0,0,0,0
	dc.b	24,24,28,28,24,36,36,36,40,40,40,40,40,40,40,40,48,24,28,28,24,24,24,28,28,32,28,28,28,28,28,28,32,28,28,28,28,28,28,28,28,28,28,28,24,36,36,40,48,48,48,40,40,40,40,40,40,36,52,12,12,16,48,48,0,0,0,0
	dc.b	48,40,40,40,40,40,40,36,36,36,36,40,40,48,48,48,48,24,28,28,24,24,24,24,36,28,32,28,24,28,28,24,28,28,32,32,28,28,28,28,28,24,36,40,40,40,40,40,40,48,40,40,40,36,36,40,36,52,16,16,48,48,48,48,0,0,0,0
	dc.b	48,40,48,48,48,48,40,40,36,36,40,40,40,40,48,48,48,36,28,24,24,24,24,24,36,36,24,28,24,24,28,24,24,24,28,28,24,36,36,24,36,40,40,40,40,40,36,36,36,40,40,36,36,36,36,36,52,16,48,48,48,40,40,40,0,0,0,0
	dc.b	40,40,40,48,48,48,48,48,40,40,36,40,40,40,48,48,48,16,24,24,24,24,24,36,36,40,36,24,24,24,28,28,28,24,24,24,24,24,24,36,40,40,36,36,36,36,36,36,36,40,40,36,36,36,36,40,48,48,48,48,40,40,40,40,0,0,0,0
	dc.b	40,40,40,40,40,48,48,48,48,16,36,40,40,48,48,48,48,48,52,24,24,36,36,36,40,40,40,40,40,36,24,28,28,28,24,24,24,24,24,24,36,36,36,36,36,36,36,36,36,36,36,40,40,36,36,48,48,48,40,40,40,40,40,36,0,0,0,0
	dc.b	40,40,36,40,40,48,48,48,48,12,44,36,40,40,48,48,48,48,16,36,36,36,36,36,36,36,36,40,48,48,40,36,24,28,28,28,28,28,24,24,36,36,24,24,24,36,36,24,24,24,36,36,40,36,40,48,48,48,40,40,40,36,36,36,0,0,0,0
	dc.b	36,40,40,40,40,40,48,48,48,12,4,40,40,40,48,48,48,48,48,16,36,24,24,36,36,36,36,36,36,40,48,40,40,40,36,24,24,24,24,24,36,36,24,24,24,24,24,24,24,24,36,24,24,36,40,48,48,40,40,36,36,36,36,36,0,0,0,0
	dc.b	36,36,40,40,36,40,48,48,48,12,4,12,40,40,40,48,48,48,48,48,52,36,24,24,36,36,36,36,36,36,40,48,48,48,48,48,48,48,40,40,16,16,40,40,40,40,40,40,40,36,36,36,24,28,24,48,48,48,40,40,36,36,36,36,0,0,0,0
	dc.b	36,36,40,40,40,40,48,48,48,16,12,4,40,40,48,48,48,48,48,48,48,40,36,24,36,36,36,36,36,40,40,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,40,36,36,36,24,24,28,28,36,48,48,40,40,40,40,40,40,0,0,0,0
	dc.b	36,36,36,40,40,40,48,48,48,48,12,4,12,40,40,40,48,48,48,48,48,48,40,36,36,24,36,36,40,40,40,36,40,40,40,40,40,40,40,40,48,48,48,48,48,48,48,48,48,40,40,36,36,36,36,36,40,40,40,48,48,48,40,40,0,0,0,0
	dc.b	36,36,36,40,40,40,48,48,48,48,16,4,4,52,40,40,48,48,48,48,40,40,40,36,24,24,36,40,40,36,36,36,36,36,36,40,40,40,40,40,48,48,48,48,48,48,40,40,48,48,48,48,40,40,40,36,40,36,36,36,36,36,40,40,0,0,0,0
	dc.b	36,36,36,36,40,40,48,48,48,48,16,12,4,4,40,40,40,48,48,48,40,40,36,36,36,24,36,36,36,36,36,40,40,40,40,40,40,36,36,40,40,40,40,40,40,40,48,48,40,40,40,48,40,40,48,48,48,48,40,40,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,40,40,48,48,48,16,16,4,4,12,40,40,48,48,48,48,40,36,24,24,24,24,40,48,40,40,48,48,48,16,12,12,12,12,12,52,52,52,40,40,40,40,48,40,40,40,40,40,40,48,48,40,40,48,48,48,40,40,36,0,0,0,0
	dc.b	36,36,40,40,40,52,40,48,48,48,16,16,12,4,4,48,40,40,48,48,48,40,36,24,28,24,36,48,48,48,40,48,48,48,48,48,48,48,16,16,12,12,12,4,4,4,12,12,16,16,16,48,40,40,48,40,40,40,40,40,40,40,40,40,0,0,0,0
	dc.b	36,44,56,52,52,60,52,48,48,48,48,16,16,12,12,12,40,48,48,48,48,40,36,24,28,40,48,48,40,40,48,40,40,48,48,48,48,48,48,48,48,48,16,16,12,12,16,16,12,12,12,16,16,16,48,48,48,40,40,36,36,36,24,24,0,0,0,0
	dc.b	36,36,36,36,48,40,40,48,48,48,16,16,12,12,12,12,12,12,12,12,16,16,16,48,48,48,48,48,48,48,48,48,40,48,40,48,48,48,36,24,24,36,36,48,48,40,40,40,16,12,12,12,16,48,48,48,40,40,36,36,36,36,36,24,0,0,0,0
	dc.b	40,40,40,40,40,40,40,40,48,48,40,40,40,16,16,16,12,12,4,4,4,4,12,12,12,16,16,48,48,48,48,48,48,48,48,48,48,36,24,24,24,36,36,40,48,48,40,40,40,12,4,12,16,48,48,48,40,40,40,36,36,36,36,36,0,0,0,0
	dc.b	36,40,48,48,48,48,40,48,40,40,48,40,40,40,40,40,40,40,40,40,40,40,40,40,52,52,12,16,16,16,48,48,40,40,40,40,40,36,24,36,36,36,36,40,48,48,48,40,40,52,4,4,16,48,48,48,48,40,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,40,40,48,40,40,40,48,48,48,48,40,40,40,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,36,36,36,40,36,24,24,40,36,40,40,40,48,40,40,40,40,60,4,12,48,48,48,48,48,40,36,36,36,36,36,0,0,0,0
	dc.b	40,36,36,36,36,36,36,36,36,36,40,40,40,40,48,48,48,48,48,48,48,40,40,40,40,40,40,40,40,36,36,36,36,36,36,40,40,36,24,24,36,40,40,48,48,48,48,40,40,40,40,4,4,16,48,48,48,48,40,40,36,36,36,24,0,0,0,0
	dc.b	40,48,48,48,48,48,40,24,24,24,24,36,36,40,40,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,40,40,40,40,40,40,36,36,36,36,24,36,48,48,48,48,48,48,40,48,40,52,4,12,16,48,48,40,40,40,40,36,36,36,0,0,0,0
	dc.b	40,40,48,40,40,48,48,40,28,28,28,24,24,36,36,36,40,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,40,40,36,36,36,36,24,36,36,16,48,48,48,48,40,40,40,36,12,12,16,48,48,48,40,36,36,40,36,36,0,0,0,0
	dc.b	40,40,40,40,40,48,48,48,36,24,24,24,36,36,36,36,36,36,40,40,40,40,40,40,40,40,40,48,48,48,48,48,40,40,36,36,36,36,36,36,36,24,24,44,12,48,48,48,48,40,40,40,40,4,12,48,48,48,40,36,36,36,36,36,0,0,0,0
	dc.b	40,40,40,40,40,40,48,48,48,40,36,36,36,36,24,24,24,24,36,24,24,24,24,36,36,28,24,24,24,24,36,40,40,48,40,36,36,36,36,36,24,36,24,24,60,12,48,48,48,48,40,40,40,52,12,48,48,48,40,40,36,36,36,40,0,0,0,0
	dc.b	40,36,40,40,40,48,48,48,48,40,40,40,40,36,36,24,36,36,36,36,36,36,36,36,36,28,28,24,28,28,28,28,24,40,48,40,40,36,36,36,36,36,36,24,36,12,16,48,48,48,40,40,36,36,52,48,48,48,40,40,40,36,36,40,0,0,0,0
	dc.b	36,40,40,40,40,48,48,48,40,36,36,40,40,40,36,36,36,36,36,36,36,36,36,36,36,24,24,24,24,24,28,28,28,28,36,36,40,40,36,36,36,36,36,24,24,36,12,48,48,40,40,40,36,36,40,48,48,48,48,40,40,40,36,36,0,0,0,0
	dc.b	40,40,40,48,48,48,48,48,40,36,36,40,40,40,48,36,36,36,36,36,36,36,40,40,36,24,24,24,24,24,24,24,28,28,28,28,24,36,40,36,36,36,24,28,28,24,44,16,48,40,40,40,36,36,36,40,40,48,48,48,40,40,40,40,0,0,0,0
	dc.b	40,48,48,48,48,48,16,40,36,36,40,40,40,40,48,40,36,40,40,40,40,40,40,36,36,36,24,24,28,28,28,24,24,28,28,28,28,28,36,36,36,24,28,24,24,24,24,16,48,40,40,36,36,36,36,36,36,40,40,48,48,48,48,48,0,0,0,0
	dc.b	48,48,16,16,12,12,52,36,40,40,40,40,40,48,48,40,40,40,40,40,36,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,32,28,24,24,24,36,24,28,28,28,16,48,48,48,40,40,40,40,36,40,40,40,40,40,36,36,40,0,0,0,0
	dc.b	48,16,12,4,12,40,36,48,40,48,48,40,48,48,48,40,36,36,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,32,28,28,28,32,28,28,24,36,24,28,32,28,16,48,40,40,40,40,40,40,40,40,36,36,24,28,28,28,28,0,0,0,0
	dc.b	16,4,4,12,40,40,40,48,40,48,48,48,48,48,36,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,36,24,28,28,28,16,48,36,36,36,36,36,36,36,24,24,24,24,24,28,24,36,0,0,0,0
	dc.b	4,4,52,40,40,48,48,40,48,48,48,16,52,24,28,24,28,24,24,24,24,24,24,28,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,28,24,24,28,28,28,24,48,48,40,36,36,36,36,24,24,24,24,36,36,36,36,36,36,0,0,0,0
	dc.b	4,52,40,40,40,48,48,48,48,48,16,52,24,28,28,24,24,36,36,24,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,28,24,48,40,40,36,36,36,36,36,24,24,36,36,36,36,40,40,48,0,0,0,0
	dc.b	16,40,48,48,48,48,48,48,48,16,52,36,24,24,24,24,24,24,36,24,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,36,40,40,36,36,36,24,24,24,24,40,48,40,40,48,40,40,48,0,0,0,0
	dc.b	40,40,48,48,48,48,48,48,16,40,36,36,36,36,36,36,36,24,36,28,32,32,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,32,24,40,36,40,36,36,36,24,24,24,40,48,48,48,48,48,40,40,40,0,0,0,0
	dc.b	48,40,48,48,48,48,48,48,40,36,24,36,24,36,40,40,36,40,24,32,32,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,32,28,36,36,36,36,36,36,36,24,24,40,48,48,48,48,48,48,40,40,40,0,0,0,0
	dc.b	48,48,48,48,40,40,48,40,24,36,36,36,36,36,36,40,48,36,28,28,24,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,24,24,24,24,28,24,24,36,36,40,16,48,48,48,48,48,48,40,40,52,0,0,0,0
	dc.b	48,40,40,36,36,40,36,24,36,36,36,36,36,40,40,40,40,24,28,24,24,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,24,24,24,28,24,28,28,24,52,16,48,48,48,48,48,48,40,40,52,4,0,0,0,0
	dc.b	36,36,36,36,36,36,24,24,24,36,36,36,36,36,40,48,48,36,24,28,28,24,24,28,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,28,24,24,24,24,24,24,24,24,28,24,52,48,48,48,48,40,48,40,40,40,52,12,4,0,0,0,0
	dc.b	36,24,28,24,24,24,24,36,36,36,36,36,40,40,40,40,48,24,28,28,24,24,24,28,28,28,28,28,28,28,28,32,28,28,28,28,28,32,32,28,28,28,28,28,28,28,28,28,24,36,48,48,48,48,48,40,48,40,40,40,60,4,12,16,0,0,0,0
	dc.b	28,28,28,24,24,36,36,40,40,40,40,40,40,40,40,40,48,28,28,28,24,36,24,28,28,32,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,36,36,40,48,48,48,40,40,40,40,40,36,52,12,12,12,16,48,0,0,0,0
	dc.b	40,36,36,36,40,40,40,36,36,40,40,40,40,48,48,48,40,28,28,24,24,24,24,24,24,28,32,28,28,28,28,24,28,28,28,28,28,28,28,28,28,28,24,36,40,40,40,40,48,48,40,40,40,40,40,36,36,52,12,12,48,16,48,48,0,0,0,0
	dc.b	48,48,48,48,48,48,40,36,36,36,36,40,48,48,48,48,48,24,28,24,24,24,24,36,36,36,28,32,28,24,24,24,24,24,24,28,24,24,24,36,36,40,40,40,40,36,36,40,40,40,40,40,40,36,36,36,40,16,48,48,48,48,40,40,0,0,0,0
	dc.b	40,40,40,48,48,48,48,40,40,36,36,40,48,40,48,48,16,44,24,28,24,24,24,36,36,40,36,24,24,28,28,28,24,24,24,24,24,24,24,36,36,36,36,36,36,36,36,36,40,40,40,36,36,36,36,36,48,48,48,48,40,40,40,40,0,0,0,0
	dc.b	40,40,40,40,40,48,48,48,48,40,36,40,40,48,48,48,48,16,24,24,36,36,36,36,36,40,40,40,36,24,28,28,28,28,24,24,24,24,24,36,36,36,36,36,36,36,36,36,36,36,40,40,36,36,36,40,48,48,48,40,36,40,40,36,0,0,0,0
	dc.b	40,40,36,40,40,48,48,48,16,12,40,40,40,48,48,48,48,16,16,36,36,36,36,36,36,36,40,40,48,40,40,24,28,28,28,28,24,28,24,36,36,36,36,36,36,36,36,36,24,36,36,40,40,36,36,40,48,48,40,40,40,36,36,36,0,0,0,0
	dc.b	40,40,36,40,40,40,48,48,48,12,52,40,40,40,48,48,48,48,16,16,24,24,36,36,36,36,36,40,40,40,48,40,40,36,24,24,24,24,28,36,36,24,24,24,24,24,36,36,24,24,24,36,36,36,40,48,48,48,40,40,40,36,36,36,0,0,0,0
	dc.b	36,40,40,36,40,48,48,48,16,12,4,52,48,40,48,48,48,48,48,16,40,36,24,36,36,36,36,36,40,40,40,48,48,48,48,48,48,40,40,40,52,40,40,40,40,40,40,36,36,36,36,36,24,24,24,36,48,48,48,40,36,40,40,36,0,0,0,0
	dc.b	36,36,40,40,40,48,48,48,48,12,4,12,40,40,48,48,48,48,48,48,48,36,36,24,36,36,36,36,40,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,36,36,24,24,28,28,28,40,48,48,40,40,40,40,36,0,0,0,0
	dc.b	36,36,40,40,40,40,48,48,48,16,12,4,52,40,48,40,48,48,48,48,48,48,36,36,36,36,36,40,40,40,36,36,40,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,40,40,40,36,36,36,24,24,24,36,48,48,48,48,48,40,0,0,0,0
	dc.b	36,36,36,40,40,40,48,48,48,48,12,4,4,40,48,48,48,48,48,48,40,40,36,36,24,36,36,40,40,36,36,36,36,36,36,40,40,40,40,40,40,40,40,48,48,48,48,48,48,48,48,40,40,40,40,36,36,36,40,36,36,36,40,36,0,0,0,0
	dc.b	36,36,36,36,40,40,48,48,48,48,16,12,4,4,40,48,48,48,48,48,40,36,36,36,36,24,36,40,36,36,36,36,36,36,40,36,36,40,40,40,40,40,40,48,48,48,40,48,40,40,48,48,40,48,48,40,48,40,40,40,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,40,48,48,48,48,16,16,4,4,16,40,48,48,48,48,48,36,36,24,24,24,36,40,40,40,40,40,48,48,16,16,12,52,16,52,40,40,40,40,40,40,40,40,40,40,40,48,48,40,40,40,48,40,40,48,48,40,40,36,0,0,0,0
	dc.b	36,44,36,36,40,40,40,48,48,48,16,16,12,4,12,40,40,48,48,48,40,40,24,28,28,28,36,48,48,48,48,48,48,48,48,48,48,16,16,12,12,12,4,4,12,12,12,12,16,16,16,40,40,40,40,48,40,40,40,40,40,40,40,40,0,0,0,0
	dc.b	36,44,44,60,52,52,16,48,48,48,48,16,12,12,4,12,40,48,48,48,48,40,36,24,28,24,40,48,40,40,48,40,40,48,48,48,48,48,48,48,48,16,16,16,16,12,12,12,12,12,12,12,16,16,16,48,48,48,40,40,36,36,36,36,0,0,0,0
	dc.b	36,36,36,40,40,48,48,48,48,16,16,12,12,12,12,12,4,4,12,12,12,12,16,48,48,48,48,48,48,48,48,40,48,48,48,48,48,40,36,24,24,36,36,40,48,48,48,40,16,4,4,12,16,48,48,48,40,40,36,36,36,36,36,36,0,0,0,0
	dc.b	40,48,40,40,40,40,40,40,48,48,40,40,40,40,16,16,52,12,12,12,4,4,12,12,12,12,16,16,48,48,48,48,48,48,40,40,40,36,24,36,24,36,36,40,48,40,40,40,40,12,4,12,16,48,48,48,40,40,36,36,36,36,36,36,0,0,0,0
	dc.b	40,40,48,48,40,40,48,40,48,48,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,52,52,52,52,40,40,48,40,40,36,36,40,40,24,36,36,36,40,40,48,48,40,48,48,40,4,4,12,16,48,48,48,48,40,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,40,36,40,40,40,40,40,40,40,48,48,40,48,40,48,48,48,40,40,40,40,40,40,40,36,40,36,36,36,36,36,36,36,48,40,24,24,36,40,40,40,48,48,48,40,48,40,52,4,12,16,48,48,48,48,40,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,40,40,36,24,24,36,36,36,40,48,40,40,48,48,48,48,48,48,48,48,48,40,48,40,40,40,40,36,36,36,36,36,40,40,36,24,24,24,40,40,48,48,48,48,48,40,40,40,4,4,16,48,48,48,40,40,40,40,36,36,36,0,0,0,0
	dc.b	48,48,48,48,48,40,36,32,28,24,24,24,36,36,36,40,40,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,36,40,40,40,36,36,36,36,24,24,40,48,48,48,48,48,40,40,48,40,4,12,16,48,48,40,40,40,40,36,36,36,0,0,0,0
	dc.b	40,48,48,40,48,48,40,28,28,28,28,24,36,36,36,40,40,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,48,40,40,40,36,36,36,36,36,24,36,16,48,48,48,48,48,48,48,36,52,4,16,48,48,48,40,36,36,36,36,36,0,0,0,0
	dc.b	36,40,40,40,40,48,48,48,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,44,40,40,40,40,40,48,48,48,48,40,40,36,36,36,36,36,36,36,24,36,12,16,48,48,48,40,40,40,40,12,12,48,48,48,40,40,40,36,36,36,0,0,0,0
	dc.b	40,40,36,40,40,48,48,48,48,40,40,36,36,36,24,36,24,36,36,36,24,24,24,24,36,24,28,24,24,28,24,36,40,40,40,40,40,36,36,36,36,36,24,24,36,12,16,48,48,48,40,40,40,40,12,48,48,48,48,40,40,36,36,40,0,0,0,0
	dc.b	36,40,40,40,40,48,48,16,36,36,40,40,40,40,36,36,36,36,36,36,36,36,36,36,36,24,28,28,24,28,28,28,28,36,40,40,40,40,36,36,36,36,24,36,36,52,12,48,48,48,40,40,40,36,52,16,48,48,40,48,40,36,36,40,0,0,0,0
	dc.b	40,40,40,40,48,48,48,48,36,36,36,36,40,40,40,36,36,36,36,36,36,36,36,36,36,24,24,24,24,24,28,28,28,28,24,36,36,40,40,36,36,36,36,36,36,24,60,16,48,48,40,40,40,36,36,40,48,48,40,40,40,36,40,40,0,0,0,0
	dc.b	40,48,40,48,48,48,48,40,36,36,36,36,36,40,48,40,36,40,40,40,40,40,40,40,36,36,36,24,24,24,24,24,28,28,28,28,28,36,40,36,36,36,36,24,28,28,36,16,48,48,40,40,36,36,36,36,40,48,48,48,48,48,40,40,0,0,0,0
	dc.b	48,40,48,48,48,16,16,36,36,40,40,40,40,48,48,40,40,40,40,40,40,40,40,36,24,24,24,24,28,28,28,28,24,28,28,28,32,28,24,36,24,24,24,24,24,24,24,52,48,48,48,40,36,36,36,36,36,36,40,48,48,48,48,48,0,0,0,0
	dc.b	48,48,16,16,12,12,40,40,40,40,40,40,40,48,48,40,48,40,40,36,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,32,28,24,24,24,24,24,24,28,28,44,48,48,40,40,40,40,40,36,36,36,40,40,36,36,24,24,0,0,0,0
	dc.b	48,12,12,4,52,40,40,48,40,40,40,48,48,48,48,40,36,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,32,28,28,24,36,36,24,28,32,52,48,40,40,40,40,40,40,40,40,36,36,36,24,28,28,28,0,0,0,0
	dc.b	12,4,4,52,40,40,40,48,48,48,48,48,48,40,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,32,28,28,28,28,28,28,28,28,24,36,24,28,28,32,52,48,40,40,36,36,36,36,36,36,24,24,24,24,28,24,24,0,0,0,0
	dc.b	4,60,40,40,48,48,48,48,48,48,48,16,44,24,24,24,24,24,24,24,24,24,24,28,28,28,28,28,32,32,32,32,32,32,32,28,28,28,28,28,28,24,24,28,28,28,24,40,48,40,36,36,36,36,36,36,24,24,36,36,24,24,36,36,0,0,0,0
	dc.b	12,40,40,40,48,48,48,48,48,16,16,36,24,24,24,24,24,24,36,24,24,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,28,32,24,40,48,48,40,36,36,36,36,36,24,36,36,36,36,40,40,40,0,0,0,0
	dc.b	48,40,48,48,48,48,48,48,16,16,36,24,36,36,24,24,24,24,36,24,28,28,32,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,32,28,36,40,40,40,36,36,36,36,24,24,36,40,40,40,40,40,40,48,0,0,0,0
	dc.b	40,48,48,48,48,48,48,48,52,36,24,36,36,36,36,36,36,36,36,28,32,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,32,24,36,36,36,36,36,36,36,24,24,24,48,48,48,48,48,40,40,40,0,0,0,0
	dc.b	48,48,48,48,48,48,48,40,36,24,24,36,36,36,40,40,40,36,24,32,32,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,32,28,36,36,36,36,36,36,36,24,24,36,52,48,48,48,48,48,48,48,40,0,0,0,0
	dc.b	48,40,48,48,40,48,40,36,36,36,36,36,36,36,40,40,40,36,28,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,32,28,28,24,36,24,24,24,36,36,24,36,36,40,48,48,48,48,48,48,48,48,40,0,0,0,0
	dc.b	40,40,40,36,36,36,36,36,36,36,36,36,36,36,40,40,40,24,28,24,24,24,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,24,24,24,24,28,28,28,24,40,16,48,48,48,48,48,48,48,40,40,12,0,0,0,0
	dc.b	36,36,36,24,36,36,24,36,36,36,36,36,36,40,40,48,48,24,28,28,28,24,28,24,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,28,24,24,24,24,24,24,24,24,28,24,36,16,48,48,48,48,48,40,40,40,40,12,4,0,0,0,0
	dc.b	24,28,28,24,36,24,24,36,36,36,36,36,36,40,40,40,40,28,28,24,24,24,28,28,28,28,28,28,28,28,28,28,32,28,28,28,28,28,28,28,24,28,24,24,28,28,28,28,28,24,40,48,48,48,48,48,48,40,40,48,52,60,4,16,0,0,0,0
	dc.b	28,28,28,24,36,36,40,48,40,40,40,40,40,40,40,48,36,32,28,24,24,36,24,24,28,32,32,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,36,40,48,48,48,40,40,40,40,40,36,36,16,12,12,16,48,0,0,0,0
	dc.b	24,24,36,40,40,40,36,36,36,40,40,40,40,48,48,48,36,28,24,24,24,24,24,36,24,28,32,28,24,28,28,24,28,28,28,32,28,28,28,28,28,28,28,24,36,40,40,40,40,48,48,40,40,40,40,36,36,36,52,16,16,48,48,48,0,0,0,0
	dc.b	48,48,48,48,48,40,36,36,36,36,40,40,40,48,48,48,40,28,24,24,24,24,24,36,36,36,28,32,28,24,24,24,24,24,24,28,24,24,36,36,36,40,40,48,40,40,40,40,40,40,40,40,40,40,36,36,36,16,48,48,48,48,40,40,0,0,0,0
	dc.b	40,48,48,48,48,48,48,40,36,36,40,40,40,48,48,48,16,36,28,24,24,24,36,36,40,40,36,28,28,24,28,28,24,24,24,24,24,24,36,36,40,36,36,36,40,36,36,36,40,40,40,36,36,36,36,36,40,48,48,48,40,48,40,36,0,0,0,0
	dc.b	40,40,40,40,48,48,48,48,40,40,36,40,40,48,48,48,16,52,24,24,36,36,36,36,40,40,40,40,36,24,28,28,28,24,24,24,24,24,24,36,36,36,36,36,36,36,36,36,36,36,40,40,36,36,36,36,48,48,48,40,40,40,36,36,0,0,0,0
	dc.b	40,40,36,40,48,48,48,48,16,52,36,40,40,48,48,48,48,16,52,36,36,36,36,36,40,40,40,40,40,40,36,28,28,28,28,24,24,28,24,36,36,36,36,36,36,36,36,36,36,36,40,40,40,36,36,36,48,48,40,40,40,36,36,36,0,0,0,0
	dc.b	40,36,40,40,40,48,48,48,16,4,40,40,40,40,48,48,48,48,16,36,24,24,36,36,36,36,40,40,40,40,48,40,36,24,28,24,24,28,24,36,24,24,24,24,36,36,24,24,24,24,36,36,36,40,40,40,48,48,48,40,40,36,36,36,0,0,0,0
	dc.b	36,40,40,40,40,40,48,48,16,12,12,40,40,48,48,48,48,48,16,16,36,24,36,36,36,36,36,40,36,36,40,48,48,48,48,40,40,40,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,48,48,48,40,36,40,40,36,0,0,0,0
	dc.b	36,36,40,40,40,48,48,48,16,12,4,12,40,48,48,48,48,48,48,48,40,36,24,36,36,36,36,40,40,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,40,40,36,36,36,24,24,28,28,28,28,40,48,48,48,48,40,36,0,0,0,0
	dc.b	36,36,40,40,40,40,48,48,48,16,4,4,40,48,40,48,48,48,48,48,48,40,36,24,36,36,36,40,40,40,40,36,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,36,36,24,24,28,28,28,36,40,48,48,48,48,40,0,0,0,0
	dc.b	36,36,36,40,40,40,48,48,48,16,12,4,12,40,40,48,48,48,48,48,48,40,36,36,24,36,40,40,40,36,36,36,36,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,36,36,36,24,24,36,40,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,40,48,48,48,48,16,4,8,52,48,48,48,48,48,48,40,36,36,36,24,36,36,40,40,36,36,36,36,36,36,36,36,40,40,40,40,40,40,40,48,48,48,40,48,40,48,48,48,48,40,40,40,40,40,36,40,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,40,48,48,48,48,16,12,4,4,40,40,48,48,48,48,40,36,24,24,24,36,36,40,36,36,40,40,40,40,40,52,52,52,52,40,40,40,40,40,40,40,40,40,48,40,40,40,40,40,48,40,40,48,48,48,40,40,48,40,0,0,0,0
	dc.b	36,36,36,36,36,40,40,48,48,48,16,12,4,4,12,40,40,48,48,48,40,36,24,28,28,24,36,40,40,40,48,48,48,48,48,48,16,12,12,12,12,12,4,4,12,12,12,12,16,16,48,48,40,48,48,48,40,40,40,40,40,40,48,48,0,0,0,0
	dc.b	36,44,60,52,52,52,16,48,48,48,48,16,12,4,4,16,48,48,48,48,40,36,24,28,32,28,40,48,48,48,48,40,48,48,48,48,48,48,48,48,16,16,16,12,12,4,4,4,12,12,12,12,12,16,48,48,48,48,48,40,40,36,36,36,0,0,0,0
	dc.b	36,36,40,40,40,48,48,48,16,16,12,12,12,12,12,12,4,4,4,4,12,16,16,16,48,48,48,48,48,48,48,48,48,48,48,48,48,40,36,24,24,36,36,40,48,48,40,40,40,4,4,12,16,48,48,48,40,40,36,36,36,36,36,36,0,0,0,0
	dc.b	48,40,48,48,40,40,40,48,48,48,48,40,40,40,40,40,16,16,12,12,12,12,12,12,12,12,12,16,48,48,48,48,48,40,40,36,40,40,36,36,24,24,36,40,40,48,48,40,40,16,4,12,16,48,48,48,40,40,40,36,36,36,36,36,0,0,0,0
	dc.b	40,40,48,40,48,48,48,48,48,48,48,48,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,36,36,36,36,40,40,36,24,36,36,36,40,48,48,48,48,40,40,12,4,12,16,48,48,48,40,40,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,40,40,40,40,40,48,48,48,48,48,48,48,48,48,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,36,40,40,24,24,36,40,40,40,48,48,48,48,40,40,52,4,4,16,48,48,48,48,40,40,36,36,36,36,0,0,0,0
	dc.b	40,36,36,40,36,24,24,24,36,36,36,36,40,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,40,40,40,36,36,36,40,40,40,36,36,24,36,40,48,48,48,48,48,48,40,40,52,4,12,16,48,48,40,40,40,40,36,36,36,0,0,0,0
	dc.b	48,48,48,48,48,36,28,32,28,28,24,24,36,36,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,40,40,40,40,36,36,36,36,24,36,16,48,48,48,48,48,40,40,40,12,4,16,48,48,48,40,40,40,36,36,36,0,0,0,0
	dc.b	40,40,40,48,48,48,36,32,28,28,28,24,24,36,36,36,40,48,48,48,48,48,16,16,16,48,48,48,48,48,48,48,48,48,48,40,36,36,36,36,36,24,24,44,16,48,48,48,48,48,40,40,40,4,12,16,48,48,40,40,40,36,36,36,0,0,0,0
	dc.b	40,40,40,40,48,48,48,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,40,40,48,48,40,40,40,40,36,36,36,36,36,36,24,24,52,12,48,48,48,40,40,40,40,52,4,16,48,48,40,40,36,36,36,36,0,0,0,0
	dc.b	36,40,40,40,48,48,48,40,36,40,40,36,36,36,24,36,36,36,36,36,36,36,36,36,36,36,24,28,24,24,28,24,36,40,40,40,40,40,36,36,36,36,36,24,36,60,12,48,48,48,48,40,36,36,60,16,48,48,40,40,40,36,36,40,0,0,0,0
	dc.b	36,36,40,48,48,48,48,40,36,36,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,24,28,24,28,28,28,28,24,40,40,40,40,36,36,36,36,36,36,36,36,12,16,48,48,48,40,40,36,52,16,48,48,48,40,40,40,40,36,0,0,0,0
	dc.b	40,40,40,48,48,48,48,40,36,36,36,40,40,40,40,36,36,36,36,36,36,36,36,36,36,36,24,24,24,24,24,28,32,28,24,24,36,40,40,36,36,36,36,36,36,24,52,16,48,48,48,40,40,36,36,40,40,48,48,48,40,40,40,40,0,0,0,0
	dc.b	48,40,48,48,48,48,48,40,36,36,40,36,36,48,48,36,36,36,40,40,40,40,40,40,40,36,36,36,24,24,24,28,28,28,28,28,28,36,40,40,36,36,36,24,24,28,28,52,16,48,40,40,40,40,36,36,36,40,48,48,48,48,48,48,0,0,0,0
	dc.b	40,48,48,48,48,16,40,36,40,36,40,40,40,48,48,40,40,40,40,48,40,40,36,36,24,24,24,24,24,24,24,24,24,28,28,28,32,32,24,36,36,24,24,24,24,24,24,44,16,48,48,40,40,36,36,36,36,36,36,40,40,48,48,40,0,0,0,0
	dc.b	48,16,16,16,12,52,36,36,40,40,40,40,48,48,48,40,48,40,36,36,24,28,28,32,32,28,28,28,28,28,28,28,24,28,28,28,28,32,28,24,24,36,24,24,24,28,28,24,16,48,48,40,40,36,40,36,36,36,40,40,40,36,24,32,0,0,0,0
	dc.b	16,12,4,12,52,40,40,40,40,48,48,48,48,48,40,36,24,28,28,28,28,28,28,28,28,28,28,32,32,32,32,32,28,28,28,28,28,32,32,28,24,24,36,24,24,28,28,24,16,48,40,40,40,40,40,40,40,40,36,36,24,24,28,32,0,0,0,0
	dc.b	12,4,60,40,40,48,40,48,48,48,48,48,16,36,24,28,28,28,28,24,24,24,28,28,28,28,28,28,28,28,28,28,32,28,28,32,28,28,28,28,28,24,36,24,28,28,28,24,48,48,40,36,40,36,36,36,36,36,24,24,24,28,28,24,0,0,0,0
	dc.b	4,16,40,48,40,48,48,48,48,48,16,16,24,28,28,24,24,24,36,24,24,24,28,28,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,28,24,24,24,28,28,24,36,48,48,40,36,36,36,36,36,24,24,24,36,36,24,36,36,0,0,0,0
	dc.b	52,40,40,48,48,48,48,48,48,16,52,36,36,24,24,24,24,24,36,24,24,24,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,28,28,36,48,48,40,36,36,36,36,36,24,24,36,36,36,36,36,40,0,0,0,0
	dc.b	40,48,48,48,48,48,48,16,16,52,36,24,36,36,36,36,24,36,36,24,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,32,28,28,28,28,32,24,40,40,40,40,36,36,36,36,24,24,36,40,40,40,40,48,40,0,0,0,0
	dc.b	40,48,48,48,48,48,48,48,52,36,24,36,36,36,40,36,36,36,36,28,32,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,32,32,28,36,48,40,36,36,36,36,36,24,24,36,48,48,48,48,48,48,40,0,0,0,0
	dc.b	40,48,48,48,48,48,48,40,36,36,36,36,36,36,40,40,40,36,28,32,32,24,28,32,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,32,32,28,36,36,36,36,36,36,36,36,24,24,44,48,48,48,48,48,48,48,40,0,0,0,0
	dc.b	48,48,48,40,40,40,40,36,36,36,36,36,36,40,40,40,40,24,28,28,28,24,28,32,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,24,36,24,24,36,36,36,36,24,36,52,16,16,48,48,48,48,48,48,40,0,0,0,0
	dc.b	40,40,36,36,36,36,36,24,36,36,36,36,36,40,40,48,36,24,28,28,24,24,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,24,24,24,24,24,24,24,24,24,36,16,16,48,48,48,48,48,48,48,48,16,0,0,0,0
	dc.b	36,36,24,36,36,24,24,36,36,36,36,36,36,40,40,48,40,24,28,28,28,24,24,24,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,28,28,24,24,24,24,24,24,28,28,28,24,52,16,48,48,48,48,48,40,40,40,12,12,0,0,0,0
	dc.b	24,28,24,24,24,24,36,36,40,36,40,36,40,40,40,48,36,28,28,28,24,24,24,24,28,32,28,28,32,32,28,28,32,28,28,28,28,28,28,28,28,28,24,24,28,28,28,28,28,24,36,48,48,48,48,48,48,40,40,40,40,12,4,12,0,0,0,0
	dc.b	32,28,24,36,36,36,40,40,40,40,40,40,48,40,40,48,24,28,28,24,24,24,36,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,28,28,28,28,28,28,28,36,40,48,48,48,48,48,40,40,36,36,52,12,12,12,48,0,0,0,0
	dc.b	32,24,40,40,40,40,40,36,40,40,40,40,48,48,48,48,24,28,24,24,24,24,36,24,24,28,32,28,24,28,28,24,28,28,28,32,28,28,32,32,28,28,28,24,36,36,40,40,40,48,48,48,40,40,40,40,36,36,52,12,16,16,16,48,0,0,0,0
	dc.b	48,48,48,40,40,36,36,36,36,40,40,40,48,48,48,48,36,24,24,24,24,24,36,36,36,24,32,32,28,24,24,24,24,24,24,24,24,24,24,36,36,36,40,40,40,40,40,40,40,48,40,36,36,40,40,36,36,40,16,48,48,48,48,48,0,0,0,0
	dc.b	48,48,48,48,48,48,40,36,36,36,40,40,40,48,48,16,52,24,28,24,36,36,36,40,40,40,24,28,28,28,28,24,24,24,24,24,24,24,36,36,40,40,40,40,40,40,36,36,36,40,40,36,36,40,36,36,36,48,48,48,48,40,40,40,0,0,0,0
	dc.b	40,48,40,40,48,48,48,48,40,36,40,40,40,48,48,48,16,44,24,36,36,36,36,40,40,40,40,36,24,24,28,32,28,24,24,24,24,24,36,36,36,36,36,36,36,36,36,36,36,40,48,40,36,36,36,24,36,48,48,48,40,40,40,40,0,0,0,0
	dc.b	40,40,40,40,40,48,48,48,16,52,36,40,48,48,48,48,16,16,36,36,36,36,36,36,40,40,40,40,40,40,24,28,28,28,28,24,28,24,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,36,36,36,40,48,48,48,40,40,36,36,0,0,0,0
	dc.b	40,36,40,48,40,48,48,48,16,12,40,40,48,48,48,48,48,16,52,36,24,36,36,36,36,36,40,40,40,40,48,40,24,28,24,24,28,24,36,24,24,24,24,36,36,36,36,36,36,36,36,36,36,40,40,40,40,48,48,48,40,36,36,36,0,0,0,0
	dc.b	36,40,40,40,40,48,48,48,16,4,12,40,40,48,48,48,48,16,16,44,36,36,36,36,36,36,36,40,40,40,40,48,48,48,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,48,48,40,40,40,36,40,0,0,0,0
	dc.b	36,40,40,40,40,48,48,48,16,12,4,40,40,48,48,48,48,48,48,48,40,36,24,36,36,36,36,40,40,40,40,48,40,48,48,48,48,48,16,16,16,16,48,48,48,40,40,40,36,36,36,24,24,28,28,28,28,36,48,48,48,40,40,40,0,0,0,0
	dc.b	36,36,40,40,40,48,48,48,48,12,4,12,40,48,48,48,48,48,48,48,48,36,36,36,36,36,40,40,40,40,36,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,40,40,36,36,24,28,28,28,32,28,36,48,48,48,48,48,0,0,0,0
	dc.b	36,36,40,40,40,40,48,48,48,16,12,4,12,40,48,48,48,48,48,48,48,40,36,36,24,36,40,40,40,36,36,36,40,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,40,40,40,36,36,36,36,24,24,24,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,40,40,40,48,48,48,48,12,4,4,48,48,48,48,48,48,40,40,36,36,36,24,36,40,40,36,36,36,36,36,36,40,40,40,40,40,40,40,40,40,40,48,48,48,48,48,48,48,48,48,40,40,40,40,40,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,40,48,48,48,48,16,12,8,4,48,40,48,48,48,48,40,36,24,24,24,36,40,36,36,36,36,36,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,40,48,48,40,40,40,0,0,0,0
	dc.b	36,36,36,36,40,40,48,48,48,16,16,12,4,4,16,40,48,48,48,48,40,36,24,28,28,36,40,40,40,40,40,48,48,48,48,48,16,16,12,12,12,12,60,12,12,60,16,16,40,40,40,40,48,48,48,48,40,40,48,48,48,48,48,40,0,0,0,0
	dc.b	36,44,44,44,52,52,16,40,48,48,16,12,4,4,4,48,48,48,48,48,40,36,24,28,32,24,40,48,48,48,48,48,48,48,48,48,48,48,48,16,16,16,12,12,4,4,4,4,4,4,12,12,12,16,16,16,48,48,48,40,40,40,36,36,0,0,0,0
	dc.b	36,40,40,40,48,48,48,48,16,16,12,12,4,4,12,4,4,4,4,4,4,12,12,16,16,16,48,48,48,48,48,48,48,48,48,40,40,40,36,36,24,24,36,40,40,48,48,48,40,12,4,12,12,16,48,48,40,40,40,36,36,36,36,36,0,0,0,0
	dc.b	48,48,48,48,40,40,40,48,48,40,48,48,40,40,40,40,52,52,52,52,52,12,52,52,12,12,12,16,48,48,48,48,40,36,36,36,40,48,36,24,36,36,36,40,40,48,48,40,40,48,4,4,12,48,48,48,48,40,40,36,36,36,36,36,0,0,0,0
	dc.b	36,40,40,40,48,40,40,40,48,48,48,48,48,40,40,48,48,48,48,40,40,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,40,48,36,24,36,36,36,40,48,48,48,40,40,40,12,4,12,16,48,48,48,48,40,36,36,36,36,36,0,0,0,0
	dc.b	36,36,24,24,36,36,36,36,40,40,40,40,48,48,48,48,48,48,48,48,48,48,40,40,40,40,40,40,40,36,36,36,36,36,36,36,40,40,36,24,24,36,40,40,40,48,48,48,48,40,40,4,4,16,48,48,48,40,40,40,40,36,36,36,0,0,0,0
	dc.b	36,40,40,24,28,28,28,28,24,24,36,36,40,40,40,48,48,48,48,48,48,48,48,48,48,48,40,48,40,40,40,40,40,36,40,40,40,40,36,36,36,24,40,48,48,48,48,48,48,40,40,40,4,12,16,48,48,40,40,40,40,36,36,36,0,0,0,0
	dc.b	48,48,48,48,36,28,32,32,32,28,28,24,36,36,36,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,40,40,40,36,36,36,36,24,24,40,48,48,48,48,48,40,40,40,60,4,16,48,48,48,48,40,36,36,36,36,0,0,0,0
	dc.b	48,40,48,48,48,40,24,28,24,24,24,24,36,36,36,36,40,40,40,40,40,40,16,16,16,16,48,48,48,48,48,48,48,48,48,40,36,36,36,36,36,36,24,36,16,48,48,48,48,48,40,40,36,12,12,16,48,48,40,40,40,36,36,36,0,0,0,0
	dc.b	40,40,40,40,48,48,48,40,40,40,36,36,36,36,36,36,24,36,36,36,36,36,36,36,40,36,36,36,36,36,40,48,40,40,40,40,36,40,40,36,36,36,36,24,44,12,16,48,48,48,40,40,40,40,4,16,48,48,48,40,36,36,36,40,0,0,0,0
	dc.b	40,40,40,40,48,48,40,36,36,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,28,28,24,24,28,24,40,48,40,40,40,36,40,36,36,36,36,24,52,12,48,48,48,48,40,40,36,52,16,48,48,48,48,40,36,36,36,0,0,0,0
	dc.b	40,40,48,40,40,48,48,36,36,36,40,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,24,28,24,24,28,28,24,36,40,48,48,40,36,36,36,36,36,24,36,52,12,48,48,48,40,40,36,36,40,48,48,48,40,40,40,40,40,0,0,0,0
	dc.b	40,40,48,48,48,48,16,36,36,36,36,36,40,48,40,36,40,36,36,36,36,36,36,36,36,36,24,24,24,24,24,28,28,28,28,24,24,40,48,40,36,36,36,36,36,36,36,12,48,48,48,40,40,40,36,36,40,48,48,48,48,40,40,48,0,0,0,0
	dc.b	48,40,48,48,48,48,40,36,36,36,40,36,40,48,40,40,36,36,40,40,40,40,40,40,40,36,36,36,36,24,24,24,24,28,28,28,32,24,40,40,40,36,36,36,36,28,28,44,16,48,48,40,40,40,36,36,36,40,40,52,48,48,48,48,0,0,0,0
	dc.b	48,48,48,48,16,16,40,36,40,40,48,40,40,48,48,40,48,48,48,40,40,36,36,36,24,24,24,24,24,24,24,24,24,24,28,28,32,32,24,36,36,24,24,24,24,28,24,24,52,48,48,40,40,36,36,36,36,36,36,36,40,48,48,48,0,0,0,0
	dc.b	48,16,16,12,12,40,36,40,40,40,40,40,48,48,48,40,40,36,36,24,24,28,28,32,32,32,28,28,28,28,28,28,28,28,28,28,28,32,28,24,36,36,24,24,24,24,28,28,52,48,48,48,40,40,40,40,36,36,36,40,40,40,36,28,0,0,0,0
	dc.b	16,12,4,12,40,48,40,48,48,48,48,48,48,40,36,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,32,28,24,36,36,36,24,28,28,28,40,48,48,40,40,40,40,40,40,40,40,40,36,24,28,32,0,0,0,0
	dc.b	4,4,52,40,40,48,40,48,48,48,48,16,52,24,24,24,28,28,24,24,24,24,24,24,28,28,28,28,28,28,28,32,28,28,28,28,28,28,28,28,28,24,24,24,28,28,28,28,40,48,40,40,40,36,36,40,40,36,24,24,24,28,28,24,0,0,0,0
	dc.b	4,52,40,48,48,48,48,48,48,48,16,52,24,28,28,24,24,24,24,24,24,24,28,24,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,28,28,24,24,28,28,28,24,48,40,40,40,36,36,36,36,24,24,24,24,24,24,24,36,0,0,0,0
	dc.b	40,40,48,48,48,48,48,48,16,16,40,36,36,36,24,24,24,24,36,36,24,24,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,28,28,36,48,48,40,36,36,36,36,24,24,24,36,36,36,36,36,40,0,0,0,0
	dc.b	40,48,48,48,48,48,48,16,16,40,36,36,36,36,36,36,36,36,36,24,28,28,28,32,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,24,40,48,40,36,36,36,36,36,36,24,36,36,48,40,40,40,40,0,0,0,0
	dc.b	48,48,48,48,48,48,48,16,36,36,36,36,36,36,36,40,36,36,36,28,32,32,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,32,28,36,40,40,36,36,36,36,36,36,24,36,40,48,48,48,48,48,40,0,0,0,0
	dc.b	40,48,48,48,48,48,40,36,36,36,36,36,36,36,40,40,40,36,28,32,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,32,28,24,36,36,36,36,36,36,36,36,36,36,52,48,48,48,48,48,48,48,0,0,0,0
	dc.b	40,48,40,40,40,40,36,24,36,36,36,36,36,40,40,40,40,24,32,28,28,28,28,32,28,32,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,24,36,36,24,36,36,36,36,24,24,36,16,16,48,48,48,48,48,48,40,0,0,0,0
	dc.b	40,36,36,36,36,36,24,36,36,36,36,40,36,40,40,48,36,28,28,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,32,28,24,24,24,36,24,24,24,24,36,36,24,36,16,48,48,48,48,48,48,48,48,40,0,0,0,0
	dc.b	36,36,36,36,36,24,36,36,36,36,36,36,40,40,48,48,36,24,28,28,24,24,24,28,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,28,28,24,24,24,24,24,24,28,28,28,24,40,16,48,48,48,48,48,40,48,40,16,4,0,0,0,0
	dc.b	28,28,24,24,24,36,36,40,40,36,40,40,36,40,40,40,28,32,28,24,24,24,24,24,28,32,28,28,28,32,28,28,32,28,28,28,28,28,28,28,24,24,24,24,28,28,28,28,24,24,36,52,16,48,48,48,48,40,40,40,40,16,4,4,0,0,0,0
	dc.b	32,28,24,36,36,40,40,40,40,40,40,40,40,48,48,40,28,28,28,24,36,36,24,24,28,32,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,36,48,48,48,48,40,40,40,40,40,40,12,12,16,16,0,0,0,0
	dc.b	28,36,40,40,40,40,36,36,40,40,40,40,48,48,48,40,28,28,24,24,24,24,36,36,24,28,32,28,28,28,28,28,28,28,28,28,28,28,32,32,32,28,28,28,24,36,36,40,40,48,48,48,40,40,40,40,40,36,36,12,12,48,16,48,0,0,0,0
	dc.b	40,48,48,40,36,36,36,36,36,40,40,40,48,48,48,52,24,24,24,24,24,24,36,36,36,28,32,32,28,24,24,24,24,24,24,24,24,24,24,24,24,36,36,40,48,40,40,40,40,48,48,40,36,40,40,36,36,36,48,48,48,48,48,40,0,0,0,0
	dc.b	48,48,48,48,40,40,40,36,36,40,40,40,40,48,48,16,44,28,24,36,36,36,36,40,40,40,24,32,28,28,28,24,24,24,24,24,24,36,36,40,40,40,40,40,40,40,36,36,36,40,40,40,36,36,36,36,36,40,48,48,48,40,40,40,0,0,0,0
	dc.b	48,40,40,48,48,48,48,40,36,40,40,40,40,48,48,48,60,36,36,36,36,36,36,40,40,48,40,36,24,28,28,28,28,24,24,24,24,24,36,36,36,36,36,36,36,36,36,36,36,40,48,40,36,36,36,36,36,48,48,48,48,40,40,40,0,0,0,0
	dc.b	40,40,40,40,48,48,48,48,52,40,40,40,48,48,48,48,16,16,36,36,36,36,36,36,36,48,48,48,40,36,24,28,28,24,24,24,24,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,36,36,36,36,40,48,48,40,40,36,36,0,0,0,0
	dc.b	36,40,40,40,40,48,48,48,12,52,40,40,48,48,48,48,48,12,36,36,36,36,36,36,36,36,40,40,40,48,40,36,28,24,24,28,28,24,36,24,36,36,36,36,36,36,36,36,36,36,36,40,40,40,36,36,36,40,48,48,40,40,40,36,0,0,0,0
	dc.b	40,40,36,40,48,48,48,48,16,4,40,48,48,48,48,48,48,16,16,36,36,36,36,36,36,36,40,40,40,40,40,48,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,24,24,24,36,36,36,36,36,40,48,48,48,40,40,40,40,0,0,0,0
	dc.b	40,36,36,40,40,48,48,48,12,4,60,40,48,48,48,48,48,48,48,40,36,36,36,36,36,36,36,36,40,48,48,48,48,48,48,48,48,48,16,52,16,52,16,40,40,40,40,40,36,36,36,36,24,24,24,24,24,24,40,48,48,48,48,40,0,0,0,0
	dc.b	36,40,40,40,40,48,48,48,16,12,4,52,48,40,48,48,48,48,48,48,40,36,36,36,36,36,40,40,40,48,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,36,36,24,28,28,28,32,32,28,36,48,48,48,48,0,0,0,0
	dc.b	36,36,40,40,40,48,48,48,48,12,4,4,40,40,48,48,48,48,48,48,40,36,36,36,36,36,48,40,36,36,36,36,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,36,36,24,24,28,28,28,28,24,36,36,36,0,0,0,0
	dc.b	36,36,40,40,40,40,48,48,48,16,12,4,4,40,48,48,48,48,48,40,40,36,36,24,36,36,48,40,36,36,36,36,36,40,40,40,40,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,40,40,40,40,36,36,36,36,24,36,36,24,0,0,0,0
	dc.b	36,36,36,40,40,40,48,48,48,48,16,4,4,12,48,48,48,48,48,48,36,36,24,36,24,36,40,36,36,36,36,36,36,36,40,40,40,40,40,40,40,40,40,40,48,40,48,40,48,48,48,48,48,48,48,48,40,48,48,48,40,40,40,40,0,0,0,0
	dc.b	36,36,36,36,40,52,40,48,48,16,16,12,4,4,48,40,48,48,48,48,36,24,28,24,24,36,40,36,36,36,40,40,40,48,48,48,16,12,12,12,52,52,12,12,52,16,16,52,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,0,0,0,0
	dc.b	40,52,44,44,44,52,16,48,48,48,12,12,4,4,4,48,48,48,48,48,36,36,24,32,28,36,40,40,40,40,48,48,40,48,48,48,48,48,16,16,16,16,12,4,4,4,4,4,4,4,12,12,12,12,16,16,48,48,48,40,40,40,40,40,0,0,0,0
	dc.b	48,48,48,48,48,48,48,48,16,16,16,12,12,12,4,4,4,4,4,4,4,12,12,12,16,16,48,48,48,48,48,48,48,40,40,36,40,40,36,36,24,24,24,36,40,48,48,48,40,12,4,4,12,16,16,48,40,40,36,36,36,36,36,36,0,0,0,0
	dc.b	40,40,40,48,48,40,48,48,48,40,40,48,40,40,40,40,40,40,40,52,52,52,52,16,12,12,12,16,48,48,40,40,36,36,36,36,40,40,36,24,36,36,36,36,40,48,48,48,48,40,4,4,12,16,48,48,48,40,40,36,36,36,36,36,0,0,0,0
	dc.b	36,36,40,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,36,48,40,24,36,36,36,36,40,48,48,48,40,40,52,8,4,16,48,48,48,40,40,40,36,36,36,36,0,0,0,0
	dc.b	24,24,24,24,24,36,36,36,36,40,40,40,48,48,48,48,48,48,48,48,48,40,40,40,48,40,40,40,40,40,40,36,36,36,36,36,36,40,36,24,24,36,40,40,48,48,48,48,48,48,40,60,4,12,16,48,48,40,40,40,40,36,36,36,0,0,0,0
	dc.b	36,36,24,28,32,28,28,28,28,24,24,36,36,40,40,40,48,48,48,48,48,48,48,48,48,48,48,40,48,40,40,40,36,36,36,40,40,40,36,36,36,24,36,40,48,48,48,48,48,40,48,40,60,4,16,48,48,48,40,40,40,40,36,36,0,0,0,0
	dc.b	48,48,48,40,24,32,32,32,28,28,28,24,24,36,36,36,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,48,40,40,40,40,36,36,36,36,36,36,36,16,48,48,48,48,48,48,40,52,4,12,16,48,48,40,40,40,40,36,36,0,0,0,0
	dc.b	40,48,48,48,48,40,36,24,36,24,24,36,36,36,36,36,36,36,36,40,40,40,52,52,16,16,16,48,48,48,48,48,48,48,40,40,40,36,36,36,36,36,24,24,52,16,48,48,48,48,48,40,40,52,4,16,48,48,40,40,36,36,36,40,0,0,0,0
	dc.b	40,48,40,48,48,48,40,40,40,40,40,36,36,24,36,24,36,36,36,36,36,36,36,36,36,36,36,24,24,36,40,40,40,40,40,40,40,36,36,36,36,36,36,36,36,52,12,48,48,48,40,40,40,40,12,16,48,48,48,40,36,36,36,40,0,0,0,0
	dc.b	40,48,40,48,48,48,36,36,40,40,40,48,40,36,36,36,36,36,36,36,36,36,36,36,24,36,36,24,28,24,24,28,24,36,40,40,40,40,40,40,36,36,36,36,36,36,12,16,48,48,40,40,40,40,40,16,48,48,48,40,40,40,40,36,0,0,0,0
	dc.b	40,40,40,48,48,48,36,36,36,36,36,40,40,48,40,36,36,36,36,36,36,36,36,36,36,40,36,24,28,24,24,28,32,28,36,36,40,40,40,40,40,36,36,36,36,24,44,12,48,48,48,48,40,36,36,36,48,48,48,48,48,40,40,40,0,0,0,0
	dc.b	40,40,40,48,48,48,36,36,36,36,36,36,40,48,40,36,40,40,40,40,40,40,40,40,40,36,36,24,24,24,24,28,28,28,28,28,24,36,48,40,36,36,36,36,36,36,36,60,16,48,40,48,40,40,36,36,36,40,48,48,48,48,48,48,0,0,0,0
	dc.b	48,48,48,48,48,16,36,36,36,36,40,40,40,48,40,36,36,40,40,48,48,48,40,40,40,36,36,36,36,36,24,24,24,28,28,28,32,28,36,40,40,36,36,36,36,24,24,24,12,48,48,40,40,40,40,36,36,36,36,40,40,48,48,48,0,0,0,0
	dc.b	48,48,48,48,16,40,36,40,40,40,40,40,40,48,48,40,48,40,40,40,36,36,24,24,24,24,24,24,24,24,24,28,28,24,24,28,32,32,28,36,36,36,24,24,24,28,28,28,52,48,48,48,40,40,36,36,36,36,36,36,36,40,48,48,0,0,0,0
	dc.b	16,16,16,16,16,36,40,40,40,48,48,48,48,48,48,36,36,36,24,24,28,28,28,32,32,32,28,28,28,28,28,28,28,28,28,32,32,32,28,28,24,36,24,24,24,24,24,24,36,48,48,40,40,40,36,40,36,36,36,40,40,48,36,36,0,0,0,0
	dc.b	12,12,12,52,40,40,48,40,48,48,48,48,48,40,36,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,32,32,28,28,32,28,28,24,36,36,36,24,28,28,32,36,48,48,40,40,40,40,40,40,48,48,40,36,36,24,28,0,0,0,0
	dc.b	8,4,40,40,48,40,48,48,48,48,16,16,44,24,28,24,24,24,24,24,24,24,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,24,36,24,28,28,28,36,48,48,40,40,36,40,40,40,36,36,24,24,24,28,28,0,0,0,0
	dc.b	12,48,48,48,48,48,48,48,48,16,16,40,24,24,24,28,24,24,36,24,24,24,28,28,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,28,28,24,24,28,28,28,24,40,48,48,40,36,36,36,36,36,36,24,24,36,36,24,24,0,0,0,0
	dc.b	48,40,48,48,48,48,48,16,16,52,36,36,36,36,36,24,24,36,36,24,24,24,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,24,24,28,28,28,24,48,40,40,40,36,36,36,36,36,24,24,36,36,36,36,36,0,0,0,0
	dc.b	48,48,48,48,48,48,48,12,52,36,36,36,36,36,36,36,36,36,36,24,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,32,28,28,28,28,28,28,36,48,40,40,40,36,36,36,36,24,24,36,36,40,40,40,40,0,0,0,0
	dc.b	48,48,48,48,48,48,48,52,36,36,36,36,36,36,40,40,40,36,24,28,32,32,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,32,32,28,24,40,40,40,36,36,36,36,36,24,24,40,48,48,48,48,48,40,0,0,0,0
	dc.b	48,48,48,48,48,48,40,36,36,36,36,36,36,40,40,40,40,36,28,32,32,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,32,28,32,28,24,36,40,40,36,36,36,36,36,24,24,40,16,48,48,48,48,48,48,0,0,0,0
	dc.b	40,40,40,40,40,36,36,36,36,36,36,36,40,40,40,48,36,24,28,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,32,28,28,24,36,36,36,36,36,36,36,36,24,36,52,16,16,48,48,48,48,48,48,0,0,0,0
	dc.b	40,36,36,36,36,24,24,36,36,36,36,40,40,40,48,48,24,28,28,28,24,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,24,24,36,24,24,24,36,36,36,36,36,52,16,48,48,48,48,48,48,48,48,0,0,0,0
	dc.b	24,24,36,36,24,24,36,36,36,36,36,40,40,40,40,48,24,28,28,28,24,24,28,28,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,28,28,24,24,24,36,24,24,28,28,24,24,36,16,16,48,48,48,48,40,40,40,48,12,0,0,0,0
	dc.b	28,24,24,24,36,36,36,40,40,40,40,40,40,40,48,36,32,28,28,24,24,24,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,24,24,24,24,28,24,24,24,28,24,36,16,48,48,48,48,48,40,40,40,40,4,4,0,0,0,0
	dc.b	28,24,36,36,40,48,48,40,40,40,48,48,40,40,48,24,28,28,24,24,36,36,24,24,28,28,28,28,28,32,28,28,28,28,28,28,28,28,28,32,28,28,28,28,28,28,28,28,24,36,40,48,48,48,40,40,48,40,40,36,16,12,12,12,0,0,0,0
	dc.b	36,36,40,40,40,36,36,36,36,40,40,40,48,48,48,36,24,24,24,24,24,24,36,36,28,28,28,28,28,28,24,28,28,28,28,28,28,28,28,28,32,28,28,28,24,24,36,36,40,40,48,48,48,40,40,40,40,36,36,52,12,16,16,16,0,0,0,0
	dc.b	48,48,40,36,36,36,36,36,36,40,40,40,48,48,48,52,28,28,24,24,24,36,36,40,36,28,32,32,28,24,24,24,24,24,24,24,24,24,24,24,24,36,36,36,40,40,40,40,48,48,40,40,40,40,40,40,36,36,40,48,48,48,48,40,0,0,0,0
	dc.b	48,48,48,40,40,36,36,36,36,40,40,40,48,48,48,16,24,24,36,36,36,36,40,40,48,36,28,32,28,28,24,24,24,24,24,24,36,36,36,36,40,40,40,40,40,40,40,40,40,40,48,40,36,36,36,36,36,36,48,48,40,48,48,48,0,0,0,0
	dc.b	40,48,48,48,48,48,40,40,36,36,40,48,48,48,48,16,52,36,36,36,36,36,36,36,40,48,40,24,24,28,28,28,24,24,24,24,24,36,40,40,40,40,40,40,40,40,36,36,36,48,48,36,36,36,36,36,36,36,48,48,48,40,40,40,0,0,0,0
	dc.b	40,40,40,48,48,48,48,48,40,40,40,48,48,48,48,48,16,52,36,24,36,36,36,40,40,48,48,40,40,24,28,28,28,24,24,24,24,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,36,36,36,36,36,48,48,48,40,40,36,0,0,0,0
	dc.b	40,40,40,40,48,48,48,48,12,40,40,40,48,48,48,48,16,12,36,24,36,36,36,36,40,40,40,40,48,40,36,24,28,24,24,28,24,36,36,24,36,36,36,36,36,36,36,36,36,36,36,40,48,40,36,36,36,36,48,48,48,40,40,36,0,0,0,0
	dc.b	40,40,40,40,40,48,48,48,12,12,40,40,48,48,48,48,48,16,52,36,36,36,36,36,40,40,40,40,40,40,40,40,40,40,36,24,24,36,36,36,36,36,24,36,36,36,36,36,24,36,36,36,36,36,40,40,40,40,48,48,48,40,40,40,0,0,0,0
	dc.b	40,36,40,40,40,40,48,16,16,4,52,48,48,48,48,48,48,48,48,40,36,36,36,36,36,36,40,40,40,40,48,48,48,48,48,48,48,16,16,16,52,52,40,40,40,40,36,36,36,36,36,36,36,24,24,36,36,36,40,48,48,48,48,40,0,0,0,0
	dc.b	40,40,40,40,48,48,48,48,16,4,4,40,48,40,48,48,48,48,48,48,36,36,36,36,36,36,40,40,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,36,36,36,36,24,28,28,28,32,32,32,24,40,48,48,48,0,0,0,0
	dc.b	36,40,40,40,40,48,48,48,16,12,4,12,40,48,48,48,48,48,48,48,40,36,36,36,36,40,40,40,40,40,36,36,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,36,36,24,24,28,28,28,28,32,28,24,36,36,0,0,0,0
	dc.b	36,36,40,40,40,48,48,48,48,16,12,8,12,48,48,48,48,48,48,40,40,36,36,36,36,36,40,40,36,36,36,36,36,40,40,40,40,40,48,48,40,40,40,48,48,48,48,48,48,48,48,48,40,40,40,36,36,36,36,24,28,24,36,24,0,0,0,0
	dc.b	36,36,36,36,40,40,48,48,48,16,12,4,8,16,48,48,48,48,48,40,36,36,36,36,36,40,40,40,36,36,36,36,36,36,36,36,36,40,40,40,48,40,40,40,48,48,40,40,48,48,48,48,48,48,48,40,40,40,40,40,40,40,36,36,0,0,0,0
	dc.b	36,36,44,40,40,52,16,48,48,16,16,12,4,4,48,48,48,48,48,40,36,24,24,24,24,36,40,36,36,36,36,40,40,40,48,48,16,12,12,12,52,52,52,52,40,40,48,48,40,48,48,48,48,48,48,48,48,48,48,48,48,40,40,48,0,0,0,0
	dc.b	40,44,44,52,52,52,52,48,48,16,12,12,4,8,12,48,48,48,48,40,36,24,28,28,24,36,40,36,36,36,40,48,48,48,48,48,48,48,16,12,12,12,4,4,4,4,4,4,4,12,12,12,16,16,16,16,48,40,48,48,48,48,48,40,0,0,0,0
	dc.b	40,48,48,48,48,48,48,40,16,16,16,12,12,12,12,4,4,4,4,4,4,4,12,12,12,16,16,48,48,48,48,48,40,36,36,36,36,40,36,24,36,24,24,36,40,48,48,40,40,16,8,4,16,16,48,48,48,40,36,36,36,36,36,36,0,0,0,0
	dc.b	48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,40,40,40,40,52,16,52,40,40,40,40,36,36,36,36,36,36,40,40,36,36,36,36,36,40,48,48,48,40,40,12,4,12,16,48,48,40,48,40,40,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,36,36,36,40,40,36,36,36,40,36,40,48,48,48,48,48,40,4,4,16,48,48,48,40,40,40,40,36,36,36,0,0,0,0
	dc.b	28,28,28,28,24,24,24,24,36,36,36,40,40,40,48,48,48,48,48,48,48,48,40,40,48,40,40,40,40,40,40,36,36,36,36,36,36,40,40,36,36,24,36,40,48,48,48,48,48,40,40,52,4,12,16,48,48,40,40,40,40,40,36,36,0,0,0,0
	dc.b	36,36,28,32,32,32,32,32,28,28,24,24,36,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,40,40,36,40,36,36,40,40,40,40,36,24,36,36,40,48,48,48,48,48,40,48,40,52,4,16,48,48,48,40,40,40,36,36,36,0,0,0,0
	dc.b	48,48,40,24,28,28,28,28,28,28,24,24,36,36,36,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,40,36,36,36,36,36,36,52,48,48,48,48,48,40,40,40,12,4,16,48,48,48,40,36,36,36,40,0,0,0,0
	dc.b	48,48,48,48,40,40,40,36,36,36,36,36,36,24,36,36,36,36,36,36,40,40,40,40,52,52,16,16,48,40,48,48,48,40,40,40,40,36,36,36,36,36,36,24,36,12,48,48,48,48,48,48,40,40,4,12,48,48,48,40,36,36,40,36,0,0,0,0
	dc.b	40,40,48,48,48,40,40,40,48,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,24,24,36,36,40,40,40,40,40,40,36,36,36,36,36,36,36,44,12,16,48,48,48,40,40,40,52,12,48,48,40,40,40,40,36,36,0,0,0,0
	dc.b	40,40,48,48,48,40,36,36,36,36,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,24,28,24,24,28,24,40,48,48,40,40,40,36,36,36,36,36,24,60,12,48,48,48,48,40,36,36,52,48,48,48,48,40,40,40,40,0,0,0,0
	dc.b	40,40,48,48,48,52,36,36,36,36,36,40,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,24,28,28,24,24,28,28,24,36,40,40,40,40,36,36,36,36,36,36,36,12,16,48,48,48,40,40,40,36,40,48,48,48,48,40,40,40,0,0,0,0
	dc.b	48,40,48,48,16,40,36,36,36,36,36,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,36,24,24,24,24,24,28,28,28,28,24,36,40,48,40,36,40,36,36,36,36,52,12,48,48,48,40,40,40,36,36,36,40,40,48,48,48,48,0,0,0,0
	dc.b	48,48,48,48,48,40,36,36,36,40,40,40,40,40,40,40,40,40,48,48,48,40,40,40,36,36,36,36,36,36,24,24,24,28,28,28,28,28,36,40,40,36,36,36,36,36,24,24,60,16,48,48,40,40,40,36,36,36,36,36,36,40,48,48,0,0,0,0
	dc.b	48,48,48,48,48,40,36,40,40,40,40,40,40,48,48,40,40,40,40,40,36,24,24,24,24,24,24,24,24,24,24,28,24,28,28,28,28,32,28,36,36,36,24,24,24,24,28,28,44,16,48,48,40,40,36,36,36,36,36,36,36,40,40,48,0,0,0,0
	dc.b	12,16,16,12,40,40,40,40,48,40,40,48,48,48,40,36,24,24,28,28,28,28,28,32,28,28,28,28,28,28,28,28,28,28,28,28,32,32,28,28,36,36,36,24,24,24,24,24,24,48,48,48,40,40,40,40,36,36,36,40,40,40,40,36,0,0,0,0
	dc.b	12,4,12,40,40,48,40,48,48,48,48,48,48,36,24,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,32,32,28,28,32,32,28,24,36,36,36,24,24,28,28,24,48,48,48,40,40,40,40,40,40,40,40,40,36,24,28,0,0,0,0
	dc.b	4,16,40,48,48,48,48,48,48,48,16,16,36,28,28,24,24,24,24,24,24,24,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,24,36,24,28,28,32,24,48,48,40,40,40,40,40,40,40,36,36,24,24,24,28,0,0,0,0
	dc.b	52,40,48,48,48,48,48,48,48,12,52,36,36,36,24,24,24,24,36,24,24,24,28,28,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,28,28,24,24,28,28,28,24,36,48,48,40,36,36,36,36,36,36,24,24,24,24,24,24,0,0,0,0
	dc.b	48,40,48,48,48,48,16,16,12,44,36,36,36,36,36,36,24,24,36,36,24,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,24,28,28,28,24,40,40,40,40,36,36,36,36,36,24,24,24,36,36,36,36,0,0,0,0
	dc.b	48,48,48,48,48,48,16,16,44,36,36,36,36,36,40,40,36,36,36,36,24,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,32,28,28,28,28,28,28,36,40,40,40,40,40,36,36,36,36,24,24,40,48,40,40,40,0,0,0,0
	dc.b	48,48,48,48,48,48,40,36,36,36,36,36,36,36,40,40,40,36,24,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,32,28,28,32,28,28,24,40,40,40,36,36,36,36,36,36,24,36,40,48,48,48,48,40,0,0,0,0
	dc.b	48,48,48,48,48,40,40,36,36,36,36,36,36,40,40,40,40,24,28,28,32,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,24,36,40,40,36,36,36,36,36,36,24,36,16,16,16,16,48,48,48,0,0,0,0
	dc.b	48,40,40,40,36,36,36,36,36,36,36,40,40,40,40,48,36,28,28,28,28,28,28,32,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,24,36,36,36,36,36,36,36,24,24,36,36,16,16,48,48,16,48,48,48,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,40,40,40,48,48,24,28,28,28,24,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,36,36,36,24,36,36,36,36,36,36,44,16,16,48,48,48,48,48,48,48,0,0,0,0
	dc.b	24,24,24,36,36,36,36,36,36,36,36,40,40,40,48,40,24,28,28,24,24,24,28,28,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,28,28,24,24,24,24,24,24,24,24,36,36,36,52,16,48,48,48,48,48,40,40,40,52,0,0,0,0
	dc.b	28,24,24,36,36,36,40,40,40,40,40,40,40,40,40,24,28,28,28,24,24,24,24,24,28,28,28,28,28,28,28,32,28,28,28,28,28,28,28,28,28,24,24,24,24,24,24,24,24,28,28,24,16,48,48,48,48,48,40,40,40,40,52,4,0,0,0,0
	dc.b	28,24,36,40,40,40,40,40,40,40,40,48,40,40,40,28,28,28,24,24,36,36,36,24,28,32,32,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,40,48,48,48,48,48,48,40,40,40,40,12,4,12,0,0,0,0
	dc.b	36,40,40,40,40,36,36,36,40,40,40,48,48,48,48,24,24,24,24,24,24,36,36,36,28,32,28,28,28,28,28,28,28,28,28,28,28,28,28,32,32,28,28,28,28,28,24,24,36,40,48,48,48,40,40,40,40,40,36,40,16,12,48,16,0,0,0,0
	dc.b	48,40,40,36,36,36,36,36,40,40,40,48,48,48,48,36,28,24,24,36,36,36,36,40,36,28,32,28,28,24,24,24,28,28,24,24,24,24,24,24,28,24,24,36,40,40,40,40,40,48,48,40,40,40,40,40,36,36,36,40,48,48,48,48,0,0,0,0
	dc.b	48,48,40,36,36,36,36,36,40,40,40,48,48,48,16,52,24,36,36,36,36,36,40,48,48,36,28,28,28,28,24,24,24,24,36,36,36,36,36,36,40,40,48,48,40,40,40,40,36,40,48,40,40,40,40,36,36,36,40,48,48,48,48,40,0,0,0,0
	dc.b	48,48,48,48,40,40,36,36,36,40,40,48,48,48,48,12,44,36,36,36,36,40,40,48,40,40,36,24,28,28,28,28,24,24,24,24,24,36,40,48,40,40,36,36,40,40,40,36,40,40,48,40,36,36,36,36,36,36,40,48,48,48,40,40,0,0,0,0
	dc.b	40,40,48,48,48,48,48,48,36,40,48,48,48,48,48,16,12,36,36,36,36,36,36,40,40,48,48,40,36,28,28,28,24,24,28,24,24,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,36,36,36,36,36,36,36,48,48,40,40,40,0,0,0,0
	dc.b	40,40,40,40,48,48,48,48,16,40,40,40,48,48,48,48,16,52,36,24,36,36,40,36,40,40,40,48,48,48,24,28,24,24,28,24,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,36,36,36,36,40,48,48,48,40,40,0,0,0,0
	dc.b	40,40,40,40,48,48,48,48,4,52,48,48,40,48,48,48,16,12,40,36,36,36,36,36,36,36,40,48,40,40,48,40,36,36,24,24,36,36,36,24,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,48,40,40,40,48,48,48,40,40,0,0,0,0
	dc.b	40,40,40,40,48,48,48,16,12,4,40,48,48,48,48,48,48,48,40,36,36,36,36,36,36,36,40,48,40,48,48,40,48,48,48,40,16,16,52,52,44,52,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,40,48,48,48,40,0,0,0,0
	dc.b	40,40,40,40,40,48,48,48,12,4,12,40,48,48,48,48,48,48,48,40,36,36,36,36,36,36,40,48,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,36,36,36,24,24,28,28,28,28,28,28,24,40,48,48,0,0,0,0
	dc.b	36,40,40,40,40,48,48,48,16,12,8,52,40,48,48,48,48,48,48,48,40,36,36,36,36,40,48,40,40,36,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,36,24,24,28,28,32,32,32,32,32,28,36,36,0,0,0,0
	dc.b	36,36,40,40,40,48,48,48,48,16,4,4,52,48,48,48,48,48,48,48,40,36,36,36,36,40,48,40,36,36,36,36,40,40,40,40,48,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,36,36,24,24,36,24,28,28,28,28,0,0,0,0
	dc.b	36,36,36,40,40,40,48,48,48,16,12,4,4,48,48,48,48,48,48,40,36,36,36,36,36,40,48,36,36,36,36,36,36,36,36,36,40,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,40,52,16,16,48,48,48,16,12,8,12,48,48,48,48,48,40,36,24,24,24,36,40,40,36,36,36,36,36,36,40,40,40,52,52,52,52,40,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,40,40,48,48,48,48,0,0,0,0
	dc.b	36,44,44,52,52,52,16,48,16,16,16,16,4,4,16,48,48,48,48,40,36,28,28,24,24,40,40,36,36,36,36,40,48,48,48,48,48,16,16,16,12,12,4,4,4,4,4,4,4,12,12,12,12,16,16,16,48,48,48,48,48,48,40,40,0,0,0,0
	dc.b	48,48,48,48,48,48,48,48,16,16,16,16,12,12,60,60,4,4,4,4,4,12,12,12,12,16,16,48,48,48,40,40,36,24,36,36,36,40,40,24,36,36,24,36,40,48,48,48,48,48,4,4,12,48,48,48,48,40,40,36,36,36,36,36,0,0,0,0
	dc.b	40,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,40,48,40,40,40,40,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,40,40,36,24,24,36,36,40,40,48,48,48,40,16,8,12,16,48,48,48,40,40,40,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,40,40,36,40,40,48,48,48,48,48,48,48,48,48,48,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,36,36,40,48,36,36,36,36,40,36,40,48,48,48,48,48,12,4,12,48,48,48,48,40,40,40,40,36,36,0,0,0,0
	dc.b	32,32,32,28,28,28,24,24,36,36,36,36,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,36,36,36,36,36,36,40,40,36,36,36,36,40,48,48,48,48,48,48,40,40,12,4,16,48,48,48,40,40,40,40,40,36,0,0,0,0
	dc.b	24,28,32,32,32,32,32,32,28,28,24,24,36,36,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,36,40,40,40,40,40,36,36,36,36,36,48,48,48,48,48,48,40,40,40,4,4,16,48,48,48,40,40,36,36,36,0,0,0,0
	dc.b	48,40,36,24,24,24,24,28,24,24,24,24,36,36,36,36,40,40,48,48,48,16,16,16,16,16,48,48,48,48,48,48,48,40,40,40,48,40,36,36,36,36,36,36,44,16,48,48,48,48,48,40,40,52,4,12,48,48,40,40,40,36,36,36,0,0,0,0
	dc.b	48,48,48,48,40,48,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,44,52,40,16,40,40,40,48,48,48,48,40,40,36,36,36,36,36,36,36,36,52,16,48,48,48,48,40,40,40,60,12,48,48,48,40,40,40,40,36,0,0,0,0
	dc.b	48,48,48,48,40,36,36,40,40,48,40,40,36,36,36,36,36,36,36,36,36,36,36,36,24,36,36,36,24,28,24,36,36,40,40,40,40,40,40,40,36,36,36,36,36,36,12,16,48,48,48,48,40,40,40,12,48,48,40,40,40,40,40,36,0,0,0,0
	dc.b	40,48,48,48,40,36,36,36,36,36,40,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,24,24,24,24,28,28,36,48,48,48,40,40,36,36,36,36,36,36,44,4,16,48,48,48,40,40,36,40,48,48,48,48,48,40,40,40,0,0,0,0
	dc.b	40,48,48,48,52,36,36,36,36,36,36,40,48,40,40,36,36,40,40,36,36,36,36,36,40,36,36,36,24,24,24,24,28,28,28,24,36,40,48,40,40,40,36,36,36,36,36,52,12,48,48,48,40,40,40,36,36,40,40,48,48,48,48,48,0,0,0,0
	dc.b	48,40,48,48,52,36,36,36,36,36,40,40,40,48,40,36,36,40,40,40,40,40,40,40,40,40,36,36,24,24,24,24,24,28,32,28,24,24,40,48,40,40,40,36,36,36,36,36,12,16,48,48,40,40,40,36,36,36,36,36,40,40,48,48,0,0,0,0
	dc.b	48,48,48,48,48,36,36,36,40,40,40,40,40,48,48,40,40,40,48,48,48,40,40,40,36,36,36,36,36,36,24,24,24,24,28,28,28,28,24,40,40,40,40,40,36,36,36,36,44,12,48,48,40,40,36,36,36,36,36,36,36,36,40,48,0,0,0,0
	dc.b	16,48,48,16,40,36,36,40,40,40,40,40,48,48,48,40,40,40,36,36,36,24,28,28,28,28,24,24,24,24,28,28,24,24,24,28,28,28,28,24,40,36,36,36,36,24,24,24,24,16,48,48,40,40,36,40,36,36,36,36,36,36,40,48,0,0,0,0
	dc.b	16,16,12,16,36,40,40,48,40,48,48,48,48,48,40,36,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,36,36,36,24,24,24,24,24,28,40,48,48,48,40,40,40,40,36,36,40,40,40,40,40,0,0,0,0
	dc.b	12,4,16,40,40,48,48,40,48,48,48,16,52,36,24,24,24,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,32,32,28,24,24,24,24,24,24,24,28,28,36,48,48,48,40,40,40,40,40,40,40,40,36,36,24,0,0,0,0
	dc.b	4,40,40,40,48,48,48,48,48,16,16,52,24,28,28,28,24,24,24,24,24,24,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,24,36,36,24,28,28,28,40,48,40,40,40,40,40,40,40,40,36,36,24,24,28,0,0,0,0
	dc.b	48,40,48,48,48,48,48,48,12,12,52,36,36,36,24,24,24,36,36,24,28,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,24,24,28,28,28,24,48,48,40,40,36,36,36,24,36,36,24,24,24,24,24,0,0,0,0
	dc.b	48,48,48,48,48,48,16,12,52,36,24,36,36,36,36,36,24,36,36,36,24,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,24,24,28,28,28,36,48,48,40,40,36,36,36,36,36,24,24,36,36,36,36,0,0,0,0
	dc.b	48,48,48,48,48,16,16,52,36,36,36,36,36,36,40,40,36,36,36,36,24,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,28,28,24,40,48,40,40,40,36,36,36,36,24,24,36,40,40,40,40,0,0,0,0
	dc.b	48,48,48,48,48,48,40,36,36,36,36,36,36,40,40,40,40,36,24,24,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,32,32,28,28,24,36,40,40,36,40,36,36,36,36,36,36,40,48,48,48,48,48,0,0,0,0
	dc.b	48,48,48,48,40,40,36,36,36,36,36,40,40,40,48,40,36,24,28,32,32,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,24,36,40,40,40,36,36,36,36,36,24,36,40,48,48,16,48,48,48,0,0,0,0
	dc.b	40,40,48,40,36,36,36,36,36,36,36,40,40,40,48,40,36,24,28,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,24,36,36,36,40,40,36,36,36,24,24,36,52,16,48,48,48,48,48,48,0,0,0,0
	dc.b	36,36,36,36,24,24,36,36,36,36,36,40,40,48,48,40,24,28,28,24,24,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,24,36,36,36,36,36,36,36,36,36,24,36,16,16,16,48,48,48,48,48,48,0,0,0,0
	dc.b	24,24,24,24,36,36,36,36,36,36,36,48,40,40,48,36,28,28,28,24,24,28,28,28,28,28,28,28,28,32,32,32,32,32,32,32,28,28,28,28,28,28,28,24,24,36,24,24,24,36,36,36,36,44,16,16,48,48,48,48,48,48,48,40,0,0,0,0
	dc.b	24,24,24,36,36,40,40,48,40,40,40,40,40,48,40,28,28,28,28,24,36,24,24,28,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,24,24,24,24,24,24,24,28,28,24,52,16,48,48,48,48,40,48,40,40,52,12,0,0,0,0
	dc.b	24,36,36,40,40,40,40,40,40,40,48,48,40,48,36,28,24,24,24,36,36,24,24,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,24,24,24,24,24,40,48,48,48,48,48,40,40,40,40,16,12,12,0,0,0,0
	dc.b	40,40,40,40,36,36,36,40,40,40,40,48,48,48,40,24,28,24,24,24,36,36,36,36,28,32,28,32,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,36,36,48,48,48,40,40,40,40,36,36,36,16,12,16,48,0,0,0,0
	dc.b	48,40,36,36,36,36,36,36,40,40,40,48,48,48,52,24,24,24,24,36,36,36,40,36,24,28,28,28,28,24,24,24,28,28,24,24,24,24,28,28,28,28,24,36,36,36,40,40,40,48,48,48,40,40,40,40,40,36,36,40,48,48,48,48,0,0,0,0
	dc.b	48,40,36,36,36,36,36,36,40,40,48,48,48,48,16,52,36,36,36,36,36,40,40,40,40,24,28,28,24,28,24,24,24,36,36,36,36,36,36,36,40,40,40,48,48,40,40,40,40,40,40,40,40,40,40,36,36,36,36,40,48,48,48,40,0,0,0,0
	dc.b	48,48,40,40,40,36,36,40,36,40,48,48,48,48,16,12,36,36,36,36,36,40,40,40,48,40,24,24,24,28,28,24,36,24,24,24,36,36,40,40,40,40,40,40,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,40,48,48,40,40,0,0,0,0
	dc.b	48,48,48,48,48,48,40,40,40,40,40,48,48,48,48,12,52,36,36,36,36,36,40,40,40,48,48,40,24,28,28,24,24,24,24,24,36,36,36,36,36,36,36,36,36,36,36,36,36,40,48,40,36,36,36,36,36,36,36,40,48,40,40,40,0,0,0,0
	dc.b	40,40,40,48,48,48,48,48,40,40,40,48,48,48,48,16,12,36,36,36,36,36,36,40,40,40,48,48,40,36,28,28,24,24,24,24,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,36,36,36,36,36,36,40,48,48,40,40,0,0,0,0
	dc.b	40,40,48,40,48,48,48,48,12,40,40,40,48,48,48,48,12,52,36,36,36,36,36,40,40,40,40,40,40,40,40,40,36,24,28,24,36,36,36,24,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,40,40,36,36,40,48,48,48,40,0,0,0,0
	dc.b	36,40,40,40,48,48,48,16,4,12,40,48,48,48,48,48,16,16,40,36,36,36,36,36,36,40,40,40,48,48,40,48,48,40,40,40,40,52,52,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,40,48,48,48,48,0,0,0,0
	dc.b	40,36,40,40,48,48,48,16,12,4,16,48,48,48,48,48,48,48,48,40,36,36,36,36,36,40,40,40,40,40,40,48,48,48,48,48,48,48,16,16,16,16,16,48,48,40,40,40,40,36,36,36,24,24,24,24,28,24,24,24,36,36,40,48,0,0,0,0
	dc.b	40,40,40,40,48,48,48,48,16,4,4,40,48,48,48,48,48,48,48,40,36,36,36,36,40,40,40,40,40,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,36,36,24,28,28,28,32,32,32,32,32,32,28,24,0,0,0,0
	dc.b	36,40,40,40,40,48,48,48,48,12,4,4,48,48,48,48,48,48,48,40,36,36,36,36,36,40,48,40,40,36,36,36,36,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,36,36,36,24,24,24,28,28,28,28,28,0,0,0,0
	dc.b	36,36,40,40,40,40,48,48,48,16,12,4,12,48,48,48,48,48,48,36,36,36,36,36,36,40,40,36,36,36,36,36,36,36,36,40,40,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,40,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,40,52,16,16,48,48,16,12,4,8,16,48,48,48,48,48,36,36,24,24,24,36,40,40,36,36,36,36,36,36,36,36,40,40,40,40,40,40,40,40,48,48,48,48,40,48,48,48,48,48,48,48,48,48,48,48,40,40,48,40,40,0,0,0,0
	dc.b	36,44,44,52,52,52,16,16,48,48,16,12,4,4,48,48,48,48,48,40,24,28,28,24,36,40,40,36,36,36,36,36,40,40,48,48,48,16,12,12,12,12,12,4,4,4,12,12,12,12,12,12,16,16,16,48,48,48,48,48,48,48,48,48,0,0,0,0
	dc.b	48,48,48,48,48,48,48,16,48,48,16,16,16,52,16,16,12,12,12,12,12,12,60,60,12,12,16,48,48,40,36,36,36,36,36,36,36,40,40,36,24,36,24,36,36,40,48,48,48,40,4,4,12,16,48,48,40,40,40,40,36,36,36,24,0,0,0,0
	dc.b	40,40,48,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,40,36,36,36,36,36,36,36,36,36,36,40,40,36,24,36,36,36,36,40,48,48,48,48,40,4,4,16,16,48,48,40,40,40,40,36,36,36,0,0,0,0
	dc.b	24,24,24,24,36,36,36,36,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,40,36,36,36,36,36,36,36,36,40,40,36,36,24,36,40,40,40,48,48,48,48,48,52,4,12,16,48,48,40,40,40,40,40,36,36,0,0,0,0
	dc.b	32,32,32,32,28,28,28,28,24,36,36,36,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,36,36,36,36,36,40,40,36,36,36,36,40,48,48,48,48,48,48,48,40,52,4,12,16,48,48,40,40,36,36,40,36,0,0,0,0
	dc.b	32,32,32,32,32,32,32,32,28,28,28,24,36,36,36,40,48,48,48,48,48,48,48,48,48,48,48,48,48,40,48,48,40,40,40,40,40,40,40,36,36,36,36,24,40,48,48,48,48,48,48,48,40,60,4,16,48,48,40,40,40,36,36,36,0,0,0,0
	dc.b	48,40,40,36,36,36,36,24,24,36,36,24,36,36,36,36,40,40,40,40,40,16,16,16,16,16,16,48,48,48,48,48,48,48,48,40,40,40,36,36,36,36,36,36,36,16,16,48,48,48,48,48,48,40,12,12,48,48,48,40,40,36,36,36,0,0,0,0
	dc.b	48,48,48,40,40,40,40,40,36,36,36,36,36,36,36,24,36,36,36,36,36,36,36,36,36,36,40,40,40,40,40,48,48,48,48,40,40,40,36,36,36,36,36,36,24,36,16,16,48,48,48,48,40,40,40,12,48,48,48,40,40,40,36,40,0,0,0,0
	dc.b	48,48,48,40,40,36,40,40,40,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,28,28,24,36,36,40,40,40,40,40,40,36,36,36,36,36,36,52,12,48,48,48,40,40,40,40,52,48,48,48,48,48,40,40,40,0,0,0,0
	dc.b	48,48,48,52,36,36,36,36,36,36,40,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,24,24,28,24,24,28,24,40,48,48,40,40,40,36,36,36,36,36,36,60,12,48,48,48,48,40,40,36,40,40,48,48,48,48,40,40,0,0,0,0
	dc.b	48,48,48,48,36,36,36,36,36,36,36,40,48,48,40,40,40,40,40,40,40,40,40,40,40,40,36,36,24,24,24,24,24,28,28,24,36,40,48,48,40,40,36,36,36,24,24,44,4,16,48,48,48,40,40,36,36,36,40,40,48,48,48,48,0,0,0,0
	dc.b	40,48,48,16,36,36,36,36,36,36,40,40,48,48,40,36,40,40,40,40,40,48,48,48,48,40,36,36,36,24,24,24,24,28,32,28,24,24,36,48,40,40,40,36,36,36,36,36,60,16,48,48,40,40,40,36,36,36,36,36,36,36,40,48,0,0,0,0
	dc.b	48,48,48,16,36,36,36,36,36,40,40,40,40,48,48,40,40,40,48,48,40,40,40,40,36,36,36,36,36,36,24,24,24,24,28,28,28,28,24,40,48,40,36,36,36,36,36,36,36,12,48,48,40,40,40,36,36,36,36,36,36,36,36,40,0,0,0,0
	dc.b	48,48,48,48,40,36,36,40,40,48,48,40,48,48,48,40,36,36,36,36,24,24,28,28,28,28,28,24,24,24,28,28,28,24,24,28,28,28,28,24,40,40,36,36,36,24,24,24,28,44,16,48,40,40,40,40,36,36,36,36,36,36,40,48,0,0,0,0
	dc.b	48,12,16,40,40,40,40,48,48,48,48,48,48,40,36,24,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,36,36,36,24,24,24,28,24,24,48,48,48,40,36,40,40,36,36,36,40,48,40,40,0,0,0,0
	dc.b	4,12,40,40,40,40,48,48,48,48,16,16,44,24,24,24,24,24,24,28,24,24,28,28,28,28,28,28,28,28,28,28,28,32,32,28,28,28,28,28,28,36,36,36,36,24,24,24,24,24,48,40,48,48,40,48,40,40,40,48,40,40,36,24,0,0,0,0
	dc.b	12,40,48,48,48,48,48,48,48,16,16,40,36,24,24,24,24,24,36,36,24,24,28,24,28,28,28,28,28,28,28,28,28,28,28,28,32,28,28,28,28,24,24,36,36,24,24,28,32,36,48,40,40,40,40,40,40,40,40,36,36,24,24,24,0,0,0,0
	dc.b	48,40,48,48,48,48,16,16,16,52,36,36,36,36,36,24,24,36,36,36,28,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,24,24,28,28,28,28,40,48,40,40,40,36,36,36,36,36,24,24,24,24,24,0,0,0,0
	dc.b	48,48,48,48,48,16,16,12,52,36,36,36,36,40,36,36,36,36,36,36,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,32,28,28,24,28,28,28,24,36,48,48,40,40,36,36,36,36,36,36,24,24,36,36,36,0,0,0,0
	dc.b	48,48,48,48,48,16,16,44,36,36,36,36,36,40,40,40,40,36,36,24,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,28,24,24,40,48,40,36,40,36,36,36,36,36,24,36,40,40,40,40,0,0,0,0
	dc.b	48,48,48,48,48,48,40,36,36,36,36,40,40,40,40,48,48,36,24,24,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,28,24,36,40,40,40,36,40,36,36,36,36,36,36,40,48,48,48,48,0,0,0,0
	dc.b	48,48,48,48,40,36,36,36,36,36,40,40,36,40,48,40,36,24,28,28,32,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,24,36,40,40,40,36,36,36,36,36,36,24,36,48,48,48,16,48,48,0,0,0,0
	dc.b	40,40,40,36,36,36,36,36,36,36,36,40,40,48,48,40,24,28,28,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,24,36,36,36,40,40,36,36,36,36,24,24,40,16,16,48,48,16,48,48,0,0,0,0
	dc.b	36,36,36,36,24,36,36,36,36,36,36,40,40,48,48,36,24,28,28,24,24,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,24,36,36,36,36,36,36,36,36,36,36,52,16,16,48,48,48,48,48,40,0,0,0,0
	dc.b	24,24,36,24,36,36,36,36,40,40,36,40,40,48,48,24,28,28,28,24,24,28,28,28,28,28,28,28,28,32,32,32,32,32,32,28,28,28,28,28,28,28,28,24,36,36,36,24,24,36,36,36,24,36,52,12,16,48,48,48,48,48,40,40,0,0,0,0
	dc.b	24,24,24,36,40,40,40,40,48,40,40,40,40,40,36,28,28,24,24,24,24,24,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,24,24,24,24,24,24,28,24,24,24,40,16,16,48,48,48,48,40,40,40,40,12,0,0,0,0
	dc.b	24,36,40,40,40,40,40,40,40,40,48,48,48,40,24,28,24,24,36,36,36,36,24,24,24,28,28,28,28,32,32,28,28,28,28,28,28,28,28,28,24,28,28,28,28,28,24,24,24,28,24,40,16,48,48,48,48,48,40,40,40,40,12,12,0,0,0,0
	dc.b	40,40,40,40,36,36,36,40,40,40,48,48,48,48,36,28,24,24,24,24,36,36,36,36,24,28,32,28,28,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,36,36,40,48,48,48,40,40,40,40,40,36,40,16,12,48,0,0,0,0
	dc.b	40,40,36,36,36,36,36,40,40,40,40,48,48,48,36,24,24,24,36,36,36,40,40,40,24,28,28,28,28,24,24,24,28,28,24,24,24,28,28,28,28,28,24,24,36,36,36,36,40,48,48,48,40,40,40,40,40,36,36,40,48,48,48,48,0,0,0,0
	dc.b	40,36,36,36,36,36,36,36,40,40,40,48,48,48,16,36,36,36,36,36,40,40,40,48,36,24,28,24,28,28,24,24,24,24,36,36,36,36,36,36,36,40,40,48,48,48,48,48,40,48,48,40,40,40,40,36,36,36,36,36,16,48,48,40,0,0,0,0
	dc.b	40,40,36,36,36,36,36,36,40,40,48,48,48,48,16,52,36,36,36,36,36,40,40,40,48,36,24,24,28,28,28,24,24,24,24,36,36,36,40,40,40,40,40,40,40,40,40,36,40,40,40,40,40,40,36,36,36,36,36,36,52,48,48,40,0,0,0,0
	dc.b	48,48,48,48,40,40,40,40,40,40,40,48,48,48,16,12,40,36,36,36,36,40,40,48,40,48,40,36,24,28,28,24,24,24,24,24,36,36,40,40,40,40,40,40,40,40,40,40,36,40,48,48,40,36,36,36,36,36,36,36,48,48,48,40,0,0,0,0
	dc.b	48,40,48,48,48,48,48,40,40,40,40,48,48,48,48,12,52,36,36,36,36,36,40,40,40,40,48,48,40,24,28,36,24,24,24,24,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,36,36,36,36,36,24,36,52,48,48,48,0,0,0,0
	dc.b	40,40,48,48,48,48,48,16,16,40,48,48,48,48,48,16,12,52,36,36,36,36,36,40,40,40,40,48,40,40,40,36,24,28,28,36,36,36,24,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,40,40,36,36,36,40,48,48,48,0,0,0,0
	dc.b	40,40,40,40,48,48,48,16,12,52,48,48,48,48,48,16,16,16,36,36,36,36,36,40,40,40,40,40,40,48,48,48,48,40,40,40,40,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,40,40,48,48,48,0,0,0,0
	dc.b	40,36,40,40,40,48,48,16,12,12,40,48,48,48,48,48,48,16,40,36,36,36,36,36,36,40,40,40,48,48,48,48,48,48,48,48,48,16,12,16,16,16,16,16,40,40,40,40,36,36,36,36,36,24,24,24,24,36,36,36,36,40,40,48,0,0,0,0
	dc.b	40,40,40,40,40,48,48,48,12,4,60,40,48,48,48,48,48,48,48,40,36,36,36,36,36,40,48,40,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,36,36,24,24,28,28,32,32,32,32,32,32,32,32,0,0,0,0
	dc.b	36,40,40,40,40,48,48,48,16,12,8,12,48,48,48,48,48,48,48,40,36,36,36,36,40,48,48,40,40,36,36,40,36,40,40,48,40,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,36,36,24,24,28,28,28,28,32,32,32,32,0,0,0,0
	dc.b	36,40,40,40,40,48,48,48,48,12,4,4,16,48,48,48,48,48,40,40,36,36,36,36,36,48,40,36,40,36,36,36,40,40,36,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,36,36,36,24,24,24,24,0,0,0,0
	dc.b	36,36,40,52,52,40,48,48,48,16,16,4,4,48,48,48,48,48,48,36,36,24,36,36,36,48,40,36,36,36,36,36,36,36,36,36,40,40,40,40,40,40,48,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,48,40,48,40,40,0,0,0,0
	dc.b	36,44,44,52,52,12,12,48,48,48,12,12,4,4,48,48,48,48,40,36,24,28,24,36,36,40,40,36,36,36,36,36,36,36,40,48,48,16,12,12,12,12,12,12,12,12,16,16,16,16,16,16,16,16,48,48,48,48,48,48,48,48,48,48,0,0,0,0
	dc.b	48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,16,16,16,52,52,52,52,52,16,52,40,40,40,36,36,36,36,36,36,36,36,40,48,36,24,36,36,24,36,48,48,48,48,48,60,8,12,16,48,48,48,40,40,40,40,36,36,36,0,0,0,0
	dc.b	40,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,48,40,40,40,36,36,36,36,36,36,36,36,36,40,40,40,36,24,36,36,36,40,48,48,48,48,48,4,4,12,16,48,48,40,40,40,40,40,36,36,0,0,0,0
	dc.b	24,24,28,24,24,36,36,36,36,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,40,40,40,36,36,36,36,36,36,40,40,36,36,36,36,36,40,40,48,48,48,48,48,48,4,4,16,48,48,48,40,36,40,40,40,36,0,0,0,0
	dc.b	32,32,32,32,32,28,28,28,24,24,24,36,36,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,36,40,40,36,36,36,40,48,40,36,36,36,36,40,40,48,48,48,48,48,48,16,4,12,16,48,48,40,40,36,36,36,40,0,0,0,0
	dc.b	28,28,28,28,32,32,32,32,28,28,24,24,36,36,36,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,40,40,40,40,36,36,36,36,36,36,48,48,48,48,48,48,40,40,16,4,16,16,48,40,40,40,36,36,36,0,0,0,0
	dc.b	48,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,52,52,16,16,16,16,16,48,48,48,48,40,48,48,48,40,40,40,36,36,36,36,36,36,52,16,48,48,48,48,48,48,40,52,12,48,48,40,40,40,40,36,36,0,0,0,0
	dc.b	16,48,40,40,48,40,40,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,36,40,48,48,40,40,40,40,40,40,36,36,36,36,36,36,52,16,48,48,48,48,48,40,40,12,48,48,48,40,40,40,40,40,0,0,0,0
	dc.b	48,48,40,36,36,36,36,40,40,40,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,24,28,28,24,36,40,40,48,40,40,36,40,36,36,36,36,36,36,12,16,48,48,48,40,40,40,40,48,48,48,48,48,40,40,40,0,0,0,0
	dc.b	48,48,52,36,36,36,36,36,36,36,40,40,48,40,36,36,36,36,36,36,40,40,36,36,36,36,36,36,36,24,28,24,24,24,28,36,48,48,48,40,40,36,40,36,36,36,36,52,12,48,48,48,48,40,40,36,36,40,40,48,48,48,48,48,0,0,0,0
	dc.b	48,48,16,36,36,36,36,36,36,36,40,40,40,40,48,40,40,40,40,40,40,40,40,40,40,40,40,36,36,24,24,24,24,24,28,28,36,40,48,48,48,36,40,36,36,36,24,36,60,12,48,48,48,40,40,40,36,36,36,36,36,40,48,48,0,0,0,0
	dc.b	48,48,16,36,36,36,36,36,36,36,36,40,48,48,40,40,40,40,40,48,40,48,40,48,40,48,40,36,24,36,36,24,24,28,28,28,24,24,36,48,48,40,40,40,36,36,36,36,52,12,48,48,48,48,40,36,36,36,36,36,24,36,36,40,0,0,0,0
	dc.b	48,48,16,40,40,36,36,36,40,40,40,40,40,48,48,40,40,40,48,48,40,40,36,36,36,36,36,36,36,36,36,24,36,24,28,28,28,28,28,36,48,40,40,40,40,36,36,36,36,60,16,48,48,48,40,36,36,36,36,36,36,36,36,40,0,0,0,0
	dc.b	48,48,16,40,36,36,40,40,48,48,48,48,48,48,48,36,36,24,24,24,24,28,28,28,28,24,24,28,28,28,28,28,28,24,24,28,28,28,28,24,36,40,36,36,36,36,36,24,24,24,16,48,48,40,40,40,36,36,36,36,36,36,40,48,0,0,0,0
	dc.b	16,16,16,40,40,40,40,48,40,48,48,48,48,40,24,24,24,28,28,28,28,28,28,28,32,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,36,36,36,24,24,24,24,24,24,40,48,48,40,40,40,36,36,36,36,40,40,40,40,0,0,0,0
	dc.b	12,52,40,40,48,48,48,48,48,48,16,16,36,24,24,24,24,24,24,24,28,28,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,32,28,24,28,36,36,36,36,24,24,24,24,24,40,48,40,48,40,40,40,40,40,40,40,48,36,24,0,0,0,0
	dc.b	52,48,48,48,48,48,48,48,48,12,52,36,36,36,24,24,24,24,36,36,24,24,24,28,28,28,28,28,28,28,28,28,28,28,32,28,28,28,28,28,28,28,28,36,36,24,24,24,28,24,40,40,40,40,40,40,40,40,40,40,36,24,24,24,0,0,0,0
	dc.b	48,48,48,48,48,48,16,16,12,52,36,36,36,36,36,36,36,36,36,36,24,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,24,36,24,32,28,28,36,40,40,40,40,40,36,36,36,36,24,24,24,24,24,0,0,0,0
	dc.b	48,48,48,48,48,16,12,12,36,36,36,36,36,36,40,40,36,36,36,24,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,28,28,32,28,28,24,24,28,28,28,24,40,48,40,40,36,36,36,36,36,36,24,24,36,36,36,0,0,0,0
	dc.b	48,48,16,48,16,16,52,36,36,36,36,40,36,40,40,48,40,36,24,24,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,28,24,24,36,48,48,40,40,36,36,36,36,36,36,24,36,40,48,40,0,0,0,0
	dc.b	48,48,48,48,48,40,36,36,36,36,36,40,40,40,48,48,40,36,24,24,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,32,32,28,28,28,36,40,48,48,40,40,36,36,36,36,24,36,36,48,48,48,48,0,0,0,0
	dc.b	48,48,48,48,36,36,36,36,36,36,40,40,40,40,48,40,36,36,24,28,32,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,28,24,40,40,40,40,36,36,36,36,36,36,36,40,48,48,48,48,48,0,0,0,0
	dc.b	40,40,40,36,36,36,36,36,36,36,40,40,40,48,48,40,24,24,28,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,24,36,36,40,40,40,36,36,36,36,36,36,36,52,16,48,48,48,48,48,0,0,0,0
	dc.b	36,36,36,24,36,36,36,36,36,36,40,40,40,48,40,36,24,28,28,24,24,24,28,32,28,28,28,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,24,36,36,36,36,40,36,36,36,24,36,36,12,16,16,48,48,48,48,48,0,0,0,0
	dc.b	24,24,24,36,36,36,36,36,40,40,40,40,48,48,36,28,28,28,24,24,28,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,24,36,36,24,36,36,36,36,36,36,36,44,12,16,16,48,48,48,48,40,40,0,0,0,0
	dc.b	24,24,36,36,40,40,40,40,40,40,40,40,48,40,24,28,24,24,36,36,24,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,24,24,36,36,24,24,24,24,36,36,36,52,16,48,48,48,48,48,48,40,40,40,0,0,0,0
	dc.b	36,36,40,40,40,40,40,40,48,48,48,40,48,40,24,24,24,24,24,24,36,36,36,28,24,28,32,28,28,28,28,28,28,28,28,28,28,28,28,28,24,24,28,24,24,24,24,24,24,28,28,36,16,16,48,48,48,48,48,48,40,40,52,60,0,0,0,0
	dc.b	40,40,40,40,36,36,36,40,40,40,48,48,48,40,24,24,24,24,24,24,36,40,36,24,24,28,28,32,28,28,28,28,28,28,28,28,28,28,28,32,28,28,28,28,28,28,28,24,24,24,36,48,48,48,48,48,48,40,40,40,36,40,16,16,0,0,0,0
	dc.b	40,40,36,36,36,36,36,40,40,40,48,48,48,16,24,24,24,36,36,36,36,40,40,36,24,28,28,28,28,24,24,28,28,28,28,28,28,24,28,28,28,28,28,24,24,24,24,36,36,40,48,48,40,40,40,40,40,36,36,36,40,48,48,48,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,40,48,48,48,48,16,16,36,36,36,40,40,40,40,40,48,36,28,28,24,24,24,24,24,24,36,36,36,36,36,36,36,36,36,40,40,40,48,40,40,40,48,48,48,40,40,40,40,36,36,36,36,40,48,48,48,0,0,0,0
	dc.b	40,36,36,36,36,36,36,40,40,40,48,48,48,48,12,40,36,36,36,40,40,40,40,48,48,36,24,24,28,28,24,36,36,36,36,36,36,40,40,40,48,40,40,40,48,48,48,40,36,40,48,40,40,36,36,36,36,36,36,36,36,16,48,48,0,0,0,0
	dc.b	48,48,40,40,36,36,36,40,40,40,48,48,48,48,12,12,36,36,36,36,36,40,40,40,48,48,40,36,28,28,24,24,24,24,24,36,36,36,40,40,40,40,40,40,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,24,36,48,48,48,0,0,0,0
	dc.b	48,48,48,48,16,52,40,40,40,40,40,48,48,48,16,12,52,36,36,36,36,40,40,40,48,48,48,48,36,28,24,24,24,24,24,36,36,36,36,36,36,36,36,40,36,36,36,36,36,40,40,40,40,40,36,36,36,36,36,36,36,16,48,48,0,0,0,0
	dc.b	40,48,48,48,48,48,48,16,40,40,48,48,48,48,16,12,12,36,36,36,40,36,36,40,40,40,40,48,40,40,36,24,24,28,24,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,40,40,36,36,36,36,36,40,48,48,0,0,0,0
	dc.b	40,40,40,40,48,48,48,16,12,48,48,48,48,48,48,16,16,52,36,36,36,36,36,36,40,40,40,40,40,40,48,40,40,44,52,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,40,40,48,40,40,48,16,0,0,0,0
	dc.b	40,36,40,40,48,48,16,16,4,12,48,48,48,48,48,16,48,16,40,36,36,36,36,36,36,40,40,48,40,48,48,48,48,48,48,48,16,16,12,12,52,52,52,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,48,0,0,0,0
	dc.b	40,40,40,40,48,48,48,16,12,4,16,48,48,48,48,48,48,48,48,40,36,36,36,36,36,40,48,48,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,36,36,24,24,28,28,32,32,32,32,32,28,28,28,0,0,0,0
	dc.b	40,40,40,40,40,48,48,48,12,4,4,16,48,48,48,48,48,48,40,40,36,36,36,36,40,48,48,40,36,36,40,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,36,36,24,24,24,28,28,28,32,32,32,32,32,0,0,0,0
	dc.b	36,40,40,36,40,48,48,48,16,12,4,4,48,48,48,48,48,48,40,36,36,36,36,36,40,40,40,36,36,36,36,36,36,40,40,40,40,40,48,40,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,36,36,36,24,24,24,28,24,0,0,0,0
	dc.b	36,36,52,52,40,40,48,48,48,16,12,8,4,48,48,48,48,48,40,36,36,36,36,36,40,40,40,36,36,36,36,36,36,36,36,36,40,40,40,40,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,40,40,40,0,0,0,0
	dc.b	36,44,52,60,60,12,16,48,48,16,12,4,8,12,48,48,48,48,48,36,28,24,36,36,36,40,40,36,36,36,36,36,36,36,36,40,40,40,52,16,16,16,16,16,16,16,16,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,0,0,0,0
	dc.b	48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,48,40,40,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,36,36,40,40,40,24,36,36,24,36,40,40,48,48,48,16,4,4,12,48,48,48,40,40,36,40,40,36,36,0,0,0,0
	dc.b	36,36,36,36,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,36,36,36,36,36,36,36,36,36,40,40,40,36,36,36,36,36,36,48,48,48,48,40,12,8,12,16,48,48,40,40,40,36,36,40,36,0,0,0,0
	dc.b	28,28,28,24,24,24,24,36,36,36,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,40,40,36,36,36,36,36,40,48,48,36,36,36,36,40,40,48,48,48,48,48,40,12,4,12,48,48,48,40,40,36,36,40,36,0,0,0,0
	dc.b	32,32,32,32,32,32,32,32,24,24,24,36,36,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,40,40,36,36,40,40,40,40,36,36,36,36,40,48,48,48,48,48,48,48,40,12,4,12,48,48,40,40,40,36,36,36,0,0,0,0
	dc.b	24,28,28,28,28,28,28,28,24,24,24,24,36,36,36,40,40,48,48,48,16,16,16,16,48,48,48,48,48,48,48,40,40,40,40,40,40,40,40,36,36,36,36,36,36,40,48,48,48,48,48,48,40,40,4,12,48,16,48,40,40,40,36,36,0,0,0,0
	dc.b	48,48,40,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,52,52,52,52,16,16,48,48,48,48,48,48,48,40,40,40,40,36,36,36,36,36,36,36,16,48,48,48,48,48,48,40,40,12,48,48,48,48,40,40,40,36,0,0,0,0
	dc.b	40,40,40,40,40,40,40,40,48,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,36,36,40,40,40,40,40,40,40,40,36,36,36,36,36,36,52,16,16,16,48,48,48,40,40,40,48,48,48,48,48,40,40,40,0,0,0,0
	dc.b	16,40,36,36,36,36,36,40,40,40,40,48,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,24,28,28,24,36,40,40,40,40,40,40,36,36,36,36,36,36,60,16,48,48,48,40,40,40,40,40,40,48,48,48,48,48,48,0,0,0,0
	dc.b	48,16,36,36,36,36,36,36,36,36,40,40,40,40,36,36,36,40,40,36,36,36,36,40,36,36,36,36,36,36,24,24,28,24,28,24,36,48,48,48,40,40,36,36,36,36,36,36,4,16,48,48,48,40,40,40,36,36,40,36,40,48,48,48,0,0,0,0
	dc.b	48,16,36,36,36,36,36,36,36,36,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,48,36,36,24,24,24,24,24,28,28,24,36,40,48,48,40,36,40,36,36,36,36,60,12,48,48,48,48,40,40,36,36,36,36,36,36,40,40,0,0,0,0
	dc.b	48,16,36,36,36,36,36,36,36,40,40,40,48,48,40,40,40,40,48,48,48,48,48,40,48,48,40,36,36,36,36,36,36,24,28,28,28,24,36,40,48,48,40,36,36,36,36,36,36,12,16,48,48,40,40,36,36,36,36,36,36,24,36,36,0,0,0,0
	dc.b	48,16,40,36,36,36,36,40,40,40,40,40,48,48,40,40,40,40,48,40,40,36,36,36,36,24,24,24,36,36,24,24,24,24,28,28,24,28,24,36,40,48,40,40,40,36,36,36,36,52,12,48,48,40,40,40,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	48,48,40,40,40,36,40,40,48,40,48,48,48,48,36,36,24,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,24,28,28,28,28,24,24,40,40,36,36,36,36,36,24,24,52,48,48,40,40,36,36,36,36,36,36,36,36,40,0,0,0,0
	dc.b	16,16,40,40,40,40,48,48,48,48,48,16,52,36,24,24,24,24,24,28,28,28,28,28,32,28,28,28,28,28,28,32,28,28,28,28,32,28,28,24,28,36,40,36,24,24,24,24,24,28,36,48,48,48,40,40,40,36,36,36,40,40,40,40,0,0,0,0
	dc.b	16,40,40,48,48,48,48,48,48,48,16,52,36,24,28,24,24,24,24,24,24,24,24,24,28,28,28,28,28,28,28,28,28,32,28,28,28,32,28,24,28,36,36,36,36,24,24,24,24,24,36,48,48,48,48,40,40,40,40,40,40,40,40,36,0,0,0,0
	dc.b	48,48,48,48,48,48,48,48,12,12,52,36,36,36,36,24,24,36,36,36,24,24,24,28,28,28,28,28,28,28,28,28,28,32,28,28,28,28,28,28,28,24,24,24,36,36,24,24,24,24,36,48,40,40,48,40,40,48,48,40,36,36,24,24,0,0,0,0
	dc.b	48,48,48,48,48,16,16,12,60,36,36,36,36,36,40,36,36,36,36,36,24,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,36,36,24,28,28,28,24,40,48,40,40,36,40,36,36,36,36,24,24,24,24,0,0,0,0
	dc.b	48,48,48,48,16,12,12,52,36,36,36,36,36,40,40,40,36,36,36,24,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,24,24,28,28,24,28,36,48,40,40,40,36,36,36,36,36,36,36,24,36,36,0,0,0,0
	dc.b	48,16,48,48,16,16,52,36,36,36,40,36,40,40,40,48,40,36,24,28,28,24,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,28,28,24,24,40,48,40,40,40,36,36,36,36,24,24,36,40,40,36,0,0,0,0
	dc.b	48,48,48,48,40,40,36,36,36,40,40,40,40,48,48,48,36,24,24,24,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,32,28,28,24,24,24,36,48,48,40,40,36,36,36,36,36,36,36,40,48,48,48,0,0,0,0
	dc.b	48,48,48,40,36,36,36,36,40,36,40,40,48,48,48,36,24,36,24,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,28,24,48,40,40,40,36,36,36,36,36,36,36,48,48,48,48,48,0,0,0,0
	dc.b	40,40,36,36,36,36,36,36,40,36,40,40,48,48,40,24,36,24,28,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,28,36,40,40,40,36,40,36,36,36,36,36,52,16,48,48,48,48,48,0,0,0,0
	dc.b	36,36,36,24,36,36,36,36,40,40,40,40,48,48,40,24,28,28,28,24,24,24,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,28,28,28,28,32,28,28,36,36,36,36,36,40,36,36,36,36,36,36,52,12,16,48,48,48,48,48,0,0,0,0
	dc.b	24,24,36,36,36,36,36,36,36,40,40,40,48,40,36,28,28,28,24,24,24,28,28,32,28,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,36,36,36,36,36,40,36,36,36,24,36,60,16,16,48,48,48,48,48,48,0,0,0,0
	dc.b	24,36,36,36,40,48,48,40,48,48,40,40,48,36,24,24,24,24,36,36,36,24,28,28,28,28,28,28,28,28,32,28,28,28,32,28,28,28,28,28,28,24,24,24,36,36,24,24,24,36,36,36,36,52,16,16,48,48,48,48,48,48,40,40,0,0,0,0
	dc.b	36,40,48,40,40,40,40,48,40,48,48,40,40,36,28,24,24,24,36,36,36,36,24,28,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,24,24,24,24,24,24,24,24,24,28,24,16,16,48,48,48,48,40,40,40,40,40,16,0,0,0,0
	dc.b	40,40,40,40,36,36,40,40,40,48,48,48,48,36,28,24,24,24,36,36,36,40,36,28,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,24,24,24,24,36,40,48,48,48,48,48,40,40,40,40,40,48,16,0,0,0,0
	dc.b	40,36,36,36,36,36,36,40,40,40,48,48,48,52,24,36,36,36,36,36,40,48,40,24,24,28,28,24,24,24,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,24,36,40,48,48,48,40,40,40,40,40,40,36,40,40,48,48,0,0,0,0
	dc.b	36,36,36,36,36,36,36,40,40,40,40,48,48,12,52,36,36,36,40,40,40,40,40,40,24,24,24,24,28,28,24,24,24,36,36,36,24,24,36,36,36,36,36,40,40,40,40,40,40,48,48,48,40,40,40,40,40,36,36,36,36,40,48,48,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,40,48,48,48,48,16,12,36,36,36,36,36,40,40,48,48,40,36,24,28,28,28,24,36,36,36,36,36,36,40,48,48,40,40,48,48,40,40,40,40,40,40,48,40,40,40,36,36,36,36,36,36,36,36,16,48,0,0,0,0
	dc.b	40,40,36,36,36,36,40,36,40,40,48,48,48,48,12,52,36,36,36,40,40,40,40,48,48,40,36,24,28,28,24,24,24,24,24,36,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,24,36,16,48,0,0,0,0
	dc.b	48,48,48,40,40,40,40,40,40,40,48,48,48,16,16,12,36,36,36,36,40,40,40,48,48,48,48,40,28,28,24,24,24,24,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,40,40,40,40,40,36,36,36,36,36,36,24,36,52,48,0,0,0,0
	dc.b	40,48,48,48,48,48,48,40,40,40,48,48,48,48,16,16,16,36,36,36,36,40,40,40,40,48,48,40,40,36,24,24,28,24,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,40,40,40,36,36,36,36,36,36,40,48,0,0,0,0
	dc.b	40,40,48,48,48,48,48,16,16,48,48,48,48,48,16,16,12,40,36,36,36,36,40,40,40,40,40,40,40,40,40,40,36,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,40,40,40,40,40,40,40,40,0,0,0,0
	dc.b	40,40,40,40,48,48,48,16,12,48,48,48,48,48,48,16,16,16,40,36,36,36,36,40,40,40,40,40,40,48,48,48,48,48,48,16,16,16,16,12,52,52,52,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,40,40,48,48,0,0,0,0
	dc.b	36,40,40,40,48,48,16,16,4,12,48,48,48,48,48,16,48,48,40,36,36,36,36,36,40,48,48,48,40,40,40,40,40,48,48,48,48,48,48,16,16,16,16,16,16,48,48,48,40,40,36,36,24,24,24,24,28,28,28,28,28,28,24,24,0,0,0,0
	dc.b	40,36,40,40,40,48,48,16,12,4,12,48,48,48,48,48,48,48,40,36,36,36,36,36,40,48,48,40,40,40,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,36,36,24,24,24,28,32,32,32,32,32,32,32,0,0,0,0
	dc.b	40,40,40,40,40,48,48,48,16,4,4,12,48,48,48,48,48,48,48,36,36,36,36,36,40,40,40,40,36,36,36,36,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,36,36,36,24,24,24,24,28,28,28,0,0,0,0
	dc.b	36,40,40,40,40,40,48,48,48,16,4,8,16,48,48,48,48,48,40,36,24,36,36,36,40,40,40,36,36,36,36,36,36,36,36,36,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,48,40,40,36,36,36,0,0,0,0
	dc.b	44,44,52,12,52,52,16,48,48,16,12,4,8,16,48,48,48,48,40,36,24,24,36,36,40,40,36,36,36,36,36,36,36,36,36,36,40,40,40,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,0,0,0,0
	dc.b	48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,36,36,36,40,40,40,36,36,36,36,36,36,48,48,48,48,48,4,4,12,48,48,48,40,40,36,36,40,40,36,0,0,0,0
	dc.b	24,36,36,36,36,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,36,36,36,36,36,36,36,36,36,36,40,40,36,36,36,36,36,36,40,48,48,48,48,16,4,4,16,48,48,48,48,40,36,36,36,40,0,0,0,0
	dc.b	28,28,28,28,28,24,24,24,36,36,36,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,40,40,36,36,36,36,36,40,40,48,36,36,36,36,36,40,40,48,48,48,48,48,16,4,4,16,48,48,40,40,40,36,36,36,0,0,0,0
	dc.b	32,32,32,32,32,32,32,32,28,28,24,36,36,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,40,40,40,40,40,40,40,36,36,36,36,36,40,48,48,48,48,48,48,40,52,4,12,16,16,40,40,40,40,36,36,0,0,0,0
	dc.b	36,36,24,24,24,24,24,24,36,36,36,36,36,36,36,36,48,40,48,16,16,16,16,16,16,16,48,48,48,48,48,48,40,40,40,40,48,48,40,40,36,36,36,36,36,40,48,48,48,48,48,48,48,40,16,12,48,48,48,40,40,40,40,36,0,0,0,0
	dc.b	48,48,48,48,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,52,52,52,16,16,48,48,48,48,48,48,48,40,40,40,40,36,36,36,36,36,36,52,16,48,48,48,48,48,48,40,12,48,48,48,48,40,40,40,40,0,0,0,0
	dc.b	40,40,40,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,40,40,40,40,36,36,36,36,36,36,16,16,48,48,48,48,40,48,40,48,48,48,48,48,40,48,48,0,0,0,0
	dc.b	40,36,36,36,36,36,36,36,40,40,40,48,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,24,24,28,24,36,36,40,48,40,40,40,40,36,36,36,36,36,44,12,16,48,48,48,48,40,40,40,40,40,48,48,48,48,48,0,0,0,0
	dc.b	16,36,36,36,36,36,36,36,36,36,40,40,48,48,40,36,40,36,36,40,40,40,40,36,40,40,36,36,36,36,24,24,24,24,28,28,36,48,48,48,40,40,36,36,36,36,36,36,60,12,48,48,48,40,40,40,36,36,36,36,36,40,40,40,0,0,0,0
	dc.b	16,36,36,36,36,36,36,36,36,36,36,40,48,48,40,40,40,40,40,40,40,40,40,40,40,40,40,40,36,36,24,24,24,24,24,28,28,36,40,48,48,40,40,40,36,36,36,36,44,4,16,48,48,40,48,40,36,36,36,36,24,24,36,36,0,0,0,0
	dc.b	16,40,36,36,36,36,36,36,40,40,40,40,48,48,40,40,40,40,48,48,48,48,48,48,40,40,40,40,36,36,36,36,36,24,24,28,28,24,24,36,48,48,40,40,40,36,36,36,36,12,12,48,48,48,40,40,36,36,36,36,36,24,36,36,0,0,0,0
	dc.b	16,40,36,36,36,36,40,40,40,40,40,40,48,48,40,40,40,40,36,36,36,36,36,24,24,24,24,24,36,36,36,24,24,24,24,24,28,28,24,28,36,48,40,40,40,36,36,36,36,36,12,48,48,40,40,40,40,36,36,36,36,36,36,36,0,0,0,0
	dc.b	16,40,40,40,40,40,48,40,40,48,48,48,48,40,36,36,36,24,28,28,28,28,24,24,24,28,28,28,28,28,28,28,28,24,24,28,28,28,28,24,28,40,40,36,36,36,36,36,36,24,44,48,48,40,40,40,36,36,36,36,36,36,36,40,0,0,0,0
	dc.b	16,40,40,40,40,40,48,48,48,48,48,16,40,24,28,24,24,24,24,28,28,28,28,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,28,36,40,36,36,36,36,24,24,28,24,40,48,48,40,40,40,40,36,36,36,40,48,40,0,0,0,0
	dc.b	48,40,48,48,48,48,48,48,48,16,16,44,36,36,24,24,28,24,36,36,24,24,24,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,36,36,36,24,24,24,24,24,24,36,48,48,40,48,40,40,40,40,40,40,40,36,0,0,0,0
	dc.b	48,40,48,48,48,48,48,48,16,16,40,36,36,36,36,24,36,36,36,36,24,24,24,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,24,36,36,36,24,24,24,24,36,40,40,40,40,40,48,48,48,40,40,36,36,24,0,0,0,0
	dc.b	48,48,48,48,48,16,12,12,52,36,36,36,36,36,40,36,36,36,36,36,24,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,24,36,24,24,28,28,28,36,48,40,40,40,36,36,36,36,36,36,24,24,24,0,0,0,0
	dc.b	48,48,48,48,16,12,12,44,36,36,36,36,40,40,40,40,36,40,36,24,28,28,28,32,28,28,28,32,32,32,32,32,32,32,32,32,32,32,28,28,32,28,28,24,24,28,28,28,28,24,40,48,40,40,40,40,36,36,36,36,24,24,36,36,0,0,0,0
	dc.b	48,16,48,16,16,16,36,36,36,36,36,40,40,40,48,48,40,24,28,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,24,24,28,28,36,48,48,40,40,36,36,36,36,36,36,24,36,40,40,0,0,0,0
	dc.b	48,48,48,48,40,36,36,36,36,40,40,40,40,40,48,40,24,28,28,24,24,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,32,28,24,24,24,24,40,48,40,40,40,36,36,36,36,36,36,36,40,48,48,0,0,0,0
	dc.b	48,48,48,40,36,36,36,40,36,40,40,40,48,48,48,36,24,24,36,28,32,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,24,28,28,24,40,48,40,40,40,40,36,36,36,36,36,40,48,48,48,48,0,0,0,0
	dc.b	40,40,36,36,36,36,36,36,40,40,40,40,40,48,40,28,24,24,24,28,28,28,28,32,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,28,24,40,48,48,40,36,36,36,36,36,36,36,52,16,48,48,48,48,0,0,0,0
	dc.b	36,36,24,36,36,36,40,36,40,40,40,40,48,48,36,28,28,28,24,24,24,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,24,40,40,40,40,40,36,36,36,36,36,36,36,12,12,48,48,48,48,48,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,40,40,40,48,48,40,28,28,28,24,24,36,24,28,28,28,28,28,28,28,28,32,32,32,32,32,32,32,28,28,28,28,28,28,24,24,36,40,36,36,36,40,36,36,36,36,36,52,12,16,16,48,48,48,48,40,0,0,0,0
	dc.b	24,36,36,40,40,40,40,48,40,48,40,40,48,36,24,24,24,24,24,36,36,24,28,28,28,28,28,28,28,32,28,28,28,28,28,28,28,28,28,28,24,24,24,24,36,36,36,36,24,36,36,36,36,36,16,16,48,48,48,48,48,48,48,40,0,0,0,0
	dc.b	36,40,40,40,40,40,40,48,40,48,48,40,40,24,24,24,24,24,36,36,36,36,24,28,28,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,24,24,24,36,36,24,28,24,24,24,36,44,16,16,48,48,48,48,40,48,48,40,40,0,0,0,0
	dc.b	40,40,40,40,36,36,40,40,40,48,48,48,40,24,24,24,24,24,36,36,36,40,36,32,24,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,28,28,28,28,24,24,24,24,28,24,40,16,48,48,48,40,48,40,40,40,40,40,48,0,0,0,0
	dc.b	40,40,36,36,36,36,36,40,40,40,48,48,48,52,24,36,36,36,36,40,40,40,36,28,24,24,28,24,24,24,24,28,28,28,28,28,28,28,28,24,24,24,28,28,28,28,24,24,24,36,40,48,48,48,48,40,40,40,40,40,36,36,40,48,0,0,0,0
	dc.b	36,36,36,36,36,36,40,40,40,48,48,48,48,12,36,36,36,36,40,40,40,40,48,36,24,24,24,28,28,24,24,36,24,36,36,36,24,24,24,24,24,24,36,36,36,36,40,40,40,40,48,48,48,40,40,40,40,36,36,36,36,36,40,16,0,0,0,0
	dc.b	36,36,36,36,36,36,36,40,40,48,48,48,48,12,16,36,36,36,40,40,40,48,48,48,24,24,24,28,28,24,24,36,36,36,36,36,40,40,40,40,48,48,48,48,48,48,40,40,48,40,48,48,40,36,40,36,36,36,36,36,36,24,36,16,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,40,40,48,48,48,16,12,44,36,36,36,40,40,40,48,48,48,40,36,28,28,36,36,24,24,24,36,36,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,36,24,36,16,0,0,0,0
	dc.b	48,40,40,36,36,36,40,40,40,48,48,48,48,16,12,60,36,36,36,36,40,40,48,40,48,48,48,24,28,24,24,24,24,24,36,36,36,36,40,40,40,40,40,40,40,40,36,36,36,40,48,48,40,36,36,36,36,36,36,36,24,36,36,52,0,0,0,0
	dc.b	48,48,48,16,48,40,40,48,48,40,48,48,48,48,12,12,44,36,36,40,40,40,40,40,48,48,48,40,40,36,24,28,28,24,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,40,40,40,40,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,48,48,48,48,48,48,40,40,48,48,48,48,16,16,12,16,36,36,36,40,36,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,40,40,40,40,40,40,40,40,0,0,0,0
	dc.b	40,40,40,48,48,48,48,16,12,48,48,48,48,48,16,16,16,40,36,36,36,36,36,40,40,40,40,48,48,48,48,48,48,48,48,16,16,52,52,52,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,48,40,40,40,0,0,0,0
	dc.b	40,40,40,40,40,48,48,16,4,16,48,48,48,48,16,16,48,48,40,36,36,36,40,40,40,40,48,48,40,40,40,48,48,48,48,48,48,48,16,16,16,16,16,16,48,40,40,40,40,36,36,36,36,36,36,36,24,24,24,24,24,24,36,36,0,0,0,0
	dc.b	36,40,40,40,40,48,48,16,12,4,16,48,48,48,48,48,48,48,40,36,36,36,36,36,40,40,40,40,40,40,40,40,48,48,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,36,36,24,28,28,32,32,32,32,32,32,32,32,0,0,0,0
	dc.b	40,36,40,40,40,48,48,16,12,4,4,16,48,48,48,48,48,48,40,40,36,36,36,36,40,40,40,40,40,40,40,40,40,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,36,36,24,24,28,28,28,28,32,32,0,0,0,0
	dc.b	40,40,40,36,40,48,48,48,16,12,4,4,48,48,48,48,48,48,40,36,36,36,36,36,40,40,36,36,36,36,36,36,36,36,36,36,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,36,36,36,36,0,0,0,0
	dc.b	36,52,60,60,52,52,16,48,48,16,12,8,4,48,48,48,48,48,36,24,24,36,36,36,48,40,36,36,36,36,36,36,36,36,36,36,36,40,40,40,40,48,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,0,0,0,0
	dc.b	40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,40,36,36,36,36,36,36,36,36,36,36,40,40,40,36,36,36,36,36,40,48,48,48,48,48,12,8,12,16,48,48,48,40,40,36,36,36,40,0,0,0,0
	dc.b	24,24,36,36,36,36,36,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,40,40,40,36,36,36,36,36,36,40,40,36,36,36,36,36,36,40,48,48,48,48,48,12,4,12,16,48,48,40,40,36,36,36,36,0,0,0,0
	dc.b	32,32,32,32,28,28,24,24,36,36,36,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,40,40,40,36,36,40,40,48,36,36,36,36,36,40,40,48,48,48,48,48,40,12,4,12,48,48,48,40,40,36,36,36,0,0,0,0
	dc.b	32,32,32,32,32,32,32,32,28,28,24,36,36,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,40,40,40,40,48,48,40,40,36,36,36,36,40,48,48,48,48,48,48,40,40,12,12,48,48,48,48,40,40,36,40,0,0,0,0
	dc.b	40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,40,52,16,16,16,12,12,16,16,48,48,48,48,48,48,40,48,48,40,48,40,36,36,36,36,36,36,36,40,48,48,48,48,48,48,40,40,12,48,48,48,40,40,40,40,40,0,0,0,0
	dc.b	40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,44,44,52,52,40,48,48,48,48,48,48,48,40,40,40,40,36,36,36,36,36,36,40,16,16,48,48,48,48,40,40,40,48,48,48,48,48,48,48,48,0,0,0,0
	dc.b	40,40,40,40,40,40,40,40,48,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,24,36,36,40,40,40,40,40,40,40,40,36,36,36,36,52,16,16,48,48,48,40,40,40,40,40,48,48,48,48,48,48,0,0,0,0
	dc.b	36,36,36,36,36,36,36,40,40,40,48,48,40,40,36,36,36,36,36,40,40,40,40,40,40,36,36,36,36,36,36,24,24,24,24,36,40,48,48,40,40,40,36,36,36,36,36,36,12,16,16,48,48,48,40,40,36,36,36,36,40,52,48,48,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,40,48,48,48,40,40,40,40,40,40,40,40,40,40,40,36,40,40,40,36,24,24,24,24,24,24,24,36,48,48,48,40,36,36,36,36,36,36,44,4,16,48,48,48,40,40,40,36,36,36,36,24,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,40,40,40,40,40,48,40,40,40,40,40,48,48,40,40,40,40,40,40,40,36,36,24,24,24,36,24,28,28,24,40,40,48,48,40,40,36,36,36,36,36,12,12,48,48,48,40,40,36,36,36,36,36,24,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,40,40,40,48,48,40,36,40,40,40,48,48,48,48,40,40,48,48,40,40,36,36,36,36,36,36,24,28,28,24,24,24,40,48,48,40,40,36,36,36,24,44,12,48,48,40,40,40,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	52,36,36,40,36,36,40,40,40,40,40,48,48,48,40,40,40,36,36,24,24,24,24,28,28,28,28,24,36,36,36,36,36,24,24,24,28,28,24,28,24,48,48,40,40,40,36,36,36,36,12,16,48,40,48,40,40,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,40,40,40,40,40,40,48,48,48,48,48,48,36,24,24,24,24,24,28,28,28,24,24,24,28,28,32,28,28,28,28,28,24,24,24,24,28,24,28,32,36,48,40,40,36,36,36,36,36,36,48,48,40,40,40,40,36,36,36,36,36,36,40,0,0,0,0
	dc.b	40,40,40,40,48,48,48,48,48,48,16,16,40,24,24,24,24,24,36,24,28,28,28,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,28,32,36,40,40,36,36,36,24,24,24,24,36,48,48,40,40,40,40,36,36,40,40,40,48,0,0,0,0
	dc.b	40,40,40,48,48,48,48,48,16,12,16,36,36,36,36,24,24,24,36,36,36,24,24,28,32,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,36,36,36,24,36,24,24,28,28,24,40,40,48,48,40,40,40,40,40,40,40,40,0,0,0,0
	dc.b	48,48,48,48,48,48,48,16,12,52,36,36,36,40,36,36,36,36,36,36,24,24,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,24,36,36,24,36,24,24,24,24,40,40,40,40,40,40,40,40,40,40,36,36,24,0,0,0,0
	dc.b	48,48,48,48,16,16,12,12,36,36,36,36,36,40,40,36,36,36,40,36,28,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,24,36,36,24,24,24,28,24,40,48,36,40,40,40,40,36,36,36,36,24,24,0,0,0,0
	dc.b	48,48,48,16,16,12,12,36,36,36,36,36,36,40,40,40,36,36,36,24,28,28,32,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,28,28,32,28,24,24,24,28,28,28,28,28,40,48,40,40,36,40,36,36,36,36,24,24,36,36,0,0,0,0
	dc.b	16,16,48,16,16,52,36,36,36,36,36,40,40,40,48,48,40,24,28,32,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,32,28,28,28,24,24,24,28,28,24,48,48,40,40,36,40,36,36,36,36,24,24,36,40,0,0,0,0
	dc.b	48,48,48,40,40,36,36,36,36,40,40,48,48,40,48,40,28,28,28,24,28,28,28,32,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,24,24,28,24,36,48,48,40,40,36,36,36,36,36,36,36,40,48,48,0,0,0,0
	dc.b	48,48,40,36,36,36,36,36,40,40,40,40,48,48,40,24,24,24,24,24,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,32,28,28,28,28,28,32,28,40,48,40,40,40,36,40,36,36,36,36,40,40,48,48,48,0,0,0,0
	dc.b	40,36,36,36,36,36,36,40,40,36,48,40,48,48,24,28,24,24,24,24,28,28,28,32,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,24,40,48,48,40,40,40,36,36,36,36,36,52,16,16,48,48,48,0,0,0,0
	dc.b	36,36,36,36,36,36,40,40,40,36,48,48,48,40,24,28,28,28,28,24,24,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,28,28,32,28,28,28,24,36,40,40,40,48,40,36,36,36,36,36,36,52,12,16,48,48,48,48,0,0,0,0
	dc.b	24,36,36,36,36,40,40,36,40,40,40,48,48,36,24,24,24,24,36,36,24,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,24,36,40,36,36,36,40,36,36,36,36,36,36,12,12,16,48,48,48,48,48,0,0,0,0
	dc.b	24,36,40,40,40,48,48,48,48,40,40,48,36,24,24,24,24,36,36,36,36,24,28,28,28,28,28,28,28,32,28,28,28,28,28,28,28,28,28,28,28,28,24,36,36,36,36,24,36,36,36,36,36,24,52,12,16,48,48,48,48,48,48,40,0,0,0,0
	dc.b	40,40,48,40,40,40,40,40,48,48,40,40,36,28,24,24,24,36,36,36,36,36,24,28,28,24,28,28,28,28,28,28,28,28,28,28,28,28,28,32,24,24,24,24,24,36,36,36,24,24,36,36,36,52,16,48,48,48,48,48,40,48,40,40,0,0,0,0
	dc.b	40,48,40,40,36,40,40,40,40,48,48,48,40,24,24,24,36,36,36,36,40,36,24,32,24,24,28,28,28,24,28,32,28,28,28,28,28,28,28,28,24,28,28,28,24,24,24,24,24,24,24,36,48,48,48,48,48,48,40,40,40,40,40,40,0,0,0,0
	dc.b	40,40,36,36,36,36,40,40,40,48,48,48,16,36,36,36,36,36,36,40,40,40,36,32,28,24,24,24,24,24,24,28,28,28,28,28,32,28,28,24,24,24,28,28,28,28,24,24,24,24,36,48,48,48,40,40,48,40,40,36,36,36,40,52,0,0,0,0
	dc.b	36,36,36,36,36,36,40,40,40,48,48,48,16,16,36,36,36,36,40,48,40,48,40,24,28,24,24,28,28,24,24,36,36,36,36,36,24,28,28,28,28,28,24,24,24,36,36,36,40,36,40,48,40,40,40,40,40,36,36,36,36,36,36,44,0,0,0,0
	dc.b	36,36,36,36,36,36,36,40,40,48,48,48,16,12,36,36,36,36,40,40,40,48,48,40,28,24,28,28,28,36,36,36,36,36,36,36,40,40,40,40,40,40,48,48,48,48,40,40,40,40,48,48,48,36,36,40,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,40,40,48,48,48,48,12,12,36,36,36,36,40,40,40,48,48,40,36,24,28,28,36,36,24,24,36,36,36,40,40,48,48,40,40,48,40,40,40,40,48,40,40,48,48,40,36,40,36,36,36,36,36,36,36,24,36,0,0,0,0
	dc.b	40,36,36,36,36,36,36,40,40,40,48,48,48,16,4,52,36,36,36,40,40,40,48,48,48,48,40,24,24,24,24,24,24,36,36,40,40,36,36,36,40,40,40,40,40,40,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,24,24,36,0,0,0,0
	dc.b	48,48,52,44,36,40,40,40,40,40,48,48,48,16,12,12,36,36,36,40,40,40,40,48,48,48,48,40,36,24,24,24,24,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,40,40,40,40,40,40,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	48,48,48,48,48,16,40,48,40,48,48,48,48,48,12,16,52,36,36,36,40,40,40,40,48,48,40,40,40,36,36,24,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,40,40,40,40,40,40,40,40,36,0,0,0,0
	dc.b	40,48,48,48,48,48,48,16,40,48,48,48,48,48,16,16,16,40,36,36,40,40,40,40,40,40,40,40,40,48,48,48,48,48,16,52,52,52,52,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,40,40,40,40,40,0,0,0,0
	dc.b	40,40,40,40,48,48,48,16,12,48,48,48,48,48,16,16,16,40,36,36,36,40,40,40,40,40,48,48,40,40,40,48,48,48,48,48,48,16,16,12,16,16,16,16,52,40,40,40,36,36,36,36,36,36,36,36,36,36,36,24,24,36,36,40,0,0,0,0
	dc.b	36,40,40,40,48,48,48,16,12,12,48,48,48,48,48,48,48,48,40,36,36,36,40,40,48,48,40,40,40,40,40,40,40,40,48,48,48,48,48,48,48,48,16,16,16,48,48,48,48,40,40,36,36,24,28,28,32,32,32,32,32,32,32,32,0,0,0,0
	dc.b	36,36,36,40,40,48,48,16,12,4,12,48,48,48,48,48,48,48,40,36,36,36,36,40,48,48,40,36,36,40,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,36,36,36,24,28,28,28,32,32,32,32,0,0,0,0
	dc.b	36,36,36,40,40,48,48,48,16,4,4,12,48,48,48,48,48,48,40,36,36,36,36,36,40,40,36,36,36,36,36,36,36,36,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,36,36,36,36,24,24,0,0,0,0
	dc.b	40,52,44,52,52,60,16,48,48,16,4,8,12,48,48,48,48,48,36,24,36,36,36,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,48,0,0,0,0
	dc.b	40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,40,36,36,36,36,36,36,36,36,36,36,40,40,36,36,36,36,36,36,48,48,48,48,48,16,4,4,12,16,48,40,40,40,36,36,36,36,0,0,0,0
	dc.b	28,24,24,36,36,36,36,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,36,40,36,36,36,36,36,40,40,48,36,36,36,36,36,40,40,48,48,48,48,48,16,4,12,16,16,48,48,40,40,36,36,36,0,0,0,0
	dc.b	32,32,32,32,32,32,28,24,24,24,36,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,36,36,36,36,40,40,48,36,36,36,36,36,40,40,48,48,48,48,48,40,16,4,12,48,48,48,40,36,36,40,40,0,0,0,0
	dc.b	32,32,32,28,28,28,28,28,24,24,24,36,36,40,40,40,48,48,48,16,16,16,48,48,48,48,48,48,48,48,40,40,40,40,40,40,40,48,48,40,36,36,36,36,36,36,40,48,48,48,48,48,48,40,16,12,48,48,40,40,40,40,40,40,0,0,0,0
	dc.b	40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,52,52,16,16,12,12,16,16,48,48,48,48,48,48,40,48,48,48,40,40,36,36,36,36,36,36,40,48,16,48,48,48,48,48,40,52,16,48,48,48,48,40,40,40,0,0,0,0
	dc.b	48,48,48,48,40,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,44,44,40,48,48,48,48,48,48,40,40,40,40,36,40,36,36,36,36,36,36,16,16,16,48,48,48,48,40,40,40,48,48,48,48,48,48,48,0,0,0,0
	dc.b	40,36,40,40,40,40,40,48,40,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,24,24,24,36,40,40,48,48,40,40,40,36,36,36,36,40,12,16,16,48,48,40,48,40,36,36,40,40,16,48,48,48,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,40,40,48,48,40,40,40,36,36,36,40,40,40,36,36,36,36,36,36,36,40,40,36,24,24,24,24,24,36,40,48,48,40,40,36,40,36,36,36,36,60,12,16,48,48,48,40,40,40,36,36,36,36,36,36,40,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,40,40,40,48,48,40,40,40,40,40,40,40,40,40,40,48,40,36,40,40,36,36,24,24,24,24,24,24,24,40,48,48,40,40,36,40,40,36,36,36,4,16,48,48,48,48,40,40,36,36,36,36,24,24,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,40,40,40,48,40,40,48,40,40,40,48,48,48,48,48,48,48,48,40,36,36,36,24,24,36,24,24,28,28,36,40,48,48,40,40,40,36,36,36,36,52,12,48,48,48,40,40,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,40,40,40,40,40,48,48,36,40,40,48,48,48,40,40,40,36,36,36,40,40,36,36,36,36,36,36,24,24,28,28,24,28,36,48,48,48,40,36,36,36,24,36,12,16,48,48,40,40,40,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,40,40,48,40,40,40,48,48,40,36,36,36,36,24,24,24,24,28,28,28,28,28,24,24,36,36,24,24,36,24,24,28,28,24,32,28,40,48,48,40,36,36,36,36,36,52,12,48,48,48,40,40,40,36,36,36,36,36,36,0,0,0,0
	dc.b	40,40,40,40,40,48,40,48,48,48,48,48,40,24,28,24,24,24,24,24,28,28,28,24,24,28,28,32,28,28,28,28,28,24,24,24,24,24,24,32,32,36,48,48,40,36,36,40,36,36,36,16,48,48,40,40,40,36,36,36,36,36,36,40,0,0,0,0
	dc.b	40,40,40,48,48,48,48,48,48,16,16,16,36,24,24,24,28,24,36,36,24,28,28,24,24,28,28,28,28,28,28,28,28,28,28,28,28,28,24,28,32,24,40,40,36,36,36,36,24,24,24,36,40,48,40,40,40,40,40,36,36,40,40,48,0,0,0,0
	dc.b	40,40,48,48,48,48,48,48,16,12,52,36,36,36,36,36,36,36,36,36,36,24,24,24,28,28,28,28,28,28,28,28,28,28,32,28,28,28,28,32,32,24,36,36,36,24,24,24,24,24,28,28,40,40,40,48,40,48,40,40,40,48,40,40,0,0,0,0
	dc.b	48,48,48,48,48,48,16,16,12,36,36,36,36,40,36,36,36,36,36,36,24,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,32,28,28,28,24,28,36,36,36,36,24,24,24,24,24,40,40,36,40,40,48,40,40,40,40,36,24,0,0,0,0
	dc.b	48,48,48,48,16,12,12,60,36,36,36,36,36,40,40,40,36,40,36,36,28,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,24,36,36,36,24,24,24,24,40,48,40,40,40,40,40,36,36,36,36,36,24,0,0,0,0
	dc.b	48,48,16,16,12,12,52,36,36,36,36,40,40,40,48,40,40,36,36,24,28,28,28,32,28,28,28,32,32,32,32,32,32,32,32,32,32,28,28,28,32,28,28,24,24,24,28,28,28,28,36,40,48,40,40,40,36,36,36,36,36,24,24,36,0,0,0,0
	dc.b	16,16,16,16,16,40,36,36,40,36,40,40,40,48,48,48,36,24,28,32,32,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,24,24,28,28,28,24,40,48,48,40,40,36,40,36,36,36,36,24,36,40,0,0,0,0
	dc.b	48,48,48,40,36,36,36,40,40,40,40,40,48,48,40,36,28,32,28,24,28,28,28,32,28,32,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,24,24,28,28,28,36,48,48,40,40,40,40,36,36,36,36,36,40,40,48,0,0,0,0
	dc.b	48,48,40,36,36,36,36,36,40,40,40,40,48,48,36,24,24,28,24,24,28,28,28,24,28,32,32,32,32,32,32,32,32,32,32,32,32,32,32,28,32,28,28,28,28,28,28,28,36,40,48,40,40,40,36,40,36,36,36,36,40,48,48,48,0,0,0,0
	dc.b	40,36,36,36,36,36,36,40,36,40,40,48,48,40,24,28,28,28,24,24,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,32,32,28,24,36,48,48,40,40,40,36,36,36,36,36,36,16,16,48,48,16,0,0,0,0
	dc.b	36,36,36,36,36,40,40,40,40,40,48,48,48,36,28,28,28,28,24,24,24,28,28,32,28,28,28,32,32,32,32,32,32,32,32,32,32,28,28,28,28,32,28,28,24,36,36,40,40,40,40,36,36,36,36,36,36,52,12,16,16,48,48,48,0,0,0,0
	dc.b	36,36,36,36,36,40,40,40,40,40,40,48,48,36,24,24,24,36,36,36,28,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,24,36,40,40,36,40,40,40,36,36,36,36,36,52,12,12,16,48,48,48,48,0,0,0,0
	dc.b	36,36,40,40,48,48,48,48,40,40,40,40,36,24,24,24,24,36,36,36,36,28,24,28,28,28,32,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,36,36,36,36,36,36,36,36,36,36,36,40,12,12,48,48,48,48,48,48,48,0,0,0,0
	dc.b	40,40,40,40,40,40,40,40,48,48,40,36,24,28,24,24,24,36,36,36,36,36,24,32,32,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,24,36,36,36,36,36,36,24,36,36,36,36,52,12,16,48,48,48,48,48,40,40,40,0,0,0,0
	dc.b	40,40,40,40,36,40,40,40,40,48,48,40,36,24,36,36,36,36,36,36,40,36,24,32,28,24,28,28,28,28,28,28,28,28,28,28,28,28,24,24,24,28,28,24,24,36,24,24,24,24,24,36,48,16,48,48,48,48,48,48,40,36,40,40,0,0,0,0
	dc.b	40,36,36,36,36,36,40,40,40,40,48,48,16,36,36,40,36,40,40,40,40,40,24,32,28,24,24,24,24,24,28,28,28,28,28,32,32,32,28,28,24,28,28,28,24,24,24,24,24,28,24,40,48,48,48,48,48,40,40,40,36,36,36,40,0,0,0,0
	dc.b	36,36,36,36,36,36,40,40,40,48,48,48,12,52,36,36,36,40,36,40,48,48,40,28,32,24,24,28,24,24,36,24,24,36,36,36,24,28,28,28,28,28,24,24,24,24,36,36,36,36,40,48,48,40,40,40,40,40,40,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,40,40,40,40,48,48,48,16,60,36,36,36,40,36,40,48,48,48,36,28,24,28,28,24,36,36,36,36,36,36,40,40,40,40,36,36,36,40,40,48,48,48,48,40,40,40,48,40,40,40,36,36,36,36,36,36,36,36,24,0,0,0,0
	dc.b	36,36,36,36,36,36,40,40,40,48,48,48,16,12,52,36,36,40,36,40,40,40,48,48,40,36,28,28,24,36,36,36,24,36,36,36,40,48,48,48,48,48,48,48,48,48,40,40,40,36,40,48,40,40,40,36,36,36,36,36,36,36,24,24,0,0,0,0
	dc.b	36,36,36,36,36,36,40,40,40,48,48,48,48,12,12,36,36,36,40,40,40,48,48,48,48,40,24,24,24,24,24,24,24,36,36,40,40,36,40,40,40,40,40,40,40,40,40,40,40,40,48,48,40,40,40,36,36,36,24,36,36,24,24,36,0,0,0,0
	dc.b	40,36,36,36,36,40,40,40,40,48,48,48,48,16,12,60,36,36,40,40,40,40,40,48,48,48,40,40,24,24,24,24,24,36,36,36,36,36,36,36,36,36,40,40,40,40,36,36,36,40,40,40,48,48,40,40,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	48,48,16,16,40,40,40,40,48,40,48,48,48,16,16,12,40,36,36,40,40,40,40,40,48,48,48,40,36,24,24,24,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,40,40,40,40,40,40,40,36,36,40,36,36,40,0,0,0,0
	dc.b	48,48,48,48,48,48,48,48,48,40,48,48,48,16,16,12,16,36,36,40,40,40,40,40,40,40,40,40,40,40,48,48,48,48,48,52,44,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,36,40,40,48,48,48,48,0,0,0,0
	dc.b	40,40,48,48,48,48,48,16,16,48,48,48,48,48,16,16,48,40,36,36,36,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,16,12,12,12,12,52,52,52,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,40,48,40,48,48,48,16,4,16,40,48,48,48,16,16,48,48,40,36,40,40,40,40,48,40,40,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,16,16,16,48,48,48,48,40,36,36,36,24,24,24,28,28,28,28,28,32,32,32,0,0,0,0
	dc.b	40,40,40,40,48,48,48,48,12,4,16,48,48,48,48,48,48,48,36,36,36,36,36,40,48,40,40,36,36,36,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,36,36,24,24,28,32,32,28,32,32,32,0,0,0,0
	dc.b	40,36,40,40,40,16,16,12,16,4,4,16,48,48,48,48,48,40,36,36,36,36,36,40,40,40,40,36,36,36,36,36,40,40,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,36,36,36,36,24,24,28,0,0,0,0
	dc.b	40,44,60,52,52,16,16,48,16,12,4,4,16,48,48,48,48,40,40,36,36,36,36,36,40,40,36,36,36,36,36,36,36,36,36,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,0,0,0,0
	dc.b	40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,40,40,36,36,36,36,36,36,36,36,36,36,40,40,36,36,36,36,36,36,40,48,48,48,48,48,12,4,12,16,16,48,40,40,36,36,36,36,0,0,0,0
	dc.b	28,24,24,24,24,36,36,48,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,36,36,36,36,36,40,40,48,40,36,36,36,36,40,40,48,48,48,48,48,48,12,4,16,48,48,48,40,40,40,36,36,0,0,0,0
	dc.b	32,32,32,32,32,32,28,24,24,24,36,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,40,40,40,40,40,40,40,48,40,36,36,36,36,40,40,48,48,48,48,48,48,40,12,12,48,48,48,40,40,40,36,36,0,0,0,0
	dc.b	28,28,28,28,24,24,24,24,24,24,36,36,36,40,40,40,48,48,16,16,16,16,16,16,16,48,48,48,48,48,48,48,40,40,40,40,40,48,48,40,40,36,36,36,36,36,40,48,48,16,48,48,48,40,40,12,16,48,48,40,40,40,40,40,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,44,52,52,12,12,12,12,16,48,48,48,48,48,48,48,48,48,40,40,40,40,40,40,36,36,36,36,16,16,16,48,48,48,40,48,40,48,48,48,48,48,48,40,48,0,0,0,0
	dc.b	48,48,48,40,40,40,40,48,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,44,40,40,48,40,40,40,36,40,40,40,40,40,40,40,40,36,36,36,52,12,16,16,48,48,48,40,40,40,40,40,16,48,48,48,48,0,0,0,0
	dc.b	40,36,36,36,40,40,40,48,40,40,40,40,40,40,36,36,36,36,36,40,40,40,36,36,36,36,36,36,36,36,36,36,24,24,24,36,40,40,40,40,40,40,40,40,36,36,36,36,60,12,16,48,48,48,48,40,40,40,36,36,36,36,40,52,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,40,40,48,48,40,40,40,40,40,40,36,36,40,40,36,40,36,36,40,40,40,36,36,36,24,24,24,24,36,40,48,48,40,40,40,40,40,40,36,36,52,4,12,48,48,48,48,40,36,36,36,36,36,24,24,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,40,40,48,48,40,40,40,40,48,48,40,40,40,40,40,40,40,40,40,40,40,36,24,24,24,24,24,24,24,36,48,48,48,40,40,40,36,36,36,36,60,12,48,48,48,40,40,40,36,36,36,36,36,24,24,0,0,0,0
	dc.b	36,36,36,36,36,36,36,40,40,40,40,40,48,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,40,36,36,36,36,24,24,36,24,28,24,36,40,48,48,40,40,40,36,36,36,36,12,16,48,48,48,40,40,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,40,40,40,40,40,40,48,40,36,40,40,40,40,40,40,40,36,36,36,36,40,40,36,36,36,36,36,36,36,24,28,28,28,28,24,48,48,40,40,40,36,36,36,36,52,12,48,48,40,40,40,40,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,40,40,40,48,48,48,48,48,36,36,36,36,36,24,24,28,28,28,28,32,32,28,28,24,24,24,24,24,36,36,24,28,24,24,32,32,40,48,48,40,40,40,36,36,36,36,12,48,48,40,40,40,40,36,36,36,36,36,36,0,0,0,0
	dc.b	40,40,40,40,40,48,48,48,48,48,48,48,40,24,28,24,24,24,24,24,28,28,28,24,28,28,28,32,28,28,28,28,28,28,28,24,28,28,24,32,32,36,40,48,40,40,40,36,36,36,36,40,48,48,48,40,40,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,40,40,48,48,48,48,48,48,16,16,40,36,36,24,24,24,24,36,36,24,24,24,28,24,24,28,28,28,28,28,28,28,28,28,28,28,28,24,28,32,24,36,48,40,36,36,36,36,36,24,24,40,48,48,40,40,40,36,36,40,40,40,40,0,0,0,0
	dc.b	48,40,48,48,48,48,48,16,12,60,40,36,36,40,40,36,24,36,36,36,36,36,24,28,28,28,28,28,28,28,28,28,32,28,28,28,28,28,28,32,32,24,24,36,40,36,36,24,24,24,28,28,24,40,40,48,48,48,48,48,48,48,40,40,0,0,0,0
	dc.b	48,48,48,48,16,16,12,12,52,36,36,36,36,36,40,36,36,36,36,36,24,28,28,24,28,28,28,28,28,28,28,28,28,28,32,28,28,32,28,28,32,24,28,24,36,36,36,24,24,24,24,24,36,36,36,40,40,40,48,40,40,40,36,36,0,0,0,0
	dc.b	48,48,48,16,12,12,12,52,36,36,36,36,40,40,40,48,36,40,36,24,28,24,28,28,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,24,36,36,36,36,24,24,24,36,40,40,36,40,36,40,40,36,36,36,36,36,0,0,0,0
	dc.b	48,48,16,12,12,52,40,36,40,40,40,40,40,40,48,40,40,36,36,28,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,28,28,28,32,28,28,24,36,24,28,28,28,28,24,40,48,48,40,40,40,40,36,36,36,36,24,24,0,0,0,0
	dc.b	16,16,16,12,52,36,36,36,36,40,40,40,40,48,48,40,36,28,28,32,32,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,24,24,28,28,28,28,36,48,48,40,40,36,40,36,36,36,36,36,36,36,0,0,0,0
	dc.b	48,48,16,40,36,36,36,40,40,40,48,40,48,48,40,36,28,32,28,24,24,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,24,28,28,28,28,24,40,48,40,40,40,36,36,36,36,36,36,36,40,48,0,0,0,0
	dc.b	48,40,36,36,36,36,40,40,40,40,48,48,48,40,24,28,28,28,24,24,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,32,32,28,24,40,48,48,40,40,40,36,36,36,36,36,36,48,48,48,0,0,0,0
	dc.b	40,36,36,36,36,40,40,40,40,40,40,48,48,40,28,28,28,28,24,24,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,32,28,24,36,40,48,48,40,40,40,36,36,36,36,36,52,16,16,48,48,0,0,0,0
	dc.b	36,36,36,36,40,40,40,40,40,48,48,48,40,24,28,28,28,28,24,24,24,28,28,32,28,28,28,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,28,36,40,40,40,48,40,36,40,40,36,36,36,36,52,12,16,16,48,48,0,0,0,0
	dc.b	36,36,36,36,36,40,40,48,40,40,40,48,36,24,24,24,36,36,36,36,24,28,24,32,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,28,28,24,24,24,40,40,36,40,40,36,36,36,36,36,36,52,12,12,16,48,48,48,48,0,0,0,0
	dc.b	36,36,40,48,48,40,40,40,40,36,40,36,24,24,24,24,24,36,36,40,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,36,40,36,36,36,40,36,36,36,36,36,52,12,16,48,48,48,48,48,48,0,0,0,0
	dc.b	40,40,48,40,40,40,48,48,48,48,40,36,28,28,24,24,36,36,36,40,36,24,28,32,28,28,28,28,28,28,28,32,28,28,28,28,28,28,28,28,24,24,36,36,36,36,36,36,24,36,40,36,36,36,52,16,48,48,48,48,48,48,40,40,0,0,0,0
	dc.b	48,40,40,36,40,40,40,48,48,48,48,40,36,24,36,36,36,36,36,40,40,36,24,28,28,24,24,28,28,28,28,28,28,28,28,28,28,28,28,24,24,24,24,24,36,24,24,24,24,24,36,40,40,16,16,48,48,48,48,48,40,40,40,36,0,0,0,0
	dc.b	40,36,36,36,36,36,40,40,48,48,48,48,16,36,40,40,40,40,40,40,40,36,24,32,28,24,24,24,24,28,28,28,28,28,28,28,32,28,28,24,24,28,28,28,24,24,24,24,24,28,24,40,48,48,48,48,40,40,40,40,36,36,36,40,0,0,0,0
	dc.b	36,36,36,36,36,40,40,40,48,48,48,16,16,36,36,36,36,40,40,48,48,48,36,32,28,24,24,28,24,36,36,24,24,24,24,24,24,28,28,32,28,28,28,28,28,24,24,24,24,24,36,48,48,40,40,40,40,40,40,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,40,40,40,48,48,48,12,52,36,36,36,36,40,48,48,48,48,24,24,28,28,28,36,36,36,36,36,36,36,36,40,40,36,36,36,36,40,40,40,40,40,40,40,36,40,48,40,40,36,40,40,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,40,40,40,48,48,48,16,12,40,36,36,40,40,40,40,48,48,40,36,24,28,24,36,36,36,36,36,36,36,36,40,48,48,48,48,48,48,48,48,48,40,40,40,36,40,48,40,40,36,40,36,36,36,36,36,36,24,24,0,0,0,0
	dc.b	24,36,36,36,36,36,40,40,40,48,48,48,16,12,60,36,36,40,36,40,48,48,48,48,48,36,24,24,24,24,24,24,36,36,40,40,40,40,40,48,48,40,40,48,48,48,40,40,40,40,40,48,40,40,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,40,40,40,48,48,48,48,16,12,4,40,36,36,40,40,40,48,48,48,48,48,40,36,24,24,24,24,36,36,36,36,36,36,40,40,36,40,40,40,40,40,40,40,36,40,40,40,48,48,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,40,40,36,36,40,40,40,48,48,48,48,16,16,12,60,36,36,36,40,40,40,40,40,40,40,40,40,36,24,24,24,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,40,40,40,40,40,40,40,40,40,36,36,36,36,0,0,0,0
	dc.b	48,48,48,16,16,40,40,40,48,48,48,48,48,16,16,12,40,40,36,36,40,40,40,40,40,40,40,40,40,40,40,40,40,52,52,44,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,40,40,40,48,48,0,0,0,0
	dc.b	48,48,48,48,48,48,48,48,40,48,48,48,48,16,16,16,16,40,36,36,36,40,40,40,40,48,48,40,40,48,48,48,48,48,48,16,16,12,12,12,12,52,52,52,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,40,48,48,48,48,48,16,12,48,48,48,48,48,16,16,48,40,36,36,36,36,40,40,40,48,48,40,40,40,40,40,48,48,48,48,48,48,16,16,16,16,16,16,16,16,48,48,48,40,40,36,36,36,24,24,24,24,24,24,28,28,28,28,0,0,0,0
	dc.b	40,40,40,40,48,48,48,16,4,12,48,48,48,48,16,48,48,48,40,36,36,36,40,40,48,40,36,36,40,40,40,40,40,40,48,48,48,48,48,48,48,48,48,16,16,48,48,48,48,48,48,40,40,36,24,24,28,28,28,32,32,32,32,32,0,0,0,0
	dc.b	36,40,40,40,16,12,16,48,12,4,12,48,48,48,48,48,48,40,36,36,36,36,40,36,48,40,40,40,40,36,36,40,40,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,36,36,24,24,24,24,28,0,0,0,0
	dc.b	36,44,52,52,16,16,16,16,16,12,4,12,48,48,48,48,48,40,36,36,36,36,36,36,40,40,36,36,36,36,36,36,36,36,36,36,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,48,40,40,40,40,0,0,0,0
	dc.b	36,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,48,40,40,40,40,36,36,36,36,36,36,36,36,36,40,40,36,36,36,36,40,36,40,48,48,48,48,48,16,4,4,48,48,48,48,40,40,36,36,36,0,0,0,0
	dc.b	28,28,24,24,24,36,36,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,40,40,36,36,36,36,36,40,40,48,40,36,36,36,36,36,40,48,48,48,48,48,48,52,4,12,48,40,40,40,48,40,40,36,0,0,0,0
	dc.b	32,32,32,32,28,28,28,24,24,24,36,36,40,48,48,48,48,48,16,16,16,48,48,48,48,48,48,48,48,40,40,40,40,40,40,36,40,48,40,40,40,36,36,36,36,36,40,48,48,48,48,48,48,48,52,12,48,48,48,48,40,40,40,40,0,0,0,0
	dc.b	28,28,24,24,24,24,36,36,36,36,36,36,36,36,40,40,48,48,16,16,16,12,12,16,16,16,48,48,48,48,48,48,48,40,40,40,48,48,48,40,40,36,36,36,36,36,40,48,48,16,48,48,48,48,40,40,48,48,48,48,48,48,48,48,0,0,0,0
	dc.b	40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,44,44,52,52,16,16,16,16,48,48,48,48,48,48,48,40,40,40,40,40,40,40,36,36,36,36,40,16,16,48,48,48,48,48,40,40,40,48,16,48,48,48,48,0,0,0,0
	dc.b	48,48,48,40,40,48,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,40,36,36,36,36,36,36,40,40,40,40,40,40,36,36,36,12,16,16,48,48,48,48,40,40,40,36,36,36,40,48,16,0,0,0,0
	dc.b	36,36,36,36,40,40,40,40,48,48,48,40,40,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,24,24,28,24,36,40,40,48,48,40,40,40,40,36,36,36,52,4,16,48,48,48,48,40,40,36,36,36,36,24,24,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,40,40,48,48,48,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,36,36,36,24,24,24,28,24,36,40,48,48,40,40,40,36,36,36,36,36,60,12,16,48,48,48,40,40,36,36,36,36,36,24,24,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,40,40,48,48,40,40,40,40,40,40,48,40,40,48,48,48,40,40,40,40,40,36,36,36,24,24,24,24,24,24,40,48,48,48,40,40,36,36,36,36,52,4,16,48,48,48,40,40,36,36,36,36,36,36,24,0,0,0,0
	dc.b	36,36,36,36,36,36,40,40,40,40,40,48,48,40,36,40,40,48,48,48,48,48,48,48,48,48,48,40,40,36,36,36,36,36,36,36,24,24,28,36,40,48,48,40,40,40,36,36,36,36,12,16,48,48,48,40,40,40,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,40,40,40,40,40,48,48,48,40,36,40,40,40,36,36,36,36,36,24,36,36,36,36,36,36,36,36,36,36,36,24,28,28,28,24,28,40,48,48,40,40,36,36,36,36,36,12,48,48,48,48,40,40,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,40,40,40,48,48,48,48,40,36,24,24,24,24,24,24,28,28,28,28,28,28,28,28,24,24,24,24,24,36,36,24,24,28,28,28,32,36,48,48,48,40,40,36,36,36,36,12,48,48,48,40,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	40,40,40,40,48,48,48,48,48,48,48,48,40,24,28,24,24,24,24,24,24,28,28,28,28,28,32,32,32,28,28,24,28,24,28,24,24,24,28,32,32,24,40,48,48,40,40,36,36,36,36,40,48,48,48,48,36,36,36,36,36,36,36,40,0,0,0,0
	dc.b	40,40,40,48,48,48,48,48,16,16,16,40,36,36,36,24,24,24,36,36,36,24,24,24,24,24,28,28,28,28,28,28,28,28,28,28,28,28,28,32,28,24,36,40,40,36,36,36,36,36,36,24,40,48,48,48,48,40,40,40,40,40,40,48,0,0,0,0
	dc.b	48,48,48,48,48,48,16,16,12,52,36,36,36,40,36,36,36,36,36,36,36,36,24,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,32,28,24,24,36,40,36,36,36,36,24,24,28,24,40,40,48,48,40,40,40,40,40,40,40,0,0,0,0
	dc.b	48,48,48,16,16,16,12,12,44,36,36,36,36,40,40,40,36,36,40,36,24,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,32,24,28,24,40,36,24,24,24,24,24,24,24,36,36,36,40,40,40,48,48,40,36,36,0,0,0,0
	dc.b	48,48,48,16,12,4,52,40,36,36,36,36,40,40,48,40,40,40,36,24,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,28,28,28,28,32,28,28,28,36,36,36,36,24,24,24,24,40,40,36,40,36,40,40,36,36,36,36,36,0,0,0,0
	dc.b	48,16,16,12,12,52,36,40,36,40,40,40,40,48,48,48,40,36,24,28,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,36,36,24,24,24,24,24,36,40,40,40,40,40,40,40,36,36,36,36,24,0,0,0,0
	dc.b	16,16,12,12,40,36,36,40,40,40,40,40,48,48,48,36,24,28,28,32,32,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,24,24,28,28,28,28,36,48,48,40,40,40,40,40,36,36,36,36,36,36,0,0,0,0
	dc.b	48,16,40,40,36,40,40,40,40,40,48,48,48,48,36,24,28,32,32,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,24,28,28,28,28,28,36,48,48,40,40,36,40,36,36,36,36,36,40,48,0,0,0,0
	dc.b	48,40,36,36,36,40,40,40,40,48,40,48,48,40,28,28,28,28,24,24,24,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,32,28,28,24,36,48,48,40,40,40,36,40,36,36,36,36,40,16,48,0,0,0,0
	dc.b	36,36,36,36,36,36,40,40,40,48,48,48,48,36,28,28,28,24,24,24,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,32,28,28,24,36,48,48,40,40,48,40,36,36,36,36,40,16,16,16,48,0,0,0,0
	dc.b	36,36,36,36,40,40,40,48,40,40,48,48,40,24,24,24,24,24,24,24,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,28,28,28,28,32,28,28,24,24,36,40,40,48,48,40,40,36,36,36,36,36,52,12,12,16,48,48,0,0,0,0
	dc.b	36,36,36,40,40,40,40,40,40,40,40,40,24,24,36,24,36,36,36,36,28,28,28,32,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,28,28,24,28,24,36,40,40,40,40,40,36,36,36,36,36,36,60,12,12,16,48,48,48,0,0,0,0
	dc.b	36,36,40,48,48,48,40,40,36,36,40,24,24,24,24,24,36,36,36,40,24,28,24,32,28,28,28,28,28,28,32,28,28,28,28,28,28,28,28,28,28,28,28,24,36,40,40,36,36,40,36,36,36,36,36,44,12,12,48,48,48,48,48,48,0,0,0,0
	dc.b	48,48,48,48,48,48,48,48,48,40,40,24,28,24,36,36,36,36,36,40,36,24,28,28,32,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,24,36,36,36,36,36,36,36,36,36,36,36,36,52,12,16,48,48,48,48,48,40,40,0,0,0,0
	dc.b	48,40,40,40,40,40,40,48,48,48,48,40,36,36,36,36,36,40,36,40,40,36,28,28,32,24,24,28,28,28,28,28,32,28,28,28,28,28,24,36,24,24,24,36,36,36,24,24,24,36,36,40,40,52,16,16,48,48,48,48,48,40,40,36,0,0,0,0
	dc.b	40,36,36,36,36,40,40,40,40,48,48,48,40,36,36,36,40,40,40,40,48,36,24,32,32,24,24,24,24,24,28,28,24,28,28,32,32,32,28,24,28,28,28,24,24,24,24,24,24,24,24,40,48,48,48,40,48,40,40,40,40,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,40,40,40,48,48,48,16,12,36,36,36,40,40,40,48,48,40,36,32,28,24,28,24,36,24,24,24,24,24,24,24,24,28,28,28,28,28,28,28,24,36,24,24,24,24,36,40,48,48,40,40,40,40,40,40,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,40,40,40,48,48,48,16,12,40,36,36,40,40,40,48,48,48,40,28,24,28,28,24,36,36,36,36,36,36,36,36,36,36,36,24,24,36,36,36,36,36,40,36,40,36,40,48,48,40,40,40,40,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,40,40,40,48,48,16,12,12,36,36,40,40,40,48,48,48,48,36,24,28,24,36,36,36,36,36,36,36,36,40,40,48,48,48,48,48,48,48,48,48,48,40,40,36,40,48,40,36,36,40,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,40,40,48,48,48,48,12,12,52,36,36,40,40,40,48,48,48,48,40,24,24,24,24,24,36,36,36,36,40,40,40,40,48,40,48,48,40,40,48,48,40,40,40,40,40,48,48,40,36,36,36,36,36,24,36,36,36,24,0,0,0,0
	dc.b	36,36,36,36,36,36,40,40,48,48,48,48,16,4,60,36,36,40,40,40,40,48,48,48,48,40,36,24,28,24,24,24,36,36,36,36,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,48,48,48,40,40,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,24,36,36,40,48,40,40,48,48,48,16,12,4,52,36,36,40,40,40,48,40,48,48,48,40,36,24,24,24,36,40,36,36,36,36,36,36,36,40,40,36,36,36,36,36,36,40,40,40,40,40,40,40,40,40,40,40,36,36,36,36,36,0,0,0,0
	dc.b	48,16,52,40,40,36,40,40,48,48,48,48,16,16,12,12,40,36,36,40,40,40,40,40,40,40,40,40,36,36,40,40,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,40,40,40,40,40,0,0,0,0
	dc.b	48,48,48,48,16,16,40,48,48,48,48,48,48,16,16,12,40,36,36,40,40,40,40,48,40,40,40,40,48,48,48,48,48,48,16,16,16,12,16,52,52,52,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,0,0,0,0
	dc.b	48,48,48,48,48,48,48,16,48,48,48,48,48,16,12,16,48,40,36,36,36,40,40,48,40,48,48,40,40,40,48,48,48,48,48,48,48,16,16,12,16,16,12,16,16,16,48,48,40,40,40,36,36,36,36,24,36,36,36,24,24,24,24,28,0,0,0,0
	dc.b	40,40,48,48,48,48,48,16,12,16,48,48,48,16,16,16,48,40,36,36,36,36,40,48,48,48,40,40,36,36,36,40,40,40,48,48,48,48,48,48,48,48,48,16,16,16,48,48,48,48,48,40,40,36,24,24,28,28,32,32,32,32,32,32,0,0,0,0
	dc.b	40,40,40,16,16,16,48,48,12,4,16,48,48,48,16,48,48,40,36,36,36,36,36,40,48,40,36,36,40,36,36,36,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,36,36,36,24,24,24,28,28,0,0,0,0
	dc.b	40,52,60,52,52,12,12,48,16,4,4,16,48,48,48,48,48,40,36,36,40,36,36,40,40,40,40,36,36,36,36,36,36,36,36,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,36,36,0,0,0,0
	dc.b	36,36,36,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,36,36,36,36,36,36,36,36,40,40,48,40,36,36,36,36,36,40,48,48,48,48,48,48,12,4,16,48,48,40,40,40,40,40,36,0,0,0,0
	dc.b	28,28,28,28,24,24,36,36,36,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,48,48,40,48,40,40,40,36,36,36,40,36,36,40,48,40,36,36,36,36,36,40,48,48,48,48,48,48,48,16,12,48,48,48,40,40,40,40,40,0,0,0,0
	dc.b	32,32,32,28,28,28,28,24,24,24,36,40,40,40,48,48,48,16,16,16,16,48,48,48,48,48,48,48,48,48,40,40,40,40,40,40,40,40,48,48,40,40,36,36,36,36,40,48,48,16,48,48,48,40,40,16,48,48,48,48,48,48,48,48,0,0,0,0
	dc.b	24,24,24,24,36,36,36,36,36,36,36,36,36,36,40,40,40,40,16,16,12,12,12,12,12,12,16,48,48,48,48,48,48,48,40,40,40,48,48,40,40,40,36,36,36,36,40,40,16,16,48,48,48,48,48,40,40,48,48,48,48,48,48,48,0,0,0,0
	dc.b	48,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,52,52,52,16,16,16,48,48,48,48,40,40,40,40,40,40,40,40,40,40,36,36,36,40,16,16,16,48,48,48,48,40,40,40,36,36,52,16,16,48,0,0,0,0
	dc.b	40,40,40,40,40,40,40,40,40,40,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,36,36,36,36,40,40,40,40,40,40,40,40,36,36,36,52,16,12,48,48,48,40,40,40,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,40,40,40,40,40,48,48,40,40,40,40,40,40,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,40,36,24,28,28,36,40,40,40,40,40,40,40,40,36,36,36,36,12,12,16,48,48,48,48,40,40,36,36,36,24,24,24,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,40,40,48,48,48,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,36,36,36,40,24,24,24,24,24,24,40,48,48,48,40,40,40,40,36,36,36,60,4,16,48,48,48,40,40,36,36,36,36,36,24,24,0,0,0,0
	dc.b	36,36,36,36,36,36,36,40,40,40,40,48,48,36,40,40,40,40,48,48,48,48,48,48,48,40,40,40,40,40,36,36,36,24,24,24,24,24,24,36,48,48,48,40,40,40,36,40,36,36,12,12,48,48,48,40,40,40,36,36,36,36,36,24,0,0,0,0
	dc.b	36,36,36,36,36,36,40,36,36,40,40,48,48,36,36,40,48,48,48,48,48,48,48,40,40,48,48,48,40,40,36,36,36,36,36,36,36,24,28,28,40,48,48,48,40,40,36,40,36,36,52,12,16,48,40,40,40,40,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,40,40,40,40,40,48,48,40,36,36,36,36,36,36,36,24,24,36,24,24,24,36,36,36,36,36,40,36,36,36,36,24,28,28,28,24,36,48,48,48,40,40,36,36,36,36,12,16,48,48,48,40,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,40,40,40,40,48,40,48,48,48,40,24,24,24,24,24,24,24,28,28,28,28,28,28,28,28,24,28,28,28,24,24,36,24,24,28,28,24,32,36,40,48,48,40,40,36,36,36,36,52,16,48,48,48,40,40,40,40,36,36,36,36,0,0,0,0
	dc.b	36,36,40,48,48,48,48,48,48,48,48,48,36,24,24,24,24,24,36,36,24,24,28,28,24,28,32,32,28,28,28,28,28,28,28,24,24,24,28,28,32,24,36,48,48,40,40,36,36,36,36,40,48,48,48,40,40,40,36,36,36,36,36,40,0,0,0,0
	dc.b	40,48,48,48,48,48,48,16,16,12,52,40,40,36,36,24,36,36,24,36,36,36,24,24,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,32,32,24,24,40,48,40,40,36,36,36,36,36,36,40,48,48,48,40,40,36,40,40,40,40,0,0,0,0
	dc.b	48,48,48,48,48,48,16,12,12,40,36,40,36,36,40,36,36,36,36,36,36,36,24,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,32,32,24,28,36,40,36,36,36,36,24,24,28,28,24,36,40,48,48,40,48,48,48,48,40,0,0,0,0
	dc.b	48,48,48,48,16,12,12,12,36,36,36,36,40,40,40,40,36,40,40,36,24,28,28,28,28,28,28,28,28,28,28,32,28,28,28,28,28,28,28,32,32,24,28,28,36,36,36,24,24,24,24,24,24,36,36,36,36,40,48,40,40,40,40,36,0,0,0,0
	dc.b	48,48,16,12,12,12,52,36,36,40,36,40,40,40,48,48,40,40,36,28,28,24,28,28,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,32,28,28,28,36,36,36,36,36,24,24,24,36,40,40,40,36,36,40,40,40,36,36,36,0,0,0,0
	dc.b	16,16,12,12,12,40,36,40,40,40,40,48,48,48,48,48,36,36,24,28,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,32,28,36,36,36,24,24,24,24,24,40,48,40,36,40,40,36,36,36,36,36,36,0,0,0,0
	dc.b	16,12,12,52,40,36,36,40,40,40,48,48,48,48,40,36,24,28,28,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,24,24,28,24,28,28,24,40,48,48,40,48,40,40,36,36,36,36,36,36,0,0,0,0
	dc.b	16,16,40,36,36,40,40,40,40,48,40,48,48,40,24,24,28,28,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,24,28,28,28,24,24,24,48,48,40,40,40,40,36,36,36,36,36,36,40,0,0,0,0
	dc.b	48,36,36,40,36,40,40,40,48,48,48,48,16,36,24,28,28,28,24,24,24,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,28,24,28,24,40,48,48,40,48,40,40,36,36,36,36,40,48,16,0,0,0,0
	dc.b	36,36,36,36,36,40,40,40,48,40,40,48,40,24,28,28,24,24,24,24,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,28,28,28,36,48,48,48,40,40,36,36,40,36,36,40,16,12,16,16,0,0,0,0
	dc.b	36,36,36,36,40,40,40,40,40,48,48,40,36,24,24,24,36,24,36,24,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,28,28,28,28,32,28,24,24,24,24,36,40,48,48,40,40,40,36,36,40,36,36,12,12,12,48,48,0,0,0,0
	dc.b	36,40,36,40,40,40,40,48,36,40,40,36,24,24,36,36,36,36,36,36,24,28,28,32,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,28,24,24,28,28,36,40,48,48,40,40,40,36,36,36,36,36,44,12,12,16,16,48,48,0,0,0,0
	dc.b	36,40,48,48,48,48,40,36,36,40,36,24,24,24,24,24,36,36,40,36,28,28,24,32,28,28,28,32,28,28,28,28,32,28,28,28,28,28,28,28,28,28,28,24,36,40,40,36,40,40,40,36,40,36,36,36,60,12,16,48,48,48,48,48,0,0,0,0
	dc.b	40,40,48,40,40,48,48,48,40,40,36,28,24,24,36,36,36,36,40,40,24,24,24,32,32,28,28,28,28,28,28,32,28,28,28,28,28,28,28,28,24,24,36,36,36,36,36,36,36,36,36,36,36,36,40,12,12,48,48,48,48,48,40,40,0,0,0,0
	dc.b	48,40,40,40,40,40,40,48,48,48,40,36,36,36,36,36,40,36,40,40,36,24,28,32,32,28,24,28,28,28,28,28,28,28,28,28,28,28,24,24,24,24,36,36,36,24,36,36,36,36,36,36,36,52,16,16,48,48,48,48,48,40,40,40,0,0,0,0
	dc.b	40,36,36,36,40,40,40,40,48,48,48,48,40,36,40,40,40,40,40,40,40,36,28,32,28,24,24,24,24,28,28,28,24,28,28,28,32,32,28,24,24,28,24,36,36,24,24,24,24,24,24,36,48,48,48,48,48,40,48,40,40,40,36,36,0,0,0,0
	dc.b	40,36,36,36,40,40,40,40,48,48,48,16,52,36,36,40,40,40,48,48,48,40,24,32,24,28,28,24,36,36,36,24,24,28,24,24,24,28,28,28,28,28,28,28,24,24,24,24,24,28,24,40,48,48,40,40,48,40,40,40,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,40,40,48,48,48,48,16,60,36,36,36,40,48,48,48,48,48,36,28,28,28,24,36,36,36,36,36,40,36,36,36,36,36,24,24,24,24,24,24,36,36,36,36,36,36,36,40,48,48,40,40,40,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,40,40,48,48,48,16,12,52,36,36,40,40,48,40,48,48,40,36,28,28,24,36,36,36,36,36,36,36,40,40,40,48,48,48,40,48,48,48,48,48,40,40,40,36,36,48,48,40,36,40,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,40,40,40,48,48,48,48,12,12,40,40,40,36,40,40,48,48,48,48,36,36,24,24,24,24,36,24,24,36,40,40,40,48,40,40,48,48,48,48,48,48,48,40,40,40,40,48,48,40,40,36,36,36,36,36,36,36,36,24,0,0,0,0
	dc.b	36,36,36,36,36,36,40,40,48,48,48,48,12,4,60,40,36,40,48,40,40,48,48,48,48,40,24,24,24,24,24,24,40,36,36,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,48,48,40,40,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,36,36,36,40,40,40,40,48,48,48,48,16,12,12,40,36,40,40,40,40,48,48,40,48,40,40,36,24,28,24,36,36,36,36,36,36,36,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,36,36,36,36,0,0,0,0
	dc.b	40,36,36,36,36,40,40,40,48,48,48,48,16,12,12,52,36,36,40,40,40,48,48,40,40,40,40,36,36,36,36,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,40,40,40,40,40,40,40,40,0,0,0,0
	dc.b	48,16,16,52,40,40,40,40,48,48,48,48,16,16,12,12,40,40,40,40,40,40,48,40,40,40,40,40,48,48,48,48,48,16,16,16,52,52,52,52,52,36,36,36,36,36,36,36,36,36,36,36,40,40,36,36,36,36,36,36,36,40,40,40,0,0,0,0
	dc.b	48,48,48,48,16,16,48,48,40,48,48,48,48,16,16,16,48,40,36,36,40,40,40,40,48,40,48,48,48,40,40,48,48,48,48,48,48,16,12,12,12,12,12,12,52,16,40,40,40,40,36,36,36,36,36,36,36,36,36,36,24,24,24,24,0,0,0,0
	dc.b	40,48,48,48,48,48,48,48,16,48,48,48,48,16,16,48,48,40,36,36,40,40,40,40,48,40,40,40,40,36,36,40,40,48,48,48,48,48,48,48,48,48,16,16,16,16,16,48,48,48,48,40,40,36,36,24,24,28,28,28,28,32,32,32,0,0,0,0
	dc.b	40,40,52,16,48,48,48,16,12,12,48,48,48,16,16,48,48,40,36,40,40,40,40,40,48,40,36,36,40,40,40,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,36,36,24,24,28,28,28,28,0,0,0,0
	dc.b	40,52,60,12,12,16,16,48,12,4,16,48,48,48,48,48,48,40,36,36,36,36,36,40,48,40,36,36,36,36,36,36,36,36,40,40,40,48,40,48,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,48,40,40,40,40,40,40,36,36,36,36,40,40,48,40,40,36,36,36,36,40,48,48,48,48,48,48,40,12,12,48,48,48,40,40,40,40,40,0,0,0,0
	dc.b	28,28,28,28,28,24,36,36,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,40,40,40,40,36,36,36,40,36,40,48,40,40,36,36,36,36,40,48,48,16,48,48,48,40,40,52,48,48,48,48,48,48,48,40,0,0,0,0
	dc.b	28,28,28,28,24,24,24,24,24,36,36,40,40,48,48,48,48,16,16,16,16,16,16,16,48,48,48,48,48,48,40,48,40,40,40,48,40,40,48,48,40,40,36,36,36,36,40,48,48,16,48,48,48,48,40,40,40,48,48,48,48,48,48,48,0,0,0,0
	dc.b	24,24,24,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,52,52,16,12,12,12,12,12,16,48,48,48,48,48,48,48,40,40,48,48,40,40,40,40,40,40,36,36,36,40,16,16,16,48,48,48,48,40,40,40,40,40,16,16,48,48,0,0,0,0
	dc.b	48,48,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,52,52,52,16,16,48,48,48,40,40,40,36,36,36,40,40,40,40,36,36,36,40,52,12,16,48,48,48,48,40,40,40,36,36,36,36,36,40,0,0,0,0
	dc.b	40,40,40,40,40,40,40,40,40,40,40,40,36,36,36,40,40,40,40,40,40,40,40,40,36,36,36,36,36,36,40,40,40,36,24,24,36,36,40,40,40,48,40,40,36,36,36,36,52,12,12,16,48,48,48,48,40,36,36,36,36,36,24,24,0,0,0,0
	dc.b	36,36,40,36,36,40,40,40,48,48,40,40,40,40,40,40,40,36,40,40,40,40,40,40,40,40,40,40,36,36,36,36,36,24,24,28,24,36,40,48,48,48,40,40,40,40,36,36,36,60,4,16,48,48,48,48,40,36,36,36,36,36,36,24,0,0,0,0
	dc.b	36,36,36,36,36,36,36,40,40,40,48,48,40,40,40,40,48,48,40,40,40,40,40,40,40,40,40,40,40,40,40,40,36,36,36,24,24,24,36,48,48,48,48,40,40,40,40,36,36,40,4,12,48,48,48,48,40,40,36,36,36,36,36,24,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,40,40,40,48,40,36,40,40,40,40,40,48,48,48,48,48,48,48,40,40,40,48,40,36,36,24,36,36,24,24,24,24,40,48,48,48,40,40,40,36,36,36,60,12,48,48,48,40,40,40,40,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,40,40,40,40,40,48,48,40,36,36,40,40,48,48,40,40,40,40,40,40,40,48,48,40,40,36,36,36,36,36,24,24,36,24,28,36,48,48,48,40,40,40,36,36,36,36,12,16,48,48,48,40,40,40,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,40,40,40,40,40,40,48,40,48,40,24,36,36,36,36,36,36,24,24,24,24,24,24,24,36,36,36,36,36,36,36,36,36,36,24,28,28,24,36,40,48,48,40,40,36,36,36,36,60,12,48,48,48,40,40,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,40,40,40,40,40,48,48,48,48,48,36,24,24,24,24,28,24,36,24,28,28,28,28,28,28,28,24,28,28,28,24,36,36,24,24,24,28,28,28,36,36,48,48,40,40,40,36,36,36,36,16,48,48,40,40,40,36,40,36,36,36,36,0,0,0,0
	dc.b	40,40,40,40,40,48,48,48,48,48,48,48,40,36,36,24,24,36,36,36,36,24,24,24,24,28,32,32,28,28,28,28,28,28,28,24,24,24,28,28,32,24,36,40,48,48,40,40,36,36,40,36,40,48,48,48,48,40,36,40,36,36,36,40,0,0,0,0
	dc.b	40,48,48,48,48,48,48,16,16,16,40,36,36,40,36,36,36,36,36,36,36,36,24,24,24,24,28,28,32,32,28,28,28,28,28,28,28,28,28,32,32,24,24,36,48,40,40,36,40,36,36,36,36,40,48,48,48,40,40,40,40,40,40,40,0,0,0,0
	dc.b	48,48,48,48,48,48,12,12,60,36,36,40,36,36,40,36,36,36,36,40,36,36,24,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,24,24,24,40,40,36,36,36,24,24,24,28,24,36,40,48,48,40,40,48,48,48,48,0,0,0,0
	dc.b	48,48,48,16,12,12,12,52,36,36,36,40,40,40,40,40,40,40,40,36,24,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,32,28,24,28,28,36,40,36,36,24,36,24,24,24,24,36,36,36,40,40,40,48,40,40,36,0,0,0,0
	dc.b	48,16,16,12,4,12,40,36,36,40,40,40,40,40,48,48,40,36,24,28,28,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,32,28,28,28,36,40,36,36,36,24,24,24,24,36,40,40,40,36,36,36,40,36,36,36,0,0,0,0
	dc.b	16,16,12,12,52,40,36,40,40,40,40,48,40,48,48,40,24,24,24,24,28,28,32,28,28,28,28,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,24,36,36,36,24,36,24,24,36,48,48,40,40,40,40,40,40,36,36,36,0,0,0,0
	dc.b	12,12,12,52,36,36,40,40,40,48,48,48,48,48,40,36,24,28,28,28,28,32,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,36,36,24,24,28,24,24,36,40,48,40,40,40,40,40,36,36,36,36,36,0,0,0,0
	dc.b	16,16,40,36,36,36,40,40,40,40,48,48,48,40,24,24,24,28,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,24,24,28,28,28,28,24,40,48,48,48,40,36,40,36,36,36,36,36,40,0,0,0,0
	dc.b	40,36,36,36,40,40,40,40,40,48,48,48,48,24,28,24,28,28,24,24,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,32,28,24,24,24,40,48,48,40,48,40,40,40,36,36,36,40,40,16,0,0,0,0
	dc.b	36,36,40,40,36,40,40,40,48,48,48,48,36,24,24,24,24,24,36,24,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,32,32,28,28,28,28,32,28,28,28,28,24,36,40,48,48,48,40,40,40,40,36,36,36,40,12,12,16,0,0,0,0
	dc.b	36,36,36,40,40,40,48,40,40,48,40,36,24,24,24,36,36,36,36,24,28,28,28,28,28,28,28,32,32,32,32,32,32,32,32,32,32,28,28,28,28,28,28,28,24,24,24,36,40,48,48,40,40,40,40,36,40,36,36,52,12,12,16,48,0,0,0,0
	dc.b	36,36,36,40,40,40,40,40,40,40,40,24,24,24,24,36,36,36,36,36,28,28,28,32,28,28,28,28,32,32,32,32,32,32,32,32,28,28,28,28,28,28,24,24,28,24,40,48,48,48,48,40,40,40,40,36,36,40,60,12,16,16,16,48,0,0,0,0
	dc.b	36,40,48,48,40,40,40,36,36,36,24,24,24,24,36,36,36,36,36,36,28,28,28,32,28,28,28,28,28,28,32,32,28,28,28,28,28,28,28,28,28,28,28,28,36,40,40,40,40,40,40,40,36,36,36,36,52,12,12,16,48,48,48,48,0,0,0,0
	dc.b	40,48,40,48,48,48,48,40,40,36,24,24,24,36,36,36,36,36,36,40,24,28,28,32,32,28,28,28,28,28,28,28,32,28,28,28,28,28,28,28,28,24,36,36,36,36,36,36,36,40,36,36,36,36,36,52,12,16,48,48,48,48,48,48,0,0,0,0
	dc.b	40,40,40,40,40,48,48,48,48,48,40,36,36,40,36,40,36,40,40,40,36,24,24,32,32,28,24,24,28,28,28,28,28,28,28,28,32,28,24,24,36,36,36,36,36,36,36,36,36,36,40,36,36,36,52,16,16,48,48,48,48,48,40,40,0,0,0,0
	dc.b	40,36,36,40,40,36,40,40,48,48,48,52,36,40,40,40,40,40,40,48,40,24,24,28,24,24,24,36,24,28,28,28,24,28,28,32,32,28,28,24,28,28,24,36,24,24,24,24,24,24,36,40,48,48,48,48,48,40,40,40,40,40,36,36,0,0,0,0
	dc.b	36,36,36,40,40,40,40,48,48,48,48,12,36,36,36,36,40,40,48,48,48,36,24,28,28,28,24,24,36,36,36,24,28,28,28,24,24,28,28,28,28,28,28,24,24,24,24,24,24,24,24,36,48,48,40,48,40,40,40,40,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,40,40,40,48,48,16,12,52,36,36,36,40,48,48,48,48,40,36,24,28,28,24,36,36,36,36,36,36,36,36,36,36,24,24,24,36,24,28,24,24,24,24,24,36,24,36,40,48,48,40,40,40,40,40,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,40,40,40,48,48,16,12,12,36,36,36,40,48,40,40,48,48,48,36,28,24,36,36,36,36,36,36,36,36,40,40,48,40,40,40,40,48,48,40,40,48,40,48,40,36,36,40,48,48,40,40,40,40,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,40,48,48,48,48,48,16,4,12,40,36,36,40,48,40,48,48,48,40,24,36,24,24,24,36,36,36,36,36,40,40,40,48,48,48,48,48,48,48,48,48,40,48,40,40,36,40,48,40,36,40,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,40,40,48,48,48,16,12,4,40,36,40,40,40,40,48,48,48,48,40,36,24,24,24,36,36,36,40,40,36,36,40,40,40,40,48,48,48,48,40,40,40,48,40,40,40,40,48,48,40,40,40,36,36,36,36,36,36,24,0,0,0,0
	dc.b	24,36,36,36,40,40,40,48,48,48,48,48,16,12,60,36,36,40,40,40,40,48,48,48,48,40,36,24,28,24,36,36,36,36,36,36,36,40,40,36,40,40,40,40,40,40,40,40,40,40,40,40,40,40,40,48,40,40,36,36,36,40,40,36,0,0,0,0
	dc.b	24,36,36,36,36,40,40,48,48,48,48,48,12,12,12,52,36,40,40,40,40,40,48,48,40,40,36,36,24,24,36,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,40,40,40,40,40,40,40,48,40,40,40,40,40,0,0,0,0
	dc.b	40,36,36,36,36,40,40,48,48,48,48,48,16,12,16,12,40,36,40,40,40,48,48,40,40,36,36,40,40,48,48,48,48,16,16,16,52,52,40,40,40,40,36,36,36,36,36,36,36,36,36,40,40,40,40,36,36,36,36,36,36,40,48,48,0,0,0,0
	dc.b	16,16,16,16,16,40,40,40,48,48,48,48,48,12,16,16,40,40,36,40,40,40,40,48,48,40,48,48,48,48,48,48,48,48,48,48,48,16,12,12,12,12,12,52,16,40,40,40,40,40,36,36,36,36,36,36,40,36,36,36,36,24,24,24,0,0,0,0
	dc.b	48,48,48,48,48,48,48,48,48,48,48,48,16,16,16,48,48,40,36,40,40,40,40,40,40,40,40,40,40,36,40,40,48,40,48,48,48,48,48,16,16,16,16,12,12,16,16,16,48,48,40,40,36,36,36,24,24,24,24,24,24,28,28,28,0,0,0,0
	dc.b	48,48,16,40,48,48,16,16,12,48,48,48,48,16,16,16,48,40,36,40,40,40,40,40,48,40,36,40,40,36,36,40,40,40,40,40,48,48,48,48,48,48,48,48,48,16,16,16,48,48,48,48,48,40,40,40,36,36,24,24,28,28,28,28,0,0,0,0
	dc.b	40,52,12,12,52,16,16,48,12,4,48,48,48,16,16,48,48,40,36,36,40,36,40,40,40,40,40,36,36,36,36,40,40,40,40,40,40,40,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,48,40,36,36,36,36,0,0,0,0
