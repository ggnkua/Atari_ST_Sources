	dc.b	20,20,20,20,20,20,24,24,24,24,4,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	16,20,20,20,20,24,20,24,24,24,20,4,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,24,24,24,24,24,20,20,24,24,24,20,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,40,40,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,28,32,28,24,24,24,24,20,20,24,24,4,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,44,40,44,40,36,40,40,48,8,4,4,8,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,12,12,12,16,24,24,24,20,16,20,24,4,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,44,8,4,4,8,44,40,48,12,12,4,12,12,4,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,4,4,12,24,20,20,16,20,24,12,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,8,56,4,4,12,4,44,12,12,4,4,4,4,12,44,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,12,4,0,20,20,20,20,20,20,4,40,40,40,40,40,40,36,36,36,36,36,36,36,36,36,36,44,4,8,8,12,4,4,4,16,20,12,4,12,12,16,8,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	48,52,16,4,4,12,20,16,20,12,12,16,4,40,40,40,36,40,36,36,36,36,36,36,36,36,36,36,40,48,12,12,4,4,8,8,12,12,12,12,12,0,12,12,4,40,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,56,56,12,4,12,12,20,12,20,20,20,4,48,40,40,40,40,40,40,36,36,36,36,36,40,8,8,44,44,4,0,0,56,8,8,20,0,12,4,16,4,4,4,4,44,36,44,8,8,48,40,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	56,4,4,12,20,20,32,32,28,32,32,32,32,24,12,44,40,40,36,40,36,36,36,36,40,8,8,4,4,44,0,4,4,4,8,8,12,0,4,0,12,4,4,8,8,44,8,0,20,20,12,8,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,12,24,28,32,32,28,32,32,32,32,32,32,28,32,12,44,40,40,36,36,40,36,40,44,4,8,4,4,8,56,4,8,12,0,8,20,12,4,12,12,8,4,8,44,44,20,24,20,20,16,16,8,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,32,28,32,32,32,24,24,32,32,32,28,32,32,32,32,4,44,40,40,36,36,36,36,44,4,8,8,4,8,8,0,4,8,4,12,12,4,0,12,56,8,4,4,8,4,20,20,20,16,20,12,12,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,32,24,32,28,24,28,24,32,32,32,32,32,32,32,32,20,44,44,36,40,36,36,40,44,4,12,4,56,8,8,0,4,8,4,4,12,4,4,12,12,8,4,4,24,24,24,12,12,20,24,20,16,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,28,32,24,24,24,20,24,32,24,20,24,24,28,32,32,28,48,44,40,36,36,44,36,36,8,56,8,8,4,4,8,4,4,4,4,12,12,12,0,12,4,8,44,20,24,20,24,12,16,24,20,12,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,24,20,24,24,20,24,24,32,24,20,24,24,32,24,32,24,44,40,40,40,40,36,36,36,44,8,4,4,4,52,4,56,4,4,4,0,16,12,12,0,4,4,8,8,12,12,20,24,12,12,8,44,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,24,32,24,24,32,32,32,32,32,20,20,28,32,32,32,0,40,36,40,36,44,8,8,44,36,36,8,4,4,4,8,8,4,0,4,4,12,12,0,0,0,20,24,16,12,20,0,12,12,8,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,32,24,32,32,32,32,32,32,32,32,28,24,32,28,0,48,40,40,40,40,8,4,8,8,44,36,36,8,4,4,4,8,8,4,8,8,4,12,0,4,8,12,20,24,24,24,16,4,8,8,40,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,32,24,32,32,32,32,32,32,24,20,24,24,12,40,40,40,40,40,40,8,8,8,4,4,8,40,44,8,4,4,4,8,8,40,40,36,8,12,12,0,12,12,12,24,24,12,8,44,44,44,44,40,36,40,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	28,24,32,32,32,28,32,32,20,12,12,20,4,48,40,40,40,40,40,40,40,8,4,4,4,8,4,4,52,8,8,8,44,44,40,36,36,40,36,48,8,20,24,16,20,20,4,48,40,44,44,44,44,40,40,40,40,40,36,36,36,36,36,36,0,0,0,0
	dc.b	32,32,32,32,28,32,24,12,4,12,8,40,40,40,40,40,40,40,36,40,40,40,8,4,4,4,8,8,4,4,4,8,36,36,36,36,36,36,36,44,44,8,20,20,24,20,48,40,40,44,44,44,44,40,40,44,44,44,40,40,36,36,36,36,0,0,0,0
	dc.b	32,32,32,28,20,4,8,48,40,40,40,40,40,40,40,40,40,36,40,36,40,40,40,8,8,8,4,8,4,4,8,40,36,36,36,36,36,36,36,36,40,8,20,20,20,20,8,44,44,40,48,44,44,48,8,12,12,56,48,40,36,36,36,36,0,0,0,0
	dc.b	32,32,24,0,8,44,40,40,40,40,40,40,36,40,40,40,40,40,40,40,36,40,40,44,8,48,8,48,40,40,36,36,36,36,36,36,36,36,40,44,44,8,20,20,20,16,12,0,4,8,4,48,56,8,20,24,24,24,12,48,36,36,36,36,0,0,0,0
	dc.b	32,20,4,4,8,44,40,40,40,40,40,40,40,40,40,40,40,40,40,44,44,40,40,44,48,8,8,8,40,36,36,36,36,36,36,36,36,40,44,44,44,44,48,12,16,12,12,12,12,12,12,8,12,20,24,24,32,24,20,8,40,40,36,36,0,0,0,0
	dc.b	56,4,4,4,4,48,40,40,40,40,40,40,40,40,44,44,40,40,44,8,4,4,4,8,4,8,4,4,44,36,36,36,36,36,36,36,36,40,44,44,44,48,48,8,12,4,20,4,8,12,0,20,32,24,20,32,32,32,24,56,40,40,36,36,0,0,0,0
	dc.b	4,4,8,4,4,48,8,48,8,8,4,56,12,12,16,20,20,12,4,8,8,4,8,8,4,4,8,4,44,36,36,36,36,36,36,36,36,40,44,44,44,44,44,44,40,8,12,8,4,20,24,32,20,20,20,20,24,32,28,12,44,36,36,36,0,0,0,0
	dc.b	20,20,20,20,20,20,20,20,24,24,24,24,28,24,32,32,32,32,28,20,4,4,4,52,4,8,8,48,40,36,36,36,36,36,36,36,36,40,40,44,36,44,44,44,44,40,44,4,24,24,20,20,16,20,12,12,16,24,32,8,40,36,36,36,0,0,0,0
	dc.b	20,20,20,16,20,12,12,20,12,12,12,20,24,28,32,32,32,28,32,28,4,48,48,44,44,44,44,40,36,36,36,36,36,36,36,44,44,44,44,40,44,40,44,44,44,8,16,32,24,16,12,20,16,20,20,16,24,24,24,48,44,40,40,40,0,0,0,0
	dc.b	20,20,16,16,12,12,0,4,12,12,12,20,24,32,32,28,32,32,32,32,24,8,48,40,40,36,40,40,36,36,36,36,36,36,44,48,48,44,48,44,44,36,40,44,8,20,24,24,20,12,12,12,12,20,24,24,32,16,8,40,40,40,40,44,0,0,0,0
	dc.b	20,20,16,12,12,12,4,12,20,16,20,20,16,32,24,32,32,32,32,32,32,4,48,48,44,36,36,40,36,36,36,36,36,44,44,8,44,44,48,48,44,40,44,44,12,16,20,20,24,16,12,12,12,24,28,32,20,8,40,44,40,44,8,44,0,0,0,0
	dc.b	20,20,20,20,20,20,24,24,20,20,16,20,32,24,32,32,24,32,32,32,32,4,4,4,8,40,40,36,36,36,36,36,36,44,44,44,44,44,44,44,44,44,36,44,20,16,20,12,20,24,20,20,24,24,12,8,48,48,40,44,44,48,48,44,0,0,0,0
	dc.b	24,20,20,16,4,12,8,8,48,48,20,28,32,28,32,28,32,32,32,32,28,8,4,8,4,8,40,36,36,36,36,36,36,44,44,40,36,36,40,40,44,48,44,40,12,20,20,12,12,28,32,24,24,12,48,44,48,44,44,44,44,8,44,8,0,0,0,0
	dc.b	4,4,4,4,48,40,40,40,48,12,32,32,32,32,32,32,32,32,32,32,16,4,4,4,8,8,36,36,36,36,36,36,36,44,44,44,40,40,36,36,36,44,36,36,44,12,20,20,16,16,16,0,4,0,12,4,8,44,44,44,8,48,48,8,0,0,0,0
	dc.b	8,8,4,8,44,40,44,8,24,28,32,24,24,24,24,32,32,32,32,28,4,48,8,4,8,44,36,36,36,36,36,36,36,44,44,8,8,8,44,40,36,36,36,40,36,40,48,8,4,12,0,4,4,4,12,12,12,8,48,48,48,48,8,48,0,0,0,0
	dc.b	8,4,8,4,44,40,4,28,32,24,20,20,20,24,20,24,24,32,28,16,44,44,40,40,44,44,36,36,36,36,36,36,44,8,8,44,44,44,8,44,36,36,36,44,36,40,36,44,40,48,4,12,12,4,4,12,12,12,12,8,48,8,44,44,0,0,0,0
	dc.b	4,4,8,8,48,56,28,32,24,24,20,20,20,20,32,24,24,32,32,8,40,48,40,44,40,36,44,36,36,36,36,44,8,44,8,8,8,8,44,44,40,36,36,36,36,36,40,40,40,40,40,48,56,12,12,4,12,12,20,16,8,44,44,36,0,0,0,0
	dc.b	8,8,4,8,20,28,32,32,32,28,32,32,32,32,32,32,32,32,12,8,4,4,8,40,44,36,36,36,36,36,36,44,44,8,44,36,44,44,44,44,44,36,40,44,44,40,44,36,36,36,36,36,36,8,12,12,20,12,12,20,4,40,44,36,0,0,0,0
	dc.b	8,8,4,24,32,28,32,32,32,32,32,24,32,32,32,32,32,32,20,12,4,4,4,8,44,40,36,36,36,36,36,44,8,44,44,40,44,44,44,44,36,40,40,44,8,12,0,4,48,40,36,36,36,40,8,12,24,20,16,16,12,44,44,44,0,0,0,0
	dc.b	8,12,28,32,32,32,32,32,32,32,32,32,32,32,28,32,32,16,20,28,20,4,4,4,44,36,36,36,36,44,44,44,44,44,44,8,8,4,8,44,36,36,36,44,16,20,20,20,12,8,44,40,40,40,40,8,16,20,20,20,16,8,44,44,0,0,0,0
	dc.b	28,28,32,32,32,32,32,32,32,32,32,32,32,32,32,28,16,12,12,20,28,12,8,4,40,44,36,36,36,36,36,44,8,8,8,8,8,8,8,8,40,44,36,8,20,20,16,20,12,12,4,48,48,8,12,24,16,20,16,20,20,8,44,48,0,0,0,0
	dc.b	32,32,32,28,32,32,32,32,32,32,32,32,32,32,32,16,12,12,12,16,20,28,4,8,40,36,40,36,36,36,36,44,8,8,8,8,8,8,8,40,44,40,36,8,20,20,12,12,24,24,24,24,24,24,32,24,24,20,20,20,20,8,8,8,0,0,0,0
	dc.b	20,20,24,24,24,24,24,24,4,44,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,24,20,28,24,24,24,28,24,4,44,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,24,24,24,24,16,24,24,24,24,52,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,44,44,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,32,24,24,24,24,20,20,24,24,20,44,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,44,48,8,44,36,36,40,44,8,0,12,4,8,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,28,24,24,24,24,24,20,20,24,24,8,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,44,4,4,12,4,8,36,44,56,12,4,4,12,12,8,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,4,12,20,28,24,24,24,16,24,24,4,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,8,4,4,4,4,56,48,52,12,12,4,4,12,12,12,44,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,8,24,24,20,20,20,20,28,4,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,44,4,4,8,4,12,4,8,12,12,12,0,4,4,20,12,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,12,4,4,20,20,20,16,20,20,24,4,40,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,44,4,12,4,4,4,8,4,20,12,4,20,12,12,0,4,48,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,0,4,12,20,20,12,12,12,20,12,8,44,40,40,40,36,36,36,36,36,36,36,36,36,8,4,44,44,12,4,0,56,4,48,4,12,0,0,12,12,4,8,4,48,36,36,44,8,8,48,40,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	0,4,12,20,12,12,12,12,12,12,12,8,44,44,44,40,36,36,36,36,40,36,40,36,4,4,4,4,44,4,4,4,56,4,8,12,12,0,0,12,12,8,4,4,44,40,4,20,20,20,12,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,20,20,12,12,20,28,32,32,32,28,28,20,4,44,44,36,40,40,36,36,40,36,48,8,8,4,8,8,4,4,8,4,4,8,12,12,4,4,20,4,8,8,8,40,8,24,24,24,20,20,16,8,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,12,28,32,28,32,32,32,32,32,32,32,32,28,20,44,44,36,36,36,40,36,40,48,4,8,8,8,8,8,12,4,8,4,4,4,12,4,4,12,4,8,4,8,44,8,20,24,20,20,20,12,12,40,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,32,32,32,32,32,32,32,32,32,32,32,32,32,28,12,36,40,40,36,44,36,36,44,8,4,4,4,4,8,8,4,4,4,4,12,12,4,0,20,4,52,8,8,20,20,20,12,12,20,24,20,20,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,32,32,32,24,24,32,32,32,32,28,32,32,32,32,32,8,44,36,44,36,36,44,36,8,4,4,8,4,4,8,12,4,4,4,4,20,0,12,12,4,8,8,8,24,24,20,24,16,20,20,20,12,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,32,32,32,28,24,32,32,28,24,24,24,32,32,32,32,4,40,44,44,40,40,36,36,36,4,4,8,8,4,4,4,4,12,4,4,12,12,12,4,12,4,44,44,0,20,20,24,24,12,20,4,44,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,24,20,20,20,24,32,24,20,20,24,24,24,32,32,8,44,36,36,48,4,8,40,36,40,8,4,4,4,8,4,4,4,0,4,0,20,12,12,4,12,12,12,0,12,12,12,24,12,8,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	16,24,24,24,24,32,32,32,28,12,24,24,24,32,28,20,48,40,40,44,8,8,8,48,36,40,36,48,4,4,4,8,8,4,4,4,4,12,12,4,4,4,20,32,32,20,24,12,4,4,44,40,40,36,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,32,32,32,32,32,32,32,32,32,16,32,32,28,32,8,44,44,36,44,4,8,8,4,8,48,44,44,8,4,4,4,4,8,44,44,44,48,12,4,0,4,4,12,20,24,24,20,8,44,48,44,36,40,36,40,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,24,24,32,32,24,32,32,32,32,24,24,12,8,44,40,40,40,44,8,8,4,4,52,52,52,52,8,4,8,44,40,40,40,36,36,40,44,4,4,20,24,0,12,20,12,8,40,48,44,44,44,40,40,40,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	24,28,32,32,32,32,32,32,32,20,20,12,8,48,44,40,36,36,40,40,44,8,4,8,4,8,8,8,4,8,8,36,36,36,36,36,36,36,36,44,44,12,28,20,24,24,4,44,40,44,44,44,44,40,40,44,44,44,40,40,36,36,36,36,0,0,0,0
	dc.b	32,32,32,32,32,32,28,32,12,56,4,48,44,40,40,40,40,40,40,36,40,44,8,8,4,4,8,4,4,8,44,36,36,36,36,36,36,36,44,36,40,8,20,20,20,20,8,36,44,44,44,44,44,44,8,8,12,4,48,40,36,36,36,36,0,0,0,0
	dc.b	32,32,32,32,28,24,12,8,48,44,44,40,40,40,40,40,36,36,36,40,40,40,8,8,44,8,8,48,48,44,36,36,36,36,36,36,36,44,44,44,44,56,24,20,20,20,12,4,8,8,8,8,4,4,4,20,20,20,12,8,36,36,36,36,0,0,0,0
	dc.b	32,32,32,28,4,44,44,40,40,44,40,40,36,40,40,40,40,36,40,40,40,40,44,48,8,8,8,40,40,36,36,36,36,36,36,36,36,44,44,44,44,48,12,20,20,12,12,20,12,12,12,8,4,4,20,24,24,24,20,4,40,40,36,36,0,0,0,0
	dc.b	32,32,20,8,44,44,40,40,40,36,40,40,40,36,40,40,40,40,8,8,8,8,8,8,4,8,8,48,36,36,36,36,36,36,36,36,36,44,44,48,44,44,44,12,20,12,12,12,4,12,0,4,12,24,28,24,32,24,24,12,40,40,36,36,0,0,0,0
	dc.b	28,12,4,52,44,44,40,40,40,36,40,40,40,40,40,40,44,48,8,8,4,52,4,4,4,8,8,8,36,36,36,36,36,36,36,36,44,44,44,44,48,44,48,48,48,4,12,8,4,4,4,20,32,24,16,20,24,24,32,20,44,40,36,36,0,0,0,0
	dc.b	4,4,8,8,44,48,44,40,36,40,36,40,44,44,44,48,44,8,8,8,4,4,4,8,4,4,8,44,40,36,36,36,36,36,36,36,44,36,36,40,44,48,44,44,44,40,44,44,4,20,24,32,24,24,12,20,24,16,32,20,44,36,36,36,0,0,0,0
	dc.b	8,8,4,8,48,48,48,8,4,12,12,20,20,20,24,24,24,20,4,8,4,8,8,52,8,8,8,36,36,36,36,36,36,36,44,44,48,44,44,36,40,40,44,44,44,40,8,4,24,24,20,20,20,20,20,12,16,24,32,12,36,36,44,44,0,0,0,0
	dc.b	20,20,20,20,20,20,24,24,20,24,24,24,32,32,32,32,32,28,32,12,44,48,40,40,40,36,40,40,36,36,36,36,36,48,48,44,44,44,48,44,40,36,44,44,44,8,12,28,24,20,12,12,12,20,20,20,24,24,20,8,40,44,44,48,0,0,0,0
	dc.b	24,20,20,20,20,12,12,12,12,12,12,20,32,28,32,32,28,32,28,28,12,8,48,40,40,40,36,36,36,36,36,36,40,44,44,48,44,44,48,48,44,36,36,40,8,20,12,24,24,20,12,12,12,20,28,20,28,20,48,44,44,48,48,44,0,0,0,0
	dc.b	20,12,12,0,12,4,4,12,12,12,20,24,32,32,32,32,32,32,32,28,20,44,8,48,40,40,40,36,36,36,36,36,36,48,44,44,44,48,48,48,44,44,36,44,20,12,20,12,20,24,12,12,12,16,32,24,20,8,44,44,48,48,48,44,0,0,0,0
	dc.b	20,20,12,0,12,0,12,12,20,20,16,16,24,32,32,32,32,32,32,32,28,4,8,4,8,44,36,36,36,36,36,36,44,48,44,44,36,36,36,44,48,36,36,44,12,20,20,12,12,24,24,24,24,28,20,8,48,8,44,44,8,8,48,48,0,0,0,0
	dc.b	20,12,12,20,20,20,20,24,24,24,24,20,24,24,28,24,32,24,32,32,32,4,8,8,8,44,36,36,36,36,36,36,36,44,44,44,44,44,36,36,36,40,36,40,4,20,20,12,12,24,32,24,20,20,4,8,44,44,44,48,8,48,48,8,0,0,0,0
	dc.b	24,24,24,20,20,12,4,4,8,8,12,32,32,32,32,32,32,32,32,32,24,4,8,8,8,44,36,36,36,36,36,36,44,8,8,8,48,48,44,44,36,36,36,44,44,4,12,20,12,20,12,12,4,4,12,12,4,4,48,48,48,48,48,48,0,0,0,0
	dc.b	12,4,8,44,40,40,40,40,44,8,32,32,32,32,32,32,32,32,32,32,12,48,48,8,44,40,36,36,36,36,36,44,48,48,48,44,48,48,48,44,36,36,36,40,36,40,44,48,48,4,4,4,4,4,4,12,0,12,4,8,48,48,44,40,0,0,0,0
	dc.b	8,8,8,44,40,40,40,44,8,32,28,32,32,32,28,24,32,32,32,32,4,44,44,44,40,36,40,36,36,36,40,48,48,44,8,8,48,48,44,44,36,36,36,36,36,36,40,40,40,44,48,8,12,4,12,0,4,16,20,12,48,40,44,36,0,0,0,0
	dc.b	4,52,44,40,40,44,44,4,32,32,28,24,24,32,24,24,24,24,28,32,44,44,44,40,36,36,36,36,36,36,40,48,48,44,44,8,44,8,44,36,44,36,36,40,36,40,40,36,40,40,40,40,48,4,12,12,12,12,12,12,12,44,44,44,0,0,0,0
	dc.b	8,52,44,40,44,44,0,28,32,16,24,16,24,24,24,24,24,32,32,20,4,8,48,40,40,36,36,36,36,36,48,48,48,36,44,40,44,40,40,44,36,36,36,36,40,44,44,44,40,36,40,40,36,40,4,12,12,12,12,12,20,8,44,44,0,0,0,0
	dc.b	52,8,48,44,48,20,28,32,32,32,32,32,32,32,32,24,32,32,24,4,4,4,4,48,40,40,36,36,36,40,48,48,44,44,8,8,8,8,8,44,40,36,36,40,8,12,16,0,8,44,40,40,36,40,44,8,20,24,20,20,12,4,44,44,0,0,0,0
	dc.b	8,4,44,8,24,28,28,32,32,32,32,32,32,32,32,32,32,32,20,0,8,8,8,44,40,40,40,36,36,36,48,48,8,8,8,8,8,8,8,44,36,44,36,44,12,20,20,24,12,4,8,44,40,36,40,44,12,20,20,20,20,12,48,8,0,0,0,0
	dc.b	52,8,4,20,28,32,32,24,32,32,32,32,32,32,32,32,32,32,24,24,4,8,4,8,40,36,40,36,36,36,44,44,8,8,8,8,8,8,8,44,44,40,36,44,20,20,20,24,12,4,4,8,44,44,8,20,20,12,16,20,20,12,48,48,0,0,0,0
	dc.b	24,24,32,32,32,24,4,44,40,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,24,24,24,28,24,4,44,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,20,24,24,24,24,24,24,4,44,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,36,36,36,36,40,36,36,48,8,44,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,24,24,24,24,24,24,24,4,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,44,8,4,8,44,40,36,40,8,12,56,12,12,8,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,28,24,24,24,24,24,28,12,44,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,44,4,4,4,4,4,44,36,8,12,4,4,0,12,12,44,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,32,24,24,24,24,20,24,24,20,44,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,8,4,8,4,56,4,8,48,12,20,0,4,4,0,20,8,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	0,12,24,24,24,24,16,24,24,24,8,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,40,4,56,8,8,12,4,8,4,20,12,12,0,4,12,20,8,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,12,24,24,20,20,20,24,24,8,40,40,40,36,36,36,36,36,36,36,36,36,36,40,36,40,40,4,4,0,4,4,8,8,12,12,12,12,12,12,0,4,4,44,36,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	0,4,12,24,20,20,12,20,20,20,48,44,40,40,40,40,36,40,36,36,36,36,36,44,8,4,8,36,4,4,4,4,4,8,8,20,12,4,12,20,0,8,4,52,40,40,36,36,8,8,48,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	0,0,24,20,12,12,20,20,20,12,48,40,40,40,40,40,36,36,36,36,36,40,44,8,8,4,4,44,4,12,4,4,12,8,8,12,12,12,4,12,4,8,4,8,44,40,4,20,20,20,12,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,20,20,12,12,12,12,12,12,4,48,44,44,40,40,40,40,36,36,36,36,40,48,52,8,4,8,8,8,4,4,4,4,4,4,20,4,4,0,20,4,8,4,44,40,8,24,24,24,20,20,16,8,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,20,12,0,0,20,20,28,24,20,20,12,4,44,40,40,40,36,36,36,36,36,44,8,8,8,4,8,8,4,4,8,4,4,4,12,12,4,0,12,8,4,8,44,40,8,24,20,24,20,20,12,12,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	0,0,12,24,28,32,32,32,32,32,32,28,32,12,48,40,40,36,36,36,44,36,44,4,4,4,4,4,44,8,4,4,4,4,4,12,4,0,0,12,4,52,8,44,12,20,20,12,12,20,24,24,20,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,32,32,32,28,32,32,32,28,32,32,32,32,28,12,44,44,40,40,40,36,36,40,8,4,4,8,4,4,8,4,4,4,4,4,12,12,0,12,12,4,8,44,4,24,24,24,24,12,12,24,24,12,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,32,32,32,32,32,28,32,32,32,32,32,32,32,28,4,40,40,40,44,40,44,36,36,8,4,4,4,4,4,4,56,0,4,4,4,20,12,12,12,4,8,36,40,20,20,20,24,20,20,20,4,44,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,32,24,24,32,32,32,24,32,32,24,32,32,28,32,12,44,44,36,44,8,8,36,36,40,8,4,4,4,4,8,4,4,4,4,4,20,12,12,12,12,4,56,4,4,12,12,20,24,12,8,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,24,20,24,24,32,32,20,20,24,24,24,28,32,32,0,44,40,40,8,8,4,48,36,36,40,8,4,4,4,4,8,8,4,4,12,4,12,0,4,12,4,24,24,24,12,20,0,12,4,48,40,40,36,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	16,20,16,24,24,24,28,20,20,20,20,24,24,32,28,0,44,44,44,4,8,8,52,8,48,44,40,8,52,4,4,4,56,8,44,36,44,4,12,4,4,4,0,24,24,24,32,12,44,44,48,44,40,40,36,40,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	32,28,28,32,28,32,32,32,20,20,24,24,32,28,20,48,44,40,44,8,8,8,4,4,4,8,8,4,8,8,8,36,40,40,44,36,36,44,4,56,0,12,12,12,12,20,20,4,44,44,44,44,40,40,40,40,40,40,36,36,36,36,36,36,0,0,0,0
	dc.b	24,28,32,28,32,32,32,32,32,24,24,32,24,12,48,44,44,40,40,48,8,4,4,8,8,8,8,8,52,8,44,40,36,36,36,36,36,36,36,44,8,24,20,20,20,20,4,44,44,48,44,44,36,40,40,44,44,44,40,36,36,36,36,36,0,0,0,0
	dc.b	32,32,32,32,32,32,32,32,32,28,20,52,48,48,44,40,40,40,40,40,48,8,4,4,4,8,4,4,4,8,40,36,36,36,36,36,36,44,40,40,40,12,20,20,24,24,8,40,40,44,44,44,40,44,48,8,4,8,48,40,36,36,36,36,0,0,0,0
	dc.b	24,32,32,32,32,32,28,28,20,12,8,8,44,40,40,40,40,40,40,40,40,44,48,8,4,8,8,8,48,40,36,36,36,36,36,36,36,44,44,44,36,56,20,20,20,20,12,8,48,8,8,8,4,8,4,12,20,20,12,44,36,36,36,36,0,0,0,0
	dc.b	32,32,32,32,32,28,28,4,48,48,40,44,40,40,44,40,40,40,40,40,40,40,48,8,8,8,44,40,36,36,36,36,36,36,36,40,44,44,44,44,40,52,24,20,20,12,12,12,12,12,12,8,12,4,0,24,24,24,20,12,40,36,36,36,0,0,0,0
	dc.b	32,32,32,32,32,0,48,44,44,44,40,40,44,40,40,40,40,36,48,48,44,44,48,8,8,8,48,36,40,36,36,36,36,36,36,44,44,44,44,48,44,44,8,20,16,0,20,56,0,12,0,4,0,4,20,24,24,24,24,20,8,40,36,36,0,0,0,0
	dc.b	32,32,28,24,8,44,44,44,40,44,40,40,40,40,40,40,8,8,8,4,4,52,4,52,8,8,8,40,36,36,36,36,36,36,36,44,44,44,44,44,44,44,44,4,4,4,20,4,0,0,4,4,12,32,32,24,24,24,24,24,8,40,36,36,0,0,0,0
	dc.b	32,32,12,44,44,44,40,40,40,40,36,40,40,40,40,40,8,8,8,8,52,8,8,52,8,52,8,40,36,36,36,36,36,36,36,40,40,40,40,36,48,44,44,44,36,8,8,48,4,4,4,20,32,24,24,20,24,16,24,24,8,40,40,40,0,0,0,0
	dc.b	32,0,44,44,40,40,40,40,40,40,40,40,40,40,40,40,8,52,8,4,4,52,4,52,8,8,44,36,36,36,36,36,36,44,48,44,44,44,44,40,40,8,44,44,40,40,44,44,8,20,24,32,24,16,20,20,32,24,24,28,8,40,40,48,0,0,0,0
	dc.b	52,52,48,40,44,40,40,44,40,40,44,44,48,48,48,44,8,8,8,8,48,44,44,48,40,36,36,40,36,36,36,36,44,44,44,44,44,48,48,40,36,36,44,44,40,40,44,12,24,24,20,20,16,20,20,12,16,28,24,20,48,44,48,48,0,0,0,0
	dc.b	8,4,48,48,48,48,8,4,0,12,20,20,24,24,28,32,24,12,4,48,48,48,40,40,40,40,40,40,36,36,36,36,48,44,48,44,48,44,48,44,44,36,40,40,36,4,20,24,32,20,12,12,20,20,24,20,20,28,20,8,44,44,48,44,0,0,0,0
	dc.b	12,12,12,20,20,20,24,24,24,24,24,28,32,32,32,32,32,28,32,4,44,8,48,40,40,40,36,36,36,36,36,36,44,48,44,40,44,48,44,44,44,36,40,36,4,20,12,12,24,16,20,12,12,12,24,24,24,24,8,44,44,48,48,44,0,0,0,0
	dc.b	24,24,20,20,20,20,12,12,12,20,20,24,28,32,32,32,32,32,32,32,4,8,8,48,44,40,40,36,36,36,36,36,44,44,44,36,36,36,44,44,44,36,36,44,12,20,20,12,12,20,20,12,20,20,24,24,20,8,44,48,48,48,48,48,0,0,0,0
	dc.b	12,12,12,0,4,0,4,12,12,20,20,24,32,32,32,32,32,32,32,32,12,8,8,4,48,36,36,36,36,36,36,36,44,44,44,44,44,40,36,36,36,40,36,36,0,20,20,12,12,24,24,24,24,24,28,4,44,44,48,48,48,48,48,8,0,0,0,0
	dc.b	12,12,0,0,0,12,12,12,12,20,24,24,32,32,28,32,32,32,32,32,24,8,8,4,48,40,36,36,36,36,36,36,48,8,8,8,48,44,40,36,36,36,36,44,8,20,20,12,12,24,28,24,24,20,12,4,4,48,48,44,48,48,48,44,0,0,0,0
	dc.b	12,12,12,12,12,20,20,24,24,28,24,24,28,24,32,24,32,32,32,32,24,8,4,8,44,40,36,36,36,36,36,44,48,48,48,44,8,44,44,36,36,36,36,40,36,48,0,12,12,16,12,12,4,4,4,4,12,12,52,48,48,44,40,40,0,0,0,0
	dc.b	20,20,24,24,24,20,12,12,12,4,12,24,32,24,32,32,32,32,32,32,20,44,48,40,44,36,44,36,36,36,44,48,48,44,8,8,48,44,44,36,36,36,36,36,36,40,36,44,44,48,8,12,4,4,4,4,4,12,12,12,48,40,40,36,0,0,0,0
	dc.b	24,12,4,8,48,44,44,40,44,44,20,28,32,32,32,32,24,32,32,28,20,44,44,40,36,36,36,36,36,44,48,48,48,48,44,44,44,48,44,36,36,36,36,36,40,40,40,36,40,40,40,44,4,12,12,4,12,0,12,12,12,44,44,44,0,0,0,0
	dc.b	8,44,40,40,40,40,44,44,44,12,28,32,28,32,28,32,32,32,32,32,12,44,40,40,36,40,36,36,36,36,48,48,44,36,40,44,44,40,36,36,36,36,36,36,36,36,36,36,40,40,40,40,36,8,12,12,0,12,12,12,20,4,44,44,0,0,0,0
	dc.b	4,44,40,40,40,40,40,44,4,28,28,32,24,28,32,24,24,24,32,28,4,8,48,40,40,36,36,36,36,40,8,48,44,36,8,48,8,8,44,36,36,36,40,44,36,8,8,8,44,40,40,40,40,40,44,4,12,20,12,20,12,12,44,44,0,0,0,0
	dc.b	52,44,40,44,40,44,48,12,32,32,32,24,16,24,16,24,28,32,32,32,4,52,8,44,40,40,36,36,36,36,48,48,8,8,8,8,8,8,48,36,36,40,36,36,4,16,20,12,0,8,44,40,36,40,36,44,4,24,20,20,20,20,8,8,0,0,0,0
	dc.b	8,44,40,40,36,44,4,28,32,32,32,32,28,32,28,32,24,32,32,12,8,8,8,44,40,36,40,36,36,36,48,48,8,8,48,8,8,8,8,36,40,40,40,36,4,20,20,24,12,4,4,48,40,40,40,40,8,20,12,20,20,20,8,48,0,0,0,0
	dc.b	32,32,32,12,4,40,40,40,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,32,32,32,24,4,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,24,24,28,24,12,44,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,44,40,40,36,40,36,36,44,8,8,8,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,24,24,24,28,24,4,44,40,40,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,40,44,4,4,0,8,44,36,40,48,12,12,12,12,12,48,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,24,24,24,24,32,24,8,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,4,4,8,4,4,8,40,44,12,4,4,4,4,12,4,40,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,24,24,24,24,24,24,12,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,8,4,8,4,4,12,52,44,4,20,12,4,4,4,20,20,48,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	28,24,24,24,24,24,24,24,20,44,40,40,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,8,12,4,8,4,4,8,44,12,20,20,12,4,0,12,12,44,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,28,24,24,16,24,20,24,20,44,40,40,36,36,36,36,36,36,36,36,36,36,40,44,40,40,40,4,12,4,4,56,8,8,4,20,0,12,12,12,12,4,12,8,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,32,20,24,16,16,24,24,20,44,40,40,40,40,36,36,36,40,36,36,36,36,44,8,4,8,36,4,12,4,4,56,8,48,4,20,0,0,12,20,4,8,4,8,40,40,36,36,4,8,48,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,24,20,24,20,20,20,24,12,40,40,44,40,40,40,36,40,36,36,40,36,44,4,8,4,4,48,8,12,4,4,12,4,8,56,12,0,0,12,12,4,8,8,44,40,36,4,12,20,20,12,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,24,20,12,12,20,20,20,4,44,40,40,40,40,40,36,36,36,36,36,36,44,4,8,8,4,8,48,4,4,4,4,4,48,4,12,0,4,12,12,8,4,8,44,40,8,20,24,20,20,20,16,8,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,20,12,12,12,12,20,12,48,48,44,40,40,40,36,40,36,36,36,36,40,44,8,8,8,4,8,48,4,4,8,4,12,4,12,12,0,4,12,12,8,4,8,36,40,4,24,24,24,16,20,12,12,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,12,12,0,12,12,12,12,4,4,4,44,44,40,40,40,36,36,40,40,40,44,4,4,4,4,4,8,8,56,4,8,4,4,4,12,4,0,12,12,8,4,44,44,4,12,20,12,12,20,24,16,24,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	0,0,12,20,28,32,32,32,32,28,32,32,0,44,40,40,40,40,36,40,36,36,44,56,4,8,4,4,8,8,4,4,4,4,4,20,12,12,12,12,8,8,40,4,28,24,24,20,12,12,24,24,12,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,28,32,28,32,32,32,32,32,32,32,32,28,12,48,40,40,40,36,44,44,40,36,4,4,4,4,4,4,4,12,0,12,4,4,12,12,12,12,12,4,44,36,48,20,24,24,24,24,12,24,12,44,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,32,32,32,32,32,32,32,32,32,32,32,32,28,4,40,40,44,44,8,44,44,36,36,8,4,8,4,4,8,8,12,4,12,4,4,20,12,12,12,12,4,4,4,4,12,12,20,24,20,4,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,32,32,24,32,32,32,24,32,24,32,32,32,32,20,48,40,44,8,4,8,48,40,40,36,8,4,4,4,8,4,8,4,12,4,4,20,0,4,4,0,0,24,20,12,0,20,4,12,12,44,40,36,36,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,24,24,32,32,20,24,24,24,24,32,32,32,24,48,40,44,8,8,8,4,8,40,36,40,44,4,12,4,4,4,8,44,44,44,8,12,4,4,56,4,20,24,24,24,24,12,44,44,48,40,40,40,36,40,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	24,20,24,24,32,32,16,20,20,20,24,32,24,32,24,44,44,44,8,8,8,4,8,4,4,8,4,8,8,8,44,40,36,40,44,36,40,44,56,56,56,4,12,12,20,24,24,20,44,44,44,44,40,40,36,40,40,40,36,36,36,36,36,36,0,0,0,0
	dc.b	24,28,32,32,32,32,20,20,20,24,32,32,32,32,12,40,44,44,48,4,4,4,8,8,8,8,4,8,4,8,36,36,36,36,36,36,36,36,40,8,8,24,24,12,12,24,4,48,44,44,44,40,40,40,40,44,48,44,40,40,36,36,36,36,0,0,0,0
	dc.b	32,32,32,32,32,32,32,20,12,16,32,32,32,0,44,40,40,40,40,48,8,4,8,8,8,8,4,4,8,40,40,36,36,36,36,36,36,44,44,40,44,20,24,20,24,24,4,40,44,44,44,40,40,40,44,48,8,8,44,40,36,36,36,36,0,0,0,0
	dc.b	24,32,32,32,32,32,32,32,28,32,24,12,4,44,40,40,40,40,40,40,48,8,8,12,4,8,4,8,44,40,36,36,36,36,36,44,44,44,44,44,44,0,16,20,20,20,8,48,44,44,48,48,8,8,4,12,20,12,12,44,40,36,36,36,0,0,0,0
	dc.b	32,32,32,32,32,32,32,32,28,12,8,48,40,40,44,40,40,40,40,40,44,44,8,8,8,44,36,40,40,36,36,36,36,36,36,40,44,44,44,44,44,12,24,12,12,20,12,12,4,12,4,8,12,8,4,12,24,16,20,20,40,40,36,36,0,0,0,0
	dc.b	32,32,32,32,32,32,32,32,4,44,48,40,40,40,40,40,40,44,44,40,40,44,8,8,8,8,40,36,36,36,36,36,36,36,36,44,44,44,44,44,44,48,12,20,20,16,20,12,12,12,12,4,12,4,0,24,24,24,20,20,4,36,36,36,0,0,0,0
	dc.b	32,32,32,32,32,28,12,48,40,40,40,44,40,40,44,40,8,8,4,8,8,8,4,4,8,8,48,36,36,36,36,36,36,36,36,40,44,40,44,44,44,44,44,12,12,12,12,0,12,12,4,56,56,12,20,24,24,16,24,20,4,40,36,36,0,0,0,0
	dc.b	32,32,32,32,20,4,40,44,40,40,44,40,36,40,40,8,8,8,4,8,8,8,4,8,8,8,44,40,36,36,36,36,36,36,40,44,40,36,36,36,44,44,44,44,48,4,12,8,12,4,44,4,20,24,32,32,24,20,20,32,12,40,40,44,0,0,0,0
	dc.b	32,32,32,20,48,40,44,40,40,40,40,40,40,40,44,8,8,8,4,8,8,4,8,4,8,48,36,40,36,36,36,36,44,44,44,44,44,44,36,36,40,44,44,44,36,40,40,40,44,44,0,24,24,24,24,28,32,32,24,24,4,44,44,48,0,0,0,0
	dc.b	32,32,0,44,40,40,40,44,40,40,40,40,40,40,40,8,4,8,4,4,8,8,8,44,8,36,40,40,36,36,36,36,44,44,44,44,44,44,44,36,36,36,44,40,40,40,40,44,8,16,28,24,24,24,24,20,32,32,24,24,12,44,48,44,0,0,0,0
	dc.b	32,8,44,44,40,44,44,40,40,40,40,40,40,44,44,48,4,8,8,44,48,40,40,36,40,40,36,36,36,36,36,40,44,44,44,44,44,44,44,44,36,40,36,40,36,36,8,12,28,24,16,16,20,20,24,20,20,24,28,20,8,44,48,44,0,0,0,0
	dc.b	8,44,40,40,40,40,40,40,40,40,40,48,48,48,48,48,8,48,48,8,8,44,40,40,36,40,40,36,36,36,36,44,44,44,44,44,44,44,44,44,36,36,36,36,44,4,20,20,24,24,20,12,12,20,24,24,20,24,20,8,44,48,48,44,0,0,0,0
	dc.b	48,40,44,48,48,48,4,56,12,20,24,24,32,32,24,32,24,12,8,8,8,8,48,40,36,36,36,36,36,36,36,40,44,36,40,36,36,36,44,44,44,40,36,36,4,20,12,0,20,24,20,12,12,12,20,28,24,28,4,44,44,8,48,44,0,0,0,0
	dc.b	4,4,12,20,20,24,28,20,24,24,32,32,32,32,32,32,32,32,24,8,8,8,8,48,36,36,40,36,36,36,36,44,44,44,44,40,44,40,36,36,36,40,36,36,12,20,20,12,0,20,20,20,20,20,20,24,4,8,8,48,48,44,48,48,0,0,0,0
	dc.b	24,24,16,20,20,12,12,12,12,20,24,24,32,32,32,32,32,32,32,24,8,8,8,8,40,36,36,36,36,36,36,44,48,8,8,44,44,44,36,36,36,36,36,40,4,20,12,20,12,20,24,24,32,32,24,12,8,44,44,44,44,44,44,40,0,0,0,0
	dc.b	20,12,12,12,0,12,12,12,12,20,16,24,32,32,32,32,32,32,32,32,4,8,4,48,36,44,36,36,36,36,44,44,48,44,48,44,44,44,44,36,36,36,36,40,44,12,20,12,12,24,24,32,24,20,12,4,12,4,8,44,44,44,40,40,0,0,0,0
	dc.b	12,4,56,12,4,12,12,12,16,16,32,32,32,32,32,24,32,32,32,28,20,8,8,44,44,36,44,36,36,44,48,48,44,44,8,8,48,48,40,36,36,36,36,36,36,44,8,12,12,12,12,12,4,4,4,4,4,12,12,4,44,40,40,40,0,0,0,0
	dc.b	12,0,12,12,12,12,16,20,24,24,32,32,32,32,32,24,24,32,28,32,20,44,44,40,40,36,36,36,36,44,48,48,48,48,48,44,44,44,36,40,40,36,36,36,40,36,40,44,40,36,44,8,4,12,4,4,4,12,12,12,4,44,44,40,0,0,0,0
	dc.b	20,20,20,20,24,24,20,24,24,20,20,24,28,32,32,24,32,32,32,32,24,44,40,40,40,40,36,36,36,48,48,48,44,40,40,40,44,40,36,36,36,36,36,36,40,40,40,36,36,40,40,40,44,4,4,0,12,0,12,12,20,4,44,44,0,0,0,0
	dc.b	24,16,12,4,4,48,48,48,48,44,0,32,32,32,32,32,24,24,32,28,20,44,44,40,40,40,36,36,36,44,48,44,36,36,48,44,44,44,36,36,36,40,40,36,36,36,44,36,40,40,40,40,40,36,8,12,12,12,12,12,12,12,48,44,0,0,0,0
	dc.b	8,48,40,44,40,40,40,40,44,8,24,32,32,32,32,32,32,32,32,32,24,48,44,40,40,40,40,36,36,48,44,48,44,8,8,8,8,8,44,36,36,36,36,36,44,8,4,56,8,48,40,40,40,40,40,44,56,12,20,20,20,20,4,48,0,0,0,0
	dc.b	40,40,40,40,40,40,40,44,48,24,32,32,32,32,32,24,24,32,32,32,12,4,48,40,40,36,36,36,36,44,48,48,8,8,48,8,48,8,40,36,36,36,36,36,8,20,12,20,12,4,8,36,36,40,40,40,8,20,20,12,20,12,12,48,0,0,0,0
	dc.b	12,4,44,44,40,40,40,40,40,40,40,40,36,36,36,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,24,20,8,40,40,40,40,40,40,40,40,40,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,40,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,28,28,28,12,40,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,40,44,44,44,40,40,36,36,36,44,8,12,4,8,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,32,28,32,0,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,40,44,4,4,4,4,48,36,40,44,56,12,4,12,12,4,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,24,24,24,24,4,44,40,40,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,40,44,4,8,8,4,4,4,44,36,4,12,4,4,4,0,12,8,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,24,24,24,28,20,48,40,40,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,40,48,4,4,8,4,12,4,44,44,12,12,0,4,4,0,20,12,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,24,24,24,24,32,4,40,40,40,40,40,36,36,36,36,36,36,36,36,36,36,40,40,40,8,4,4,8,4,4,8,8,4,20,12,20,0,0,12,20,56,44,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,32,24,24,24,24,24,12,40,40,40,40,40,40,36,36,40,36,36,36,36,36,40,44,40,40,8,12,12,0,4,8,8,8,12,12,12,12,12,12,0,8,4,40,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,24,20,20,24,28,0,40,40,40,40,40,36,40,36,36,36,36,36,36,48,4,4,8,36,8,12,4,4,4,4,8,8,12,12,4,12,12,20,8,4,8,44,36,36,36,40,4,8,48,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,24,20,16,16,28,0,40,40,40,40,40,40,40,36,36,40,40,36,44,8,8,4,4,8,44,12,4,4,12,4,44,8,12,12,4,0,12,12,8,4,8,40,40,36,4,20,20,20,12,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	16,24,16,20,20,24,24,4,40,44,40,40,36,40,40,36,36,36,36,40,44,52,8,8,4,8,8,4,4,4,4,12,4,8,20,4,0,12,12,0,8,4,44,40,36,8,20,24,24,16,20,20,8,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,20,20,12,20,20,20,8,40,40,40,40,40,40,36,40,40,40,36,36,48,8,8,8,4,8,44,8,12,52,4,4,4,4,12,12,4,4,20,4,4,8,44,40,40,12,24,24,20,16,20,12,12,40,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,12,20,12,12,20,4,40,40,44,40,40,40,40,40,40,40,36,40,36,40,52,4,4,4,4,8,44,4,4,4,4,4,4,20,12,0,4,20,4,4,8,40,40,8,0,20,12,20,20,24,20,20,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,12,12,12,12,12,8,8,8,48,44,44,40,40,36,40,36,40,40,44,40,8,4,4,8,4,4,8,8,4,52,4,4,4,12,12,12,0,12,4,8,44,40,4,24,24,24,12,0,12,24,24,20,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,12,12,24,24,24,24,32,20,20,8,44,44,40,40,40,40,36,44,44,40,4,4,8,4,4,4,4,4,0,0,4,4,4,12,12,12,12,12,44,44,36,4,24,20,20,24,20,12,24,20,44,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,20,32,32,32,32,32,24,32,32,32,32,12,44,40,40,40,44,8,44,40,44,40,8,4,52,4,4,8,4,0,12,56,4,4,12,12,12,12,12,0,8,8,52,12,20,16,24,24,20,4,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,32,32,32,32,32,32,32,32,32,32,32,32,12,40,40,40,8,52,8,40,40,40,40,8,4,4,4,8,8,4,4,4,4,4,12,12,0,4,0,4,0,20,12,4,12,12,4,20,20,44,40,40,36,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,32,32,32,32,32,32,32,24,32,32,32,32,28,48,40,48,8,8,8,4,48,44,40,40,48,4,4,4,4,4,4,44,44,8,48,4,12,4,4,56,0,24,24,24,16,16,12,44,8,44,40,40,40,36,40,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	32,32,32,32,32,20,32,32,24,32,32,28,32,32,8,44,48,8,8,8,4,4,8,8,8,8,8,8,8,48,8,36,36,44,40,40,44,4,4,12,56,8,12,20,24,24,32,20,48,44,44,40,40,40,40,44,44,40,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,24,32,32,20,24,20,24,24,32,32,32,24,8,40,40,8,8,4,8,4,8,8,8,4,4,8,8,40,36,40,36,36,36,40,36,40,8,52,4,20,16,12,12,20,20,4,44,44,44,44,36,40,40,48,44,44,40,36,36,36,36,36,0,0,0,0
	dc.b	32,32,32,32,28,16,20,20,20,28,32,24,32,28,44,40,44,44,8,4,4,8,8,8,8,8,4,8,44,40,36,36,36,36,36,44,44,44,44,40,8,28,24,20,20,20,4,44,44,44,44,40,40,40,44,44,8,8,40,40,36,36,36,36,0,0,0,0
	dc.b	32,32,32,32,32,24,20,16,20,32,24,32,28,56,44,40,40,40,40,48,8,4,4,56,8,4,12,8,40,40,36,36,36,36,36,40,44,44,44,40,44,12,24,24,24,24,4,48,44,48,44,44,8,48,12,4,12,12,4,44,36,36,36,36,0,0,0,0
	dc.b	32,32,32,32,32,32,24,20,20,20,28,32,4,40,44,40,40,40,36,44,8,48,8,8,48,44,40,36,40,36,36,36,36,36,44,40,44,40,44,44,44,20,20,12,20,20,12,12,8,56,4,8,12,4,12,12,20,12,20,20,36,40,36,36,0,0,0,0
	dc.b	32,32,32,32,32,32,28,32,24,28,12,8,48,44,40,40,40,40,40,40,44,48,8,8,8,40,36,36,40,36,36,36,36,36,44,44,44,44,44,44,40,4,20,20,16,12,12,12,12,12,12,4,12,4,4,12,24,24,20,20,12,40,36,36,0,0,0,0
	dc.b	32,32,32,32,32,32,32,32,32,4,48,40,40,40,40,48,8,48,48,44,8,8,8,4,8,44,40,36,36,36,36,36,36,36,36,40,44,36,44,44,44,44,8,20,20,12,12,12,12,0,4,12,0,4,0,20,24,20,20,24,12,44,40,36,0,0,0,0
	dc.b	32,32,32,32,32,32,32,20,8,44,40,40,44,40,48,8,8,4,52,4,8,4,4,8,4,44,40,40,36,36,36,36,36,36,44,40,40,40,36,44,44,44,44,8,8,12,12,4,12,56,8,4,4,20,24,24,24,20,20,24,12,8,44,44,0,0,0,0
	dc.b	32,32,32,32,32,28,4,48,44,40,40,44,40,40,8,8,8,8,8,8,8,4,4,52,8,40,40,40,36,36,36,36,44,44,44,44,44,36,40,40,44,44,44,36,40,48,8,36,8,48,44,4,12,32,24,32,32,24,20,24,20,48,44,44,0,0,0,0
	dc.b	24,32,32,28,20,8,44,40,40,40,44,40,40,40,8,4,8,4,4,4,8,4,8,8,44,40,40,40,36,36,36,44,44,40,44,44,44,44,36,36,36,36,40,40,40,40,40,40,36,44,4,24,24,20,20,32,32,28,16,24,24,8,8,44,0,0,0,0
	dc.b	32,32,32,12,44,44,40,40,40,40,40,40,40,40,8,52,8,8,8,44,44,44,40,36,40,40,36,36,36,36,36,44,44,44,44,48,44,44,40,40,40,36,40,40,36,36,40,44,4,20,24,20,24,24,24,32,20,32,28,20,20,8,48,44,0,0,0,0
	dc.b	32,32,4,44,40,40,40,44,40,40,40,40,40,40,48,8,8,8,8,48,40,40,40,40,36,40,40,36,36,36,44,44,48,40,44,44,44,44,44,44,36,36,36,40,40,44,4,12,24,32,20,16,20,20,16,20,12,16,32,20,8,48,44,44,0,0,0,0
	dc.b	28,8,44,44,40,40,40,40,40,40,44,40,44,40,40,48,8,8,48,8,8,44,40,40,40,36,36,40,36,36,44,44,44,36,36,36,36,44,44,40,44,36,36,36,40,12,20,12,20,24,20,20,12,20,20,24,24,16,28,8,44,44,8,48,0,0,0,0
	dc.b	48,44,40,40,40,40,40,40,40,40,48,48,48,8,8,48,48,48,8,48,8,8,44,36,36,36,36,36,36,36,44,40,44,44,40,36,44,40,40,36,36,44,36,40,4,20,12,0,12,24,20,20,12,12,20,24,24,24,20,8,44,48,44,44,0,0,0,0
	dc.b	40,40,40,40,48,8,4,12,20,24,32,24,32,32,32,32,20,0,4,4,8,8,8,40,40,36,36,36,36,36,40,44,48,8,48,44,44,36,36,36,36,36,36,36,12,20,20,12,12,12,20,24,16,20,20,24,12,8,48,44,48,44,40,40,0,0,0,0
	dc.b	4,4,12,20,24,24,24,24,24,24,24,32,32,32,32,32,32,28,12,4,8,8,8,40,40,44,36,36,36,36,44,48,48,48,48,44,44,44,40,40,36,36,36,44,48,20,12,20,0,20,24,24,24,32,32,24,4,8,44,44,44,44,40,40,0,0,0,0
	dc.b	24,24,24,20,20,12,20,12,20,20,24,24,32,32,32,32,32,32,32,20,4,4,48,40,36,36,40,36,36,48,48,44,44,44,8,48,48,44,40,36,36,36,36,36,36,8,20,20,20,24,32,32,24,12,12,4,4,4,12,44,40,40,40,36,0,0,0,0
	dc.b	20,12,0,12,12,12,12,12,12,20,24,32,32,32,32,32,32,32,32,28,8,48,40,40,40,36,36,36,36,48,48,48,48,48,48,8,44,40,36,36,36,44,36,36,40,44,44,8,4,4,4,4,12,4,4,4,4,12,12,12,4,44,44,40,0,0,0,0
	dc.b	4,12,12,0,4,12,12,12,20,16,24,32,32,32,32,32,28,32,32,32,12,40,40,36,36,40,36,36,36,48,48,44,44,36,44,40,44,40,36,36,36,36,36,36,40,40,40,40,40,40,44,44,8,4,4,4,4,0,12,12,12,52,36,40,0,0,0,0
	dc.b	4,0,0,12,12,12,12,20,20,24,32,32,28,32,32,32,24,32,32,32,16,44,40,36,40,36,36,40,36,44,48,40,36,36,48,44,44,44,36,36,36,36,36,40,40,40,40,40,40,40,36,40,40,44,4,12,56,0,0,12,12,20,8,44,0,0,0,0
	dc.b	12,12,12,20,16,24,24,32,32,32,28,32,32,32,32,32,32,32,32,32,20,44,44,40,40,40,40,36,36,48,44,44,44,48,8,8,8,44,40,36,36,36,36,40,40,44,44,44,44,40,40,36,40,40,36,4,12,12,12,20,20,12,4,44,0,0,0,0
	dc.b	20,24,24,28,20,12,4,12,4,0,12,32,32,32,32,32,32,32,32,32,24,48,44,40,36,36,40,36,36,48,48,48,48,8,48,8,48,8,36,40,36,36,40,40,40,4,12,12,4,8,40,40,36,40,40,40,52,12,12,12,20,12,12,8,0,0,0,0
	dc.b	44,44,40,40,40,40,36,36,40,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,44,44,40,40,36,40,36,40,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,36,36,36,40,36,40,36,36,36,36,36,36,36,44,44,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,16,4,40,44,40,36,40,40,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,36,36,40,44,8,8,48,36,40,36,40,44,8,56,12,12,8,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,32,24,4,44,40,40,40,40,40,40,40,40,40,40,40,40,40,36,36,36,36,36,36,40,40,44,12,4,12,4,8,44,40,40,8,12,4,4,12,12,4,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,32,28,24,4,44,40,40,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,36,40,44,4,8,4,4,4,4,48,40,44,12,4,4,4,4,12,20,44,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,24,28,24,8,44,40,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,36,40,44,4,8,8,8,0,12,4,36,4,20,12,4,4,4,12,20,8,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,24,32,32,12,44,40,40,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,40,48,12,0,8,4,4,8,8,44,12,20,12,12,0,4,12,12,8,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,24,24,24,24,44,44,40,40,40,40,40,40,40,40,36,36,36,36,36,44,48,44,40,48,12,12,12,0,4,8,8,8,20,12,0,12,20,12,4,4,48,40,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,24,24,28,24,48,44,40,40,40,36,40,40,40,40,36,36,40,40,48,4,4,8,44,48,0,4,4,0,0,8,48,4,20,12,4,12,20,4,8,4,44,40,36,36,36,40,12,8,48,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,24,24,24,28,8,40,40,40,40,40,40,36,40,40,36,36,36,44,4,8,8,4,8,44,4,4,4,4,4,8,8,4,20,4,4,12,20,4,8,4,44,40,40,36,4,20,20,20,12,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,20,24,24,24,8,44,40,40,40,40,40,36,40,40,36,36,40,48,8,8,8,8,8,44,4,4,4,8,4,4,48,0,12,0,0,12,12,8,4,8,36,40,40,8,20,24,20,20,20,16,8,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,20,16,16,24,20,48,44,40,36,36,40,40,40,40,40,40,40,36,48,8,8,8,12,8,48,8,0,4,8,4,4,4,12,12,4,12,12,20,4,4,44,40,40,36,12,24,24,20,20,20,12,12,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,12,20,20,24,4,44,44,44,40,40,40,36,40,36,40,40,40,36,44,4,4,4,4,4,8,44,4,4,8,4,0,4,0,12,4,0,12,20,4,8,44,40,36,44,0,20,20,20,20,24,20,20,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,20,12,20,20,8,44,44,44,40,44,36,40,36,40,40,40,36,40,40,48,4,4,8,4,4,8,44,4,4,4,4,4,0,20,0,12,12,12,4,48,40,40,4,20,24,24,12,12,16,24,20,20,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,12,20,20,4,44,44,48,44,44,44,40,44,40,40,36,36,40,40,40,40,4,4,8,4,4,4,4,56,4,12,4,4,4,12,12,12,0,12,4,44,40,36,4,32,24,16,24,12,12,24,24,4,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,12,12,12,56,56,12,12,56,4,48,44,40,40,40,40,40,48,44,44,40,44,4,4,4,4,4,8,8,4,0,0,4,8,12,20,12,12,12,12,4,8,8,4,20,16,16,24,32,20,12,4,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,12,32,32,32,32,32,32,32,32,24,4,44,44,40,44,8,8,8,44,40,40,44,8,4,4,4,8,8,8,0,0,4,4,0,20,0,0,0,0,12,8,12,12,8,12,12,12,16,32,44,40,40,36,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	28,32,32,32,32,32,28,32,32,32,32,32,4,44,44,48,4,8,8,8,44,36,40,36,48,4,4,4,4,4,4,8,8,8,8,4,12,4,4,0,12,56,24,24,20,12,20,0,8,8,48,40,40,40,36,44,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	32,32,32,32,32,24,32,32,32,32,32,28,32,48,44,48,8,8,48,4,4,8,48,48,48,8,4,8,8,8,8,36,36,44,36,40,8,12,4,12,4,8,20,24,24,20,32,20,44,44,44,40,40,40,44,44,44,40,36,36,36,36,36,36,0,0,0,0
	dc.b	32,32,32,32,16,24,32,32,32,32,32,24,32,4,44,40,8,8,4,8,4,8,8,4,4,8,8,8,44,36,36,40,36,36,36,40,40,8,4,0,12,12,12,12,20,24,24,20,44,44,44,44,40,36,44,44,44,44,40,40,36,36,36,36,0,0,0,0
	dc.b	32,32,32,24,20,24,24,24,24,32,28,32,32,4,48,40,44,8,4,4,8,8,8,8,8,8,4,8,36,40,36,36,36,36,44,36,44,44,44,44,4,24,20,12,12,20,12,44,44,44,44,40,40,44,48,44,48,44,44,40,36,36,36,36,0,0,0,0
	dc.b	24,32,32,32,20,20,20,20,20,32,32,32,28,12,44,44,44,44,8,8,4,4,4,8,4,4,4,44,40,40,36,36,36,36,36,44,44,44,44,40,8,24,24,24,24,24,12,40,44,48,44,44,8,44,4,4,4,12,4,44,36,36,36,36,0,0,0,0
	dc.b	32,32,32,32,20,20,20,24,24,24,32,32,28,8,40,40,40,36,44,8,44,8,4,8,48,48,36,40,36,36,36,36,36,40,44,40,44,44,44,40,44,20,20,20,20,16,4,4,8,4,8,8,12,8,12,12,12,20,20,12,40,40,36,36,0,0,0,0
	dc.b	32,32,32,32,24,12,20,24,24,24,32,32,4,48,44,40,40,40,36,44,8,8,48,48,44,40,40,36,36,36,36,36,36,44,40,44,44,44,44,44,48,20,20,12,20,16,12,0,12,12,12,4,12,4,0,0,20,16,20,20,12,44,36,36,0,0,0,0
	dc.b	32,32,32,32,32,32,24,16,16,32,28,56,48,44,44,44,44,44,36,44,8,8,8,8,48,36,40,40,36,36,36,36,36,36,36,40,40,44,44,44,44,8,12,20,20,12,12,0,12,0,4,12,0,12,4,12,32,24,24,20,12,48,40,36,0,0,0,0
	dc.b	32,32,32,32,32,32,32,32,28,16,8,44,44,44,8,8,4,8,4,8,8,4,8,8,8,40,40,40,36,36,36,36,36,44,40,36,40,36,40,44,44,44,44,12,12,12,12,0,12,4,8,12,4,0,0,20,20,20,12,20,24,8,44,44,0,0,0,0
	dc.b	32,32,32,28,32,32,28,32,12,44,44,44,44,8,8,8,8,4,8,8,4,8,8,8,44,36,40,40,36,36,36,44,44,44,44,44,40,40,40,44,44,44,40,44,44,8,4,8,56,8,44,8,8,12,28,28,32,24,20,20,24,8,44,44,0,0,0,0
	dc.b	32,32,32,32,32,32,28,4,48,44,44,44,44,8,8,8,4,8,8,8,8,4,4,8,40,40,40,36,36,36,44,44,44,44,44,44,44,44,40,40,40,36,40,36,40,40,40,40,36,44,44,8,4,24,24,24,32,24,12,28,32,12,48,44,0,0,0,0
	dc.b	32,32,32,32,32,28,8,44,44,44,44,40,44,8,8,8,4,4,8,8,4,8,40,40,36,40,40,36,36,36,44,44,44,44,44,48,44,44,40,40,36,40,36,40,40,36,40,40,44,44,12,28,24,32,20,24,32,28,24,20,24,12,44,44,0,0,0,0
	dc.b	24,32,32,32,20,8,44,44,44,44,40,40,40,48,4,8,48,48,44,40,36,36,40,40,40,40,36,36,36,36,44,44,44,40,44,48,40,44,44,40,40,40,36,40,40,40,40,48,4,20,24,20,24,24,24,32,24,16,32,20,20,4,44,44,0,0,0,0
	dc.b	32,28,28,12,8,44,40,40,40,40,36,40,44,44,8,8,8,8,8,48,40,40,40,40,40,40,40,36,36,36,44,44,36,40,40,36,36,48,40,40,36,40,36,36,40,44,12,20,24,24,24,12,12,20,16,32,24,20,24,24,8,48,48,48,0,0,0,0
	dc.b	32,32,12,44,44,40,40,40,44,40,36,44,36,44,44,48,48,48,48,8,8,40,36,40,40,36,40,36,36,36,44,40,44,40,36,40,44,40,36,36,36,44,36,40,44,20,20,0,12,24,24,24,12,20,12,24,24,24,24,20,48,44,48,40,0,0,0,0
	dc.b	28,8,44,44,44,40,40,44,40,40,40,36,40,44,44,8,48,8,4,8,8,4,36,40,40,36,36,36,36,36,44,44,48,48,44,44,44,40,36,36,36,36,36,44,0,20,20,12,0,20,20,24,12,20,20,20,20,12,20,8,48,44,40,40,0,0,0,0
	dc.b	8,44,44,44,40,40,40,44,44,48,48,48,48,8,8,8,4,8,4,8,8,8,48,40,40,40,36,36,36,44,44,48,48,8,44,44,44,36,40,40,36,36,36,36,4,20,12,12,12,12,24,20,16,24,24,24,20,44,44,44,44,44,40,40,0,0,0,0
	dc.b	44,44,44,44,48,8,4,12,20,24,32,32,32,28,32,24,12,4,4,8,8,4,44,40,40,36,40,36,36,8,48,48,8,44,48,44,48,44,40,36,40,36,40,36,44,12,20,12,12,12,24,24,32,32,32,32,12,4,4,44,44,44,44,44,0,0,0,0
	dc.b	8,8,4,20,24,24,24,24,32,24,32,32,32,32,28,32,32,28,4,8,4,48,44,40,36,36,36,36,48,48,48,48,48,48,48,48,44,44,40,40,40,36,36,36,36,48,4,20,20,20,24,24,24,12,4,4,4,12,12,12,8,40,44,40,0,0,0,0
	dc.b	24,24,24,20,20,12,16,20,20,20,24,32,32,32,32,32,32,32,32,4,44,44,40,40,40,40,36,36,48,44,48,44,44,40,40,44,40,40,40,40,36,36,36,36,40,40,44,44,8,4,4,8,4,4,4,4,4,4,0,12,12,8,36,40,0,0,0,0
	dc.b	20,12,12,12,12,12,12,20,12,20,24,24,28,32,32,32,32,32,32,28,48,40,40,36,36,36,36,40,44,48,44,40,40,36,48,44,40,40,40,36,40,36,40,36,36,40,36,40,40,44,40,40,44,44,4,12,4,12,4,12,12,12,8,44,0,0,0,0
	dc.b	12,56,4,12,4,12,12,12,20,24,24,32,32,32,32,32,32,32,28,32,4,44,44,40,40,36,36,36,48,44,44,40,44,48,8,48,8,36,40,40,40,36,36,40,36,40,40,40,40,44,40,36,40,40,44,4,0,0,0,12,12,12,12,48,0,0,0,0
	dc.b	56,56,56,4,12,12,12,20,20,24,32,32,32,32,32,32,32,32,32,32,12,44,40,36,36,36,40,36,44,48,48,48,48,48,48,8,48,44,40,40,40,40,40,36,40,44,8,4,8,36,36,40,36,40,40,40,4,12,12,12,20,12,20,8,0,0,0,0
	dc.b	40,36,36,40,40,36,40,40,40,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,40,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	44,40,36,40,36,40,40,36,40,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,36,40,40,40,44,36,36,36,36,36,36,36,44,48,8,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	44,44,40,40,40,36,36,40,40,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,36,40,48,8,4,8,44,40,36,36,36,8,12,12,12,4,4,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,8,44,36,40,36,40,36,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,36,40,44,12,4,4,12,0,40,40,44,8,12,12,4,4,12,12,8,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,24,4,44,44,40,36,36,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,36,40,4,4,4,8,0,12,8,40,44,56,12,4,4,4,4,20,4,40,40,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	28,32,24,8,44,40,40,36,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,40,44,4,8,8,8,0,0,8,44,48,12,12,12,4,4,0,20,12,44,36,36,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,32,24,20,44,36,36,40,40,40,40,40,40,40,40,40,40,36,36,36,36,36,36,40,44,12,0,4,4,4,8,8,48,4,20,12,20,12,12,12,0,4,44,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,32,32,24,4,44,40,40,40,40,40,40,40,40,40,40,36,36,36,40,44,8,44,40,48,4,0,12,12,0,8,8,8,4,20,0,0,12,20,0,8,4,44,40,36,36,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,32,24,12,40,40,36,36,40,36,36,40,40,40,40,36,40,40,8,8,4,4,44,44,12,4,4,4,4,8,8,8,12,12,0,0,12,20,4,8,8,40,40,40,40,36,8,12,8,48,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,24,32,20,44,44,36,36,40,40,36,40,40,40,40,36,36,48,8,8,8,56,8,44,4,4,4,4,0,4,8,8,12,12,0,4,12,20,4,4,48,40,40,40,36,4,20,20,20,12,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,24,24,20,44,44,36,36,36,36,40,40,40,40,40,36,40,8,4,8,8,4,8,48,8,56,4,4,4,0,8,8,12,0,0,0,12,12,8,4,44,40,40,36,8,20,24,20,20,20,20,8,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,20,24,28,12,44,40,44,36,40,36,40,40,40,40,40,36,40,8,8,8,8,4,8,48,8,12,4,8,4,12,8,8,20,12,4,0,12,0,4,4,44,40,36,40,12,24,24,20,20,20,12,12,40,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,20,24,24,4,44,40,40,36,36,40,40,40,36,36,36,40,36,44,8,4,4,4,4,8,48,8,12,8,4,0,4,4,12,12,0,4,12,0,4,44,36,40,40,44,12,16,20,20,20,20,20,20,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,20,24,24,48,44,44,40,40,40,40,36,40,40,36,36,36,40,44,8,12,4,8,4,4,8,44,4,4,4,0,4,4,12,12,12,12,12,12,8,44,40,36,4,12,20,16,12,12,16,24,24,20,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,16,24,56,44,44,44,40,44,40,36,40,40,40,40,36,40,40,40,40,4,4,8,4,4,4,4,4,0,0,4,12,4,0,20,12,12,12,12,48,40,40,40,12,24,20,24,24,12,12,24,24,4,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,20,20,8,44,44,44,44,40,40,40,44,40,40,36,40,36,44,44,44,40,4,4,4,4,4,8,8,4,12,12,0,4,4,12,12,12,12,20,12,4,44,4,4,24,24,16,24,24,16,12,12,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,12,56,48,48,48,8,48,48,44,44,40,40,36,44,8,8,48,44,40,36,44,8,4,4,4,8,8,8,8,4,0,4,4,20,12,0,4,0,0,12,4,12,8,4,12,12,20,24,24,8,40,40,36,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,4,12,20,24,32,32,28,24,12,8,44,44,44,44,8,8,4,48,36,40,36,44,48,4,56,4,8,4,12,4,8,8,8,8,12,12,12,4,0,4,12,20,12,12,12,12,4,4,12,8,44,40,36,44,44,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	16,32,28,32,32,32,24,32,32,28,28,4,44,40,48,8,48,8,4,4,8,44,44,44,8,8,4,4,8,8,8,36,36,36,36,48,12,4,12,12,4,4,20,28,24,16,24,20,44,8,44,44,40,44,44,44,44,40,36,36,36,36,36,36,0,0,0,0
	dc.b	32,32,32,32,20,32,32,28,32,32,32,28,8,44,48,8,48,8,8,4,4,8,8,4,4,8,8,44,40,36,40,36,36,36,40,40,48,4,0,12,12,4,12,24,24,24,32,24,44,44,44,44,40,44,44,44,44,44,40,40,36,36,36,36,0,0,0,0
	dc.b	32,32,32,20,24,32,32,32,32,32,32,32,12,44,44,48,8,4,8,8,8,8,8,8,8,8,8,40,36,36,36,36,36,44,44,44,44,40,44,8,4,24,20,12,12,24,20,4,44,44,40,44,36,44,44,44,44,44,44,40,36,36,36,36,0,0,0,0
	dc.b	32,28,28,16,24,24,24,24,32,32,32,32,20,44,44,44,48,8,56,4,4,8,8,8,4,4,8,40,40,40,36,36,36,44,40,40,44,44,40,40,4,24,24,16,20,16,12,44,44,48,40,44,48,44,4,4,4,4,8,44,36,36,36,36,0,0,0,0
	dc.b	32,32,24,16,24,20,24,24,32,32,32,28,20,44,44,40,40,48,44,8,8,4,4,8,8,8,36,36,36,36,36,36,40,40,44,44,44,44,44,36,48,20,24,16,24,24,4,8,8,4,44,8,56,8,0,4,20,20,20,12,36,40,36,36,0,0,0,0
	dc.b	28,32,20,20,20,24,24,24,24,32,32,32,20,48,44,40,40,40,48,48,8,8,8,44,36,36,40,36,36,36,36,36,44,44,40,44,44,44,44,40,48,20,20,12,20,20,12,12,0,12,0,4,12,4,4,12,12,12,12,20,12,44,36,36,0,0,0,0
	dc.b	32,32,32,20,20,20,20,24,32,24,32,28,4,44,44,44,44,40,40,48,8,8,8,48,40,40,36,36,36,36,36,36,36,36,36,36,40,44,44,44,44,12,24,20,12,12,12,4,12,4,0,0,0,4,4,12,24,24,24,16,12,8,40,36,0,0,0,0
	dc.b	32,32,32,20,20,20,24,24,20,32,28,56,44,48,8,48,48,48,48,8,8,8,8,8,40,40,40,36,36,36,36,36,36,36,40,40,40,40,44,44,44,40,4,20,20,12,12,0,12,12,4,12,12,4,4,12,16,24,12,20,24,4,44,44,0,0,0,0
	dc.b	32,32,28,32,32,16,12,16,20,28,0,48,48,4,8,8,8,4,8,4,8,8,8,8,40,36,36,36,36,36,36,44,48,44,44,44,36,40,40,44,44,44,44,8,8,4,12,8,12,4,48,56,4,8,12,24,24,20,20,20,24,12,40,44,0,0,0,0
	dc.b	32,32,32,28,32,32,32,32,28,56,48,48,8,8,48,4,8,8,8,8,4,4,4,44,40,40,36,36,36,40,44,48,48,44,44,48,44,36,40,40,40,36,40,40,40,44,36,40,44,44,40,44,44,0,28,24,32,24,12,20,24,20,44,44,0,0,0,0
	dc.b	32,28,32,32,32,32,28,32,4,48,44,44,8,8,8,4,4,4,4,4,4,8,8,40,36,40,36,36,36,44,44,44,48,44,44,48,44,44,40,40,36,36,36,40,36,40,40,40,40,40,44,4,12,20,24,32,32,32,20,12,24,24,8,44,0,0,0,0
	dc.b	32,32,32,32,32,28,24,8,44,40,44,44,8,4,8,8,8,8,44,44,44,40,36,36,40,36,36,36,36,44,44,40,40,44,48,48,44,44,44,40,40,36,36,40,40,40,40,40,40,8,12,24,24,24,24,24,24,24,24,20,20,20,48,44,0,0,0,0
	dc.b	32,24,32,32,32,16,8,44,44,44,40,44,44,8,8,48,48,8,44,36,40,40,40,40,40,36,36,36,36,44,44,44,36,40,40,40,44,48,40,36,36,40,36,40,36,40,44,8,12,24,28,20,20,24,24,32,32,20,24,32,20,8,48,44,0,0,0,0
	dc.b	24,32,32,32,24,48,44,44,44,40,40,44,44,48,8,48,48,8,8,44,40,36,36,40,40,36,36,36,36,44,44,40,36,36,40,36,44,44,36,36,36,44,36,36,40,8,12,20,16,32,24,20,12,20,16,32,28,20,16,32,4,44,44,40,0,0,0,0
	dc.b	32,32,28,56,44,44,40,44,36,36,40,36,40,44,48,8,48,8,8,8,8,44,40,40,40,36,36,36,36,36,44,44,48,44,40,40,44,40,36,36,36,36,36,36,8,20,20,12,4,20,24,24,12,20,20,12,24,12,24,24,8,44,40,40,0,0,0,0
	dc.b	32,28,4,44,44,40,44,44,44,44,40,40,40,44,44,8,8,8,4,8,4,44,36,40,40,40,36,36,36,44,48,48,48,44,48,44,44,36,40,36,36,36,36,44,4,20,12,12,12,12,20,24,20,16,16,20,24,8,12,4,44,40,40,40,0,0,0,0
	dc.b	28,12,44,44,40,40,44,40,40,44,40,44,44,8,8,4,4,4,4,8,8,48,40,36,40,36,36,36,48,48,44,48,8,48,44,44,48,44,40,40,40,36,36,36,8,20,12,20,0,4,20,24,24,24,32,24,24,12,8,48,44,40,44,40,0,0,0,0
	dc.b	56,44,44,40,44,36,44,44,44,44,48,8,8,4,52,8,8,8,8,8,4,44,40,36,36,36,36,36,44,40,48,48,48,8,44,44,40,44,40,40,36,40,36,36,40,4,20,12,12,12,24,24,24,32,24,24,12,4,4,4,8,44,44,36,0,0,0,0
	dc.b	44,40,44,44,48,8,4,56,16,24,32,24,32,32,24,24,12,4,8,8,48,40,40,36,36,44,36,36,48,44,48,44,44,36,44,40,36,40,36,36,36,36,36,36,40,44,8,12,20,20,28,20,24,12,4,4,4,12,0,0,12,8,40,36,0,0,0,0
	dc.b	8,8,4,12,24,24,32,24,32,24,32,32,32,32,32,32,32,16,8,44,44,40,40,36,36,36,36,48,44,48,36,40,40,36,48,36,40,40,36,36,36,36,36,36,40,36,44,44,48,8,48,8,48,4,12,4,4,4,4,4,12,0,8,44,0,0,0,0
	dc.b	24,24,24,24,24,20,20,20,20,16,24,24,32,28,32,32,32,32,20,48,44,40,40,40,40,36,40,44,48,44,44,36,44,8,44,48,44,40,36,40,40,36,40,36,36,40,40,44,40,36,40,44,40,44,48,4,0,0,0,0,12,12,12,44,0,0,0,0
	dc.b	20,20,20,12,12,12,12,12,16,20,24,32,32,32,32,32,32,32,32,12,44,40,44,40,36,36,40,48,44,48,44,44,48,8,8,48,48,44,40,40,40,36,36,40,36,40,40,40,44,40,36,40,36,40,40,48,4,12,12,12,12,12,12,4,0,0,0,0
	dc.b	40,36,36,40,36,36,36,40,40,40,40,40,40,40,40,40,40,40,36,36,36,36,36,40,40,36,40,40,36,36,36,36,36,36,36,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,40,40,36,36,40,36,40,40,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,36,40,40,44,44,36,36,36,36,36,40,44,8,8,8,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,40,40,40,36,36,40,36,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,36,40,48,4,12,4,8,40,40,36,40,44,12,12,12,12,12,8,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,40,36,40,36,36,36,40,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,40,48,12,52,4,4,12,8,36,36,44,12,12,4,4,4,12,12,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	48,40,40,40,40,40,36,40,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,36,4,8,8,4,4,12,4,40,40,8,12,4,4,4,4,12,20,8,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,44,44,36,36,40,36,40,40,40,40,40,40,40,40,40,36,36,40,36,36,36,36,44,12,4,8,8,4,4,52,48,40,4,20,20,0,4,4,12,12,8,40,40,36,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	28,20,44,40,40,36,36,40,40,40,40,40,40,40,40,40,36,36,36,36,36,36,40,48,0,12,4,8,0,8,8,8,44,20,20,12,12,12,0,12,4,8,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,32,56,36,40,40,36,40,40,40,40,40,40,40,40,40,36,40,44,48,8,48,40,44,12,4,12,12,0,8,8,8,8,20,12,12,12,12,20,4,4,8,40,40,36,36,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	28,24,20,48,44,40,36,36,40,40,40,40,40,40,40,40,36,40,8,4,4,4,44,44,12,0,4,4,12,52,8,8,4,20,0,0,0,12,20,4,52,48,40,36,40,36,36,4,4,8,48,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,32,28,48,40,36,40,36,40,40,40,40,40,40,40,40,40,44,4,8,52,4,8,44,4,0,4,4,0,4,48,8,4,12,0,0,0,12,0,52,4,36,40,36,36,36,8,20,20,20,12,8,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,32,28,4,40,44,36,40,40,40,40,40,40,40,40,40,36,48,8,8,8,52,8,44,8,12,4,8,4,4,8,8,4,20,0,12,12,16,4,4,8,40,40,40,40,8,20,24,24,20,20,16,8,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,24,8,44,40,36,40,40,40,40,40,40,40,40,40,40,8,52,8,8,4,8,48,44,4,4,8,8,12,4,8,4,20,4,12,0,20,4,4,48,40,40,40,36,12,24,24,20,16,20,12,12,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,32,8,40,40,36,40,40,40,40,40,40,40,40,40,40,44,4,8,4,4,4,8,44,8,56,4,4,4,0,4,4,20,4,12,0,20,4,52,44,36,40,40,44,12,20,16,20,20,20,16,20,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,24,24,44,36,40,40,40,40,40,40,40,40,40,40,40,40,44,8,12,8,8,4,12,8,48,4,4,4,4,4,4,4,20,12,12,12,12,4,48,36,40,40,4,12,12,20,12,12,20,24,24,20,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,12,44,40,44,36,40,40,40,40,40,40,40,40,40,36,40,44,4,4,8,4,4,4,8,8,0,4,0,4,8,4,20,12,12,0,12,4,44,40,40,36,12,28,24,24,20,12,0,24,24,12,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,24,8,44,44,44,40,40,40,40,40,40,40,40,40,40,40,40,44,8,4,4,4,4,4,8,4,4,12,0,12,4,52,12,20,12,12,12,12,4,48,8,4,12,24,24,16,24,24,16,16,12,48,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,4,44,44,44,44,44,44,44,40,40,36,40,40,48,52,48,40,40,40,48,8,52,4,4,8,4,8,8,12,12,4,4,4,20,0,12,12,0,12,12,12,4,8,12,12,20,24,24,20,4,44,44,36,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,8,44,48,44,44,44,44,44,44,44,40,44,44,8,8,8,48,36,40,36,40,8,4,4,4,8,4,4,8,4,4,4,4,4,20,0,4,12,0,8,4,20,12,4,12,12,4,12,20,4,40,36,40,44,44,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	48,48,48,52,12,12,12,12,8,48,44,44,40,8,8,8,8,52,8,48,44,36,44,8,4,4,4,4,12,8,8,40,40,44,44,4,12,0,12,12,8,12,24,24,20,12,20,12,44,8,44,40,40,44,44,44,44,40,36,36,36,36,36,36,0,0,0,0
	dc.b	4,20,28,32,32,32,32,28,28,12,8,44,44,48,8,48,8,4,4,4,8,8,8,8,8,8,8,36,40,40,36,36,36,40,40,44,4,12,12,12,4,4,20,24,28,24,24,24,44,40,44,44,40,44,44,44,44,40,40,36,36,36,36,36,0,0,0,0
	dc.b	32,28,32,24,24,32,32,32,32,32,20,8,44,44,8,8,4,8,8,8,8,8,8,8,8,8,44,40,36,36,36,36,44,40,40,44,44,44,8,4,56,12,12,12,20,24,24,20,44,36,40,40,40,44,40,44,44,36,40,40,36,36,36,36,0,0,0,0
	dc.b	32,32,20,20,32,32,28,32,32,32,32,12,44,44,44,8,4,4,8,8,8,8,8,8,4,8,44,36,40,40,36,36,40,44,36,44,44,44,40,40,12,24,24,12,12,20,12,8,44,44,40,44,44,44,4,8,52,4,8,44,36,36,36,36,0,0,0,0
	dc.b	32,32,20,24,32,28,32,32,32,32,32,24,48,44,44,44,48,8,8,4,8,8,4,8,4,44,40,36,36,36,36,36,44,44,44,44,44,44,44,40,8,24,24,20,24,24,0,8,8,8,44,4,12,8,12,4,12,20,12,12,36,40,36,36,0,0,0,0
	dc.b	32,24,20,24,24,24,24,24,32,32,32,28,48,44,44,40,44,48,48,8,8,8,48,44,40,36,36,40,40,36,36,36,40,40,40,44,44,44,44,36,8,20,20,20,20,24,0,0,56,12,12,4,12,8,0,12,12,12,12,20,20,44,36,36,0,0,0,0
	dc.b	32,20,24,24,20,24,20,32,32,32,32,28,48,44,44,44,44,40,8,48,8,8,44,40,40,40,36,40,36,36,36,36,40,36,40,36,40,44,44,44,8,20,20,12,12,20,12,4,12,12,4,0,12,4,8,0,20,20,20,20,20,4,36,36,0,0,0,0
	dc.b	32,24,12,20,24,20,24,32,32,24,32,24,44,44,48,44,44,44,40,8,8,8,8,40,40,40,40,36,36,36,36,36,40,40,40,36,36,40,44,44,44,8,12,20,20,12,0,4,12,4,8,12,0,0,4,4,20,28,20,20,20,4,48,44,0,0,0,0
	dc.b	32,32,20,20,20,24,24,28,24,32,32,12,4,8,8,4,8,52,4,8,8,8,52,36,40,40,36,36,36,36,44,44,48,44,44,40,36,40,40,44,44,44,8,4,4,12,12,52,12,4,8,12,4,4,4,12,20,24,20,20,20,20,44,44,0,0,0,0
	dc.b	32,32,20,12,20,20,24,24,24,28,20,8,8,48,4,52,8,8,4,4,8,8,8,40,36,36,36,40,40,40,44,48,44,44,44,44,40,40,40,36,36,36,40,44,40,48,8,44,8,44,36,48,48,48,20,32,24,24,12,12,24,24,44,44,0,0,0,0
	dc.b	32,32,32,32,20,20,20,20,32,20,48,48,8,8,4,8,4,8,8,4,52,8,44,40,36,36,40,40,44,44,44,44,48,44,44,44,44,44,40,40,40,36,36,40,36,40,40,36,40,36,40,44,44,8,24,24,24,28,20,0,20,24,12,44,0,0,0,0
	dc.b	32,32,32,28,32,32,32,32,20,44,48,52,4,4,52,4,8,52,8,8,48,40,40,40,40,40,36,36,44,44,44,40,40,44,48,44,44,44,36,36,36,40,36,36,40,40,40,40,40,40,44,12,20,12,28,24,24,24,24,20,20,24,4,44,0,0,0,0
	dc.b	32,32,32,32,32,20,28,20,48,44,44,48,4,8,8,8,8,44,40,36,36,40,36,40,36,40,40,40,44,44,44,40,40,40,40,40,44,44,36,36,36,40,36,40,40,40,36,44,44,8,12,24,24,28,28,24,24,24,24,32,20,12,8,40,0,0,0,0
	dc.b	28,24,24,32,32,32,24,44,44,44,44,44,48,8,48,48,8,48,44,40,40,40,40,36,40,36,40,36,44,40,44,44,36,40,40,36,44,44,36,36,36,40,36,40,40,40,48,4,20,24,24,24,12,20,32,32,20,28,20,32,20,48,44,40,0,0,0,0
	dc.b	32,32,32,32,28,12,48,44,44,44,44,44,48,8,8,48,48,8,8,44,40,36,40,40,40,40,36,36,36,36,44,44,44,44,40,36,44,40,36,36,36,36,36,36,44,4,20,20,0,24,24,20,20,12,24,32,20,4,20,24,20,44,40,40,0,0,0,0
	dc.b	24,28,32,32,20,48,44,40,36,44,40,40,40,48,48,48,8,8,8,4,44,40,36,40,40,40,40,36,36,48,48,48,48,48,48,44,36,40,40,36,36,36,36,44,8,24,12,12,12,12,20,24,20,12,24,20,24,12,12,24,4,44,40,40,0,0,0,0
	dc.b	32,32,28,12,44,44,44,40,40,40,40,40,44,44,8,52,4,8,8,4,8,40,36,40,40,36,36,36,48,44,44,48,8,44,44,44,44,44,36,40,40,36,36,40,8,20,12,20,12,12,20,24,24,20,20,20,20,16,8,48,44,44,44,44,0,0,0,0
	dc.b	32,32,12,44,44,36,44,44,44,40,44,48,8,8,4,8,8,4,8,8,8,40,40,36,36,36,40,44,44,44,44,48,8,44,48,44,36,44,40,36,36,36,40,36,44,20,12,12,12,0,20,16,24,24,28,32,24,20,4,52,8,44,44,40,0,0,0,0
	dc.b	28,12,44,44,44,40,40,40,40,44,48,8,8,4,8,8,8,4,8,8,48,40,40,36,36,44,36,48,48,44,44,44,44,40,40,40,40,40,40,36,36,36,36,36,36,8,20,12,12,12,20,24,24,28,20,20,20,4,4,4,4,48,40,40,0,0,0,0
	dc.b	12,48,44,40,44,44,44,44,44,48,4,8,8,8,4,4,8,8,8,48,44,36,40,36,36,36,36,44,44,44,40,40,40,36,48,40,36,36,36,40,40,36,40,40,36,40,44,12,12,20,16,24,20,20,4,4,4,4,4,12,12,4,8,44,0,0,0,0
	dc.b	44,44,44,44,48,48,12,56,12,24,24,24,32,32,20,12,8,44,40,36,40,40,36,36,36,36,40,44,8,44,36,40,44,8,44,36,40,40,40,36,40,40,36,40,40,40,40,44,48,8,44,48,44,44,8,4,4,4,4,0,12,12,12,44,0,0,0,0
	dc.b	44,44,52,12,20,24,32,32,32,32,32,32,32,32,32,32,24,4,44,36,40,40,40,36,36,36,40,48,44,44,36,36,48,8,8,44,40,40,36,40,40,36,40,40,40,40,40,40,44,40,40,40,40,40,44,8,12,12,12,0,12,12,12,12,0,0,0,0
	dc.b	36,36,36,36,36,36,40,36,36,36,36,36,36,40,40,40,40,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,40,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,40,40,36,36,36,36,36,40,40,40,40,36,36,36,36,36,40,36,40,44,44,8,44,36,36,36,36,44,44,52,56,4,4,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,40,36,36,36,36,36,40,40,40,40,36,36,36,36,36,36,36,4,4,12,56,52,44,40,36,40,44,4,12,12,12,20,0,44,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,40,40,36,36,36,36,36,36,8,4,8,4,4,12,8,44,40,40,4,12,4,4,4,4,12,4,44,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,40,36,36,36,36,36,36,36,36,36,36,40,40,40,40,36,36,36,36,36,36,40,4,52,52,8,4,12,56,44,36,44,12,12,4,4,4,4,12,12,44,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,36,40,36,36,36,36,36,36,36,36,36,40,40,40,40,40,36,36,36,36,36,44,4,4,8,8,4,12,8,8,40,8,20,20,12,4,4,4,20,4,44,40,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	44,36,40,40,36,36,36,40,36,36,36,36,40,40,40,40,40,36,36,40,36,36,44,56,12,4,8,0,8,8,8,44,4,20,12,12,12,0,12,56,8,44,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,40,36,40,36,36,36,36,36,36,36,36,40,40,40,40,40,44,8,8,48,44,44,12,0,12,0,12,4,8,8,44,12,12,12,12,12,20,12,4,52,44,36,36,36,36,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,48,40,40,40,36,36,36,36,36,36,40,40,36,36,36,40,8,4,4,4,44,40,56,0,4,4,4,4,8,8,48,12,12,0,4,0,20,0,8,52,40,40,36,40,36,36,4,4,8,48,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,4,44,40,36,36,36,36,36,36,36,40,36,36,36,36,48,4,8,4,4,52,40,8,12,4,4,4,56,8,8,8,12,12,0,12,0,20,4,8,48,36,40,36,36,36,4,20,20,20,12,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	28,12,44,40,40,40,36,36,36,36,36,36,36,36,36,36,8,8,4,8,52,8,8,8,12,4,8,4,12,4,8,8,12,12,12,0,12,20,4,4,48,40,40,40,40,8,20,20,24,20,20,20,8,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,20,44,40,40,36,36,36,36,36,36,36,36,36,36,36,8,8,8,8,4,8,44,48,4,4,4,4,4,4,8,8,12,0,0,0,12,12,4,52,40,40,40,36,36,12,24,24,20,20,20,12,12,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,20,48,40,40,40,36,36,36,36,36,36,36,36,40,40,48,4,4,4,4,4,8,48,8,12,4,4,4,12,56,8,20,12,12,12,12,12,52,44,40,36,40,40,44,20,24,24,20,16,16,16,20,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,12,44,40,40,40,40,36,36,36,36,36,36,40,40,40,40,4,4,4,4,4,4,8,44,4,12,4,0,4,4,4,12,12,12,12,12,20,4,44,40,40,40,4,4,12,16,12,12,16,24,24,20,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,0,44,40,40,40,40,36,36,36,36,36,36,40,40,40,36,8,4,4,8,4,4,4,4,8,4,12,0,4,4,52,12,20,4,12,12,20,8,40,36,40,40,12,24,24,24,20,12,12,24,20,12,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,8,40,44,40,40,36,40,36,36,36,36,36,40,40,40,40,36,8,4,4,4,4,4,52,4,4,0,12,4,4,52,4,20,12,12,0,12,12,48,8,8,4,12,24,24,20,24,20,12,20,20,8,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,44,44,40,40,40,40,36,40,40,40,40,40,48,8,44,40,40,36,8,4,4,4,4,8,8,8,8,12,12,4,4,4,12,12,0,0,12,12,12,12,12,12,4,20,20,20,20,24,24,4,48,44,44,44,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	48,40,44,44,44,40,40,40,40,40,36,40,48,52,52,52,44,40,40,36,44,8,4,4,4,8,8,52,4,4,4,4,4,4,20,12,0,0,0,12,4,4,12,8,4,12,12,12,20,24,12,44,40,44,44,44,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	48,48,44,44,44,44,44,44,40,40,44,44,8,8,8,8,8,48,44,36,40,44,8,4,4,4,4,4,8,8,8,44,44,44,52,12,12,4,4,4,8,12,24,20,12,0,12,0,48,4,8,40,40,44,40,44,44,40,36,36,36,36,36,36,0,0,0,0
	dc.b	44,44,48,44,48,48,8,44,44,40,44,44,52,8,44,8,8,4,8,8,8,8,8,8,8,8,48,40,36,40,36,40,40,44,40,8,12,12,12,12,4,4,24,32,24,16,24,24,8,40,40,40,40,44,44,44,44,40,40,40,36,36,36,36,0,0,0,0
	dc.b	48,4,20,24,32,28,24,12,52,44,44,44,48,52,8,4,8,8,8,8,8,4,8,8,8,8,36,36,36,40,40,40,40,40,36,44,48,8,4,4,4,4,12,20,24,24,24,28,8,40,44,40,44,40,44,44,44,36,40,40,36,36,36,36,0,0,0,0
	dc.b	24,28,28,32,24,32,32,32,28,12,48,44,44,8,52,4,4,8,4,8,8,8,8,8,52,44,36,36,36,40,36,40,40,44,44,44,44,40,40,44,0,24,20,12,12,20,20,12,44,40,40,40,44,44,8,8,8,4,48,44,36,36,36,36,0,0,0,0
	dc.b	32,24,20,24,28,32,32,32,32,28,4,44,40,44,48,8,4,4,4,52,52,8,4,4,8,36,36,36,36,36,36,44,44,44,44,44,44,44,36,36,12,28,20,16,20,20,12,44,8,44,36,52,4,48,12,4,12,12,12,4,36,40,36,36,0,0,0,0
	dc.b	32,20,32,32,32,32,32,32,28,32,24,48,44,40,44,44,48,8,8,8,8,8,44,44,40,40,36,36,36,36,36,44,36,40,44,44,44,44,40,40,8,20,28,16,24,24,12,4,0,12,4,4,12,8,4,12,12,12,12,20,20,44,36,36,0,0,0,0
	dc.b	20,20,32,32,24,32,28,32,32,32,28,4,44,44,44,44,48,48,48,48,48,44,36,36,40,40,36,40,36,36,36,36,36,40,36,36,44,44,44,44,8,20,20,16,20,20,4,0,12,0,4,0,12,52,8,12,12,20,20,12,20,12,40,36,0,0,0,0
	dc.b	12,20,24,20,24,32,24,32,32,32,28,4,44,48,40,40,44,48,8,4,8,8,36,36,40,40,40,40,36,36,36,44,40,40,36,40,40,44,44,44,8,12,20,12,20,12,12,4,12,4,4,12,12,56,4,4,12,24,24,20,20,12,8,44,0,0,0,0
	dc.b	20,20,24,24,24,24,24,32,32,32,28,12,48,48,48,48,44,8,8,8,8,8,44,36,40,40,40,40,36,44,44,44,44,44,44,40,36,40,40,44,44,44,4,12,12,12,12,56,12,4,8,12,4,4,12,8,20,24,20,12,16,20,8,44,0,0,0,0
	dc.b	20,20,20,12,20,20,28,32,32,32,28,8,8,52,8,8,8,4,4,8,8,8,40,40,40,40,36,40,44,44,44,48,44,44,44,44,40,36,40,40,40,40,44,8,8,8,52,48,4,8,40,8,8,44,8,20,20,20,20,16,20,24,12,44,0,0,0,0
	dc.b	20,20,20,20,20,24,32,24,24,32,20,8,48,8,8,4,8,8,52,4,4,48,44,40,36,40,40,40,40,44,44,44,48,44,44,44,44,40,40,36,40,36,36,36,40,40,36,40,36,40,40,44,40,44,12,24,24,32,20,0,12,24,20,44,0,0,0,0
	dc.b	24,20,20,24,24,24,28,20,32,28,8,52,8,4,52,8,8,52,4,4,8,36,40,40,40,40,40,40,44,44,44,44,48,44,44,44,44,40,40,40,36,40,36,36,40,36,40,36,36,40,40,44,8,48,20,24,24,24,24,16,20,20,20,44,0,0,0,0
	dc.b	32,32,24,20,12,12,16,24,28,4,48,8,8,8,8,4,8,8,44,40,36,40,36,40,40,40,40,36,44,44,44,40,40,40,40,40,44,40,36,36,36,36,40,36,36,40,40,36,36,40,44,12,24,20,20,24,24,24,20,24,16,20,12,44,0,0,0,0
	dc.b	32,32,32,32,32,28,32,32,4,44,48,8,48,48,48,48,44,44,36,36,36,36,36,36,40,40,40,36,44,36,44,36,36,36,36,36,44,40,36,36,36,44,36,40,36,40,36,44,8,56,12,24,16,24,32,24,24,24,32,24,24,0,48,40,0,0,0,0
	dc.b	32,28,32,32,32,32,28,12,44,44,44,48,8,48,48,48,8,48,44,40,36,36,36,36,36,36,36,40,44,40,40,44,44,36,36,36,36,36,36,36,36,36,36,36,40,44,8,12,20,20,24,24,20,12,28,28,20,8,24,20,32,8,36,36,0,0,0,0
	dc.b	24,32,32,32,32,32,12,48,44,40,44,44,48,8,48,48,48,8,8,40,40,36,36,36,36,40,40,36,44,44,48,48,48,44,44,44,36,40,36,40,36,36,36,36,44,20,20,20,0,20,24,24,20,12,24,32,32,4,12,24,24,8,40,40,0,0,0,0
	dc.b	32,32,32,32,28,20,48,40,44,44,40,40,44,48,8,8,8,8,4,8,40,36,40,36,36,40,36,44,44,44,44,48,8,44,40,44,36,44,40,40,36,40,36,36,4,20,12,20,12,0,20,20,24,16,16,24,16,20,8,12,12,48,44,44,0,0,0,0
	dc.b	32,32,32,32,12,48,44,44,40,36,44,40,48,8,4,4,4,8,8,52,44,36,36,36,36,36,40,40,44,44,44,48,48,40,48,36,36,44,40,36,40,36,36,36,8,20,12,12,12,4,20,20,20,28,24,24,20,24,4,8,8,44,44,36,0,0,0,0
	dc.b	32,32,32,16,44,44,40,36,40,44,8,8,4,8,4,8,4,8,52,8,44,36,36,40,36,40,48,44,48,44,44,44,44,40,44,36,36,36,36,36,40,36,36,40,40,12,20,0,12,12,20,20,20,24,32,32,28,24,4,4,8,48,40,44,0,0,0,0
	dc.b	32,28,20,8,36,44,44,40,44,48,52,52,52,4,8,52,4,8,4,48,36,36,36,36,40,36,44,44,48,44,40,36,36,36,48,36,40,36,40,36,36,40,40,40,36,40,4,20,12,16,20,24,24,32,20,4,12,4,4,12,12,4,44,44,0,0,0,0
	dc.b	28,20,48,44,40,44,44,40,44,52,8,4,8,8,4,52,8,48,44,36,36,36,36,36,36,40,48,44,44,40,36,36,44,44,36,36,36,36,40,40,40,40,36,36,40,36,44,8,4,12,20,20,20,12,4,4,4,4,4,4,12,12,12,48,0,0,0,0
	dc.b	20,44,44,40,44,44,40,40,48,52,8,8,8,4,48,44,36,44,44,36,44,36,36,36,40,36,44,44,44,40,36,44,48,8,48,48,40,40,36,40,40,36,40,36,36,40,36,36,40,44,44,44,44,40,48,52,56,4,4,4,0,4,12,12,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,40,40,36,36,36,36,40,36,36,40,40,36,36,36,36,36,36,40,40,44,44,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,40,36,36,36,36,36,40,44,8,8,48,40,36,36,36,40,44,8,12,12,56,4,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,36,36,36,36,36,36,44,4,12,4,12,12,44,36,40,36,36,52,12,4,12,12,12,12,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,36,36,36,36,36,40,8,4,8,4,8,12,4,44,44,40,44,12,12,4,4,4,12,20,8,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,36,36,40,36,40,40,4,4,8,8,4,12,12,8,40,36,4,12,4,4,4,4,12,20,8,40,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,40,36,40,40,40,40,36,36,40,36,40,4,4,8,8,8,0,8,8,44,40,0,20,20,12,4,4,12,12,48,44,40,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,36,40,36,40,40,48,12,0,12,0,4,4,8,8,44,48,20,12,12,20,12,0,12,4,48,40,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,44,8,8,44,40,44,0,0,4,4,12,4,8,8,48,8,20,12,0,12,12,20,0,4,8,36,40,36,36,36,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,40,40,36,36,40,36,36,36,36,40,36,40,40,40,44,8,4,4,4,48,36,4,12,4,4,12,0,8,8,8,8,20,0,0,0,12,20,4,4,44,40,36,40,40,36,36,4,12,8,44,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	44,36,36,36,36,36,36,36,40,36,36,40,40,40,40,8,8,8,8,4,8,44,52,12,4,8,4,12,8,8,44,4,20,12,0,4,12,20,4,52,44,40,40,36,36,36,4,20,16,20,12,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	44,40,36,36,36,36,36,36,36,40,36,36,40,36,36,8,8,8,8,4,8,48,48,12,4,4,8,4,4,8,8,4,20,0,12,0,12,12,4,8,40,36,40,40,36,8,16,20,20,20,20,20,8,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	44,44,40,36,36,36,36,36,36,40,36,36,40,40,36,8,8,8,8,4,8,48,44,4,0,4,4,4,0,8,44,4,12,4,0,12,20,4,4,44,40,40,40,36,36,12,24,24,20,20,20,12,12,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	44,40,40,36,36,36,40,36,36,36,36,40,36,40,36,8,4,4,4,4,4,8,48,48,12,4,8,4,12,4,4,4,20,0,12,12,12,12,4,40,36,40,36,40,44,20,20,24,20,20,24,20,20,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	48,44,40,36,40,36,40,36,36,36,36,36,36,36,36,44,4,4,4,8,4,4,8,44,8,0,8,12,0,4,4,12,20,12,12,12,20,12,48,40,40,40,40,4,8,12,20,12,12,16,24,24,16,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	44,44,40,36,36,36,36,36,36,36,36,36,36,40,40,36,8,12,8,8,8,4,12,8,8,4,12,12,4,4,4,4,12,12,12,12,12,12,44,40,36,40,36,4,20,24,24,20,0,12,20,24,12,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	44,44,36,44,36,36,36,36,40,40,36,36,36,36,36,40,40,8,12,8,8,4,4,4,8,4,0,0,12,4,4,4,12,20,12,0,12,12,52,48,48,4,4,20,24,24,20,24,20,12,16,24,4,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	44,40,36,40,40,36,36,40,40,36,40,40,48,48,40,36,40,40,8,4,8,4,4,4,8,8,8,12,12,4,4,8,12,20,0,12,12,12,12,12,12,4,4,12,24,24,16,24,24,24,12,8,44,44,44,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	44,40,44,36,36,44,40,36,44,40,40,48,8,8,8,44,40,36,36,48,4,4,4,4,8,8,8,8,4,4,12,4,4,12,12,12,12,12,12,12,12,4,4,4,4,12,12,12,24,20,12,40,40,44,40,44,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	40,44,36,40,44,36,40,40,40,40,44,8,52,8,8,8,44,40,40,40,44,8,4,4,4,4,4,4,8,44,48,48,44,8,12,12,0,0,4,4,12,12,20,12,4,4,12,4,8,12,8,44,44,44,44,44,40,40,36,36,36,36,36,36,0,0,0,0
	dc.b	44,44,44,40,44,40,44,44,40,44,44,8,8,8,8,52,4,8,48,48,48,8,8,8,8,8,8,36,36,40,36,36,40,40,8,12,12,12,12,4,4,12,24,32,24,12,20,24,48,36,44,40,44,44,44,44,44,40,40,40,36,36,36,36,0,0,0,0
	dc.b	44,44,44,44,44,44,44,44,44,44,44,8,8,48,8,8,8,52,8,8,8,8,52,8,8,36,36,40,40,36,40,44,40,36,44,48,4,4,4,56,8,8,20,24,24,24,24,24,4,40,44,40,44,44,44,44,40,40,40,36,36,36,36,36,0,0,0,0
	dc.b	48,44,8,4,4,4,48,44,44,44,40,8,8,8,4,8,8,4,8,8,52,8,8,8,8,36,36,40,36,44,40,36,40,44,44,44,40,36,48,44,52,20,12,12,20,24,24,24,8,40,40,40,44,44,8,8,44,8,48,44,36,36,36,36,0,0,0,0
	dc.b	20,24,32,32,28,28,32,4,44,44,44,44,48,48,52,4,4,8,4,8,8,52,4,8,44,36,36,36,36,36,44,44,44,40,44,44,44,44,40,36,12,24,20,12,12,20,12,44,8,40,44,8,4,48,12,4,12,12,12,8,40,36,36,36,0,0,0,0
	dc.b	32,32,24,24,32,32,28,32,24,44,44,40,44,44,48,8,8,4,4,8,4,8,8,44,36,40,36,36,36,36,36,40,40,40,44,44,44,44,44,44,4,24,24,24,24,24,12,8,52,56,8,4,12,8,12,12,12,12,12,20,20,44,36,36,0,0,0,0
	dc.b	20,20,32,32,32,32,32,32,32,24,48,44,44,40,44,48,8,48,48,8,48,40,36,36,36,36,40,36,36,36,36,36,36,36,36,36,44,44,44,36,4,20,20,20,24,20,12,4,12,12,0,4,12,4,4,12,12,12,12,12,20,12,36,36,0,0,0,0
	dc.b	20,24,32,32,32,32,32,32,32,32,8,44,44,44,40,40,48,48,8,8,8,40,36,36,40,40,40,40,36,36,36,36,40,36,40,40,40,44,36,44,4,20,20,12,12,20,12,4,12,4,4,0,0,4,4,56,12,20,24,24,20,12,8,44,0,0,0,0
	dc.b	24,32,24,32,32,28,32,32,32,32,12,40,44,44,36,44,44,8,52,8,8,44,36,36,40,36,36,40,44,44,44,44,44,44,36,40,40,36,44,40,44,4,20,20,20,12,12,0,12,4,52,12,12,4,12,4,12,20,20,12,20,20,4,44,0,0,0,0
	dc.b	20,20,24,16,24,32,32,32,32,28,4,8,8,8,8,4,8,8,8,8,8,44,40,40,36,40,40,44,44,44,44,48,44,44,44,36,36,40,40,40,36,36,8,4,4,12,4,52,12,4,40,4,8,44,4,4,12,20,20,20,20,20,0,44,0,0,0,0
	dc.b	20,24,32,24,16,24,32,32,32,28,20,8,4,4,8,8,8,8,8,8,8,44,40,40,40,40,40,44,44,44,44,44,48,44,44,44,40,36,40,36,40,40,40,36,44,44,44,36,40,36,40,44,40,44,8,20,24,24,20,0,12,24,20,48,0,0,0,0
	dc.b	20,20,20,24,28,32,32,32,32,32,4,44,8,8,8,8,8,8,4,4,48,36,40,40,36,36,40,44,44,44,44,44,48,44,44,44,44,40,36,36,40,36,36,36,40,40,40,40,40,40,36,40,44,40,4,24,24,24,16,20,12,20,24,8,0,0,0,0
	dc.b	20,20,20,20,32,32,24,24,32,28,8,8,4,52,52,4,8,8,8,48,36,40,40,36,40,36,40,44,44,44,40,36,40,40,36,44,40,40,36,36,36,40,36,40,36,36,40,36,36,40,36,44,4,4,4,24,24,24,24,24,12,20,20,8,0,0,0,0
	dc.b	12,20,20,24,24,24,20,24,32,4,8,8,8,8,8,44,44,36,40,36,40,40,36,40,36,40,40,44,44,40,36,36,36,40,40,36,44,40,36,36,36,44,36,36,36,36,36,36,36,44,48,56,24,24,24,24,24,24,24,20,24,16,12,44,0,0,0,0
	dc.b	32,20,20,20,12,16,24,28,12,44,48,48,48,48,48,48,44,36,40,40,36,36,36,36,40,36,40,44,40,40,44,40,40,36,36,36,36,36,36,36,36,36,36,36,36,40,40,48,4,12,20,24,20,20,32,24,20,8,24,24,32,12,44,36,0,0,0,0
	dc.b	32,32,28,32,24,28,28,20,48,44,48,8,48,8,48,8,8,44,36,36,36,36,36,36,36,40,36,40,44,44,48,44,44,44,36,36,36,36,40,36,36,36,36,36,36,8,12,20,20,20,24,32,24,12,24,28,24,4,56,24,24,20,44,44,0,0,0,0
	dc.b	32,32,32,32,32,32,32,8,48,44,44,8,8,48,48,48,8,8,8,40,36,36,36,36,36,36,40,48,48,44,44,48,44,44,48,36,40,36,36,40,36,36,36,36,44,20,20,20,12,4,20,20,24,16,32,24,28,20,8,24,24,12,44,44,0,0,0,0
	dc.b	32,32,32,32,28,32,52,44,44,40,44,40,48,8,8,4,8,52,8,44,36,40,36,36,36,36,44,44,44,44,44,48,48,44,44,40,40,40,36,40,40,36,36,36,8,20,12,12,12,4,20,20,24,28,32,32,20,20,0,48,8,48,44,40,0,0,0,0
	dc.b	32,32,32,32,32,4,44,44,44,44,40,48,8,4,4,4,52,8,52,48,36,36,36,40,40,36,44,44,48,44,44,44,44,40,44,36,36,36,36,36,36,40,36,36,44,12,12,12,12,4,12,16,20,20,32,32,24,24,20,4,8,48,44,44,0,0,0,0
	dc.b	32,28,32,28,12,44,44,44,44,48,4,4,8,8,8,8,8,8,8,36,40,40,36,36,36,44,44,44,40,40,40,36,40,36,48,36,36,36,40,36,40,40,36,40,36,8,20,12,12,12,20,20,24,20,24,24,32,24,4,4,56,4,48,44,0,0,0,0
	dc.b	32,32,32,20,44,44,44,44,48,52,4,4,8,8,52,4,52,52,48,40,36,36,36,36,36,44,44,48,40,36,40,40,44,40,36,36,40,36,36,36,36,36,40,36,40,44,8,12,12,20,20,24,24,24,24,4,4,4,52,4,4,4,4,48,0,0,0,0
	dc.b	32,32,24,44,44,44,40,40,4,8,4,8,8,4,8,8,48,40,40,40,36,40,44,36,40,44,44,44,44,40,36,44,44,48,8,36,36,40,36,40,40,36,40,40,40,40,40,48,4,12,12,12,20,12,8,4,4,4,4,4,12,56,12,12,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,40,40,36,40,40,40,40,36,36,40,36,36,40,36,40,36,36,36,36,36,36,36,40,44,8,8,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,36,40,40,36,36,36,44,8,52,4,8,44,36,36,36,36,36,8,12,12,12,4,4,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,36,36,36,36,36,44,4,4,4,4,4,8,40,36,40,40,8,12,12,4,4,12,12,8,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,36,36,36,40,40,8,12,8,4,4,0,12,8,36,44,44,0,0,4,4,0,0,12,12,44,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,36,36,36,36,36,4,4,8,8,52,0,12,8,44,40,48,12,12,4,4,4,4,12,12,44,36,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,36,36,36,44,40,4,4,4,8,4,4,4,52,44,36,4,20,20,12,4,4,4,16,4,44,40,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,36,36,36,44,40,12,12,0,0,4,12,44,8,48,40,12,20,12,12,20,20,12,12,4,44,40,40,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,44,8,8,8,36,40,4,0,0,4,12,0,8,8,8,44,12,16,0,0,0,20,12,4,4,44,40,40,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,40,36,40,40,48,4,4,4,4,44,40,12,0,0,4,4,0,8,8,8,48,12,12,0,0,0,20,12,4,4,36,36,40,40,36,36,8,4,12,8,44,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,40,36,36,40,36,8,8,8,4,4,8,44,8,12,4,8,4,56,4,8,8,48,20,12,4,0,0,20,12,4,48,36,36,40,40,40,36,4,20,20,20,12,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,40,36,36,36,40,40,4,8,8,8,4,8,48,48,12,4,4,52,4,0,8,8,48,12,12,0,12,12,20,4,4,44,36,36,36,40,36,8,12,20,16,20,20,20,8,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,40,36,40,40,4,8,8,8,4,8,48,44,4,0,4,8,4,0,4,48,48,20,0,0,12,12,20,4,44,40,36,36,40,40,44,12,24,24,20,20,12,12,12,40,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,40,36,40,8,4,4,4,4,4,8,48,48,0,4,4,4,4,12,4,48,12,12,0,12,12,16,4,48,40,36,36,36,40,44,20,24,24,24,16,24,20,20,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,40,36,36,40,36,36,8,56,4,4,8,4,4,8,44,4,12,4,4,0,4,56,4,20,12,12,12,12,20,4,36,40,40,40,40,8,48,12,20,12,12,20,24,24,20,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,8,12,8,8,4,4,4,8,48,0,12,0,4,4,4,4,12,20,12,4,12,20,4,44,40,36,40,40,4,20,20,16,12,12,12,16,24,20,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,40,40,36,44,4,4,8,4,4,4,4,4,4,4,12,0,0,8,52,0,20,0,0,12,12,12,48,44,44,4,4,20,28,24,24,24,12,12,16,24,12,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,36,36,36,40,40,40,44,44,36,36,36,48,52,4,52,4,8,4,8,8,4,12,12,4,8,52,52,20,12,0,0,12,12,12,12,4,12,4,12,24,24,16,24,24,20,12,4,48,44,44,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	44,36,40,40,36,36,36,36,36,36,48,4,52,44,40,36,36,40,8,52,4,4,4,4,8,8,8,0,4,12,4,4,12,12,0,12,12,12,12,12,12,4,8,52,12,20,12,20,24,24,20,40,44,44,44,44,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,44,36,36,36,36,44,36,36,44,8,8,8,8,48,36,40,36,40,8,4,56,4,4,8,52,4,8,48,8,8,8,48,12,20,12,0,0,12,12,12,4,12,4,4,56,12,4,4,20,12,44,44,44,44,44,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,40,40,40,40,36,36,36,36,44,4,8,8,8,52,8,48,44,40,44,8,8,4,4,4,52,8,40,36,36,40,36,36,48,4,20,0,12,12,4,4,20,24,24,12,4,12,12,44,48,48,44,44,44,44,44,36,40,36,40,36,36,36,36,0,0,0,0
	dc.b	44,40,44,44,40,36,40,44,40,48,52,44,8,52,8,8,4,8,52,8,8,8,8,8,44,36,36,40,40,40,44,44,40,40,48,4,12,4,12,4,8,4,24,24,24,24,24,24,4,40,44,40,44,44,44,44,40,40,40,40,36,36,36,36,0,0,0,0
	dc.b	44,44,44,44,44,40,44,40,36,40,8,52,8,52,8,8,8,8,8,8,8,8,8,8,36,40,36,36,40,36,40,40,40,44,44,44,44,8,48,8,44,12,12,20,24,24,24,32,12,36,40,36,44,44,8,44,44,48,44,44,36,36,36,36,0,0,0,0
	dc.b	44,44,44,44,44,44,40,44,44,40,44,8,8,4,8,8,8,8,8,8,8,8,4,44,36,36,40,36,36,36,44,44,44,44,44,44,44,36,44,36,20,24,20,4,12,20,20,12,8,44,44,8,8,44,12,4,4,12,4,8,40,40,36,36,0,0,0,0
	dc.b	52,56,12,20,56,8,48,44,40,44,40,36,48,8,4,4,4,4,8,8,4,4,8,40,40,36,36,36,36,36,36,36,36,40,44,44,44,44,36,40,12,24,24,16,24,16,12,48,8,4,48,56,12,8,12,12,12,12,20,20,12,44,36,36,0,0,0,0
	dc.b	32,32,32,32,32,32,28,4,44,44,40,40,36,44,48,8,8,52,8,8,44,44,36,36,40,40,36,40,36,36,36,36,36,36,40,44,44,40,44,40,4,24,20,16,24,24,12,4,4,12,4,0,12,4,4,12,0,12,12,12,12,20,40,36,0,0,0,0
	dc.b	24,24,24,32,28,32,32,32,4,44,44,44,44,36,36,48,48,48,8,8,40,36,36,40,40,36,40,36,36,36,36,36,36,40,40,36,40,44,36,44,12,20,12,20,20,20,12,4,12,4,4,4,4,4,4,12,12,12,20,24,20,12,4,44,0,0,0,0
	dc.b	24,28,32,32,32,32,32,32,32,48,44,40,40,36,36,44,8,8,8,8,44,40,40,36,36,36,40,44,44,44,44,44,44,44,40,36,40,44,44,40,8,12,20,12,20,12,0,12,12,8,4,12,0,0,0,4,12,24,20,12,20,20,4,44,0,0,0,0
	dc.b	32,32,32,32,32,32,32,32,28,12,48,48,48,44,48,48,8,8,8,8,48,40,36,40,40,40,40,44,44,44,44,48,44,44,40,36,36,40,36,36,40,48,12,12,12,12,12,4,12,4,8,12,4,8,12,8,4,20,16,20,20,16,12,44,0,0,0,0
	dc.b	32,24,24,24,32,32,32,32,32,20,8,52,8,8,4,52,4,8,8,4,48,40,36,36,36,40,44,40,44,44,44,44,48,44,44,36,40,36,40,40,40,40,44,48,44,8,8,44,44,40,40,48,44,44,44,8,20,20,16,12,12,20,24,4,0,0,0,0
	dc.b	24,16,24,32,24,32,32,32,32,16,48,8,8,8,48,8,8,4,4,8,40,40,40,40,36,40,44,44,44,44,44,44,44,44,40,44,36,36,36,36,40,36,40,40,40,36,40,36,40,40,40,40,44,40,44,24,24,24,24,12,12,20,24,12,0,0,0,0
	dc.b	20,20,24,20,24,32,32,32,32,32,8,8,8,8,8,8,52,4,8,48,40,40,36,40,40,40,44,44,40,40,36,40,36,36,44,44,40,36,40,36,36,40,40,36,36,36,36,40,36,36,40,40,40,44,48,24,24,16,24,24,20,16,24,12,0,0,0,0
	dc.b	20,20,20,24,32,32,32,32,32,20,8,8,8,4,8,8,8,48,40,36,36,36,36,40,40,36,44,44,44,40,36,36,36,36,40,36,44,44,36,36,36,44,36,40,36,36,40,36,36,40,40,44,12,20,4,20,24,24,24,20,20,20,16,4,0,0,0,0
	dc.b	20,16,24,24,28,32,24,32,28,4,8,8,8,8,48,44,36,40,36,36,36,36,36,40,36,40,44,40,40,40,36,36,40,40,36,36,36,36,36,36,36,36,36,36,36,40,40,40,44,48,8,4,24,24,24,20,24,12,24,24,24,24,4,44,0,0,0,0
	dc.b	20,20,24,32,32,20,20,32,20,44,48,8,48,8,8,48,44,36,36,36,36,36,40,36,36,40,36,44,44,44,48,44,44,44,40,36,36,36,36,40,36,36,36,36,36,40,48,4,4,20,24,24,24,12,24,28,20,4,8,24,24,24,8,36,0,0,0,0
	dc.b	20,20,16,16,16,20,28,32,8,44,48,48,48,48,48,8,8,44,40,36,36,36,36,36,36,36,40,44,44,44,44,44,40,44,44,40,40,36,36,36,36,36,36,36,44,4,20,20,20,12,20,24,24,16,24,20,28,12,48,20,24,32,4,40,0,0,0,0
	dc.b	32,24,20,24,24,32,32,4,44,44,48,48,48,48,48,8,4,52,44,40,40,36,40,36,36,40,44,44,44,44,40,44,40,44,44,36,36,36,36,36,40,40,36,36,44,24,12,12,12,4,20,20,24,24,24,24,24,24,4,44,20,12,44,36,0,0,0,0
	dc.b	32,32,32,32,32,32,24,48,44,44,44,44,8,8,4,8,4,8,8,36,36,40,36,36,36,44,44,44,48,44,44,44,44,36,44,36,40,36,36,36,40,36,36,40,8,20,12,12,12,4,12,20,20,24,32,32,24,16,20,4,48,44,44,44,0,0,0,0
	dc.b	32,28,32,32,32,24,48,44,44,48,48,8,4,4,4,8,8,8,48,36,36,36,36,36,36,44,44,44,44,40,40,40,36,40,48,36,36,36,40,36,36,40,40,36,36,12,20,12,12,12,12,20,20,20,24,32,32,20,24,4,4,52,48,44,0,0,0,0
	dc.b	32,32,28,32,32,4,44,44,48,8,4,8,8,8,4,8,8,52,44,40,36,36,36,36,40,44,44,44,40,36,36,40,44,36,36,36,40,36,36,36,36,40,36,36,40,48,12,12,56,12,20,20,16,24,24,20,20,24,12,4,4,56,4,48,0,0,0,0
	dc.b	32,32,32,32,4,44,44,48,8,4,8,8,8,8,8,4,8,48,36,36,36,36,44,36,40,44,44,44,36,40,40,44,44,44,40,36,36,36,36,36,36,40,36,40,40,40,48,12,12,20,20,24,24,24,32,4,4,8,52,4,4,4,12,12,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,36,40,36,36,36,36,36,44,44,40,36,36,36,36,36,36,40,44,52,4,8,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,36,40,36,36,36,36,44,52,56,4,4,44,36,36,36,36,44,8,12,12,12,12,12,8,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,40,36,36,36,40,40,40,40,36,36,36,36,44,4,4,52,4,12,4,44,36,36,36,44,0,4,4,4,4,12,12,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,40,40,40,36,36,36,36,36,36,36,36,52,12,8,4,4,4,12,4,36,40,36,8,12,4,4,4,4,4,20,4,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,40,40,36,36,40,40,36,36,40,36,44,4,8,4,4,8,12,4,4,44,36,44,12,20,4,4,4,4,12,20,4,40,36,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,40,36,40,40,44,0,0,8,8,8,4,4,8,48,36,44,12,20,20,12,4,4,12,12,48,44,40,36,36,40,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,40,40,36,36,40,36,40,40,44,4,12,0,12,0,0,8,8,8,44,8,20,12,0,12,20,12,12,4,48,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,36,40,44,8,8,44,40,36,12,0,0,4,0,12,8,8,8,36,4,20,12,0,0,12,16,12,4,8,36,36,36,36,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,40,8,52,4,4,4,44,40,4,12,4,4,4,4,4,48,8,44,4,20,0,0,0,12,20,4,4,44,36,36,36,40,40,36,44,12,12,8,48,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,40,36,36,40,36,4,8,8,4,4,8,44,8,12,4,4,4,0,4,8,8,44,12,12,0,4,0,12,20,4,4,44,36,40,36,40,40,44,12,20,20,20,12,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,40,36,40,4,8,8,8,4,8,48,44,12,0,8,4,4,12,8,8,44,4,20,0,0,12,12,20,4,8,36,36,36,36,40,40,48,20,20,20,20,20,20,8,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,48,8,8,8,8,4,8,48,44,4,4,8,8,4,0,12,8,44,4,20,0,0,12,12,12,4,44,40,36,36,36,40,44,12,24,24,16,16,12,12,12,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,44,52,8,4,4,4,4,8,48,44,12,4,8,4,4,0,4,48,4,12,0,12,12,20,20,4,44,40,40,36,40,36,8,20,20,24,20,16,16,20,20,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,36,8,4,4,4,8,4,4,8,48,4,0,4,4,4,4,12,4,56,20,12,12,12,12,12,44,40,40,36,40,44,8,8,20,24,12,20,24,24,24,20,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,40,40,36,36,40,44,4,4,8,4,8,4,4,8,44,4,12,0,0,4,4,4,4,20,12,12,12,12,12,44,44,40,40,36,8,4,4,12,20,12,0,12,20,24,20,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,36,36,48,12,52,8,4,4,4,4,4,4,0,0,0,4,4,4,4,20,12,12,12,12,20,4,44,36,48,4,8,20,28,24,24,24,12,12,20,24,20,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,40,36,40,36,40,36,36,40,36,44,36,40,36,36,48,4,52,52,4,8,52,8,52,4,12,12,4,4,8,8,12,20,0,12,12,12,12,4,4,4,12,4,20,24,24,16,24,24,16,12,12,8,44,44,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,40,36,36,36,36,36,40,8,8,8,44,40,36,36,48,4,4,8,8,4,4,8,8,8,4,12,12,4,4,4,20,12,0,12,12,12,16,12,4,56,8,4,20,16,20,24,24,24,12,44,40,44,44,36,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,36,44,40,44,8,8,8,8,44,36,36,40,44,8,4,4,4,4,8,8,4,4,8,8,4,4,8,4,20,12,12,12,12,12,12,56,4,4,8,4,12,12,4,12,20,20,48,44,44,44,40,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,8,8,8,8,8,52,44,44,36,40,36,8,4,4,4,4,4,4,8,40,36,40,44,40,44,4,20,12,0,0,12,12,4,20,24,16,4,4,12,56,44,4,52,44,44,44,44,44,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,44,36,36,40,36,36,36,48,8,8,48,8,52,4,8,8,8,8,8,8,8,52,8,44,36,40,40,40,40,44,44,40,44,4,12,12,12,12,4,8,12,24,24,24,20,16,24,4,40,36,44,44,44,44,44,40,36,40,40,36,36,36,36,0,0,0,0
	dc.b	36,36,36,40,36,40,40,36,44,52,48,8,4,8,8,52,8,8,8,4,8,8,52,36,40,40,36,40,36,44,40,40,44,44,44,48,8,44,4,8,8,4,20,24,24,24,24,24,20,36,40,44,44,44,8,44,36,44,44,40,36,36,36,36,0,0,0,0
	dc.b	44,40,40,44,40,40,44,40,40,48,8,8,4,8,4,8,8,8,8,8,8,52,8,36,36,36,36,36,36,40,44,36,44,44,44,44,40,40,40,36,12,16,12,0,20,24,24,24,4,44,44,8,8,44,4,4,4,12,4,48,36,40,36,36,0,0,0,0
	dc.b	44,44,44,40,44,44,40,44,44,44,44,8,4,4,4,4,4,8,8,4,4,8,40,40,40,40,36,36,36,36,40,36,40,44,44,40,44,44,36,48,16,24,20,12,20,20,12,8,8,8,44,56,4,8,12,12,12,12,12,20,4,44,36,36,0,0,0,0
	dc.b	44,48,48,44,44,44,44,44,36,40,36,44,48,52,8,4,4,4,52,8,8,44,36,36,40,40,40,36,36,36,40,36,40,40,44,44,44,40,40,44,12,24,16,20,24,24,12,4,12,0,4,4,12,4,4,0,4,12,12,12,16,20,36,36,0,0,0,0
	dc.b	12,20,20,20,4,8,44,44,44,44,44,40,40,48,48,48,8,48,8,40,40,40,36,36,40,40,36,40,36,40,36,36,40,40,36,40,36,44,40,36,12,20,20,20,24,20,12,4,0,4,4,4,4,4,8,12,4,12,12,20,16,12,12,44,0,0,0,0
	dc.b	32,28,32,28,32,28,56,48,44,40,36,40,40,36,48,48,8,8,8,44,36,40,36,36,40,36,40,44,44,44,44,40,44,44,40,36,40,44,44,44,12,20,20,12,20,12,4,4,0,4,4,0,4,12,4,12,12,20,24,20,20,20,4,44,0,0,0,0
	dc.b	24,24,32,32,32,28,32,16,48,44,44,44,44,44,44,48,8,8,8,48,40,36,36,36,36,40,44,44,44,44,44,48,44,44,36,36,40,36,40,40,44,4,20,20,20,12,12,4,0,4,8,12,8,8,12,4,4,20,20,12,12,20,12,8,0,0,0,0
	dc.b	32,32,32,32,28,32,28,32,8,48,48,48,8,8,8,8,8,8,8,48,36,40,40,40,36,40,44,40,44,40,44,44,8,36,44,36,36,36,40,40,40,44,8,4,4,4,4,48,4,48,36,8,44,44,8,48,4,12,20,16,20,20,24,4,0,0,0,0
	dc.b	28,32,32,32,32,32,32,32,20,8,8,8,8,8,8,52,8,52,52,48,36,40,36,36,40,44,40,44,44,44,44,44,44,44,36,44,36,36,40,36,40,36,36,36,44,40,40,36,40,36,36,36,40,36,36,4,24,24,24,12,4,20,24,24,0,0,0,0
	dc.b	28,24,32,32,32,32,32,32,24,8,8,4,8,48,8,48,8,4,8,44,40,40,36,40,40,36,44,44,36,40,40,36,40,44,36,36,40,36,36,36,40,40,36,40,40,36,40,40,36,36,40,36,40,36,44,12,20,24,24,16,20,12,20,24,0,0,0,0
	dc.b	24,24,24,24,32,32,32,32,24,8,8,8,8,4,52,56,8,8,36,36,36,36,36,36,40,44,36,36,40,36,36,36,36,36,40,36,44,44,36,36,36,40,36,36,36,36,40,36,40,36,36,36,44,8,48,12,24,24,24,16,24,12,20,24,0,0,0,0
	dc.b	24,24,24,24,28,32,32,32,32,4,8,8,8,8,48,44,36,36,36,36,36,36,36,36,40,36,36,36,40,36,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,40,40,44,12,24,16,12,24,20,24,24,20,24,12,4,0,0,0,0
	dc.b	16,20,24,28,32,32,28,32,20,48,48,48,48,8,44,40,40,36,36,36,36,36,36,36,40,36,40,36,44,40,44,44,44,40,36,36,36,36,36,36,36,36,36,36,36,36,40,44,48,4,4,4,20,16,24,24,20,12,0,24,24,32,12,40,0,0,0,0
	dc.b	20,24,24,32,32,32,32,32,20,48,48,48,48,48,48,48,44,36,36,36,36,36,36,36,36,40,44,44,44,44,44,44,44,44,36,36,36,36,36,36,40,36,36,36,36,48,4,12,20,20,24,24,28,20,20,24,24,12,44,12,20,20,20,44,0,0,0,0
	dc.b	24,24,28,32,32,24,32,32,8,48,8,48,8,8,8,8,8,44,36,36,36,36,36,36,36,44,44,44,44,44,44,44,40,44,36,36,36,36,36,36,36,40,36,36,44,12,20,12,20,4,20,24,28,24,20,16,24,24,4,48,24,32,12,44,0,0,0,0
	dc.b	24,24,24,16,24,24,28,4,48,44,48,48,48,8,8,4,4,8,36,36,36,36,40,36,36,44,44,44,48,44,44,44,36,40,40,36,36,36,36,36,40,36,40,36,8,20,12,12,20,4,12,12,24,24,24,24,24,20,20,8,8,0,48,44,0,0,0,0
	dc.b	12,20,20,24,32,28,28,8,44,44,8,48,8,4,8,8,52,8,36,36,36,36,36,36,44,44,44,44,44,36,40,40,40,36,40,36,36,36,40,36,36,40,36,36,44,20,12,12,20,56,56,12,16,24,24,28,32,20,20,12,4,8,48,44,0,0,0,0
	dc.b	32,32,32,32,32,28,12,44,48,48,4,4,4,8,8,8,8,48,36,40,36,36,36,36,44,44,44,44,36,36,40,36,44,40,36,36,36,36,40,36,40,36,40,40,40,4,20,4,4,12,12,20,20,24,24,24,28,24,24,12,4,4,4,48,0,0,0,0
	dc.b	32,32,32,32,32,20,48,48,8,4,4,48,8,8,8,8,8,44,36,40,36,36,36,40,44,44,44,36,36,36,36,44,40,44,36,36,36,36,36,36,36,40,36,40,40,44,4,20,56,0,20,12,20,16,24,20,4,20,16,4,4,12,56,12,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,36,36,36,40,44,44,48,44,40,36,36,36,36,40,40,44,4,12,0,4,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,44,4,4,56,12,44,36,36,36,40,36,44,12,12,56,12,12,12,44,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,36,40,36,44,56,4,4,4,0,12,44,36,36,40,44,4,12,4,4,4,0,12,56,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,40,36,40,40,40,40,40,36,36,36,36,4,4,8,4,4,12,12,52,44,40,40,44,12,0,4,4,12,4,12,20,48,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,40,36,40,40,40,36,40,40,40,40,44,4,4,8,4,4,0,12,4,44,36,40,8,20,12,4,4,4,4,12,12,44,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,40,40,36,36,40,36,40,44,12,4,4,8,8,0,8,8,8,40,44,0,20,20,12,12,4,4,20,4,44,36,36,36,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,40,36,40,40,40,36,36,44,0,12,0,12,4,12,8,8,8,44,44,12,20,12,0,20,12,12,12,8,44,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,40,48,8,8,44,36,36,0,0,0,4,12,0,8,8,8,44,44,20,12,0,4,12,12,20,4,4,44,40,36,40,36,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,40,8,52,4,4,4,44,36,12,0,4,4,4,0,4,8,8,44,48,20,12,0,0,12,12,20,4,8,40,36,36,36,40,36,40,8,12,12,8,48,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,44,52,8,4,4,4,8,44,8,12,4,8,4,4,0,8,8,44,48,20,0,4,12,0,20,20,4,48,36,36,36,36,36,40,44,12,20,20,20,12,8,44,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,48,8,8,4,8,8,48,8,44,12,0,4,52,4,0,8,8,48,8,20,0,4,12,12,12,12,8,44,36,36,40,36,36,36,4,20,12,20,20,20,16,8,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,40,8,8,8,8,8,4,8,48,44,4,12,4,4,4,12,12,8,48,48,20,12,12,12,12,20,12,8,40,36,36,36,40,44,8,12,20,28,20,20,12,12,12,40,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,48,8,8,52,4,0,4,8,48,48,12,4,8,4,0,12,4,8,44,20,12,12,12,12,20,12,44,40,36,40,36,40,40,4,20,20,28,20,16,20,20,20,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,40,36,44,4,4,4,8,4,4,52,44,48,8,4,4,4,4,4,0,4,4,20,12,12,12,12,20,4,40,40,40,36,36,48,8,8,20,20,20,20,20,16,24,20,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,40,40,44,12,4,4,8,8,12,4,8,44,4,4,4,0,56,4,4,4,20,12,12,12,12,12,4,40,40,36,36,40,8,4,8,12,12,4,0,12,28,28,20,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,40,8,4,8,52,8,4,4,4,4,4,12,4,12,4,4,4,8,12,20,12,12,12,20,12,48,44,40,8,4,8,12,28,28,28,20,12,12,20,16,20,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,40,36,40,40,36,36,44,4,4,8,52,4,8,52,4,4,4,12,12,0,4,4,8,4,20,12,12,12,0,20,4,4,4,4,4,4,16,28,20,20,28,20,12,12,12,12,44,44,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,44,8,48,36,36,36,44,52,4,8,8,8,4,4,8,8,8,0,0,4,4,4,4,12,20,12,4,12,12,20,12,4,0,4,8,56,20,28,16,20,28,28,12,8,44,44,44,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,40,44,48,8,52,8,48,44,36,36,40,8,4,4,4,8,4,8,8,8,4,4,4,4,4,4,4,12,12,12,12,12,12,12,12,0,4,48,4,4,20,12,12,16,20,20,8,44,44,44,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,40,36,36,36,36,36,8,8,44,8,52,8,40,36,40,36,40,4,4,4,4,4,4,4,4,8,40,40,44,44,44,4,20,12,12,12,12,12,12,4,12,20,4,8,4,12,4,8,12,12,48,44,44,40,40,36,36,36,40,36,36,36,36,0,0,0,0
	dc.b	40,36,36,40,36,36,40,8,8,8,8,8,8,52,8,44,44,48,8,8,8,4,8,48,44,40,36,40,40,36,44,40,44,4,12,12,12,12,4,4,8,20,28,28,20,4,12,20,8,44,44,44,44,44,44,40,40,40,40,40,36,36,36,36,0,0,0,0
	dc.b	36,40,36,36,40,40,36,8,8,8,8,4,52,52,52,52,52,8,8,52,8,8,44,36,36,40,36,40,36,44,40,40,44,44,48,4,52,4,4,4,48,12,28,24,28,20,28,28,20,36,40,44,44,44,8,40,40,40,40,44,40,36,36,36,0,0,0,0
	dc.b	36,40,40,36,40,40,36,44,8,8,8,8,8,8,52,8,8,8,8,8,8,8,40,36,36,36,36,36,36,40,40,44,44,40,44,44,40,40,44,44,4,12,12,20,28,28,28,28,12,44,44,48,48,44,4,8,8,4,4,48,40,36,36,36,0,0,0,0
	dc.b	40,36,40,40,36,40,40,40,48,8,52,52,4,8,8,52,8,8,4,8,4,44,40,40,36,40,36,36,40,36,36,40,44,44,44,44,44,40,40,48,16,28,12,4,12,20,20,0,8,48,48,4,4,8,12,12,12,12,12,12,4,44,36,36,0,0,0,0
	dc.b	40,40,40,40,40,40,40,40,40,44,48,8,4,4,4,4,52,4,4,8,8,44,36,36,36,36,40,36,36,36,36,36,36,40,40,40,44,40,40,48,20,28,20,20,20,20,12,4,4,4,4,12,12,44,4,12,12,4,20,12,20,20,40,36,0,0,0,0
	dc.b	40,44,40,44,44,44,40,40,40,40,44,36,8,44,8,52,8,8,44,36,40,40,36,36,40,40,36,36,36,36,36,36,36,40,40,44,40,44,40,44,12,20,20,16,16,28,20,4,0,4,4,4,4,4,4,12,4,12,0,12,12,16,12,44,0,0,0,0
	dc.b	48,48,44,44,44,44,44,40,40,40,44,40,40,48,48,48,48,8,44,36,36,36,36,36,40,36,44,44,44,44,40,40,44,44,36,36,40,44,40,44,12,20,20,16,20,20,4,4,0,4,4,4,4,0,4,4,12,12,20,20,20,20,4,8,0,0,0,0
	dc.b	20,20,20,4,8,44,44,44,44,40,40,40,40,44,48,8,8,8,8,40,36,40,36,40,40,40,44,40,44,44,44,48,44,36,36,36,36,36,40,40,4,20,20,12,20,12,12,0,4,4,4,12,4,4,12,4,4,20,20,20,12,20,20,8,0,0,0,0
	dc.b	28,28,28,28,28,20,48,44,44,44,44,44,44,44,8,52,8,8,8,36,36,40,36,40,40,44,44,44,40,40,44,44,40,36,40,36,36,36,40,36,40,8,12,20,12,12,4,4,4,8,44,4,48,44,52,4,4,12,20,20,12,20,20,12,0,0,0,0
	dc.b	28,28,28,28,28,28,12,8,8,8,52,8,52,8,8,8,8,8,8,40,36,36,40,36,36,44,44,44,44,44,44,44,44,44,40,36,36,40,36,40,36,40,44,44,8,48,44,40,44,40,40,36,36,36,40,44,4,20,16,16,12,12,20,28,0,0,0,0
	dc.b	28,28,28,28,28,28,28,12,8,4,8,8,8,8,8,4,52,52,44,36,36,36,40,36,44,40,44,40,36,40,36,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,44,36,4,20,28,28,16,12,0,20,20,0,0,0,0
	dc.b	28,28,28,28,28,28,28,28,8,8,8,48,48,8,8,4,8,8,36,36,36,36,36,40,40,40,40,36,36,36,36,36,36,40,36,36,44,40,36,36,36,40,36,36,36,36,40,36,36,36,36,36,40,40,40,4,28,16,20,28,20,20,20,20,0,0,0,0
	dc.b	28,28,28,28,28,28,28,28,4,8,8,4,8,8,52,8,36,36,36,36,36,36,36,36,36,40,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,40,36,40,44,4,4,4,28,20,28,20,16,16,16,20,0,0,0,0
	dc.b	28,28,28,28,28,28,28,28,4,8,8,8,8,48,40,36,40,36,36,36,36,36,36,36,40,40,40,40,44,44,40,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,44,44,4,28,20,12,20,12,4,28,16,24,20,8,0,0,0,0
	dc.b	28,24,28,28,28,24,28,28,8,44,48,48,48,48,44,36,36,36,36,36,36,36,36,36,36,40,44,44,44,44,44,40,44,40,36,36,36,36,36,40,36,36,36,36,44,40,44,8,8,0,20,12,12,20,16,28,20,12,8,12,28,28,28,8,0,0,0,0
	dc.b	24,24,28,28,28,28,28,28,8,48,48,48,8,8,8,44,40,36,36,36,36,36,36,36,40,44,44,44,44,44,44,44,40,40,36,36,36,36,36,40,36,40,36,36,36,4,20,12,20,16,20,28,28,20,20,16,20,28,4,48,12,20,28,4,0,0,0,0
	dc.b	28,28,28,28,28,24,28,4,48,48,48,44,48,48,8,52,48,36,36,36,36,36,36,40,44,44,44,40,48,44,44,44,40,40,36,36,36,36,36,40,40,36,36,36,44,20,20,4,12,4,12,20,28,20,28,20,16,28,20,48,4,20,20,8,0,0,0,0
	dc.b	28,28,28,28,28,28,28,20,48,44,48,48,8,8,8,52,8,40,36,36,36,36,36,40,44,44,44,44,44,40,40,40,40,36,36,36,36,36,36,40,36,40,36,40,48,20,12,12,20,12,4,12,28,20,12,28,28,16,28,0,4,48,48,44,0,0,0,0
	dc.b	28,28,28,24,28,28,28,8,44,44,8,4,52,52,8,8,52,44,36,36,36,40,40,44,44,44,44,44,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,40,36,12,12,0,12,12,0,12,20,28,20,20,28,28,20,28,8,4,52,48,0,0,0,0
	dc.b	28,28,28,28,28,28,20,48,48,8,4,4,8,8,8,4,8,40,36,36,36,36,36,44,44,44,40,36,36,36,36,44,36,36,36,36,36,36,36,36,36,36,36,36,36,8,20,0,4,12,12,12,20,20,28,20,20,28,28,20,4,4,4,52,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,40,40,40,36,36,40,36,36,40,48,8,8,44,40,36,36,36,36,36,36,44,4,16,16,12,4,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,40,40,36,36,36,40,36,8,12,4,12,12,8,40,36,40,36,36,44,4,16,12,12,12,16,4,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,40,40,36,40,40,36,8,12,8,8,4,4,12,8,40,40,36,36,8,12,4,4,4,4,4,20,8,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,40,36,36,36,40,40,36,36,36,4,4,8,12,4,12,12,4,44,40,40,40,0,12,4,4,0,12,4,20,4,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,40,40,40,40,36,40,44,12,8,8,4,4,4,0,4,8,40,36,48,12,16,4,4,4,4,4,20,4,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,40,36,36,40,40,36,44,4,12,4,8,8,0,8,8,8,44,40,8,16,20,20,20,4,4,12,12,48,40,36,36,36,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,40,36,36,40,36,40,44,12,12,12,12,0,0,8,8,8,44,36,4,20,16,12,16,16,12,16,4,44,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,44,48,8,8,40,36,40,0,0,0,4,12,12,4,8,8,44,40,4,20,0,4,0,12,20,12,4,48,40,36,36,36,36,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,36,36,36,36,40,36,8,4,4,4,8,44,40,4,12,4,4,4,12,4,8,8,48,44,0,20,12,12,4,16,20,12,4,44,40,36,36,36,36,40,44,4,16,16,8,48,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,40,8,4,8,8,4,4,8,44,8,12,4,4,4,4,12,8,8,48,40,12,16,0,4,16,12,20,4,4,44,36,36,36,36,40,40,8,12,20,20,20,12,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,40,36,8,8,8,8,4,8,8,44,44,12,4,8,4,4,56,4,8,8,44,12,12,4,12,16,12,20,4,48,36,40,36,36,36,40,44,52,16,16,16,20,20,16,8,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,4,8,8,8,8,4,48,8,44,4,12,4,8,4,0,0,8,48,44,12,16,12,12,12,12,16,4,48,36,36,36,40,40,44,8,0,28,16,20,12,12,12,12,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,40,8,8,8,8,4,4,8,48,48,8,12,4,8,4,0,12,0,8,44,12,20,0,12,12,12,20,52,44,40,36,36,36,40,44,4,20,28,28,16,20,16,20,20,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,40,36,48,4,4,4,4,4,12,8,48,44,4,12,4,4,4,4,0,12,8,0,20,12,12,12,12,16,8,36,40,36,40,44,48,48,4,16,20,20,20,16,28,24,20,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,40,4,4,4,8,8,4,4,4,48,48,4,4,4,12,0,4,4,4,0,20,12,12,12,12,16,48,40,36,40,40,44,4,4,8,16,20,12,12,16,16,28,20,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,48,4,4,8,8,4,4,4,4,8,4,12,0,4,4,4,4,4,4,16,12,12,20,16,20,4,44,40,40,4,8,8,12,20,20,20,16,4,4,16,28,20,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,40,40,40,40,36,8,4,8,8,8,4,4,4,4,8,4,12,0,12,4,4,8,8,16,16,16,16,12,16,12,4,4,4,4,4,4,20,28,28,16,28,16,0,12,20,16,44,44,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,40,36,36,36,36,40,44,48,36,44,36,40,8,4,4,8,4,8,4,8,8,4,8,12,12,4,8,4,8,12,20,12,4,12,16,20,20,4,4,12,8,4,12,20,28,20,16,28,28,12,48,44,44,44,40,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,36,48,8,4,8,44,40,36,36,48,8,4,8,4,8,4,8,4,8,8,4,12,4,56,12,4,12,16,12,0,4,12,20,12,4,4,4,48,4,16,16,12,20,28,20,20,8,44,44,44,40,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	40,36,36,36,40,36,8,8,8,8,8,44,36,40,36,44,48,4,4,4,4,4,8,12,4,8,52,48,48,8,44,8,16,16,12,12,16,20,12,4,4,4,4,4,8,4,12,4,56,20,20,52,44,40,44,40,40,40,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,40,36,44,8,8,8,48,8,4,8,44,40,36,44,8,8,4,4,4,8,8,44,40,36,36,40,40,44,44,4,4,20,12,20,16,12,4,4,20,28,20,4,48,12,16,48,44,48,44,44,44,36,40,40,36,40,40,36,36,36,36,0,0,0,0
	dc.b	40,36,36,36,36,44,8,8,8,8,4,8,8,8,8,8,8,8,8,8,8,8,36,36,36,36,40,40,40,44,40,40,44,48,4,12,4,4,4,8,44,20,28,28,28,16,20,28,12,40,44,44,44,44,44,36,40,40,44,44,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,44,8,8,8,8,8,8,8,8,8,8,8,8,8,8,8,44,36,36,40,36,36,36,44,40,40,44,44,40,44,44,36,48,48,44,8,12,16,20,28,28,24,32,20,44,44,44,44,48,8,8,44,8,8,44,40,40,36,36,0,0,0,0
	dc.b	36,36,36,36,36,40,44,8,8,4,8,8,8,8,8,8,8,8,8,52,8,44,40,36,36,36,36,36,40,36,36,40,40,44,40,44,44,40,36,48,16,20,12,12,20,20,28,20,12,48,44,4,4,44,4,12,4,16,12,12,4,44,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,40,44,48,4,4,8,8,8,8,8,8,8,4,8,44,44,36,36,36,40,36,40,36,36,36,36,36,44,36,40,44,40,40,8,20,28,16,12,16,20,16,4,4,4,8,4,12,48,4,12,12,4,16,16,16,12,40,36,0,0,0,0
	dc.b	36,40,36,36,44,36,44,40,40,48,48,8,8,4,12,4,4,8,48,36,40,36,36,36,40,36,40,40,36,36,36,40,36,40,44,36,40,36,40,48,16,28,20,20,28,20,20,4,4,4,4,4,12,8,4,12,4,12,12,0,16,12,12,44,0,0,0,0
	dc.b	44,36,44,40,36,40,36,40,40,36,44,44,8,48,48,48,44,44,40,36,40,36,36,40,36,40,44,44,44,44,40,40,36,44,36,36,40,44,44,48,16,20,12,16,16,20,12,4,0,8,4,4,4,4,4,0,12,12,12,20,20,16,12,4,0,0,0,0
	dc.b	40,36,44,44,40,44,44,36,44,40,40,40,44,48,8,8,8,48,36,40,36,40,36,36,40,44,44,40,44,44,44,36,40,36,36,40,36,36,40,44,16,12,12,16,20,20,4,0,0,8,4,12,4,12,12,4,4,12,20,20,12,20,16,4,0,0,0,0
	dc.b	44,44,44,44,44,44,44,44,36,36,40,36,36,48,8,8,8,8,40,40,36,40,40,40,40,44,44,44,40,40,44,44,44,40,36,36,36,40,40,40,8,12,16,20,12,12,0,4,56,8,48,4,4,44,4,4,4,12,20,20,16,12,20,12,0,0,0,0
	dc.b	20,16,4,8,44,48,48,48,44,8,48,48,48,8,8,8,8,8,36,36,36,36,36,36,40,40,36,44,44,44,44,44,36,44,36,36,36,36,36,40,36,44,8,4,4,8,8,44,44,40,36,40,36,36,36,44,48,4,12,20,16,16,20,20,0,0,0,0
	dc.b	28,28,28,28,4,48,4,8,4,8,4,8,8,8,8,8,8,8,36,36,36,36,36,40,36,40,40,36,36,36,36,40,44,36,40,36,40,36,40,40,36,36,36,36,36,40,36,36,40,36,36,36,36,40,44,48,0,28,28,20,0,4,16,28,0,0,0,0
	dc.b	28,28,28,28,28,12,48,8,8,8,48,8,8,8,8,8,8,44,40,36,36,36,40,36,44,40,40,36,36,36,36,36,36,40,36,36,44,40,40,36,36,40,36,36,40,36,40,40,36,36,36,40,36,36,40,48,20,20,16,28,20,16,16,20,0,0,0,0
	dc.b	28,28,28,28,28,28,4,8,8,8,8,8,8,8,4,8,36,36,36,36,36,40,36,36,36,40,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,40,40,44,48,48,20,28,28,20,20,16,12,20,0,0,0,0
	dc.b	28,28,28,28,28,28,20,8,8,4,8,8,8,8,48,36,36,36,36,36,36,36,36,36,36,36,44,40,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,36,36,40,48,20,20,8,0,12,0,28,28,16,28,4,0,0,0,0
	dc.b	28,28,28,28,28,24,28,56,8,8,8,8,44,36,40,40,36,36,36,36,36,36,36,36,36,40,44,44,44,44,36,40,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,44,44,44,8,8,8,20,28,20,16,12,8,12,20,20,28,0,0,0,0,0
	dc.b	28,28,28,28,28,32,28,4,48,48,48,8,48,48,36,40,36,36,36,36,40,40,36,36,40,44,44,44,44,44,44,44,36,36,36,36,36,36,36,36,40,40,36,36,36,44,4,56,4,16,28,20,0,16,12,20,20,20,4,8,20,28,20,16,0,0,0,0
	dc.b	28,28,28,28,28,32,28,4,48,48,48,48,48,8,48,40,40,36,36,36,36,36,36,40,44,44,40,40,48,44,44,44,36,36,36,36,36,36,36,36,36,36,36,40,44,12,20,12,12,20,20,20,20,20,28,20,12,20,16,44,4,16,28,20,0,0,0,0
	dc.b	28,28,28,28,28,24,28,56,48,8,48,44,8,8,4,8,40,36,36,36,36,36,40,44,44,44,44,44,44,40,40,40,36,36,36,36,36,36,36,36,36,36,40,40,44,12,16,0,12,16,0,20,28,20,20,28,16,28,28,0,8,4,4,4,0,0,0,0
	dc.b	28,28,28,28,28,28,28,8,48,48,48,8,8,8,8,8,40,40,36,36,36,36,40,44,44,44,44,36,40,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,48,12,16,0,12,12,4,20,28,28,4,16,28,28,20,20,4,4,48,44,0,0,0,0
	dc.b	28,28,28,28,28,28,20,48,44,48,8,4,8,8,8,8,44,40,36,36,36,36,40,44,44,44,40,40,36,36,36,44,36,36,36,36,36,36,36,36,36,36,36,40,40,4,16,4,56,16,4,0,28,28,16,20,20,28,28,20,56,8,4,4,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,40,40,36,36,36,36,36,36,8,4,4,8,40,36,36,36,36,36,40,44,4,20,20,20,12,8,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,40,40,4,12,4,4,0,4,44,36,36,36,40,40,4,12,0,4,4,12,20,8,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,8,0,8,4,4,4,12,8,40,40,36,40,44,12,12,4,4,12,4,12,12,44,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,40,40,40,36,36,40,12,4,4,4,8,12,12,12,48,40,40,36,8,12,4,4,4,0,4,12,20,48,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,44,0,8,8,52,4,4,12,4,8,36,40,44,4,20,12,4,4,4,4,12,12,44,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,40,40,40,40,40,40,36,48,12,12,4,8,8,4,4,8,8,44,36,44,12,20,20,20,12,4,4,12,4,44,40,40,36,36,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,8,4,12,0,12,0,12,4,8,8,44,36,44,20,12,12,12,20,20,20,12,8,44,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,44,8,8,48,40,40,44,12,0,4,4,0,12,4,8,8,48,40,8,20,12,12,4,4,12,20,0,4,40,40,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,40,44,4,8,4,4,8,44,36,0,12,4,4,4,0,0,8,8,8,36,4,20,12,0,4,4,12,20,4,4,36,36,36,36,36,40,36,44,4,12,12,8,48,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,40,8,8,8,4,4,4,48,40,4,12,4,4,4,4,12,8,48,8,40,4,16,0,4,20,12,20,20,4,44,36,36,36,36,40,40,40,4,20,20,20,20,12,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,40,44,4,8,8,8,52,8,8,48,48,12,4,4,52,4,0,4,8,4,44,8,20,0,4,12,16,12,20,4,40,40,36,36,40,40,40,44,4,20,12,20,20,20,16,8,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,40,48,52,8,8,8,4,8,8,48,44,56,0,4,8,4,4,0,4,48,44,8,20,12,12,12,12,12,20,8,40,40,36,40,36,40,48,4,12,20,28,16,12,12,12,12,40,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,44,52,8,8,8,4,4,8,48,48,8,12,4,4,4,4,0,12,8,44,8,20,12,0,12,12,20,12,8,36,36,36,40,40,40,8,4,20,20,16,20,16,20,20,20,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,40,8,4,4,4,4,4,4,8,48,44,4,12,4,4,4,4,0,0,8,8,20,12,12,12,12,20,12,40,40,36,40,36,44,48,48,12,16,28,20,20,20,20,28,20,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,40,48,12,4,4,8,8,4,12,8,48,44,12,4,4,12,4,4,4,12,4,16,12,12,12,12,20,12,44,40,36,36,40,48,4,4,8,12,20,12,12,20,20,24,20,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,40,36,8,12,8,8,4,4,4,4,4,48,4,12,4,12,4,4,4,4,4,20,12,12,16,12,12,12,44,44,40,40,4,8,4,4,12,20,20,12,4,4,20,28,28,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,36,36,36,40,40,44,4,4,4,8,4,4,8,4,4,4,4,12,0,12,0,8,4,8,0,20,12,20,12,12,20,4,44,8,4,4,4,4,28,28,28,16,28,12,12,12,28,20,48,44,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,40,40,44,40,36,40,44,4,4,4,8,4,4,8,8,8,4,0,12,12,4,8,8,8,4,20,16,12,12,12,12,20,12,4,4,4,4,4,20,28,16,20,28,28,20,4,4,8,44,40,40,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,44,52,8,44,40,36,36,40,52,4,4,4,4,8,4,8,8,8,4,0,0,4,4,4,4,0,20,12,12,12,20,20,20,4,4,12,8,48,4,20,16,16,20,28,20,16,8,44,44,40,40,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,44,8,8,4,8,48,44,36,40,36,8,4,4,4,4,4,4,8,8,4,8,48,8,8,4,8,8,12,12,12,4,16,20,12,4,4,4,4,8,48,4,12,12,4,12,16,28,12,44,40,40,36,36,40,40,40,36,36,36,36,0,0,0,0
	dc.b	36,36,36,40,44,8,8,8,8,4,8,44,36,36,36,40,8,4,4,4,4,4,4,8,44,36,40,40,36,40,44,8,12,12,12,12,20,12,12,4,4,20,20,12,44,4,4,4,48,8,56,44,44,44,40,36,36,36,40,44,36,36,36,36,0,0,0,0
	dc.b	36,40,36,36,8,8,8,8,8,4,4,8,8,48,44,8,8,8,8,8,8,40,40,36,40,40,40,40,36,44,40,36,48,4,12,20,12,4,4,8,48,28,16,28,28,4,12,28,4,40,44,40,44,44,36,36,40,36,40,44,36,36,36,36,0,0,0,0
	dc.b	36,36,40,40,44,8,48,48,4,8,8,8,8,52,8,8,8,8,8,8,48,36,36,36,36,36,36,40,44,40,44,44,44,44,4,44,44,4,48,44,48,12,28,28,20,28,28,28,20,44,44,44,44,44,44,8,44,8,52,48,36,40,36,36,0,0,0,0
	dc.b	36,40,40,36,44,8,8,8,4,4,8,8,8,8,8,8,8,8,8,4,44,40,36,36,36,40,36,40,40,36,40,40,44,44,40,40,40,40,40,48,4,12,12,16,28,28,20,28,16,48,44,56,8,44,12,4,4,12,12,4,8,44,36,36,0,0,0,0
	dc.b	40,36,40,40,36,44,8,4,4,8,8,8,8,4,8,8,8,8,4,44,40,44,36,36,36,40,36,36,36,40,36,36,40,40,40,36,44,36,40,4,28,20,12,12,12,20,20,12,4,4,8,12,4,44,4,12,12,12,12,20,12,12,40,36,0,0,0,0
	dc.b	36,36,36,40,44,36,40,44,8,4,4,4,4,4,4,8,4,4,48,36,40,36,36,40,36,40,36,36,36,36,36,36,36,40,36,40,40,40,40,52,20,20,16,20,20,16,20,4,4,0,4,4,4,8,4,12,4,4,12,4,12,16,12,44,0,0,0,0
	dc.b	40,36,40,40,40,40,36,40,40,44,8,8,8,52,8,52,44,40,40,36,36,36,40,36,40,40,44,44,40,40,40,40,40,44,36,40,36,44,44,48,20,16,16,12,28,28,12,4,4,8,4,4,12,4,4,12,12,12,4,12,12,12,12,4,0,0,0,0
	dc.b	40,40,40,40,40,40,44,36,44,40,36,40,8,8,48,48,8,36,36,36,36,40,36,40,40,44,44,40,44,44,40,40,40,40,36,40,40,36,36,8,16,20,20,16,20,20,4,4,4,8,4,0,4,0,0,0,4,12,20,20,20,20,20,0,0,0,0,0
	dc.b	40,40,40,40,40,40,40,40,40,40,40,40,48,8,8,8,48,40,40,36,40,36,36,44,36,44,44,44,40,40,44,40,40,40,36,36,36,40,36,44,12,12,20,20,20,12,4,4,12,8,8,4,4,44,56,4,4,0,20,16,12,12,12,20,0,0,0,0
	dc.b	44,40,44,44,40,44,40,40,40,40,40,40,48,8,8,8,8,40,36,36,36,36,40,40,40,40,44,40,40,44,44,40,40,40,36,36,36,40,36,40,44,4,12,12,12,4,4,8,8,44,36,48,36,36,44,44,48,4,16,20,20,20,20,20,0,0,0,0
	dc.b	44,44,44,44,48,48,8,48,48,8,8,8,8,8,8,8,8,40,36,36,36,36,36,40,40,40,36,40,36,36,44,36,44,40,36,36,36,36,36,40,40,40,44,44,44,44,40,40,40,36,36,40,36,40,44,40,48,12,16,16,12,12,12,20,0,0,0,0
	dc.b	4,48,44,48,52,8,8,4,8,8,8,8,8,8,8,8,8,36,36,36,36,36,36,40,40,40,36,36,36,36,36,36,36,40,36,36,44,44,36,36,40,36,40,36,36,36,36,36,36,36,36,36,36,40,40,44,12,20,28,20,20,12,12,20,0,0,0,0
	dc.b	28,28,16,0,8,48,48,8,8,8,8,48,8,8,4,8,44,36,36,40,36,36,36,36,36,40,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,36,36,36,40,40,40,44,12,20,16,16,16,16,12,12,0,0,0,0
	dc.b	28,28,28,28,4,48,8,4,8,8,8,52,8,8,8,40,36,40,36,36,36,36,36,40,36,36,40,40,44,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,40,40,8,4,44,4,28,20,28,28,20,20,20,0,0,0,0
	dc.b	28,28,28,28,28,4,8,4,4,4,4,8,48,44,36,40,36,36,36,36,36,36,36,36,40,40,40,44,44,44,44,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,44,40,44,40,12,28,12,4,12,4,20,28,16,28,20,0,0,0,0
	dc.b	28,28,28,28,28,12,48,8,8,48,48,44,44,36,36,36,40,36,36,36,36,36,36,40,36,44,44,44,44,44,44,44,40,36,36,36,36,36,36,36,36,36,36,36,40,40,44,8,8,8,12,4,4,12,16,28,20,12,4,8,12,28,20,24,0,0,0,0
	dc.b	28,28,28,28,28,28,4,48,48,48,48,8,48,44,36,36,36,36,36,36,36,36,36,44,44,44,40,40,48,44,44,44,40,36,36,36,36,36,36,36,36,36,40,36,36,8,12,20,12,20,28,20,20,0,16,20,20,20,12,8,4,20,28,28,0,0,0,0
	dc.b	28,28,28,24,28,28,4,48,48,48,48,48,8,4,44,36,36,36,36,36,36,36,40,44,40,40,44,44,44,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,44,12,20,0,0,20,12,20,28,12,20,28,12,20,28,4,48,4,20,20,0,0,0,0
	dc.b	28,28,28,32,24,28,4,48,48,48,48,48,8,8,52,36,40,36,36,36,36,36,44,40,44,40,44,36,40,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,48,12,12,0,4,20,4,16,28,12,16,20,20,20,28,20,4,4,44,48,0,0,0,0
	dc.b	28,28,28,28,28,28,4,44,48,48,8,8,52,8,8,48,36,36,36,36,36,36,40,44,44,40,36,36,36,36,36,44,36,36,36,36,36,36,36,36,40,36,40,40,44,12,20,4,4,20,16,28,28,28,0,0,20,28,16,20,20,4,4,48,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,40,44,4,4,4,4,44,40,40,36,36,36,36,44,4,20,16,12,16,16,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,44,4,56,4,4,4,12,44,36,40,36,36,40,8,20,4,4,4,4,12,12,48,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,40,36,36,36,36,40,36,40,4,0,8,4,4,4,12,4,44,36,40,36,36,56,12,4,4,4,0,12,20,4,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,44,0,8,4,4,4,4,20,12,8,36,40,44,48,12,12,4,4,0,12,4,16,4,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,40,40,36,36,36,40,8,0,4,8,8,4,4,4,8,8,36,36,36,8,20,16,12,4,4,4,4,20,4,36,40,36,36,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,40,40,36,48,4,0,4,4,8,4,4,8,52,48,40,36,4,20,16,16,12,12,4,4,12,44,36,40,40,36,36,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,40,40,36,36,36,48,12,12,0,4,12,12,4,8,8,44,36,44,12,20,12,12,12,16,20,16,4,44,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,40,44,8,8,44,40,36,44,16,0,4,4,0,12,12,8,8,8,40,36,12,20,0,0,4,12,20,20,4,48,40,40,40,36,36,36,36,36,44,4,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,8,4,8,4,4,48,40,44,12,0,4,4,4,0,0,8,8,44,44,44,16,12,0,0,12,12,16,20,4,36,40,36,36,36,36,40,40,48,4,16,16,8,48,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,44,4,8,8,4,4,8,8,36,4,0,4,4,4,4,12,8,48,4,44,44,20,16,4,4,12,12,16,16,4,44,36,36,36,40,40,40,44,4,20,20,20,20,12,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,40,8,8,8,4,8,4,8,48,8,8,12,4,8,4,4,12,4,8,8,44,44,12,16,4,16,12,12,20,12,44,40,36,36,36,36,40,44,44,4,20,12,20,20,20,16,8,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,40,8,8,8,8,8,8,8,48,48,44,4,0,4,4,4,4,12,4,8,44,44,20,12,12,12,12,12,20,0,44,40,40,36,36,36,44,48,4,12,20,24,20,12,12,12,12,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,8,8,8,8,8,4,4,48,8,48,52,12,4,4,4,4,12,0,4,44,36,16,12,4,12,12,12,20,4,40,40,40,36,40,44,40,4,4,20,28,16,16,16,16,20,20,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,40,36,48,4,4,4,4,4,4,4,44,48,44,12,0,4,4,12,4,0,12,4,44,16,20,12,12,12,16,16,4,36,40,36,40,40,44,48,44,4,28,16,28,20,16,16,28,20,44,44,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,40,8,12,4,8,4,8,4,4,48,48,8,12,4,4,0,4,4,4,4,4,12,16,12,12,12,12,16,4,40,40,40,40,40,8,4,8,4,20,16,12,12,20,28,24,20,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,36,36,36,44,4,4,8,8,8,4,8,4,4,48,4,12,4,12,4,4,4,4,4,0,16,12,12,0,12,20,4,44,36,40,8,8,8,4,4,4,12,16,12,4,12,16,16,28,4,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,40,36,40,8,12,8,8,8,4,8,4,4,4,8,12,12,0,0,4,4,4,8,4,20,12,12,16,16,20,16,48,44,48,4,4,4,8,20,24,24,28,20,12,12,12,28,20,8,44,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,40,36,40,40,36,8,4,8,8,8,8,8,8,8,4,8,4,12,0,4,4,8,8,8,16,20,20,16,12,12,20,12,12,4,12,4,52,4,24,28,24,16,28,24,12,0,0,4,44,36,40,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,44,8,44,44,36,40,36,8,12,8,8,8,4,8,4,8,8,8,0,0,12,4,4,4,4,4,20,16,12,4,12,20,16,12,4,4,4,44,8,12,20,28,16,20,28,24,16,8,44,44,40,36,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	36,40,36,44,8,8,8,8,44,40,40,36,48,4,4,4,4,4,4,8,8,8,8,4,8,4,4,56,4,8,0,16,12,12,16,12,16,12,4,4,12,48,48,8,12,12,16,12,20,20,28,12,44,44,36,40,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,8,8,8,8,8,8,44,36,40,36,36,8,4,4,4,4,4,4,4,4,48,44,40,44,40,36,40,44,12,20,16,12,16,16,12,4,8,4,12,12,8,44,4,12,4,8,4,16,4,44,36,36,40,36,36,40,40,36,36,36,36,0,0,0,0
	dc.b	36,40,40,8,8,8,8,8,4,8,8,40,44,40,44,8,8,8,4,4,8,8,36,36,40,36,36,36,40,44,40,8,4,12,12,20,16,4,56,48,4,28,16,28,12,8,4,16,4,40,48,44,44,40,36,36,40,36,40,44,36,36,36,36,0,0,0,0
	dc.b	36,36,36,8,8,8,48,8,4,8,8,4,8,8,8,8,8,8,8,8,40,36,36,36,36,40,40,40,36,44,44,44,44,4,12,4,4,4,48,44,44,20,28,28,28,20,28,28,16,44,40,44,44,40,8,8,44,48,8,8,40,36,36,36,0,0,0,0
	dc.b	36,36,40,48,8,48,8,8,8,8,8,4,8,8,8,8,8,8,52,48,36,40,40,36,40,36,36,40,40,36,36,40,44,44,36,40,36,36,40,44,8,12,24,16,28,28,16,16,24,48,44,4,48,44,56,4,4,12,12,4,48,44,36,36,0,0,0,0
	dc.b	40,36,40,44,8,52,4,8,8,8,8,8,8,8,8,8,8,8,8,44,40,44,40,36,36,40,36,36,36,36,40,36,36,40,36,40,40,36,36,4,16,20,12,12,20,28,28,28,12,8,8,0,4,44,0,0,4,12,0,16,16,12,36,36,0,0,0,0
	dc.b	40,36,40,36,44,48,8,4,4,8,8,8,8,8,8,8,4,8,44,36,40,36,36,36,40,40,40,36,36,36,36,36,36,36,40,44,40,40,44,4,28,20,12,12,16,16,12,4,4,0,4,4,0,8,4,12,12,4,12,12,12,12,12,44,0,0,0,0
	dc.b	36,36,36,36,40,40,44,8,8,8,4,4,4,4,4,8,8,40,40,40,36,40,40,36,36,40,44,36,40,40,40,36,36,44,36,36,36,44,44,4,28,16,20,16,20,20,20,4,4,8,4,4,4,4,4,0,4,4,12,4,12,12,12,4,0,0,0,0
	dc.b	36,40,36,40,36,36,36,40,36,44,48,8,8,8,8,44,36,36,40,36,40,40,36,44,40,44,44,44,44,36,36,40,36,40,36,36,36,40,36,8,20,20,16,20,28,16,12,4,4,8,12,4,4,4,0,0,12,0,12,20,20,20,16,12,0,0,0,0
	dc.b	36,36,36,40,36,36,40,36,36,40,44,48,48,8,8,44,36,36,36,36,36,36,40,36,40,44,44,44,40,40,40,44,40,40,36,36,36,36,36,8,16,16,12,16,16,16,4,4,12,8,8,12,4,4,4,4,12,4,20,20,12,12,16,16,0,0,0,0
	dc.b	36,36,40,36,44,40,36,40,40,36,40,8,8,8,8,8,36,36,36,40,36,36,36,36,40,44,44,40,36,44,40,40,36,36,36,36,36,40,36,44,4,16,20,20,16,12,4,4,8,44,44,8,36,40,44,48,48,4,20,16,12,20,16,20,0,0,0,0
	dc.b	36,40,44,40,44,44,40,36,40,44,44,8,8,8,8,8,40,36,40,36,36,36,36,40,40,36,40,36,36,44,36,36,44,36,36,36,36,36,36,36,40,44,4,4,52,48,44,40,36,36,40,40,36,44,44,44,44,8,12,16,16,12,16,16,0,0,0,0
	dc.b	44,36,48,8,48,8,8,8,8,4,8,4,8,8,8,8,36,40,36,36,36,36,40,36,40,40,40,36,36,36,36,36,36,36,36,36,44,40,36,36,40,36,40,40,36,40,40,40,36,36,36,36,40,40,40,40,48,20,28,16,16,12,0,16,0,0,0,0
	dc.b	44,48,8,8,48,8,8,8,8,8,8,8,8,8,8,8,36,36,36,36,36,36,36,40,36,40,36,36,40,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,44,40,40,0,16,20,16,16,20,12,12,0,0,0,0
	dc.b	8,48,8,44,48,8,8,8,48,48,8,8,8,4,8,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,44,36,40,40,44,44,40,4,20,24,28,28,16,20,12,0,0,0,0
	dc.b	4,4,8,8,48,8,8,8,8,8,8,8,8,48,40,40,36,36,36,36,36,36,40,36,40,36,40,44,44,40,44,40,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,40,36,40,36,44,8,12,4,4,16,0,16,28,16,16,24,0,0,0,0
	dc.b	28,24,4,8,8,8,8,8,8,8,8,44,40,40,36,36,36,36,36,36,36,40,36,40,40,44,44,44,44,36,44,44,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,44,48,44,44,8,48,4,20,28,0,12,4,8,12,20,24,24,0,0,0,0
	dc.b	24,28,28,24,8,8,8,48,8,8,48,44,40,36,36,36,36,36,36,36,40,36,40,40,44,44,44,40,48,44,44,40,36,36,36,36,36,36,36,36,36,36,40,36,40,44,4,12,56,4,20,28,12,4,20,20,20,20,12,8,4,20,16,16,0,0,0,0
	dc.b	24,28,28,28,4,44,48,48,44,48,44,48,48,40,36,36,36,36,36,36,36,36,44,40,40,40,44,44,44,40,36,36,36,36,36,36,36,36,36,36,36,40,36,36,40,4,12,20,4,20,24,16,28,4,16,24,16,20,20,12,8,4,28,28,0,0,0,0
	dc.b	24,28,24,24,28,44,48,48,48,48,48,8,8,48,40,36,36,36,36,36,36,40,44,40,44,44,44,40,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,36,48,12,16,4,4,20,20,20,28,0,12,20,20,12,24,28,4,4,4,4,0,0,0,0
	dc.b	28,28,24,28,28,8,48,48,48,48,8,8,8,8,44,40,36,36,36,36,36,44,40,44,44,40,36,36,36,36,36,44,36,36,36,36,36,36,36,36,36,40,40,36,44,12,16,4,4,16,16,16,20,16,12,16,16,16,20,20,16,4,4,48,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,40,36,40,36,36,36,44,0,4,4,0,48,36,40,36,36,40,40,40,4,16,12,4,12,20,12,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,8,0,4,4,4,0,4,44,40,36,36,40,44,44,16,12,4,4,4,4,20,4,44,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,40,36,36,36,36,36,40,4,4,4,4,4,4,12,12,44,36,36,40,40,4,16,4,4,12,0,4,12,20,48,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,40,40,36,36,8,12,4,4,4,4,12,12,4,8,40,40,40,44,4,12,4,4,4,12,4,12,20,48,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,40,36,8,4,4,8,4,4,4,0,4,4,44,40,36,44,16,16,16,4,4,4,4,12,16,44,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,40,36,36,36,8,12,4,4,4,8,4,4,8,8,48,36,40,8,20,16,16,16,16,4,4,12,4,44,36,36,40,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,40,36,36,40,8,12,12,4,12,12,12,4,8,8,8,40,40,8,20,16,12,12,16,20,16,16,8,40,36,40,40,36,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,8,8,8,44,36,36,8,12,0,0,4,0,0,4,8,8,8,40,36,4,20,12,4,12,4,12,20,16,8,44,40,36,40,36,36,36,36,36,48,52,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,36,40,8,4,4,4,4,44,40,48,12,4,4,4,4,12,12,8,48,4,44,44,4,20,12,4,0,12,12,20,12,48,40,40,36,36,36,36,40,44,48,4,16,16,8,48,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,40,8,8,8,8,4,4,52,44,44,0,4,4,4,4,4,12,4,8,8,48,40,4,20,12,12,12,12,16,20,4,44,36,36,36,36,36,36,40,48,4,20,20,20,20,12,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,40,40,40,8,4,52,4,4,4,8,48,44,52,12,4,4,4,4,0,4,8,8,44,40,4,16,4,12,16,12,12,16,4,44,36,36,40,36,36,40,40,4,12,20,16,16,20,20,16,8,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,40,36,36,36,44,4,8,8,8,8,4,8,48,48,48,0,4,4,4,4,4,12,4,8,48,44,4,20,12,12,12,12,16,20,4,44,40,40,36,36,36,44,4,4,4,20,20,12,12,12,12,12,40,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,40,4,8,8,8,8,4,8,48,48,48,4,12,4,4,4,12,4,12,8,44,40,4,20,12,12,12,12,20,20,44,36,36,36,40,44,44,40,4,4,20,24,24,20,20,16,16,20,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,44,8,8,8,4,4,4,4,8,48,48,48,4,4,4,4,4,4,12,12,8,44,4,16,16,12,12,12,20,16,44,40,40,36,36,36,8,44,8,12,24,20,24,20,16,20,24,16,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,40,36,40,44,12,4,4,8,4,4,4,8,8,44,4,12,4,4,4,12,4,4,4,4,4,20,20,12,12,12,20,16,44,36,40,40,36,40,4,4,8,4,20,20,16,12,20,24,24,20,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,36,40,8,0,8,4,8,4,4,0,8,52,48,4,12,4,4,4,4,4,4,4,4,20,12,12,12,4,16,16,48,44,36,36,8,8,4,4,4,4,12,16,12,12,12,20,20,24,12,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,48,4,4,4,8,8,4,4,4,4,4,4,12,12,12,4,4,4,8,4,4,16,16,0,12,12,16,20,8,44,44,8,4,12,4,4,16,24,16,20,20,4,12,16,20,28,4,44,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,40,36,40,44,12,8,4,8,4,4,8,8,8,4,8,12,12,0,12,4,4,8,8,12,20,16,16,16,16,24,20,4,4,4,4,4,4,12,24,24,24,20,24,20,12,12,16,12,48,40,40,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,44,44,44,40,40,36,8,4,4,8,8,8,8,4,8,8,8,8,12,12,4,4,4,8,4,4,12,20,16,12,12,20,20,16,56,4,4,8,48,4,20,24,24,16,20,24,24,16,8,36,36,40,36,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	36,40,8,52,8,8,44,40,36,36,36,4,4,4,8,8,8,4,8,8,8,8,4,4,4,56,12,4,4,4,20,12,4,16,20,16,20,4,4,4,4,44,48,4,12,20,20,20,24,20,20,16,44,44,36,36,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	36,44,8,8,8,8,8,44,40,40,40,36,8,4,4,4,4,4,4,8,4,4,8,44,44,48,8,8,36,44,12,20,20,20,16,12,16,12,8,4,4,8,8,48,48,4,16,4,4,12,20,12,44,44,36,36,40,36,40,40,36,36,36,36,0,0,0,0
	dc.b	36,44,8,8,8,8,8,4,48,44,36,40,44,36,4,4,4,12,4,4,4,8,36,36,40,36,40,40,40,44,8,4,12,16,16,16,12,56,4,8,4,24,28,12,8,48,12,12,48,44,8,44,44,40,40,40,40,36,40,44,36,36,36,36,0,0,0,0
	dc.b	40,48,8,8,8,48,8,4,52,52,8,48,8,8,4,8,8,8,8,44,36,36,36,36,36,36,36,40,40,44,44,44,48,12,12,4,4,56,48,44,4,24,24,24,20,12,12,24,12,44,40,44,40,40,8,48,44,48,8,8,40,40,36,36,0,0,0,0
	dc.b	36,44,8,8,48,8,52,8,8,8,4,8,52,8,4,8,8,8,8,36,40,40,36,36,36,36,36,36,40,36,44,40,44,44,48,44,44,48,40,44,48,20,24,16,24,28,24,24,24,8,44,4,48,44,4,0,8,56,12,4,44,44,36,36,0,0,0,0
	dc.b	36,44,8,8,8,8,8,8,8,8,8,8,48,48,8,8,8,52,44,36,40,44,36,36,40,36,36,36,36,36,36,36,36,36,36,36,40,36,40,8,16,12,16,16,20,24,24,24,24,8,8,4,4,48,4,0,0,12,4,12,12,4,40,40,0,0,0,0
	dc.b	40,36,40,8,4,4,8,8,52,8,8,52,8,8,8,8,4,8,40,36,36,40,36,36,40,40,40,40,36,36,40,36,36,40,36,44,40,40,40,12,24,20,12,12,12,24,20,16,4,4,4,0,4,8,4,0,4,4,12,12,12,16,12,44,0,0,0,0
	dc.b	36,40,36,44,44,8,52,52,4,8,4,4,8,4,8,4,8,44,36,40,36,40,40,36,40,40,44,40,36,40,36,36,40,44,40,36,36,44,44,4,24,16,16,12,20,20,12,4,4,4,4,4,4,4,8,0,4,4,12,4,12,16,12,12,0,0,0,0
	dc.b	36,36,36,40,40,36,44,8,52,52,4,8,4,8,8,40,40,36,40,36,36,40,36,36,40,44,44,40,40,36,36,40,40,36,36,36,40,40,40,4,16,20,16,20,24,20,16,4,4,8,4,12,4,4,4,12,0,4,12,12,16,12,12,12,0,0,0,0
	dc.b	36,36,40,36,36,36,40,40,44,44,44,48,44,8,44,40,36,36,36,36,40,36,36,36,36,40,44,44,40,40,36,40,36,44,36,36,36,36,36,4,16,20,20,16,24,20,4,4,4,8,4,56,4,4,4,4,4,0,12,20,20,12,16,20,0,0,0,0
	dc.b	36,36,36,36,36,40,36,40,40,44,48,8,8,8,8,36,36,36,36,36,36,36,36,36,44,44,40,36,40,36,36,36,36,36,36,36,36,36,36,8,16,20,16,16,16,12,0,4,4,48,48,8,36,44,4,8,8,4,16,20,12,12,16,16,0,0,0,0
	dc.b	36,40,36,36,40,40,36,36,36,40,44,8,8,8,8,44,36,36,40,36,36,36,40,36,40,40,36,36,44,44,36,40,40,36,40,36,36,36,36,40,44,12,12,12,0,4,48,44,44,36,36,36,36,44,44,44,44,44,0,12,20,20,16,20,0,0,0,0
	dc.b	36,44,44,44,44,40,44,44,44,8,8,8,44,8,8,36,36,36,36,36,40,36,40,40,36,40,36,36,36,36,36,36,40,36,36,36,44,40,40,36,40,36,44,44,44,36,36,40,36,36,36,36,36,36,40,40,44,4,16,20,16,4,4,16,0,0,0,0
	dc.b	44,52,52,8,8,8,8,8,52,8,8,8,8,8,8,36,36,36,36,36,36,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,40,36,36,36,36,44,44,40,36,44,24,16,24,20,16,12,12,0,0,0,0
	dc.b	48,8,44,48,4,8,8,8,44,8,8,8,4,4,44,40,40,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,40,40,40,40,48,20,20,24,24,20,20,0,0,0,0,0
	dc.b	8,8,48,48,8,8,8,44,48,8,8,4,52,8,40,36,36,36,36,36,36,40,40,36,40,40,36,44,40,40,36,40,36,36,36,36,36,36,36,36,40,36,36,36,36,40,36,40,40,40,36,40,40,40,8,44,48,16,16,20,24,12,16,24,0,0,0,0
	dc.b	8,8,8,8,8,8,8,8,8,8,4,8,44,36,40,36,36,36,36,36,36,36,36,36,36,44,44,44,44,40,44,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,44,44,44,48,8,20,20,4,12,12,4,20,24,20,24,0,0,0,0
	dc.b	8,8,52,8,8,4,4,8,52,8,40,36,36,40,36,40,36,36,36,40,36,36,40,44,44,44,44,40,44,40,44,40,36,36,36,36,36,36,36,36,40,36,36,40,36,36,8,4,4,4,4,12,4,4,16,20,20,16,12,8,4,16,28,12,0,0,0,0
	dc.b	4,44,8,8,8,8,48,8,48,44,44,40,40,40,36,36,36,40,36,36,36,36,36,36,40,40,44,44,44,44,40,40,36,36,36,36,36,36,36,36,36,40,40,40,40,48,12,20,16,12,20,28,20,4,12,20,16,20,16,12,8,12,16,24,0,0,0,0
	dc.b	24,20,44,44,48,48,48,44,48,48,8,48,36,36,36,36,36,40,36,36,40,44,44,40,44,44,44,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,36,40,44,4,12,12,4,16,24,16,24,12,0,24,20,12,24,20,4,8,12,20,0,0,0,0
	dc.b	24,24,12,48,48,48,48,48,44,48,8,8,8,36,36,36,36,36,36,36,36,36,40,44,44,40,36,40,40,36,40,44,36,36,36,36,36,36,36,36,36,40,40,40,44,12,12,4,4,16,24,16,24,12,4,16,20,16,16,24,20,4,8,8,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,4,0,0,12,12,8,36,40,36,36,36,40,40,8,20,12,4,12,12,20,4,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,36,36,4,12,4,4,4,0,12,8,36,40,36,36,40,44,12,12,4,4,12,4,4,20,8,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,36,36,36,36,36,36,36,36,48,4,4,4,4,4,4,12,12,44,36,36,40,40,44,12,4,4,4,4,12,4,20,4,40,40,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,40,36,36,4,4,8,4,4,4,12,12,4,52,36,36,36,40,4,20,4,4,4,4,4,12,16,12,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,40,40,36,36,40,4,4,4,8,4,8,4,4,4,4,44,36,40,44,4,20,20,0,4,4,4,4,20,4,40,40,36,36,36,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,40,40,40,40,4,12,12,4,4,8,4,4,8,8,48,36,40,44,12,20,20,20,20,12,0,4,12,44,40,36,36,40,36,36,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,40,36,40,36,36,4,12,0,0,12,12,12,4,8,8,8,44,36,44,20,20,12,12,12,20,16,20,12,44,40,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,44,48,8,44,36,40,40,4,12,4,4,4,0,12,4,8,8,8,44,40,44,20,12,12,4,12,12,12,20,4,44,40,40,36,36,36,36,36,40,36,8,4,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,36,36,36,36,44,8,4,4,4,8,40,36,8,12,0,4,4,4,4,12,4,8,8,44,36,8,20,12,12,12,12,4,20,20,4,44,36,36,36,36,36,40,40,44,4,12,20,20,8,48,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,44,4,8,8,8,4,4,8,44,44,12,0,4,4,4,4,12,4,8,8,48,36,8,20,12,4,12,12,12,20,16,4,40,36,40,36,36,36,40,44,8,0,20,20,20,20,12,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,48,52,8,8,4,4,4,8,8,40,4,12,4,4,4,4,4,12,8,8,48,36,8,16,12,12,12,16,12,12,12,48,40,36,40,36,40,40,36,44,4,12,20,16,20,20,20,20,8,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,36,36,36,8,4,8,8,8,4,8,44,48,48,8,12,4,4,8,4,4,12,4,8,48,40,4,20,12,12,12,12,12,20,12,44,40,40,40,36,36,40,8,4,4,12,20,16,12,4,12,12,12,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,40,36,8,8,8,8,8,8,4,8,48,48,48,12,4,4,4,4,4,12,4,4,48,40,48,20,12,0,12,12,12,20,4,40,40,40,40,40,44,44,8,4,4,20,24,16,20,20,20,12,20,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,36,36,36,48,4,8,8,8,4,4,4,44,48,48,8,12,4,4,4,4,0,4,12,4,36,48,20,20,12,12,12,20,20,4,36,40,36,36,36,44,8,44,52,12,24,24,24,20,16,16,24,20,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,4,4,4,4,4,4,4,4,8,48,48,4,56,4,4,0,4,4,0,4,4,4,12,20,20,20,12,12,20,4,44,40,40,36,36,8,4,4,48,12,20,24,20,20,20,24,24,20,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,36,36,36,36,8,4,4,4,8,8,4,4,4,8,48,44,12,4,4,12,4,4,4,4,4,4,12,20,12,12,4,12,16,0,44,40,36,40,8,48,4,4,4,4,12,12,12,12,12,16,24,24,12,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,40,4,0,4,52,8,8,4,4,4,4,8,8,12,12,4,4,4,4,4,4,4,12,20,12,0,0,12,20,4,44,40,40,8,56,4,4,4,4,12,16,20,12,4,12,12,24,24,12,44,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,36,36,36,36,40,44,4,4,4,8,8,4,8,4,4,4,8,4,12,12,0,0,4,4,8,8,4,20,12,12,12,20,24,20,4,4,4,56,4,4,4,4,24,24,24,24,24,12,4,0,20,12,48,40,40,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,36,40,36,36,36,36,8,4,4,4,8,8,8,4,52,8,8,8,4,12,12,0,4,4,4,8,8,12,24,16,12,12,12,24,20,4,12,4,56,48,4,4,24,24,24,12,24,24,24,12,48,44,40,36,40,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	40,44,8,8,44,40,36,36,36,4,4,4,8,4,8,8,8,8,8,8,8,4,12,0,4,4,4,56,4,12,20,12,16,24,24,12,12,4,8,12,4,44,4,0,20,24,16,20,24,24,20,12,44,40,36,36,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	44,8,8,4,4,44,40,36,36,40,4,4,4,4,4,8,8,8,8,8,4,4,8,8,4,4,4,8,44,4,16,20,24,20,12,4,12,0,4,4,4,44,44,44,4,12,12,4,12,24,20,20,44,36,36,36,36,40,40,40,36,36,36,36,0,0,0,0
	dc.b	8,8,8,8,4,8,48,44,36,36,36,44,8,4,0,0,4,4,4,4,4,8,36,36,36,36,40,40,36,44,12,20,24,12,12,12,12,4,8,4,4,12,20,4,48,8,56,0,48,8,4,52,44,36,40,40,36,40,40,44,36,36,36,36,0,0,0,0
	dc.b	8,8,8,8,8,4,8,4,48,40,36,40,48,8,8,4,4,4,8,48,36,40,36,40,40,36,36,40,40,44,44,48,4,12,20,4,12,56,48,44,12,24,24,24,12,48,4,20,56,40,44,44,40,40,8,48,44,44,8,48,40,40,36,36,0,0,0,0
	dc.b	8,8,8,48,48,8,4,8,4,4,8,8,8,8,8,8,8,8,40,36,40,40,36,36,36,36,40,40,40,40,44,40,48,4,4,48,8,48,36,44,44,24,24,24,24,24,20,24,20,8,44,4,48,44,56,0,8,4,12,4,44,44,36,36,0,0,0,0
	dc.b	8,8,8,44,8,8,8,8,8,4,8,8,8,48,8,8,52,44,36,36,40,44,36,36,36,36,36,36,36,36,40,40,40,40,40,40,40,40,40,48,4,20,20,20,24,24,24,24,24,4,4,12,8,44,4,0,4,12,4,12,4,4,36,36,0,0,0,0
	dc.b	40,8,8,8,4,8,8,8,8,8,8,8,8,8,8,8,8,40,36,36,36,36,40,36,36,40,36,36,36,36,36,36,40,40,40,40,36,40,40,4,24,12,12,20,20,24,24,24,20,4,4,4,4,8,4,0,4,4,12,20,12,20,12,44,0,0,0,0
	dc.b	36,44,8,4,4,4,8,8,8,8,8,8,8,8,4,4,44,36,40,36,36,36,40,36,36,36,44,40,36,40,40,36,36,44,36,36,40,44,44,12,24,20,12,12,12,16,20,0,8,4,4,4,4,4,4,12,4,4,12,4,4,12,12,12,0,0,0,0
	dc.b	36,36,36,44,8,52,4,4,8,8,4,4,4,4,8,36,36,36,36,36,36,40,40,40,40,44,44,40,40,36,36,36,40,36,36,36,40,40,40,12,16,20,20,16,28,16,12,4,8,8,56,4,4,4,4,0,0,4,12,4,12,12,12,12,0,0,0,0
	dc.b	40,40,36,36,40,44,48,8,8,4,8,8,8,48,36,36,36,40,36,36,36,40,36,40,40,40,44,44,40,40,36,36,36,40,36,36,36,36,44,4,20,16,12,20,24,24,12,4,4,8,4,4,8,4,4,12,4,12,12,20,20,12,20,20,0,0,0,0
	dc.b	36,36,36,36,36,40,36,40,44,48,8,48,8,48,36,36,36,36,36,36,36,36,36,40,44,44,36,40,40,36,36,36,36,36,36,36,40,40,36,56,20,20,20,24,16,12,4,4,4,8,8,52,44,44,4,8,4,4,12,20,12,12,12,20,0,0,0,0
	dc.b	36,36,36,40,36,36,36,36,40,48,8,48,44,8,40,36,36,36,36,36,36,36,40,40,36,36,40,44,36,40,36,36,36,36,36,36,36,40,40,8,12,12,12,20,12,12,8,48,48,36,36,40,36,40,44,44,40,44,12,12,12,20,20,20,0,0,0,0
	dc.b	40,36,40,36,36,36,36,40,40,48,8,8,8,8,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,40,36,40,44,40,36,36,40,8,4,4,44,44,40,40,36,36,36,36,40,40,40,40,40,44,4,12,20,0,4,12,0,0,0,0
	dc.b	44,44,44,44,40,44,44,8,8,8,8,8,8,8,40,36,36,40,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,40,36,36,36,36,40,36,36,40,44,40,40,40,40,0,24,24,20,12,12,56,0,0,0,0
	dc.b	52,8,8,4,4,8,4,8,8,8,8,8,4,8,40,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,40,40,40,36,44,20,16,20,20,16,20,4,0,0,0,0
	dc.b	8,44,8,8,8,8,44,48,48,8,8,8,4,44,36,36,40,36,36,36,36,36,36,36,36,40,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,36,36,36,40,36,40,40,36,40,44,12,20,24,20,20,16,20,0,0,0,0
	dc.b	8,48,48,8,8,48,8,48,8,8,8,52,44,36,36,36,36,36,36,40,36,36,36,36,36,44,44,40,36,40,40,36,36,36,36,36,36,36,36,36,40,36,36,36,40,36,36,36,40,36,40,44,40,44,4,4,48,4,20,4,20,24,20,16,0,0,0,0
	dc.b	8,48,8,8,8,8,8,8,52,8,8,36,36,36,40,36,36,36,36,36,36,40,44,44,44,44,44,40,40,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,44,44,8,4,4,4,52,8,20,24,20,12,4,4,0,20,24,16,0,0,0,0
	dc.b	8,8,8,8,8,4,8,8,48,40,36,36,36,36,36,40,36,36,36,36,36,40,40,36,40,40,44,44,44,44,40,36,36,36,36,36,36,36,36,36,36,40,36,36,36,44,4,12,12,4,4,20,12,4,12,20,20,20,12,0,8,12,20,16,0,0,0,0
	dc.b	8,8,8,8,48,48,48,44,48,8,44,36,36,36,36,36,36,36,36,36,40,40,44,40,44,44,44,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,40,36,40,4,12,20,20,12,24,24,20,12,4,20,24,12,20,20,4,8,12,24,0,0,0,0
	dc.b	44,44,48,48,48,48,44,44,48,48,8,44,36,36,36,36,36,36,36,36,40,36,40,44,44,40,36,36,36,36,36,44,36,36,36,36,36,36,36,36,40,36,36,40,44,12,12,12,4,4,24,24,16,20,4,20,24,12,12,24,20,4,4,4,0,0,0,0
	dc.b	36,36,36,36,40,40,36,36,36,36,36,36,40,44,4,12,0,0,12,8,36,40,36,40,36,40,40,48,20,12,4,4,12,12,20,4,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,44,4,4,4,4,4,12,12,8,36,40,40,36,40,40,4,20,4,4,12,12,4,12,12,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,40,4,12,4,4,4,4,4,12,12,8,40,36,40,40,44,12,4,4,4,4,4,4,12,20,48,40,40,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,4,4,4,4,4,4,12,12,0,8,36,40,40,40,48,20,12,4,4,4,4,4,12,20,44,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,44,12,4,4,8,4,8,12,0,8,4,48,40,36,36,4,20,20,12,4,4,4,4,0,12,48,40,40,40,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,44,12,4,12,4,8,8,4,4,8,8,48,40,40,40,4,20,12,20,20,12,12,4,12,4,36,40,40,36,40,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,44,0,12,12,4,0,12,12,4,8,8,8,40,40,40,12,20,12,12,12,12,20,20,20,4,40,40,36,36,40,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,44,48,48,44,40,36,44,0,12,4,0,0,4,12,0,8,8,8,44,36,40,12,20,12,12,12,12,12,16,20,48,40,40,40,36,36,36,40,36,40,48,8,4,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,40,8,4,4,4,4,44,40,40,4,12,4,4,4,4,4,12,4,48,8,48,40,44,12,20,12,12,12,12,12,20,12,48,36,36,36,36,36,40,36,40,44,4,12,20,20,8,48,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,48,8,8,8,8,4,4,48,40,8,20,4,4,4,4,4,12,4,8,8,48,40,44,12,20,12,12,12,12,12,20,12,36,36,36,36,36,36,36,40,44,4,12,24,16,20,20,12,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,40,40,4,8,4,8,8,12,8,8,48,44,12,12,4,4,4,4,0,4,8,8,8,40,44,12,20,0,12,12,16,0,20,4,44,40,36,36,40,40,40,40,48,4,20,16,20,16,20,20,16,8,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,40,4,8,8,8,8,4,8,48,48,44,4,12,4,4,4,4,4,12,4,8,48,40,44,20,20,4,12,12,12,12,20,4,36,36,36,36,40,40,36,8,4,4,12,20,16,12,4,12,12,12,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,44,4,8,8,8,8,8,8,48,8,48,44,12,12,4,4,4,4,4,12,8,8,40,40,12,20,12,12,12,12,16,20,8,36,36,36,40,40,44,44,4,4,4,20,24,24,16,20,20,12,20,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,40,44,4,8,8,8,8,4,4,8,44,8,48,4,12,4,4,4,4,0,12,4,8,40,44,4,16,12,12,12,12,20,20,44,40,40,36,40,36,8,8,48,4,12,20,16,16,20,12,20,24,20,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,8,4,4,4,4,4,4,4,8,48,8,48,12,4,4,4,4,4,0,12,12,4,4,0,24,20,20,12,20,20,20,8,40,40,36,36,40,4,4,4,48,12,16,24,24,20,24,24,24,20,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,44,4,4,4,8,8,8,4,4,8,8,44,8,12,4,4,4,4,4,4,4,4,4,4,20,20,12,12,12,12,20,48,44,40,40,40,48,8,4,4,4,4,20,20,12,12,12,20,24,24,12,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,4,56,8,8,8,8,8,8,4,4,4,44,4,12,4,0,4,4,0,8,4,4,4,20,12,12,12,4,12,20,8,36,40,44,4,4,4,4,4,56,0,12,20,4,4,12,12,20,24,12,44,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,40,36,36,40,4,0,8,8,8,8,4,8,4,4,4,4,4,12,0,4,4,12,4,8,8,4,20,12,12,12,12,16,20,12,8,8,52,12,4,52,4,4,24,24,24,24,20,4,4,12,20,20,4,36,40,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,36,40,36,36,44,4,4,8,8,8,8,8,8,4,4,8,8,0,12,0,0,4,8,4,8,8,12,24,16,20,20,24,24,20,12,12,4,56,4,48,4,4,24,24,16,16,24,24,24,4,8,8,36,40,36,36,36,40,36,36,36,36,36,0,0,0,0
	dc.b	44,48,44,36,36,36,44,4,4,8,8,8,8,4,8,4,8,8,8,4,12,12,4,4,4,4,4,4,4,24,16,12,16,24,20,12,4,4,4,4,48,48,4,20,24,24,16,16,24,24,20,56,44,40,36,36,40,36,40,36,36,36,36,36,0,0,0,0
	dc.b	8,8,8,48,44,40,36,36,4,4,4,8,8,8,8,8,8,8,8,8,8,4,4,4,12,4,4,4,8,20,16,16,16,20,12,12,4,4,52,56,8,44,44,48,12,12,20,12,20,24,20,20,44,40,40,40,40,36,40,40,36,36,36,36,0,0,0,0
	dc.b	8,8,8,8,8,44,40,40,36,36,8,4,12,4,4,4,8,8,4,4,8,8,36,36,44,44,40,36,44,4,20,24,24,12,4,12,4,56,8,56,8,8,4,48,44,4,12,4,8,56,20,12,48,40,36,40,36,40,40,44,36,36,36,36,0,0,0,0
	dc.b	8,8,8,8,8,48,48,36,40,40,36,44,8,4,12,4,12,8,4,8,40,36,36,40,40,36,36,40,36,48,4,4,20,12,20,4,12,4,48,48,4,24,24,12,8,44,0,12,8,40,48,44,40,36,8,48,44,48,48,44,36,36,36,36,0,0,0,0
	dc.b	8,8,44,8,8,4,8,8,48,8,48,8,4,8,8,8,8,36,36,36,36,40,36,36,36,36,36,40,40,40,44,36,4,12,4,8,56,48,40,44,4,24,24,24,24,12,12,24,20,48,44,8,48,44,12,4,48,4,56,4,44,44,36,36,0,0,0,0
	dc.b	48,48,48,8,8,8,8,4,8,8,8,8,8,44,8,8,8,40,36,36,40,44,40,36,40,40,36,36,36,36,44,40,40,44,40,40,40,36,40,48,4,24,24,16,24,24,24,24,24,4,4,12,8,48,4,12,4,12,4,4,4,8,36,36,0,0,0,0
	dc.b	8,44,8,8,8,8,8,8,8,8,8,44,8,8,8,52,44,36,36,36,36,40,36,36,40,36,36,40,36,36,36,36,40,36,40,40,36,40,40,8,12,12,20,16,24,24,24,24,24,4,8,4,4,8,4,12,4,4,0,12,20,20,12,44,0,0,0,0
	dc.b	52,8,4,8,8,8,8,8,8,8,48,8,8,8,4,8,36,36,36,36,36,40,36,36,40,40,44,40,36,40,40,36,40,44,40,36,40,44,44,20,20,20,12,12,12,24,20,20,12,4,4,4,4,8,4,4,4,4,12,12,4,12,12,12,0,0,0,0
	dc.b	44,8,4,4,8,8,8,8,8,8,8,8,8,4,8,36,36,36,40,36,36,40,40,40,36,44,40,36,40,36,36,36,40,36,36,40,40,40,44,12,24,24,12,12,16,16,12,4,8,8,4,4,4,4,4,12,4,4,4,4,12,12,12,4,0,0,0,0
	dc.b	36,40,48,8,4,4,4,4,4,4,8,52,8,44,36,36,36,36,36,36,36,36,36,36,40,36,44,44,36,40,36,36,36,44,36,36,40,36,44,12,16,20,12,20,24,16,12,4,4,48,4,4,8,4,4,4,4,4,12,12,20,12,20,20,0,0,0,0
	dc.b	36,36,36,36,36,40,44,8,8,8,8,48,44,40,36,36,36,36,36,36,36,36,36,36,44,44,36,36,40,36,36,36,36,36,36,36,40,40,44,12,16,20,20,20,24,20,4,4,4,44,4,4,44,48,4,4,4,4,12,20,12,12,12,12,0,0,0,0
	dc.b	36,36,36,36,36,36,40,48,44,8,48,8,8,36,36,36,36,36,36,36,36,36,36,36,36,44,40,40,36,40,36,36,36,36,36,40,36,36,40,4,20,12,20,16,20,0,4,8,8,36,40,44,40,40,44,44,40,8,4,20,12,20,20,12,0,0,0,0
	dc.b	40,36,36,36,36,36,36,36,44,8,8,48,8,44,36,36,36,36,36,36,36,36,40,36,36,40,36,36,36,36,40,36,36,36,40,36,44,44,40,44,4,12,12,12,4,48,40,36,36,36,36,40,40,36,40,40,40,36,8,12,20,12,12,12,0,0,0,0
	dc.b	36,36,36,36,36,36,36,44,8,8,48,8,8,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,48,44,40,36,40,40,36,36,36,36,36,36,36,36,40,48,12,20,20,4,4,4,0,0,0,0
	dc.b	48,44,44,44,44,8,8,8,8,8,8,8,8,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,40,36,36,36,36,40,36,36,36,36,40,40,56,20,16,24,20,12,4,0,0,0,0
	dc.b	8,8,8,8,52,8,8,8,8,8,8,8,48,40,36,36,36,36,36,36,36,36,36,36,36,40,36,40,40,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,40,40,36,40,40,40,40,40,36,40,4,20,24,16,20,16,20,0,0,0,0
	dc.b	48,8,8,48,8,48,48,48,8,8,8,8,44,36,36,36,36,36,36,36,36,36,36,36,36,44,44,40,40,36,36,36,36,36,36,36,36,36,36,36,40,36,40,36,36,40,40,40,36,40,40,40,40,40,44,44,40,4,20,16,16,24,12,20,0,0,0,0
	dc.b	48,8,8,48,8,48,48,48,8,4,8,40,36,36,36,36,36,36,36,36,36,36,40,44,44,44,44,36,40,40,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,40,40,44,48,8,8,8,8,8,4,24,4,4,12,4,12,20,20,16,0,0,0,0
	dc.b	48,8,8,8,4,8,8,8,8,44,36,36,36,36,36,40,36,36,36,36,40,40,40,40,40,40,44,44,44,44,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,8,4,0,4,4,4,4,4,12,20,24,20,12,12,8,12,20,24,0,0,0,0
	dc.b	8,8,8,8,8,4,8,48,44,36,36,36,36,36,36,36,36,36,36,36,40,40,40,40,44,44,44,36,36,40,36,36,36,36,36,36,36,36,36,40,40,36,40,36,40,8,12,12,20,12,12,20,20,0,4,20,16,12,20,12,4,8,12,20,0,0,0,0
	dc.b	8,8,8,8,48,48,44,48,48,44,36,36,36,36,36,36,36,36,36,36,40,40,40,44,44,40,36,40,36,36,36,44,36,36,36,36,36,36,36,36,40,40,40,40,44,4,4,20,20,12,24,20,20,20,8,12,24,12,20,24,12,8,8,12,0,0,0,0
	dc.b	36,36,40,36,36,36,36,36,36,36,40,36,8,12,4,4,0,12,4,40,40,36,40,36,40,36,44,12,16,4,4,4,4,20,12,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,36,36,36,36,36,36,8,12,4,4,4,4,4,12,4,36,40,40,40,40,44,4,20,4,4,12,12,12,4,20,4,40,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,40,36,36,40,4,4,4,4,4,4,4,12,4,48,40,36,36,40,44,4,12,4,4,12,4,4,12,20,12,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,40,48,12,4,4,4,4,4,4,16,12,4,36,40,36,36,44,12,12,4,4,4,4,4,4,16,12,44,44,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,8,4,4,4,8,4,4,4,4,4,4,48,36,36,40,44,16,20,16,4,4,4,4,4,16,4,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,40,36,40,8,12,12,0,4,8,4,4,4,8,4,8,44,40,36,8,20,20,16,24,16,12,4,4,16,8,44,40,40,36,40,36,36,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,40,36,8,12,12,0,0,12,0,12,4,8,48,8,44,36,36,4,20,16,12,12,16,20,20,20,12,44,44,40,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,40,44,48,44,36,36,40,44,12,12,4,4,4,0,12,4,48,48,4,44,36,36,4,20,12,12,12,12,12,16,24,4,44,40,40,36,36,36,36,36,36,40,8,4,4,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,44,8,4,4,8,8,44,36,44,12,4,12,4,4,4,0,16,48,48,4,8,36,36,4,24,16,12,12,12,12,16,24,4,40,36,36,36,36,36,36,40,44,48,12,12,20,20,8,44,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,40,8,8,8,8,4,4,8,44,44,4,12,4,4,4,4,4,16,4,48,8,48,36,40,4,24,12,4,12,12,12,16,20,8,36,36,36,36,36,36,36,40,48,4,20,24,12,20,20,12,8,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,8,4,8,8,8,4,4,8,8,44,8,16,0,4,4,4,4,4,4,8,8,8,44,36,4,24,12,12,12,12,12,16,20,48,36,40,36,36,40,36,40,44,4,4,16,20,20,20,20,20,20,8,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,8,8,8,4,8,8,4,8,44,48,44,12,0,4,8,4,4,0,16,4,48,8,36,44,4,20,12,12,12,12,12,16,20,44,36,36,36,36,36,36,44,52,4,4,16,24,20,12,4,12,12,12,36,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,8,8,8,8,8,8,4,8,48,8,48,4,12,4,4,8,4,4,0,12,4,48,44,36,4,20,4,12,12,12,12,20,12,36,36,36,36,40,40,44,44,4,4,4,16,24,24,20,20,12,12,20,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,8,8,8,8,48,8,4,8,48,48,48,8,12,0,4,8,4,0,4,12,4,8,44,40,4,20,16,12,12,12,16,24,0,44,36,40,36,36,44,8,44,8,4,12,24,20,16,16,16,24,24,12,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,8,4,4,4,4,4,4,12,8,8,48,48,4,12,4,4,4,4,12,4,12,12,8,48,4,24,20,20,20,12,20,20,12,44,36,40,36,36,48,4,4,8,8,12,20,24,24,24,20,20,24,20,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,40,4,0,4,4,8,8,8,12,4,48,44,48,4,12,4,4,0,4,4,4,4,12,4,4,12,20,20,12,12,16,20,12,44,40,36,40,40,48,4,4,4,8,4,20,16,12,12,12,24,24,24,16,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,36,8,4,8,8,8,8,8,4,4,4,8,8,44,4,0,4,12,4,4,0,4,4,4,4,16,20,12,4,4,4,24,12,44,40,36,8,4,4,8,4,4,4,4,12,12,4,12,12,12,16,24,12,44,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,44,8,4,8,8,8,8,8,4,4,4,4,4,4,12,12,0,4,4,4,4,4,4,4,12,20,12,12,0,12,24,20,48,44,8,4,12,4,4,4,4,20,24,16,24,20,4,4,16,20,20,4,40,40,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	36,40,36,44,4,4,8,8,8,8,8,4,8,4,4,4,4,12,12,0,4,12,4,8,4,8,4,20,20,12,12,20,20,20,12,12,4,4,4,8,8,4,4,24,24,24,24,24,24,16,4,52,8,40,36,36,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	40,36,40,36,44,4,4,8,8,8,8,8,4,4,8,8,8,8,4,16,12,4,4,8,8,4,4,12,20,20,12,20,24,24,12,12,12,4,4,8,44,8,56,24,24,24,12,20,24,24,20,4,40,40,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,44,40,36,36,36,4,4,4,8,8,4,4,8,8,8,8,8,8,4,12,0,4,56,4,4,4,8,4,20,12,16,16,12,0,12,4,8,4,4,8,44,44,4,20,20,20,20,24,24,16,20,44,36,40,36,36,40,40,40,36,36,36,36,0,0,0,0
	dc.b	4,8,8,44,40,36,40,8,4,12,4,8,4,4,4,8,8,8,4,4,8,44,48,8,8,8,48,40,4,20,20,20,20,12,4,12,4,4,4,12,48,44,44,44,48,12,12,4,4,20,20,20,8,40,36,40,36,40,40,44,36,36,36,36,0,0,0,0
	dc.b	8,8,8,48,48,36,40,36,36,8,4,4,4,4,4,4,4,4,56,48,40,36,36,36,40,40,36,40,8,12,20,20,16,12,12,12,12,4,48,8,4,20,20,4,44,48,12,12,8,48,4,8,44,36,8,48,44,48,44,44,40,40,36,36,0,0,0,0
	dc.b	48,8,8,8,8,8,36,36,36,36,48,8,4,8,4,8,48,44,40,36,40,40,40,36,36,36,40,40,36,36,44,8,12,20,4,4,4,48,40,44,12,24,24,24,12,48,4,16,12,44,44,48,48,44,56,4,48,4,12,52,44,44,36,36,0,0,0,0
	dc.b	8,44,8,8,4,4,8,8,8,8,8,8,8,8,8,8,36,36,36,36,40,44,40,36,36,36,40,36,36,36,36,44,8,48,36,44,40,36,36,48,4,24,24,24,24,24,16,24,24,4,8,4,8,48,4,4,8,12,4,4,4,8,36,36,0,0,0,0
	dc.b	48,8,8,8,8,8,8,4,8,8,8,48,8,8,8,48,36,36,36,36,36,36,36,36,36,40,36,36,40,36,36,44,36,40,36,36,40,40,36,48,4,20,24,24,24,24,24,24,24,12,4,4,4,8,4,12,4,4,4,12,12,12,12,44,0,0,0,0
	dc.b	8,8,8,8,8,8,8,8,8,44,8,8,8,8,4,44,36,36,36,36,36,36,36,36,40,40,40,36,36,40,36,36,40,44,40,36,40,44,44,12,20,16,12,20,20,24,24,24,24,4,4,4,4,8,4,0,4,4,12,12,4,12,12,12,0,0,0,0
	dc.b	4,4,8,8,8,8,8,8,8,8,8,8,8,8,48,36,36,36,36,36,36,40,40,40,36,44,40,36,36,36,36,36,36,40,36,36,36,40,44,20,24,12,0,12,16,20,20,0,8,4,4,4,4,4,4,4,4,4,4,12,0,12,12,0,0,0,0,0
	dc.b	8,4,4,8,8,8,8,4,8,8,8,4,8,48,40,36,36,36,36,36,36,36,36,36,40,36,44,44,40,40,36,36,36,36,40,36,36,36,48,20,20,20,20,16,24,20,12,4,8,8,4,4,8,4,4,4,4,4,0,12,12,12,12,12,0,0,0,0
	dc.b	36,44,8,8,8,4,4,4,4,4,8,48,36,40,36,36,36,36,36,36,36,36,36,36,44,44,40,36,36,36,36,36,36,36,36,36,40,40,48,12,20,12,12,20,16,20,12,4,4,44,4,4,44,8,4,4,4,4,0,16,20,12,12,20,0,0,0,0
	dc.b	36,36,36,44,40,48,48,48,8,48,48,44,36,36,36,36,36,36,36,36,36,36,36,40,36,40,44,40,36,40,36,36,36,40,36,40,36,36,48,12,16,20,20,24,24,16,4,4,8,36,44,44,40,40,44,44,44,4,4,16,12,12,20,12,0,0,0,0
	dc.b	40,36,36,36,36,36,44,48,48,8,8,8,40,36,36,36,36,36,36,36,36,36,36,36,36,40,40,36,36,36,36,36,36,36,40,36,44,44,44,8,12,16,12,20,4,4,44,44,44,40,36,40,40,36,36,36,40,36,8,12,16,20,12,20,0,0,0,0
	dc.b	40,36,36,36,36,36,40,44,8,8,48,8,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,48,8,4,8,44,44,36,36,40,36,36,40,36,36,36,36,40,44,8,12,16,4,4,4,0,0,0,0
	dc.b	36,40,36,36,40,36,44,8,48,48,8,8,44,40,36,36,36,36,36,36,36,40,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,36,36,36,36,36,36,36,36,36,36,40,36,36,48,20,24,24,16,12,4,0,0,0,0
	dc.b	40,44,44,48,8,52,8,8,8,8,8,8,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,40,4,20,16,16,20,20,20,0,0,0,0
	dc.b	4,8,8,8,52,8,48,48,8,8,4,48,40,36,36,36,36,36,36,36,36,36,36,36,36,44,36,44,36,40,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,40,40,36,36,40,36,36,40,36,36,36,36,4,16,24,28,16,16,12,0,0,0,0
	dc.b	8,8,48,8,44,48,8,8,8,8,8,44,36,36,36,36,36,36,36,36,36,36,40,44,44,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,40,44,44,8,8,48,48,48,4,8,48,12,12,12,20,20,16,0,0,0,0
	dc.b	8,8,8,8,8,48,8,8,8,8,36,36,36,36,36,36,36,36,36,40,44,40,40,40,40,40,36,40,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,40,36,40,44,8,4,4,4,8,8,8,12,20,24,12,4,12,8,12,20,24,0,0,0,0
	dc.b	8,8,8,8,8,8,8,8,44,40,36,36,40,36,36,36,36,36,36,36,40,36,40,44,44,44,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,44,4,12,12,4,4,12,12,8,4,20,20,20,20,12,4,8,12,12,0,0,0,0
	dc.b	8,8,8,8,8,8,8,36,40,36,36,36,36,36,36,36,36,36,36,36,40,40,40,44,44,40,36,40,36,36,36,44,36,36,36,36,36,36,36,36,40,40,36,40,44,4,12,4,20,16,12,24,24,12,8,16,24,12,12,20,12,4,8,12,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,40,36,44,4,12,4,4,0,12,4,44,36,40,36,40,40,40,40,12,16,12,4,4,4,12,20,8,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,40,4,0,4,4,4,4,0,12,4,40,36,36,40,36,36,8,20,4,4,4,12,12,4,12,16,48,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,48,12,4,4,4,4,4,0,16,4,44,40,36,36,40,40,4,16,4,4,4,12,4,4,12,20,48,44,36,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,4,4,4,4,4,4,4,0,16,4,4,44,40,36,36,44,0,16,0,4,4,4,4,4,12,20,8,40,36,40,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,4,0,4,8,8,4,4,0,4,4,4,48,40,36,36,44,12,20,20,12,4,4,8,4,0,16,44,36,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,4,12,12,0,8,4,8,0,4,4,8,8,44,44,36,44,16,16,12,20,16,12,12,4,16,4,44,40,36,44,36,40,36,36,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,4,12,12,12,12,12,12,12,4,44,4,4,36,36,36,48,24,20,12,12,16,20,20,20,20,8,40,44,40,36,40,40,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,40,44,44,40,36,36,40,4,12,12,4,4,0,0,16,4,48,44,4,44,36,36,48,20,16,12,12,12,12,12,20,20,8,40,36,40,36,36,36,36,36,36,40,8,4,4,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,44,4,4,4,8,44,40,36,8,16,0,4,4,4,4,12,12,8,48,4,48,36,36,48,24,20,12,12,12,12,16,24,20,48,36,40,36,40,36,36,36,40,44,4,12,12,20,20,8,48,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	48,4,4,8,4,4,4,48,44,44,12,0,4,4,4,4,0,12,8,8,4,8,36,40,48,16,16,12,4,12,12,16,20,12,44,36,36,36,36,36,36,36,40,4,0,12,24,16,12,20,12,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,8,8,8,8,4,4,8,48,44,4,12,4,4,4,4,4,4,0,48,8,8,36,44,48,24,20,12,12,12,12,12,16,12,44,36,36,36,36,40,44,40,44,4,4,24,28,20,20,20,20,16,8,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,8,4,8,8,4,8,48,48,48,8,16,4,4,4,4,4,0,12,4,8,8,44,40,8,16,12,12,16,12,12,12,24,4,36,36,36,40,36,36,40,48,4,4,4,16,24,12,4,4,12,12,12,36,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,4,4,8,8,4,48,48,48,44,12,12,4,4,4,4,0,0,12,8,8,44,36,8,20,12,12,12,12,12,20,24,4,40,36,36,36,36,36,44,8,4,4,8,16,24,28,20,16,12,12,20,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,8,8,8,8,4,8,48,48,48,4,12,4,4,4,4,12,4,12,4,8,44,40,48,20,16,12,12,12,12,20,20,48,36,36,40,40,36,40,8,44,52,4,12,24,20,16,20,20,20,24,16,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,8,8,8,8,4,4,4,8,44,48,48,12,12,4,8,4,0,12,0,12,4,48,44,48,20,20,20,16,16,20,20,20,48,36,40,40,36,36,4,4,4,48,8,12,20,24,24,24,20,16,24,20,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,4,4,4,4,4,4,48,44,48,4,12,4,4,4,12,4,4,0,0,0,4,4,4,24,20,20,16,16,20,20,4,44,40,40,40,36,4,4,4,4,48,12,20,16,16,12,20,24,24,24,16,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	48,56,4,8,8,8,8,4,4,4,8,48,44,8,12,4,4,0,4,4,0,4,4,0,4,4,24,16,12,4,12,20,24,8,36,44,36,4,4,8,4,4,4,4,4,16,16,4,12,0,16,24,24,20,44,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,8,0,4,8,8,8,8,4,4,4,4,8,8,0,12,0,0,12,4,4,4,8,4,4,0,20,12,0,0,4,16,28,4,44,44,8,4,4,56,4,4,8,4,12,16,16,12,8,12,12,20,20,12,36,40,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,44,4,12,8,8,8,8,8,4,4,4,4,4,8,12,16,12,0,4,4,4,8,8,8,4,20,20,16,16,20,20,16,16,4,4,4,0,4,48,4,4,0,24,24,24,24,24,16,4,4,4,4,48,36,40,40,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,36,48,4,4,8,8,8,8,8,8,8,4,4,8,8,0,12,0,12,4,4,8,4,8,4,12,20,20,20,20,16,16,24,12,12,4,4,4,48,48,4,12,24,24,24,12,24,24,24,16,8,44,40,36,36,40,40,36,40,36,36,36,36,0,0,0,0
	dc.b	36,40,36,44,4,12,8,8,8,8,8,8,4,8,8,8,8,4,4,12,0,4,4,4,4,4,4,4,16,16,12,12,16,20,12,12,4,8,4,4,44,44,44,16,20,24,20,16,24,24,16,20,44,40,36,40,40,40,40,40,36,36,36,36,0,0,0,0
	dc.b	8,44,40,36,40,4,4,4,8,8,4,8,4,8,8,8,8,8,4,4,8,0,4,12,4,8,44,48,20,16,20,16,20,4,12,4,4,8,4,4,44,44,44,44,4,12,20,16,16,24,20,28,4,40,36,36,36,36,40,44,36,36,36,36,0,0,0,0
	dc.b	8,44,44,36,36,36,44,4,4,4,8,4,4,4,8,8,8,4,4,48,36,36,36,36,36,44,40,36,12,20,24,20,20,4,12,12,12,8,8,8,44,4,4,48,40,4,12,4,44,4,12,4,48,40,8,8,44,48,44,40,36,40,36,36,0,0,0,0
	dc.b	8,8,48,44,44,40,40,36,44,8,0,4,12,4,4,4,4,48,36,36,40,40,40,36,36,40,40,40,44,4,4,12,16,16,4,12,12,48,40,44,12,24,28,12,4,44,4,16,56,44,48,48,44,44,56,4,44,4,56,52,44,44,36,36,0,0,0,0
	dc.b	8,4,8,8,8,44,44,44,8,8,8,8,8,8,8,44,36,36,36,36,40,44,40,36,40,36,36,40,36,36,44,4,12,4,44,8,36,36,40,48,12,24,24,24,24,12,12,24,24,8,8,4,8,48,4,4,8,12,4,4,4,48,36,36,0,0,0,0
	dc.b	8,8,8,4,4,4,4,8,8,8,8,44,8,8,8,36,36,36,36,36,36,36,36,36,40,40,36,36,36,36,36,36,40,36,36,40,40,40,40,44,4,24,24,16,24,24,24,24,24,12,4,4,8,4,4,0,4,4,4,4,16,12,12,44,0,0,0,0
	dc.b	8,8,8,8,8,8,8,8,8,44,8,8,8,8,48,36,36,36,36,36,36,36,36,40,36,40,44,40,36,40,40,36,36,44,40,36,40,44,44,4,12,16,20,20,20,28,20,24,24,12,8,4,4,8,4,0,4,4,4,12,4,12,12,12,0,0,0,0
	dc.b	8,8,8,8,8,48,8,8,8,8,8,8,8,8,40,36,36,36,36,36,36,40,40,40,40,44,40,36,36,36,36,36,40,36,36,36,36,40,44,20,20,16,12,12,20,24,24,16,12,4,4,4,4,4,8,12,4,4,12,12,0,12,12,0,0,0,0,0
	dc.b	8,8,8,8,8,8,8,8,8,48,8,8,4,44,36,36,36,36,36,36,36,40,36,36,40,36,44,44,40,40,36,36,36,40,36,36,40,40,8,20,16,20,12,16,16,20,16,4,44,8,4,4,8,4,4,4,4,4,4,12,12,0,12,12,0,0,0,0
	dc.b	4,8,8,8,8,8,8,8,8,8,8,48,36,36,36,36,36,36,36,36,36,36,36,36,44,44,36,36,40,36,36,36,36,36,36,36,36,36,8,20,20,16,16,20,24,16,16,4,4,48,4,4,44,4,4,4,4,4,0,12,16,16,16,12,0,0,0,0
	dc.b	44,8,8,8,8,4,4,4,4,8,48,36,40,36,36,36,36,36,36,36,36,36,36,40,36,36,40,36,36,40,36,36,36,40,36,36,36,36,8,16,20,20,12,20,24,20,12,8,8,44,48,8,36,40,44,44,44,4,4,16,16,0,12,12,0,0,0,0
	dc.b	40,36,36,44,44,48,48,48,48,8,8,40,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,40,44,36,44,12,16,16,20,16,16,4,48,44,44,40,36,40,40,36,36,40,36,40,48,12,12,16,12,16,0,0,0,0
	dc.b	40,36,36,40,36,44,48,48,48,8,48,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,8,0,12,12,12,8,44,44,40,36,36,36,36,36,36,36,36,36,36,44,4,12,16,0,4,0,0,0,0
	dc.b	40,40,36,36,36,40,44,8,48,48,8,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,44,44,44,44,36,36,36,36,36,36,36,36,40,36,36,36,40,44,4,16,20,12,12,4,0,0,0,0
	dc.b	36,36,36,36,44,8,8,8,8,48,8,44,36,36,40,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,40,36,36,36,36,36,36,36,40,40,36,36,36,36,36,36,36,36,40,36,36,36,36,36,40,48,20,20,16,20,16,16,0,0,0,0
	dc.b	44,44,48,8,8,8,8,8,8,8,8,36,40,36,36,40,36,36,36,36,36,36,36,36,40,44,40,36,36,36,36,36,36,36,36,40,36,36,40,36,40,36,36,36,40,36,40,40,36,36,36,36,36,36,40,40,40,8,16,16,20,16,12,16,0,0,0,0
	dc.b	8,8,8,8,48,48,48,48,8,8,8,36,36,36,40,36,36,36,36,36,36,36,36,40,36,40,36,36,36,36,36,36,36,40,36,36,36,36,36,36,40,40,36,36,36,40,36,40,36,44,44,44,48,44,44,44,44,44,12,16,16,24,20,12,0,0,0,0
	dc.b	8,8,48,44,48,48,48,8,8,8,36,40,36,36,36,36,36,36,36,36,36,36,40,44,36,40,40,36,36,36,36,36,36,40,36,36,40,36,36,36,36,40,36,36,36,36,40,48,8,4,4,8,8,8,4,16,16,4,0,12,4,12,20,20,0,0,0,0
	dc.b	48,8,8,48,48,8,8,8,8,40,36,36,40,36,36,36,36,36,36,36,36,36,36,40,44,44,44,40,36,36,36,36,36,36,36,36,40,36,36,40,40,36,36,36,36,44,52,4,4,4,4,4,4,8,4,20,16,24,12,12,4,8,12,16,0,0,0,0
	dc.b	8,8,8,8,8,8,8,44,40,36,40,36,36,40,36,36,36,36,36,36,36,36,36,36,44,36,36,36,36,36,36,44,36,36,36,36,36,40,40,36,40,40,36,40,36,8,12,4,12,12,4,16,20,0,8,12,16,20,20,16,12,4,4,12,0,0,0,0
	dc.b	36,36,36,36,40,36,36,36,40,8,12,4,4,4,12,12,4,44,36,40,36,40,40,44,40,4,20,4,4,12,4,12,12,20,44,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,36,36,36,44,12,4,4,4,4,4,12,12,4,40,36,36,36,40,40,44,16,12,4,4,12,12,4,0,20,4,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,4,0,4,4,4,4,4,0,16,12,44,36,40,40,36,36,48,20,4,4,4,12,12,12,4,20,12,44,36,36,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,40,36,36,36,40,36,44,12,8,4,4,4,4,4,0,12,4,4,44,36,36,36,40,4,12,12,4,4,4,4,4,4,20,4,44,40,44,40,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,44,0,4,4,8,4,4,4,12,4,4,4,44,36,36,40,36,0,20,20,16,4,4,4,4,4,12,4,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,40,48,0,12,12,4,8,8,8,0,4,8,8,48,44,44,44,44,12,20,16,20,20,16,12,12,4,16,8,44,36,40,36,36,40,36,36,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,40,36,36,36,36,44,12,12,12,12,4,12,12,12,4,8,8,8,44,40,36,44,16,20,16,12,12,12,20,20,20,12,44,40,36,36,40,36,36,36,40,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,40,44,36,40,36,36,44,12,16,12,0,4,12,0,12,4,8,8,8,44,36,40,44,12,20,12,12,12,12,12,16,20,12,44,44,36,40,36,36,36,36,36,36,44,4,4,4,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,4,8,48,40,36,44,12,12,12,4,4,4,12,12,4,8,8,8,48,36,36,44,16,20,12,12,12,12,20,16,24,4,44,36,36,36,36,36,36,36,40,48,4,12,12,20,20,8,48,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,8,4,4,8,44,40,4,16,0,4,4,4,4,0,12,4,4,8,8,40,36,36,16,24,16,12,12,12,12,20,20,8,44,36,36,40,40,36,36,40,44,4,12,16,24,12,12,20,12,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,8,4,4,8,8,44,44,16,4,4,4,4,4,4,12,4,44,8,8,36,36,44,12,24,16,12,12,12,12,16,24,8,36,36,36,36,40,36,44,36,48,4,0,24,28,20,20,24,20,16,8,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,4,4,4,8,48,48,48,56,12,4,8,4,4,4,12,4,4,8,8,44,40,44,16,20,12,20,16,12,12,12,20,44,40,36,36,40,36,40,44,4,4,4,4,20,24,20,4,4,12,12,12,40,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,8,8,4,48,48,48,48,4,16,0,4,8,4,4,4,12,12,44,8,44,36,44,20,20,12,12,12,12,12,20,20,48,40,36,36,36,36,36,36,4,4,4,4,12,24,16,16,12,0,12,20,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,8,8,4,8,48,8,48,48,12,0,4,8,8,4,0,0,12,4,48,44,36,44,12,20,0,12,12,12,12,24,12,40,36,36,40,40,36,44,44,44,4,4,12,24,24,20,16,20,20,24,16,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,8,8,4,4,8,48,48,48,4,16,4,4,4,4,0,0,12,12,4,44,44,44,0,24,16,12,16,16,20,24,0,44,40,36,36,36,44,4,4,4,48,4,20,20,20,24,20,20,20,24,28,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,4,4,4,4,8,44,48,48,4,12,4,8,4,0,4,12,0,12,12,4,4,4,20,24,20,20,20,20,16,12,44,36,36,40,40,44,4,4,4,8,44,16,20,24,20,20,20,24,24,24,12,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	0,4,4,8,8,4,4,4,8,48,48,8,12,12,4,4,12,4,4,12,0,4,12,4,4,12,20,12,12,12,24,24,16,44,40,40,36,4,8,8,4,4,4,4,12,20,20,4,12,12,12,20,24,20,48,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	0,4,8,8,8,8,8,4,12,4,8,44,8,12,0,0,0,12,4,4,4,4,4,4,4,20,20,12,12,12,16,24,20,48,36,44,8,0,4,4,4,4,8,8,4,4,12,12,4,12,16,20,24,16,48,40,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,8,8,8,8,4,8,4,4,4,4,4,16,12,12,4,4,4,4,4,8,8,8,12,12,12,16,24,28,24,12,12,8,4,4,12,8,8,4,4,4,24,24,24,20,24,12,8,4,12,12,8,36,36,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	8,4,4,8,8,8,8,4,4,8,4,4,8,8,4,12,12,12,12,0,8,8,8,4,8,12,24,20,24,24,24,24,20,16,12,12,4,4,4,44,8,4,16,24,24,20,20,24,24,24,4,48,44,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,8,4,4,8,8,8,8,4,8,8,8,4,8,8,8,12,12,12,4,4,8,8,4,4,4,12,16,24,16,12,20,20,12,12,4,8,4,4,48,44,8,56,20,24,24,12,16,24,24,20,16,44,40,36,36,40,36,40,44,36,36,36,36,0,0,0,0
	dc.b	40,36,44,12,4,8,8,8,8,8,4,8,4,8,8,8,8,4,0,12,12,12,12,4,4,4,44,4,20,12,12,16,20,0,12,4,4,4,56,8,44,40,44,8,12,20,20,20,16,24,16,24,4,40,40,40,36,40,40,44,36,36,36,36,0,0,0,0
	dc.b	44,40,36,36,52,4,4,8,8,8,8,8,8,4,8,8,8,4,8,44,48,8,8,48,44,44,40,4,20,20,20,16,12,4,12,12,4,8,56,48,44,44,44,40,48,4,12,56,56,20,20,20,4,40,8,48,44,48,44,40,40,40,36,36,0,0,0,0
	dc.b	48,44,44,40,36,44,8,4,4,4,0,4,4,4,4,4,4,48,36,36,36,40,36,36,36,40,36,48,12,20,16,12,16,12,12,12,4,48,36,44,8,24,20,4,44,44,12,12,4,44,48,8,44,48,4,4,48,8,56,4,44,44,36,36,0,0,0,0
	dc.b	8,44,44,44,36,36,40,44,8,4,4,4,4,4,8,8,36,36,36,36,40,44,40,36,36,36,36,40,44,44,8,12,12,4,8,4,40,36,36,48,20,24,24,24,12,44,4,16,16,8,8,8,44,48,4,4,8,12,4,4,4,48,40,36,0,0,0,0
	dc.b	8,4,8,8,8,8,44,8,8,8,8,44,8,8,36,36,36,36,36,36,36,36,36,36,36,40,36,36,40,36,36,8,8,36,40,40,40,40,40,44,12,24,24,24,24,24,12,24,24,12,4,4,8,44,4,12,8,4,4,4,12,12,12,44,0,0,0,0
	dc.b	8,8,8,4,8,8,8,8,4,48,8,8,8,8,40,40,36,36,36,36,36,36,36,36,40,40,44,40,40,40,36,36,40,40,36,36,40,44,44,8,12,24,20,20,28,24,24,24,24,20,8,4,4,48,4,4,8,4,4,12,12,12,12,12,0,0,0,0
	dc.b	8,8,8,8,8,8,8,8,8,8,8,8,8,44,36,40,36,36,36,36,36,40,40,36,36,44,40,36,36,36,36,36,36,40,36,40,40,36,44,12,12,12,16,28,16,24,24,24,24,12,8,4,4,4,4,0,4,4,4,12,4,12,12,0,0,0,0,0
	dc.b	8,8,8,8,8,8,8,8,8,48,8,4,44,36,36,36,36,36,36,36,36,36,36,36,40,40,44,44,40,36,36,36,36,36,36,36,36,36,4,20,24,12,4,12,12,20,20,16,4,8,4,8,8,4,4,4,4,4,4,12,4,12,4,12,0,0,0,0
	dc.b	8,8,8,8,8,8,8,8,8,8,8,8,36,36,36,36,36,36,36,36,36,36,36,36,44,44,40,40,40,36,36,36,36,36,36,36,36,36,8,24,20,20,12,16,20,16,12,4,8,44,4,8,44,4,4,8,4,12,0,12,12,20,12,20,0,0,0,0
	dc.b	8,4,8,8,8,8,8,8,4,8,44,36,40,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,40,36,4,20,20,12,16,20,20,24,12,4,8,44,8,8,36,44,48,44,44,4,4,12,20,12,12,12,0,0,0,0
	dc.b	8,8,8,4,8,4,4,8,8,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,44,36,4,16,16,20,20,20,24,16,4,48,44,36,36,40,40,36,40,36,40,40,48,12,12,0,12,16,0,0,0,0
	dc.b	36,36,36,44,44,48,48,48,48,8,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,40,36,36,36,36,36,44,12,12,12,16,16,4,48,44,40,36,36,36,36,36,40,36,36,36,36,44,4,12,16,12,4,0,0,0,0
	dc.b	36,36,40,36,40,48,48,8,48,48,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,40,36,36,36,36,8,4,4,4,4,44,36,36,36,40,40,36,36,36,36,36,36,36,40,44,12,16,12,4,4,0,0,0,0
	dc.b	36,36,36,36,44,8,44,48,48,8,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,40,36,36,36,36,36,36,36,36,40,36,36,36,36,36,44,0,20,24,20,20,12,0,0,0,0
	dc.b	36,36,40,44,8,8,8,8,48,8,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,44,36,36,36,36,36,36,40,36,36,36,36,36,40,36,36,40,36,36,36,36,40,40,40,40,36,36,36,36,36,36,40,48,12,12,20,20,12,16,0,0,0,0
	dc.b	44,8,8,8,8,8,8,48,8,8,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,40,36,36,36,36,36,40,36,36,36,36,36,36,36,36,40,36,40,36,36,44,36,44,44,44,44,36,36,44,12,16,20,20,20,12,0,0,0,0
	dc.b	8,8,8,44,48,48,48,8,8,44,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,40,36,36,36,36,36,40,36,36,36,40,36,36,36,36,36,40,44,48,8,8,8,8,8,8,4,4,48,4,16,4,16,20,20,0,0,0,0
	dc.b	48,8,44,48,48,48,8,8,8,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,44,36,44,36,36,36,36,36,36,36,36,36,36,40,36,40,40,36,40,36,36,36,8,4,4,4,4,8,8,8,8,16,24,20,0,12,4,8,12,16,0,0,0,0
	dc.b	8,48,48,48,8,8,8,8,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,44,36,36,36,36,36,36,44,36,36,36,40,40,40,36,36,40,40,40,40,40,8,4,0,4,4,4,4,4,4,8,16,12,20,20,12,12,8,4,16,0,0,0,0
	dc.b	36,36,36,36,40,40,36,44,4,12,4,4,4,0,16,8,44,36,36,36,36,36,40,36,8,20,0,4,4,12,4,12,20,4,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,40,52,12,8,4,4,4,4,0,16,52,36,40,36,36,36,36,40,12,16,4,4,12,12,12,4,16,20,44,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,44,12,4,4,4,4,4,4,12,16,12,44,36,36,36,40,40,48,16,0,4,4,12,12,12,4,4,20,8,36,40,36,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,40,8,12,8,4,4,4,4,4,12,12,4,52,36,36,40,36,36,8,20,12,4,4,4,4,4,4,12,20,8,44,36,44,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,40,4,0,4,4,8,8,8,4,12,8,4,4,44,36,36,36,40,52,20,20,12,4,4,4,8,4,12,12,44,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,4,12,16,4,4,8,4,8,12,8,8,8,8,40,44,44,36,4,20,20,16,20,12,20,16,12,12,12,44,40,36,36,36,40,40,36,36,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,40,40,40,4,12,12,12,12,0,12,0,12,8,8,8,52,44,36,40,36,56,24,16,12,12,16,16,20,20,20,4,44,40,36,40,40,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,40,4,12,12,0,12,0,0,12,12,4,8,8,8,44,40,36,36,56,20,20,12,12,12,16,12,20,20,8,44,36,36,36,40,36,36,36,36,36,44,4,4,56,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,48,36,40,40,8,12,0,4,4,4,4,0,12,0,48,8,8,8,36,36,36,12,24,16,12,12,12,16,20,20,20,48,40,36,36,36,36,36,36,40,44,44,0,12,16,16,20,8,48,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,4,4,8,44,36,44,12,12,0,4,4,4,4,0,12,8,8,52,48,44,36,36,4,24,20,12,12,16,12,20,24,16,44,44,40,36,36,36,40,36,36,48,4,12,16,24,16,20,20,12,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,8,52,8,48,44,4,12,4,4,4,4,4,0,12,4,44,8,8,44,36,40,4,28,12,12,12,12,12,12,20,12,44,40,36,36,36,36,40,36,48,8,4,12,16,24,24,20,20,20,16,8,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,0,4,8,48,44,8,16,0,4,4,52,4,4,12,12,44,8,8,40,40,36,4,24,20,16,16,12,12,0,20,12,44,36,36,36,36,36,36,44,4,4,4,0,24,24,12,4,12,16,12,12,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	52,8,4,8,8,48,48,48,12,0,4,4,4,8,4,4,12,4,8,8,44,36,36,12,20,12,12,16,12,12,20,24,56,36,36,36,36,36,36,36,44,4,4,4,4,16,24,16,12,12,12,12,20,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,4,8,48,48,48,48,4,16,4,4,4,4,4,0,0,12,8,8,48,36,40,4,20,12,12,12,4,12,20,24,52,36,36,40,36,40,44,8,44,8,4,8,12,24,24,16,20,20,24,20,12,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	44,8,4,4,8,48,48,48,8,12,0,4,8,4,4,0,0,12,12,8,44,40,44,52,24,12,12,12,12,20,24,20,48,36,36,40,36,36,44,4,4,48,8,4,20,20,20,16,16,20,16,24,24,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,4,4,0,4,8,44,48,48,4,16,4,4,4,4,4,0,4,0,12,4,8,8,4,20,24,20,20,20,20,20,16,52,40,36,36,40,40,48,4,4,8,48,8,20,20,24,24,20,24,16,24,24,16,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,4,4,4,8,48,44,48,12,16,4,8,4,0,4,4,0,12,0,0,4,8,4,20,20,16,20,24,24,24,4,36,40,36,8,8,48,8,52,4,0,8,12,20,20,12,16,12,20,20,16,20,8,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,8,8,8,8,4,4,4,8,48,48,4,12,4,12,12,4,4,4,4,4,4,4,4,12,20,16,0,24,24,24,24,4,44,40,44,8,12,12,56,52,8,8,4,4,12,12,4,4,12,12,16,24,20,8,40,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	4,52,8,8,8,4,8,0,12,8,8,8,16,12,0,4,4,4,4,4,8,4,8,8,12,24,12,12,24,24,24,24,12,44,8,8,12,4,8,8,12,4,8,12,16,20,20,16,4,8,4,12,20,4,44,40,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	8,4,8,8,8,8,8,8,8,4,56,4,8,12,16,12,12,4,0,4,8,8,8,4,0,20,12,24,24,24,24,20,16,12,12,4,4,12,48,48,4,52,20,24,24,20,20,24,24,12,8,48,44,40,36,36,36,36,36,40,36,36,36,36,0,0,0,0
	dc.b	12,8,8,8,8,48,8,4,8,8,4,8,8,8,0,16,12,4,12,4,8,8,4,4,8,12,28,24,24,16,16,20,20,12,12,4,8,0,4,36,44,8,12,24,24,20,12,20,24,24,24,12,44,40,36,40,40,40,40,40,36,36,36,36,0,0,0,0
	dc.b	8,0,4,8,8,8,8,52,8,8,8,8,8,8,8,4,12,16,12,4,4,4,4,0,4,8,8,12,20,16,12,12,20,0,12,8,8,12,56,8,44,40,44,12,20,24,20,12,20,24,16,20,12,36,40,36,36,36,40,44,36,36,36,36,0,0,0,0
	dc.b	40,44,12,12,8,8,8,8,4,8,8,8,8,8,8,8,8,4,4,4,12,4,4,8,48,44,44,16,16,16,12,16,12,4,12,4,4,4,4,48,40,36,44,36,8,12,16,12,20,24,16,24,4,40,8,8,44,8,44,40,40,40,36,36,0,0,0,0
	dc.b	36,36,36,4,4,4,8,8,4,4,8,8,8,8,8,4,52,48,36,40,36,44,36,36,36,40,44,12,24,20,16,12,12,12,12,12,4,44,40,44,48,12,4,48,44,4,12,4,44,8,4,4,8,48,4,8,48,8,12,4,44,44,36,36,0,0,0,0
	dc.b	48,44,40,36,44,8,4,4,0,12,4,12,4,4,4,4,36,36,36,36,40,44,40,36,40,36,36,48,4,4,12,12,16,4,4,12,36,36,40,48,12,24,24,12,4,44,0,12,0,8,8,8,44,48,8,4,8,12,12,4,4,44,40,36,0,0,0,0
	dc.b	48,44,44,40,36,36,44,8,8,8,4,4,8,44,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,40,8,12,52,44,44,40,36,40,40,44,20,24,24,24,24,4,4,24,28,4,4,52,8,44,4,4,8,4,4,4,12,12,4,44,0,0,0,0
	dc.b	8,8,8,8,8,8,8,8,4,48,8,8,8,36,40,36,36,36,36,36,36,36,36,36,40,40,44,40,40,36,36,40,36,44,36,36,40,44,44,44,12,20,16,28,24,24,24,24,24,20,8,4,8,44,4,4,8,4,4,4,12,12,12,12,0,0,0,0
	dc.b	8,8,8,8,8,8,8,8,8,8,8,8,48,36,40,36,36,36,36,36,36,36,40,40,36,44,40,36,40,40,36,40,40,36,36,40,40,40,44,12,16,20,24,16,16,24,16,16,28,20,8,4,4,8,4,4,4,4,0,12,4,12,12,0,0,0,0,0
	dc.b	8,8,8,8,8,8,48,48,8,44,8,8,44,36,36,36,36,36,36,36,36,36,36,36,40,36,44,44,36,36,40,36,36,40,36,36,36,40,4,20,20,12,16,16,20,24,24,24,16,4,4,8,4,12,4,4,4,4,0,0,4,12,4,4,0,0,0,0
	dc.b	8,8,8,48,8,8,8,48,8,8,52,48,36,40,40,36,36,36,36,36,36,36,36,36,44,36,36,36,36,36,36,36,36,36,36,36,36,36,4,20,20,16,0,12,12,16,12,0,48,8,4,8,44,4,4,4,4,4,0,0,0,12,12,20,0,0,0,0
	dc.b	8,8,8,8,8,8,8,8,52,52,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,40,36,4,24,16,16,12,20,24,16,16,4,8,44,4,8,40,48,44,44,44,4,4,12,20,12,12,12,0,0,0,0
	dc.b	8,8,8,8,4,4,4,8,8,36,36,40,36,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,40,40,36,44,36,4,20,20,12,12,20,24,20,0,8,48,36,40,40,40,36,40,36,36,40,48,12,16,4,12,12,0,0,0,0
	dc.b	8,8,8,8,8,8,8,48,44,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,40,36,36,40,36,36,36,36,36,4,12,16,16,20,20,20,4,44,36,36,36,36,36,36,36,36,36,36,36,36,4,12,16,16,12,0,0,0,0
	dc.b	36,40,44,44,44,48,44,48,44,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,40,36,36,36,40,36,36,36,36,40,44,12,12,12,16,12,8,44,44,40,40,40,36,36,36,36,36,36,36,36,36,8,12,12,4,0,0,0,0,0
	dc.b	36,40,36,44,8,8,48,48,8,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,36,36,36,36,36,40,36,40,36,36,36,40,36,44,48,8,8,44,40,40,36,40,36,36,36,36,36,36,36,36,36,36,44,16,20,20,12,12,0,0,0,0
	dc.b	40,36,36,44,48,8,48,48,8,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,44,40,40,36,36,36,36,36,36,36,36,36,36,40,36,40,36,36,40,36,40,40,40,40,40,36,36,36,36,36,36,40,44,12,20,20,20,16,16,0,0,0,0
	dc.b	36,40,44,8,8,8,48,8,8,44,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,40,36,40,40,36,36,36,40,36,40,40,36,36,36,36,40,44,44,40,36,40,44,12,16,20,20,16,12,0,0,0,0
	dc.b	8,8,8,8,8,8,48,8,8,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,40,40,36,36,36,36,36,36,40,36,40,36,36,36,40,44,8,8,8,8,8,8,8,8,44,0,16,12,12,20,20,0,0,0,0
	dc.b	8,8,44,48,48,48,8,8,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,44,40,36,36,36,36,36,36,36,36,36,36,40,36,40,36,36,40,36,36,44,8,4,4,8,8,8,8,8,4,20,12,4,12,4,8,16,20,0,0,0,0
	dc.b	44,48,48,48,44,8,8,48,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,44,36,36,36,36,36,40,44,36,36,40,36,36,36,36,36,36,36,40,36,36,44,52,4,4,8,4,8,8,8,8,16,16,24,12,4,12,8,4,12,0,0,0,0
	dc.b	36,36,36,36,36,40,8,12,4,4,4,4,0,12,4,36,36,36,36,36,36,40,40,4,20,4,4,12,12,12,4,16,20,44,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,48,12,4,4,4,4,4,4,12,12,8,40,36,36,36,36,40,36,4,16,12,4,56,12,12,12,4,20,4,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,4,12,4,4,4,0,4,4,12,16,4,44,40,36,36,40,40,44,12,12,4,4,4,16,12,4,0,20,12,44,36,36,36,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,44,12,4,4,4,12,4,4,4,16,12,4,8,36,36,36,36,36,44,20,16,12,4,4,4,4,12,4,20,4,40,40,36,44,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,40,44,12,4,4,8,4,4,4,4,12,4,4,4,44,40,36,36,40,44,16,20,20,12,4,4,4,4,4,20,4,44,36,36,36,40,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,40,44,12,12,12,4,4,8,4,4,4,8,8,8,8,36,40,44,40,8,20,20,16,20,20,12,12,12,12,20,8,36,36,36,36,36,40,40,36,36,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,36,36,36,48,12,12,12,12,0,0,0,0,0,8,8,8,8,40,36,40,40,8,24,20,16,12,12,16,16,20,20,16,48,44,36,36,36,40,36,36,36,40,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,40,44,12,12,12,0,0,0,0,16,16,8,8,8,52,44,36,36,44,4,24,20,12,16,12,12,16,16,20,16,44,36,36,36,36,40,36,40,36,36,40,8,56,12,56,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	44,40,40,36,40,12,16,0,0,4,4,4,12,16,4,8,48,4,44,36,40,36,4,24,16,12,16,16,12,20,20,24,12,44,36,36,36,40,36,36,36,36,44,8,12,0,16,20,16,8,48,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,48,36,40,4,16,0,4,4,4,4,0,12,4,48,48,8,8,40,44,40,52,24,16,16,16,12,20,20,16,20,8,40,44,36,36,36,36,36,36,40,8,4,12,16,24,20,20,20,12,8,36,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,8,48,44,8,12,0,4,4,4,4,4,0,16,4,48,8,8,36,44,36,48,20,24,20,12,12,12,12,20,24,4,40,36,36,36,36,36,40,44,48,4,4,12,16,24,24,24,20,20,20,8,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,8,8,48,48,12,12,4,4,4,4,4,4,12,4,44,8,8,44,36,40,44,24,24,20,12,12,16,12,16,24,8,36,36,36,36,36,36,36,8,4,4,0,12,24,24,16,4,12,12,12,12,40,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,8,48,48,48,4,12,4,4,4,8,4,4,0,12,8,44,4,44,36,36,8,24,16,16,12,12,16,16,16,24,8,40,36,36,36,36,36,40,8,4,52,4,4,12,16,12,12,4,4,12,20,48,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,4,8,8,48,48,8,16,4,4,4,4,4,4,0,12,12,8,8,48,36,36,8,24,12,12,12,0,12,20,20,20,44,36,36,40,36,36,44,44,36,52,4,4,4,24,24,20,20,20,20,20,12,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,4,8,44,48,48,44,0,12,4,4,4,4,4,0,12,12,0,8,44,44,36,48,24,16,12,0,12,12,12,24,4,36,36,36,36,36,44,4,4,8,44,8,4,20,20,24,16,16,20,20,24,24,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,8,48,48,44,8,16,12,4,8,4,4,0,0,12,12,12,8,44,48,8,20,24,16,16,20,20,24,24,12,44,40,40,36,40,40,4,4,4,4,48,4,20,20,24,24,24,16,24,24,24,12,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,12,8,48,44,48,8,20,0,4,8,4,0,4,0,12,0,12,0,0,4,4,12,24,24,24,24,12,16,20,48,40,40,36,4,8,44,4,4,4,4,4,16,20,20,12,12,20,20,24,20,24,8,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,8,4,4,8,48,48,48,4,12,0,4,12,0,4,4,4,4,0,4,4,4,8,4,24,16,24,24,24,24,16,48,40,36,48,12,0,4,4,8,8,4,4,4,16,16,0,56,12,12,16,24,24,8,40,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,8,8,4,0,4,4,8,44,0,16,4,0,12,4,4,0,4,4,4,4,8,4,20,20,12,16,24,24,24,24,8,44,52,4,4,8,8,4,56,8,44,8,4,4,12,0,8,4,12,16,20,0,48,40,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,8,8,8,4,8,4,4,4,8,12,16,0,12,4,4,0,4,8,8,8,8,4,16,16,12,24,24,24,24,20,12,4,12,4,0,4,44,8,4,4,0,24,24,24,20,24,20,4,44,48,8,48,36,36,36,36,36,40,36,36,36,36,0,0,0,0
	dc.b	8,8,8,48,4,8,8,4,4,4,8,8,0,16,12,0,0,0,4,8,8,8,4,8,16,24,24,24,24,20,12,20,12,12,12,4,4,4,8,36,4,4,20,24,16,16,16,24,24,24,20,4,44,40,36,40,40,40,40,40,36,36,36,36,0,0,0,0
	dc.b	8,8,8,8,44,8,8,8,8,8,8,8,8,12,12,12,0,4,8,8,4,4,4,4,4,12,20,20,12,20,12,16,16,12,4,4,4,4,4,44,44,40,4,20,24,24,12,12,24,24,16,20,12,36,40,40,36,36,40,44,36,36,36,36,0,0,0,0
	dc.b	0,8,8,8,8,8,4,8,8,8,8,8,44,8,8,0,12,4,12,0,4,12,4,4,44,44,4,20,20,12,12,16,12,4,4,4,4,12,4,36,40,40,36,8,12,20,24,20,20,24,16,24,20,44,8,48,44,8,44,40,40,40,36,36,0,0,0,0
	dc.b	8,4,4,8,8,8,8,4,8,8,8,8,8,8,8,4,8,48,8,8,8,8,48,36,36,40,4,20,20,16,16,12,4,12,12,12,8,8,36,36,44,44,44,44,44,0,0,12,4,0,20,20,56,48,4,8,48,8,12,4,44,44,36,36,0,0,0,0
	dc.b	40,44,52,56,12,8,8,4,8,8,4,8,4,8,4,8,36,36,36,36,40,40,40,36,40,36,44,20,20,12,16,16,16,12,12,4,40,36,40,48,8,24,12,4,44,48,56,12,4,48,4,8,44,48,4,4,48,12,4,4,4,44,40,36,0,0,0,0
	dc.b	40,36,36,36,8,8,4,0,0,0,12,0,4,4,36,36,36,36,36,36,36,36,36,36,36,40,40,44,48,8,12,12,4,44,8,40,40,40,40,44,24,24,24,20,12,44,8,16,20,4,4,4,44,48,4,4,48,4,4,4,12,4,12,44,0,0,0,0
	dc.b	44,44,40,44,44,8,52,52,4,44,8,8,44,36,36,36,36,36,36,36,36,36,36,36,40,36,40,36,40,36,44,8,44,44,36,36,40,44,44,44,20,24,24,24,24,20,12,24,28,16,4,4,8,8,4,4,8,4,4,4,12,12,12,12,0,0,0,0
	dc.b	4,8,8,8,8,8,8,8,8,8,8,48,40,40,36,36,36,36,36,36,36,40,40,40,40,44,40,40,36,36,36,36,40,36,36,36,36,40,40,4,12,24,16,20,24,24,24,24,16,24,4,8,8,8,4,4,8,4,56,12,4,4,12,4,0,0,0,0
	dc.b	8,8,8,8,8,48,8,48,8,8,8,44,40,36,36,36,36,36,36,36,36,36,36,36,40,40,44,36,36,36,36,36,36,36,36,40,36,36,8,16,16,12,24,24,20,24,24,24,24,20,8,8,4,4,4,4,4,4,4,0,4,0,4,12,0,0,0,0
	dc.b	8,8,48,8,8,44,44,44,8,4,8,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,12,20,20,0,0,12,20,24,16,20,12,8,4,48,48,4,4,4,4,4,0,12,4,12,12,16,0,0,0,0
	dc.b	8,48,8,48,8,8,48,8,4,8,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,40,36,36,12,16,20,16,0,16,20,16,16,4,44,48,8,48,40,8,8,44,4,4,4,12,12,12,12,12,0,0,0,0
	dc.b	8,8,8,8,8,8,8,8,8,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,40,36,40,40,44,44,12,20,16,12,16,20,16,20,16,4,44,36,44,40,40,36,40,36,40,40,48,0,20,0,0,0,0,0,0,0
	dc.b	8,8,8,8,8,52,4,48,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,44,12,16,20,12,12,24,24,12,4,44,36,36,36,36,36,36,36,36,36,36,36,4,12,12,16,12,0,0,0,0
	dc.b	8,8,8,8,8,8,44,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,36,36,36,36,36,40,36,40,4,12,12,12,20,20,12,48,40,44,36,36,36,36,36,36,36,36,36,36,40,8,12,12,12,4,0,0,0,0
	dc.b	36,36,8,48,48,48,44,48,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,40,36,36,40,36,36,52,12,12,12,4,44,40,36,40,36,36,40,36,36,36,36,36,36,36,36,4,16,20,12,4,0,0,0,0
	dc.b	36,40,40,48,48,8,48,8,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,40,36,36,40,36,36,36,40,44,44,36,36,36,36,40,36,36,36,36,36,36,36,40,40,36,36,4,20,20,20,16,16,0,0,0,0
	dc.b	36,36,48,8,44,48,48,8,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,40,36,36,36,40,36,36,40,36,40,36,36,36,36,40,36,36,36,36,36,36,36,36,40,40,4,12,16,16,16,12,0,0,0,0
	dc.b	44,44,8,8,8,8,44,8,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,40,40,40,40,36,36,36,36,36,44,44,8,8,8,8,8,48,48,44,4,16,20,20,16,16,0,0,0,0
	dc.b	8,8,8,8,8,44,8,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,44,40,36,36,36,36,36,36,36,36,40,36,36,36,40,40,36,40,40,40,36,8,8,4,8,8,8,8,8,8,4,4,8,12,12,4,16,20,0,0,0,0
	dc.b	44,48,48,48,44,8,8,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,44,36,36,36,36,36,36,44,36,36,36,36,36,40,36,36,36,36,36,40,36,44,8,4,4,4,8,8,8,8,8,4,20,20,12,4,12,4,4,12,0,0,0,0
	dc.b	36,36,40,40,44,0,0,4,4,4,0,0,16,4,36,40,36,40,36,36,36,40,44,20,12,4,4,12,12,4,12,20,0,44,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,40,4,0,4,4,4,4,4,4,12,12,44,40,36,36,36,36,36,36,4,20,4,4,4,12,12,0,4,16,16,44,40,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,8,12,4,4,4,4,0,4,12,16,12,4,44,40,40,36,36,40,44,4,12,4,4,4,12,12,0,0,12,20,48,40,36,36,40,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,4,12,4,4,4,0,4,4,4,16,12,4,8,36,36,36,40,36,44,12,20,12,4,4,4,4,12,4,12,20,48,40,36,36,44,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,40,12,4,4,4,4,4,4,4,4,12,4,4,8,44,40,36,36,40,44,16,20,20,12,4,4,4,4,4,16,20,44,40,36,36,40,40,36,40,36,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,36,36,12,12,16,4,4,8,8,4,4,0,8,8,8,48,36,40,40,36,44,20,16,16,20,20,16,12,12,0,12,12,44,36,36,36,36,40,36,40,36,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,40,12,12,12,12,12,12,4,4,12,0,8,8,8,8,36,40,36,36,44,20,20,16,12,16,16,20,20,20,20,4,44,40,36,36,36,40,36,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,4,16,12,0,12,12,12,12,16,12,8,8,8,8,44,36,36,40,8,24,16,16,12,16,12,12,16,20,24,4,40,44,36,36,36,36,36,40,36,40,44,8,12,12,0,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,40,36,4,16,12,0,0,4,0,0,12,16,4,48,8,8,44,40,36,36,4,24,20,16,16,16,16,16,20,20,20,8,36,40,36,36,36,36,36,36,36,8,4,12,12,12,20,16,16,48,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	44,40,36,8,16,0,4,4,4,4,4,0,16,4,48,8,4,48,40,36,44,44,24,16,16,12,16,16,20,16,24,20,48,44,44,36,36,36,36,36,36,36,4,4,12,16,24,20,20,20,12,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,48,44,44,16,12,4,4,4,4,4,4,12,12,8,48,4,48,44,36,44,44,16,24,16,16,12,12,16,20,24,0,36,36,36,40,36,36,36,40,44,8,4,12,0,24,24,24,24,20,20,20,8,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,8,44,4,16,12,4,4,4,4,4,0,12,4,48,48,8,44,40,36,36,4,24,24,12,12,12,12,12,20,20,44,44,36,36,40,36,36,44,4,4,4,4,16,24,28,16,12,12,16,12,12,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,48,8,8,16,0,4,4,8,4,4,4,12,12,8,8,48,44,36,40,44,20,24,20,20,16,16,12,12,20,16,36,36,36,36,36,36,40,40,4,4,4,4,12,16,16,0,4,4,4,12,20,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	48,48,8,48,44,12,16,0,4,4,8,8,4,0,16,4,48,8,44,40,40,48,20,20,12,12,12,16,20,20,24,12,36,40,36,36,40,44,44,44,48,4,4,4,4,20,28,20,20,20,20,20,12,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,48,8,44,8,4,16,0,4,4,8,4,4,0,0,16,4,8,44,36,44,44,20,20,12,12,4,4,12,24,28,48,44,36,40,36,40,44,4,4,44,44,4,4,16,20,16,20,20,20,20,24,28,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,8,48,44,48,48,12,12,4,4,4,4,4,12,0,0,12,4,48,44,44,48,20,16,12,12,16,20,16,20,20,44,36,36,36,40,40,44,4,4,4,8,8,4,28,16,24,24,20,16,16,16,24,16,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,8,44,8,48,8,16,0,4,4,8,4,12,4,0,12,12,0,4,4,4,4,20,24,24,24,24,24,12,24,4,40,36,36,36,8,44,8,4,4,4,4,4,20,16,16,20,20,20,20,24,16,24,8,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,0,4,8,48,44,44,4,12,0,4,8,0,4,12,4,12,4,12,0,4,4,4,8,4,20,28,16,24,20,20,12,44,40,36,8,12,4,4,8,8,8,56,8,4,20,20,4,12,16,12,16,24,24,0,40,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,4,12,8,8,8,48,4,16,0,4,0,4,4,0,4,12,4,4,4,4,8,4,20,20,20,24,24,24,24,0,44,44,8,4,4,8,4,4,56,48,48,48,44,12,12,4,8,4,12,16,20,12,8,36,40,40,40,36,36,36,36,36,0,0,0,0
	dc.b	8,8,8,4,0,12,8,8,8,0,16,0,0,0,4,4,4,4,8,4,4,8,8,12,24,12,12,20,24,28,24,12,4,4,4,4,12,8,48,4,56,8,44,12,20,16,20,20,12,44,48,8,56,48,40,36,36,36,40,36,36,36,36,36,0,0,0,0
	dc.b	48,8,8,8,8,4,4,4,4,4,12,16,12,12,4,4,4,4,8,8,8,8,8,12,24,16,16,20,16,24,16,16,12,0,0,4,12,4,36,48,8,8,16,24,24,24,20,24,24,28,4,48,44,40,36,40,40,40,40,40,36,36,36,36,0,0,0,0
	dc.b	8,48,8,8,8,4,8,8,4,8,8,4,16,12,0,0,4,4,8,4,8,4,4,4,24,28,24,24,12,16,12,20,12,12,4,4,4,4,8,36,44,36,12,24,20,16,12,16,16,24,24,20,56,40,40,36,36,36,40,44,36,36,36,36,0,0,0,0
	dc.b	8,48,48,8,8,8,8,8,8,8,8,8,8,12,12,12,12,4,4,4,4,4,4,4,8,4,16,12,20,16,12,16,0,12,4,4,4,56,8,36,40,36,48,56,20,24,20,12,20,16,20,20,20,44,8,48,44,48,44,36,40,40,36,36,0,0,0,0
	dc.b	8,8,8,8,8,4,8,4,8,8,8,8,8,8,4,4,12,0,4,12,4,4,8,40,40,44,12,20,12,16,16,12,0,12,12,4,48,4,44,40,36,36,36,44,4,12,20,20,16,24,24,20,20,8,4,8,48,8,4,4,44,44,40,36,0,0,0,0
	dc.b	0,4,8,8,8,8,4,8,8,8,8,8,8,8,4,48,40,44,44,44,44,40,36,36,40,44,16,20,16,16,12,12,12,12,12,4,36,36,36,36,48,4,4,44,40,4,12,4,4,8,4,56,8,8,8,8,48,12,4,4,4,44,40,36,0,0,0,0
	dc.b	44,8,4,4,4,4,4,4,4,4,4,4,4,4,36,36,36,36,36,36,36,36,36,36,36,40,4,16,12,12,16,12,4,4,4,40,36,40,40,44,16,24,24,12,8,44,12,12,12,4,4,8,44,8,4,8,48,4,4,4,4,4,4,44,0,0,0,0
	dc.b	36,36,40,8,4,4,0,12,0,12,4,8,44,36,40,40,36,36,36,36,36,36,36,36,40,36,40,44,36,8,12,4,44,36,40,36,40,44,44,44,24,24,24,28,20,4,8,20,20,12,8,4,8,8,4,4,8,4,4,4,12,12,12,12,0,0,0,0
	dc.b	44,36,44,8,8,8,8,8,8,8,48,40,36,40,36,36,36,36,36,36,36,36,40,40,36,36,36,40,40,40,36,36,36,36,36,36,40,40,40,44,20,24,24,20,24,24,20,24,24,24,4,8,4,8,4,4,8,4,4,12,4,8,12,12,0,0,0,0
	dc.b	4,4,8,8,8,44,48,48,8,8,48,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,40,36,36,36,36,36,36,36,40,36,36,36,48,0,12,20,24,24,16,24,16,24,16,24,4,44,4,4,4,4,4,4,4,0,4,12,4,12,0,0,0,0
	dc.b	8,8,8,8,44,8,48,44,8,8,44,40,36,36,40,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,40,36,40,36,36,40,40,4,20,16,12,20,20,28,24,24,20,24,16,4,44,8,4,8,4,4,4,0,4,4,4,4,12,0,0,0,0
	dc.b	8,48,8,8,8,40,8,8,8,48,36,40,36,36,36,40,36,36,36,36,36,36,36,40,36,36,36,40,36,36,40,36,36,36,40,36,36,36,16,20,20,4,4,12,12,16,20,20,4,8,8,44,36,8,8,44,4,4,4,12,12,12,12,16,0,0,0,0
	dc.b	8,8,8,8,8,44,8,8,8,40,40,36,36,36,40,36,36,36,36,36,40,36,36,36,40,36,36,36,36,36,36,36,40,36,40,36,44,44,16,24,20,20,4,12,20,16,12,4,44,44,48,40,40,36,36,36,40,36,8,4,16,12,4,0,0,0,0,0
	dc.b	8,8,8,8,8,8,8,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,44,16,20,16,12,16,20,20,20,12,48,36,36,36,36,36,36,36,36,36,36,40,8,12,12,12,12,0,0,0,0
	dc.b	8,8,8,4,4,4,44,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,36,36,36,36,36,36,36,44,12,16,20,20,20,24,24,12,48,44,40,36,36,36,36,36,36,36,36,36,36,8,12,12,12,12,0,0,0,0
	dc.b	8,8,8,8,48,44,8,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,8,12,12,16,12,16,4,44,40,36,36,36,36,36,40,36,36,36,36,40,36,44,12,12,4,4,0,0,0,0
	dc.b	36,8,48,48,48,48,8,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,40,36,36,8,4,4,4,8,36,36,36,40,36,36,36,36,36,36,36,36,40,40,44,12,20,20,16,16,0,0,0,0
	dc.b	36,40,8,48,8,48,8,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,40,40,36,36,36,36,36,36,36,40,40,36,36,36,36,40,40,36,36,40,40,36,8,16,12,16,16,12,0,0,0,0
	dc.b	44,8,8,48,44,48,8,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,40,36,36,40,36,40,44,8,44,48,8,8,44,44,40,4,12,16,20,12,16,0,0,0,0
	dc.b	48,8,8,8,8,48,48,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,44,40,36,36,36,36,36,36,36,36,40,40,36,36,36,40,40,36,36,36,36,44,8,8,8,8,8,8,8,8,8,8,4,12,16,12,20,20,0,0,0,0
	dc.b	8,8,48,48,44,8,48,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,44,36,36,36,36,36,36,44,40,36,36,36,36,36,36,36,36,36,36,36,40,40,8,4,4,4,8,8,8,8,8,8,12,12,8,4,12,8,4,16,0,0,0,0
	dc.b	36,36,36,4,12,0,4,4,4,12,12,12,44,36,36,36,40,36,36,36,36,48,20,16,4,4,12,12,12,0,12,20,48,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,36,8,12,4,4,4,4,4,4,12,12,12,44,40,40,36,36,36,36,40,4,20,4,4,0,12,12,12,12,12,24,4,36,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,44,12,4,4,4,12,4,4,4,0,16,12,4,44,36,36,36,36,36,36,4,20,4,4,4,4,12,4,0,4,20,56,40,36,36,36,40,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,8,12,4,4,4,4,4,4,4,12,20,12,4,8,36,36,40,36,40,44,0,16,12,12,4,4,12,4,12,12,20,4,44,36,36,36,44,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,8,0,4,4,4,4,4,4,4,0,12,4,4,8,44,36,36,36,36,36,12,24,12,12,4,4,4,4,4,0,24,4,44,44,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,4,12,12,12,4,4,4,8,8,12,4,8,8,8,44,40,36,36,40,44,0,20,16,20,16,16,12,12,0,12,20,48,36,36,36,36,40,40,40,40,36,36,36,40,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,4,12,12,12,12,0,4,4,0,12,0,8,8,8,8,36,36,36,36,44,20,24,20,12,12,20,20,20,20,16,16,48,36,36,36,36,36,40,36,40,36,40,40,40,8,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,8,12,16,12,12,12,12,12,12,12,0,8,8,8,8,44,36,36,36,44,20,20,20,16,12,12,12,16,16,20,20,48,36,44,36,36,36,36,36,36,36,44,44,4,12,12,4,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,48,16,12,0,0,0,12,0,0,16,12,8,8,48,4,44,36,36,36,44,24,20,12,16,20,16,20,12,16,20,16,44,36,40,36,40,36,36,36,36,44,4,4,12,0,12,16,20,16,48,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,44,16,12,12,4,4,4,4,12,12,12,8,8,48,8,8,40,36,36,44,20,24,16,16,12,20,20,24,16,24,4,36,40,44,44,36,36,40,36,36,48,4,4,12,16,24,24,24,20,12,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	44,40,0,16,12,4,4,4,4,4,0,16,56,48,48,8,44,40,36,36,36,12,24,24,20,20,20,16,20,24,16,44,36,36,36,36,36,36,40,36,48,4,12,12,12,24,24,24,20,20,20,16,8,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,48,4,20,4,4,4,8,4,4,4,12,12,8,48,8,4,44,40,36,40,44,24,20,20,16,12,12,12,12,24,8,36,36,36,36,36,36,36,48,4,4,12,4,16,24,24,20,12,12,20,12,12,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	48,8,8,12,12,4,4,4,8,4,4,4,16,4,48,8,8,44,36,36,44,8,24,24,24,16,16,12,12,16,24,4,36,36,36,36,36,36,36,48,4,4,4,4,12,20,16,4,4,4,4,12,20,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	48,48,44,12,16,4,4,4,8,4,4,4,12,16,8,8,8,48,36,40,36,12,24,16,16,20,16,12,20,20,24,4,36,36,36,36,36,44,44,40,4,4,4,4,4,12,24,20,20,20,20,20,12,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	48,48,48,8,20,0,4,4,4,8,4,4,0,16,0,8,8,44,44,36,44,12,16,12,12,12,16,12,24,24,16,44,36,36,36,36,36,8,4,4,44,8,4,4,20,24,16,20,16,16,20,24,20,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	48,48,48,48,0,16,4,4,4,8,4,0,0,0,12,12,8,48,36,36,44,12,24,12,56,24,24,24,24,24,4,44,36,36,36,36,40,4,4,4,8,44,4,4,24,16,24,16,20,20,16,24,24,12,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	48,48,8,44,8,20,12,4,4,8,8,0,12,12,4,12,0,4,48,8,4,12,24,16,20,24,24,24,16,20,12,44,36,36,36,36,48,44,4,4,4,4,4,4,20,16,24,24,24,16,24,24,24,24,4,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,44,48,8,48,8,20,12,4,8,4,0,0,4,0,4,0,12,4,12,4,8,12,12,12,4,20,16,20,12,20,8,36,36,36,4,4,4,4,8,4,8,4,8,12,20,20,4,16,16,12,20,16,24,0,40,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,8,44,44,48,4,20,0,4,4,12,4,4,4,12,0,4,4,4,4,4,8,8,4,28,24,16,24,24,24,44,36,44,8,4,4,4,4,4,4,44,48,44,8,16,12,12,8,12,16,12,20,24,4,36,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,4,8,44,44,4,16,0,0,0,12,4,4,0,4,4,4,4,4,8,4,20,24,20,24,24,24,24,24,4,8,4,4,4,4,44,8,4,4,8,44,8,4,0,12,12,4,44,8,56,12,8,44,36,36,36,40,36,36,36,36,36,0,0,0,0
	dc.b	8,8,4,12,4,4,4,8,0,12,12,0,4,4,4,4,4,4,8,8,8,8,12,24,20,20,20,20,24,24,12,16,0,4,4,4,4,48,44,8,4,48,4,24,24,24,24,24,24,0,8,44,44,40,40,36,40,40,40,40,36,36,36,36,0,0,0,0
	dc.b	8,8,8,8,8,4,4,4,8,0,12,12,12,0,12,0,4,8,8,8,8,4,4,20,20,24,20,20,20,16,16,20,12,12,4,4,56,4,44,36,44,36,16,24,24,16,12,20,24,24,24,12,4,40,36,40,36,36,40,44,36,36,36,36,0,0,0,0
	dc.b	44,8,8,8,4,8,8,8,8,8,4,12,12,12,4,0,4,8,4,4,4,4,4,12,20,28,20,12,12,16,16,16,0,0,4,4,4,4,48,36,36,36,4,20,16,24,16,12,20,24,16,20,20,48,8,48,44,8,44,36,40,40,36,36,0,0,0,0
	dc.b	8,48,8,4,8,8,8,8,8,8,8,8,0,12,16,12,0,4,4,4,4,4,8,44,44,4,16,16,16,16,16,12,12,12,4,4,4,8,44,36,40,40,36,8,16,20,24,20,16,24,16,20,24,4,4,8,48,8,4,4,44,44,40,36,0,0,0,0
	dc.b	8,8,8,8,8,4,8,8,8,8,8,8,8,8,4,8,4,4,4,4,8,40,36,36,44,4,20,20,16,16,12,0,12,0,12,8,40,40,36,36,36,44,44,36,48,56,12,12,4,12,20,20,12,8,8,8,44,0,4,4,4,44,40,36,0,0,0,0
	dc.b	8,8,8,8,8,8,8,4,8,8,8,8,4,8,40,36,36,36,36,40,40,36,36,36,40,8,20,20,20,16,16,12,0,12,4,40,36,40,40,36,4,20,16,4,44,48,12,56,0,8,8,8,44,8,4,8,8,4,4,4,4,4,4,44,0,0,0,0
	dc.b	4,12,4,4,4,4,4,8,4,4,4,4,52,36,36,36,36,36,36,36,36,40,36,36,36,44,4,4,4,12,16,12,8,48,36,40,40,44,44,44,20,24,24,16,0,8,4,16,20,0,4,4,8,8,4,8,8,4,4,4,12,12,12,12,0,0,0,0
	dc.b	36,36,8,4,4,0,12,0,56,8,48,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,40,8,8,44,36,36,36,36,36,40,36,8,24,24,24,24,24,20,4,20,24,24,4,8,8,8,4,4,8,8,4,4,0,4,12,4,0,0,0,0
	dc.b	44,8,8,8,8,44,44,8,8,44,36,40,36,36,40,36,40,36,36,36,36,36,36,40,36,36,40,36,36,36,36,36,36,40,36,36,36,36,44,8,20,24,24,20,24,24,24,24,20,24,4,8,4,4,8,4,4,4,4,4,4,4,0,0,0,0,0,0
	dc.b	8,8,8,8,8,48,48,8,8,44,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,40,40,40,36,36,36,36,36,36,36,36,8,16,16,20,24,24,20,16,24,16,24,24,4,44,8,4,8,4,4,4,0,0,4,4,4,0,0,0,0,0
	dc.b	8,8,48,44,8,44,8,8,8,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,40,36,16,16,20,4,12,20,24,24,24,24,20,0,8,44,44,8,8,44,4,4,4,0,4,12,12,16,0,0,0,0
	dc.b	8,8,8,48,8,48,8,8,40,36,40,36,36,36,36,36,36,40,36,36,36,36,40,36,36,36,36,36,36,36,40,36,36,40,40,36,44,44,20,20,20,4,4,4,12,20,20,4,48,44,44,40,40,40,36,36,40,36,48,4,12,12,12,0,0,0,0,0
	dc.b	8,8,8,8,48,8,8,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,8,20,16,16,20,12,20,24,16,12,8,36,44,36,36,36,36,36,36,36,40,36,4,12,0,12,12,0,0,0,0
	dc.b	8,8,8,8,8,8,44,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,36,36,40,36,36,36,36,8,12,20,16,12,16,20,20,16,12,44,36,40,36,36,36,36,36,36,40,36,36,44,12,12,16,12,0,0,0,0
	dc.b	8,8,8,4,8,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,40,36,36,36,44,12,16,20,16,24,24,20,12,44,40,36,36,40,40,36,36,36,36,36,36,36,44,4,4,0,8,0,0,0,0
	dc.b	8,8,8,48,48,44,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,8,12,12,12,16,4,44,36,36,36,36,36,36,36,36,36,36,36,36,40,36,8,16,20,12,4,0,0,0,0
	dc.b	44,8,48,48,48,8,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,40,40,36,36,36,44,8,8,48,44,36,40,36,36,36,40,36,36,36,40,36,36,36,36,44,16,16,16,20,16,0,0,0,0
	dc.b	44,48,48,44,44,48,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,40,36,36,40,40,36,36,36,36,40,36,40,36,36,36,36,44,44,48,48,8,48,44,44,44,8,16,12,20,16,16,0,0,0,0
	dc.b	8,48,8,44,44,8,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,44,40,36,36,36,36,40,36,36,36,36,36,36,40,36,40,36,40,36,40,40,44,8,8,8,8,8,8,8,8,48,44,8,12,12,16,20,20,0,0,0,0
	dc.b	8,8,8,8,44,8,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,44,36,36,36,36,36,36,44,36,36,36,36,36,36,40,36,36,36,36,36,36,36,44,4,4,8,8,8,8,8,8,8,8,8,8,0,12,4,4,16,0,0,0,0
	dc.b	36,8,12,4,4,4,4,4,0,16,0,44,36,40,36,36,36,36,40,44,44,16,12,4,0,12,12,0,12,0,20,0,40,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	44,12,4,4,4,4,4,4,4,12,12,4,44,36,36,36,36,36,36,40,8,16,0,4,4,12,12,12,0,0,16,20,44,40,36,36,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,12,4,4,4,4,0,4,4,12,20,0,8,40,36,36,36,40,36,36,4,16,4,4,4,12,12,12,4,4,12,20,48,40,36,36,36,36,40,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	16,4,4,4,4,12,12,4,4,16,20,0,4,44,36,40,40,36,40,36,4,16,16,12,12,4,4,12,0,12,12,16,48,36,40,40,36,44,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	16,4,4,4,4,4,4,4,4,16,4,4,4,8,36,36,36,36,36,44,4,24,20,12,4,4,4,4,4,4,20,20,44,36,44,40,36,36,36,40,36,36,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,12,4,0,4,4,8,4,4,12,8,8,8,8,44,40,36,36,40,36,4,20,20,20,20,20,16,12,12,0,16,12,44,36,36,36,36,36,40,36,40,36,36,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,16,12,16,0,4,4,4,4,12,4,8,8,8,8,36,40,36,36,36,12,24,20,12,16,20,16,20,24,16,20,4,44,40,36,40,36,36,40,40,40,36,40,40,44,8,8,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	16,12,12,0,0,12,12,12,12,16,8,8,8,8,8,36,36,36,40,44,16,24,20,20,12,12,16,16,16,20,20,4,40,36,44,36,36,36,40,36,36,36,44,48,12,12,12,4,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,16,12,0,4,0,0,0,0,20,4,8,8,8,8,44,36,36,36,44,16,16,16,20,20,16,16,16,16,16,24,4,36,36,36,36,36,36,36,36,36,48,4,4,12,4,12,20,16,12,44,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	16,12,0,0,4,4,4,0,0,16,12,48,8,8,8,44,36,36,36,44,20,24,16,16,20,20,20,20,12,24,20,48,40,36,44,44,36,36,36,36,36,4,4,12,12,16,28,24,16,24,12,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,16,0,4,4,4,4,4,4,0,20,4,8,48,8,8,36,36,40,44,12,24,24,20,20,16,16,28,20,24,4,36,44,36,40,36,36,40,36,44,8,4,12,12,12,28,24,24,24,20,20,20,8,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,12,12,4,4,4,8,4,4,12,16,0,48,48,8,8,36,36,40,36,44,16,24,16,20,20,20,16,16,28,4,44,40,36,40,40,40,36,40,8,4,4,4,4,12,20,28,20,16,16,16,12,12,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	48,12,12,12,4,4,8,4,4,4,0,16,8,48,8,8,44,36,36,40,44,4,24,20,20,20,12,12,16,20,20,44,36,36,36,40,40,36,40,8,4,4,4,4,16,20,20,4,4,8,4,12,20,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	48,12,16,4,4,4,4,8,4,4,12,16,4,8,8,8,44,36,40,40,8,28,28,24,24,24,20,16,16,24,20,44,36,36,36,36,36,44,44,44,4,4,4,4,4,16,24,20,12,16,12,16,12,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	48,8,20,12,4,4,8,4,4,4,4,12,16,4,44,8,44,40,44,36,4,24,16,16,20,24,24,28,24,24,0,44,36,36,36,36,44,4,4,44,44,52,4,4,20,24,16,20,20,20,20,24,24,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	48,44,4,20,0,4,4,8,4,4,0,0,12,12,4,8,48,44,36,36,4,28,12,12,16,24,24,24,24,20,44,40,36,36,36,36,44,4,4,4,8,44,4,4,24,16,20,20,20,12,16,24,24,12,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	48,44,8,16,12,0,8,8,4,8,0,0,0,12,16,4,8,36,44,8,0,24,16,16,24,24,24,24,24,16,8,36,36,36,36,36,44,8,4,4,4,4,4,4,24,20,24,24,24,16,24,24,24,24,4,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	48,48,48,8,20,0,4,4,8,8,4,12,4,0,0,12,0,0,4,4,4,12,20,20,20,12,28,16,12,20,12,40,36,36,8,56,4,8,4,8,4,4,4,4,20,20,20,4,20,20,16,16,16,20,12,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	48,44,44,44,12,16,4,4,4,4,4,4,4,0,0,0,0,0,4,4,4,4,4,4,4,12,24,16,24,16,16,44,36,44,4,4,4,4,4,4,8,44,8,44,4,20,16,56,4,20,16,16,24,24,4,40,40,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,8,48,44,44,4,20,0,4,4,12,4,4,4,4,4,4,4,4,4,4,8,4,16,24,28,24,16,24,24,12,44,8,4,4,4,8,8,4,4,8,44,36,44,48,4,4,4,8,44,4,16,12,12,48,36,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,8,8,8,4,12,0,12,0,0,4,4,12,4,4,4,8,4,8,8,12,24,20,24,20,24,24,24,20,4,4,0,4,0,4,36,8,4,8,44,8,16,20,16,28,20,16,4,44,44,44,40,36,36,36,40,40,44,36,36,36,36,0,0,0,0
	dc.b	8,8,4,0,4,4,8,12,16,12,0,4,12,4,4,4,8,8,8,8,8,4,28,16,20,12,12,16,24,16,16,16,12,4,4,4,4,8,36,36,44,40,20,24,24,24,12,24,24,24,20,4,48,40,40,36,36,36,40,44,36,36,36,36,0,0,0,0
	dc.b	8,8,4,8,4,4,8,8,12,12,12,0,0,4,4,8,8,8,8,8,4,4,12,24,24,24,28,20,12,12,20,16,0,4,4,4,4,4,44,36,40,40,12,24,16,16,12,0,20,24,24,20,16,48,8,48,44,48,44,36,40,40,36,36,0,0,0,0
	dc.b	8,8,8,8,8,8,8,8,8,4,12,16,12,12,0,8,4,4,4,4,4,4,8,12,16,20,12,4,12,12,16,12,12,0,4,8,4,8,44,40,36,40,48,12,24,24,24,16,16,20,16,16,24,4,4,48,48,4,4,4,44,44,36,36,0,0,0,0
	dc.b	48,8,8,8,8,8,8,8,8,48,8,4,12,12,12,12,4,4,12,4,8,44,40,44,48,12,16,16,16,16,12,0,12,0,4,48,36,40,36,36,40,40,36,44,8,16,20,16,16,24,24,20,20,12,8,8,44,4,4,4,8,44,40,36,0,0,0,0
	dc.b	8,44,8,4,8,8,8,4,8,8,8,4,4,8,48,8,4,8,48,44,40,36,36,40,48,20,16,20,16,16,0,0,12,12,12,40,40,40,40,40,48,4,8,44,44,8,4,12,4,4,12,4,4,8,8,8,8,4,4,4,8,4,12,44,0,0,0,0
	dc.b	8,8,8,4,8,8,4,8,8,8,4,8,8,36,36,36,36,36,36,40,36,40,36,36,44,12,20,20,12,16,16,0,4,8,36,36,36,44,44,44,12,24,24,12,8,44,56,12,12,0,8,4,44,8,4,8,8,4,4,4,12,12,12,12,0,0,0,0
	dc.b	4,4,4,4,4,4,4,4,4,4,8,36,36,36,36,40,36,40,36,36,36,36,36,36,40,44,8,8,8,12,12,48,36,36,36,36,36,40,36,48,24,16,24,20,16,12,8,12,20,16,8,8,8,8,4,4,8,4,4,4,12,4,0,4,0,0,0,0
	dc.b	8,4,4,0,4,12,4,4,8,40,40,36,40,36,36,36,36,36,36,36,36,36,36,36,40,40,36,36,36,44,44,36,36,40,36,36,40,36,44,8,24,24,24,28,24,24,20,20,24,24,4,8,4,8,8,4,4,4,4,0,8,4,12,4,0,0,0,0
	dc.b	8,8,8,8,48,48,44,8,44,40,36,36,36,40,36,36,36,36,36,40,36,36,36,36,40,36,36,36,36,40,36,40,36,36,36,36,36,40,48,4,20,24,20,20,20,16,24,24,16,24,4,44,8,4,4,8,4,4,4,0,4,4,4,4,0,0,0,0
	dc.b	8,8,44,8,8,44,8,8,36,36,36,36,36,36,36,36,36,36,40,36,36,40,36,36,36,36,36,40,36,36,40,36,36,36,40,40,36,40,12,16,12,12,24,24,24,24,24,20,24,24,4,44,48,8,8,44,4,4,4,0,4,0,12,16,0,0,0,0
	dc.b	48,48,48,48,8,48,8,48,36,36,36,36,40,36,40,36,40,40,40,36,36,40,36,36,36,36,36,36,36,36,36,40,36,36,40,36,44,44,20,20,16,4,4,12,16,24,24,20,12,8,48,40,40,36,36,40,36,36,4,4,12,12,0,0,0,0,0,0
	dc.b	8,8,48,48,44,8,8,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,8,20,20,20,4,4,12,16,16,16,4,44,40,36,36,36,36,36,36,36,36,36,8,16,12,4,12,0,0,0,0
	dc.b	8,8,44,8,8,8,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,36,36,36,36,36,36,36,8,20,20,12,16,20,20,16,16,16,48,40,36,40,36,36,36,36,36,36,36,36,48,4,12,16,12,0,0,0,0
	dc.b	8,8,8,8,8,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,40,36,36,36,36,8,16,20,16,16,20,16,28,20,4,44,40,36,36,36,36,36,36,36,36,36,36,44,4,12,12,8,0,0,0,0
	dc.b	8,8,8,8,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,44,0,16,12,20,24,24,16,8,36,40,44,36,40,36,36,36,36,36,36,40,40,44,4,12,12,4,0,0,0,0
	dc.b	8,48,48,48,44,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,8,4,12,12,4,8,44,36,36,36,36,36,36,40,36,36,36,36,36,40,40,4,20,20,20,16,0,0,0,0
	dc.b	48,48,44,44,48,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,40,36,36,36,36,36,44,44,44,44,36,36,36,40,36,40,44,48,48,48,48,48,44,44,44,48,12,12,12,16,16,0,0,0,0
	dc.b	48,48,48,44,44,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,44,40,36,36,36,36,36,36,36,36,36,40,36,40,40,36,40,36,40,40,40,44,8,8,8,8,8,8,8,8,8,48,8,12,12,20,20,20,0,0,0,0
	dc.b	48,48,48,48,48,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,44,36,36,36,36,36,36,44,36,36,36,36,36,36,40,40,36,40,36,40,36,36,48,8,8,8,8,8,8,8,48,8,8,8,8,12,12,0,0,20,0,0,0,0
	dc.b	12,12,4,4,4,4,4,12,16,4,40,36,36,36,40,40,36,36,36,44,16,16,4,4,4,12,0,0,12,20,20,48,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,4,4,4,0,4,4,12,16,12,8,36,36,36,36,36,36,40,40,44,20,4,4,4,12,12,12,12,4,12,16,8,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,0,0,4,4,0,16,12,56,44,36,36,36,40,36,44,36,8,20,0,4,4,12,4,12,4,4,0,20,4,44,36,36,40,36,40,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,12,4,4,4,4,20,12,12,4,44,40,36,40,40,36,36,4,20,12,12,12,12,12,12,12,12,0,16,4,44,36,36,36,36,44,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,4,4,4,4,12,16,4,4,4,8,36,40,36,36,36,44,4,20,20,20,0,4,4,4,4,12,20,24,4,44,36,36,40,36,36,36,36,36,36,36,36,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,12,4,4,4,4,4,4,0,8,8,8,8,36,36,40,36,36,36,8,24,16,20,16,16,20,12,12,4,12,16,48,36,36,36,36,36,36,44,36,36,36,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,16,4,4,8,4,8,0,0,8,8,8,8,44,36,36,36,44,36,4,24,16,12,16,16,20,24,20,20,16,20,48,36,36,36,36,40,36,40,36,40,36,40,40,48,8,8,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,12,12,16,12,12,12,12,12,8,8,8,8,8,36,36,40,36,40,12,24,20,20,12,12,12,16,16,20,20,20,48,36,36,44,36,36,40,36,40,36,40,44,8,12,12,12,4,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,0,4,0,12,0,12,12,16,8,8,8,8,8,36,36,36,36,44,12,28,16,20,20,16,12,12,16,20,20,12,44,36,36,36,36,36,36,36,36,40,8,4,12,12,4,16,16,20,12,48,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	0,12,0,12,4,4,0,12,20,4,8,48,8,8,44,36,40,36,36,16,24,16,16,20,20,20,20,16,20,24,12,44,36,36,44,44,36,40,36,40,44,4,4,12,4,12,24,24,24,20,12,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,0,4,4,4,4,0,12,12,12,8,48,48,8,8,36,36,36,40,4,28,24,20,20,20,24,28,20,24,12,44,36,36,36,36,36,36,36,36,48,8,4,4,12,16,24,24,24,20,20,20,20,8,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,4,4,4,4,4,4,4,12,20,8,48,48,8,8,36,36,40,36,48,20,24,24,16,20,20,20,24,24,16,44,40,36,40,36,40,36,40,48,4,4,4,4,12,12,20,24,20,16,12,20,12,20,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	16,4,4,4,4,4,4,4,0,16,56,44,8,8,8,36,36,36,36,40,44,24,24,24,16,20,16,20,20,24,4,36,36,36,36,40,36,40,44,4,4,4,4,4,20,20,20,4,4,8,4,12,20,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,12,4,4,4,8,8,4,4,12,16,8,48,8,8,44,36,36,44,36,8,24,24,24,24,24,16,12,16,24,56,36,36,40,36,36,40,44,40,8,4,4,4,4,4,16,20,12,12,12,12,12,12,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,12,4,4,4,8,4,8,4,0,16,12,8,8,8,44,36,40,40,44,24,24,24,20,24,24,24,28,24,24,4,36,40,36,36,40,8,4,8,40,8,4,4,4,16,24,24,20,20,24,24,28,20,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,16,0,4,4,8,8,8,4,12,0,16,12,8,8,44,40,44,44,8,24,16,12,12,16,24,24,24,24,12,44,36,36,36,36,40,4,4,4,4,44,8,4,4,24,20,16,16,12,16,16,16,24,20,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,16,12,4,4,8,8,8,4,0,0,12,16,12,8,44,36,36,44,4,24,16,12,20,24,24,24,24,24,4,40,36,36,36,36,40,44,4,4,4,4,4,4,4,28,16,24,28,16,16,20,28,24,24,4,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	44,4,20,4,4,4,8,4,4,12,12,0,0,16,12,4,8,8,4,4,20,28,16,24,24,20,24,20,16,20,44,36,40,36,8,4,8,8,8,8,4,4,4,4,24,16,16,16,20,28,20,24,16,24,12,40,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	48,44,12,20,12,4,4,8,4,4,0,12,12,4,12,12,4,0,0,4,4,12,12,4,4,4,20,20,12,20,4,40,36,8,4,12,4,4,4,4,44,48,8,44,16,20,20,4,56,12,12,12,16,24,12,44,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	44,44,8,12,12,4,4,4,4,0,0,4,4,4,4,4,4,4,4,8,4,8,8,4,12,20,28,24,20,24,4,44,8,4,0,4,48,4,4,4,48,40,40,44,48,12,12,12,48,8,12,20,12,16,8,36,40,36,40,36,36,36,36,36,0,0,0,0
	dc.b	8,44,44,8,12,16,0,4,4,0,4,4,4,4,0,4,4,4,4,4,8,8,16,28,24,28,24,16,20,24,4,4,4,4,4,0,44,44,4,4,48,44,44,48,4,4,16,12,0,44,44,44,48,44,40,40,36,40,40,40,36,36,36,36,0,0,0,0
	dc.b	12,4,8,8,8,16,16,0,12,4,12,4,4,4,4,8,8,8,8,8,8,12,24,16,24,16,12,20,24,20,16,12,0,4,4,0,4,36,36,8,44,36,12,20,24,28,24,20,24,20,4,48,44,40,40,40,40,36,40,44,36,36,36,36,0,0,0,0
	dc.b	4,4,4,4,4,4,16,16,12,12,4,12,0,4,4,8,8,8,8,8,4,16,24,16,16,12,16,20,20,16,20,12,0,8,8,4,56,8,48,36,36,40,20,28,16,16,12,12,24,28,24,20,12,44,8,48,44,8,44,36,40,40,36,36,0,0,0,0
	dc.b	8,8,8,4,8,8,8,0,16,12,12,4,12,4,8,8,8,4,8,4,4,12,24,24,24,24,20,12,12,12,16,12,0,4,4,4,4,48,36,36,40,36,4,16,20,24,16,12,12,20,24,16,24,12,8,48,48,8,4,4,44,44,36,36,0,0,0,0
	dc.b	4,8,4,8,4,8,8,8,4,12,12,16,0,0,8,4,4,4,4,56,4,44,8,12,16,12,0,4,12,12,12,4,12,0,4,8,8,40,40,36,36,40,44,8,12,24,24,16,20,20,24,16,24,16,8,48,44,4,8,4,8,44,40,36,0,0,0,0
	dc.b	8,8,8,8,8,8,8,8,44,8,4,0,12,12,12,12,12,4,4,8,36,36,40,36,0,12,20,16,16,16,12,12,4,12,4,40,40,36,36,36,36,36,44,36,44,4,12,12,12,12,20,20,16,4,8,48,8,4,4,4,8,8,12,44,0,0,0,0
	dc.b	8,4,4,8,8,8,8,8,8,8,4,8,44,44,48,48,44,36,40,36,36,40,36,36,4,20,20,16,20,16,12,12,12,4,40,36,36,44,44,40,4,12,12,4,44,44,12,56,12,8,8,8,48,8,4,8,8,4,4,4,0,12,12,4,0,0,0,0
	dc.b	8,8,4,8,8,8,4,8,8,4,8,40,36,36,40,36,36,40,36,36,40,36,36,36,8,20,20,16,12,12,12,8,44,40,36,36,36,36,40,48,20,24,28,12,4,4,4,12,16,16,8,8,8,8,8,4,8,4,4,4,12,4,0,4,0,0,0,0
	dc.b	8,4,4,4,4,4,4,4,4,8,40,40,36,40,36,36,36,40,36,36,36,36,40,36,36,44,44,44,8,4,8,40,36,36,36,40,36,40,44,8,24,16,24,24,20,12,8,12,16,20,4,4,4,8,8,8,8,4,4,4,8,4,12,4,0,0,0,0
	dc.b	4,12,12,12,4,4,4,48,40,40,36,36,40,36,36,36,40,36,36,36,40,36,36,36,40,36,40,36,36,36,40,36,36,36,36,36,36,40,40,4,24,28,24,16,28,24,24,24,24,24,20,44,8,8,8,4,4,4,4,12,4,4,4,8,0,0,0,0
	dc.b	8,8,48,44,8,8,8,36,36,36,36,40,36,36,40,40,36,36,36,36,36,36,36,36,36,40,36,36,36,36,40,36,36,36,36,40,40,36,4,12,16,24,16,20,16,16,16,20,16,28,16,44,48,8,48,44,4,4,4,0,4,4,4,12,0,0,0,0
	dc.b	48,48,48,48,8,8,48,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,44,44,12,16,16,0,20,24,24,24,24,24,24,20,44,40,40,36,40,40,36,40,4,4,0,12,12,0,0,0,0,0
	dc.b	48,48,8,44,48,8,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,8,20,16,16,8,4,12,16,20,24,16,4,48,36,36,36,36,36,36,36,36,36,4,12,4,4,4,0,0,0,0
	dc.b	8,8,48,8,8,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,36,36,36,36,40,36,36,4,20,20,20,12,4,12,20,16,12,4,36,36,44,36,36,36,36,36,36,36,40,44,12,12,12,16,0,0,0,0
	dc.b	48,8,44,8,8,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,40,36,36,40,36,4,20,20,12,16,16,28,16,16,12,48,36,36,36,36,36,36,40,36,36,36,36,44,12,4,12,0,0,0,0,0
	dc.b	8,8,8,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,40,36,36,36,4,12,20,20,20,20,20,24,16,8,40,44,36,40,36,40,36,36,36,40,36,36,40,4,0,12,8,0,0,0,0
	dc.b	8,52,8,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,44,12,12,16,20,24,20,4,44,40,36,36,36,36,36,36,36,40,36,36,36,40,8,12,20,16,12,0,0,0,0
	dc.b	8,44,48,40,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,40,36,40,44,4,4,12,8,44,36,36,36,40,36,44,48,8,48,8,44,44,44,44,36,12,16,0,12,16,0,0,0,0
	dc.b	44,44,44,48,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,44,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,44,36,40,36,40,44,48,8,8,8,8,8,8,8,8,8,48,12,12,16,20,12,0,0,0,0
	dc.b	48,44,48,8,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,44,36,36,36,36,36,36,44,36,36,36,36,40,36,36,36,36,36,36,36,40,36,44,8,8,8,8,8,48,44,44,8,8,48,48,4,12,12,16,20,0,0,0,0
	dc.b	4,4,4,4,0,0,12,12,48,36,40,36,36,36,36,40,36,44,44,0,20,12,56,56,0,12,12,4,12,20,4,44,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,12,4,4,4,12,16,0,48,40,40,36,36,36,36,36,36,44,20,4,4,4,4,12,12,12,12,4,20,12,44,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,12,0,0,4,4,12,12,12,4,40,36,36,40,36,36,36,40,8,20,0,4,4,0,4,12,4,4,12,12,12,44,40,36,36,36,36,36,36,36,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	0,0,0,4,4,4,12,20,12,12,8,36,36,36,36,36,36,40,4,20,12,12,12,12,12,12,16,16,0,12,20,44,36,36,36,36,40,44,40,40,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,12,4,4,4,4,12,12,4,4,4,8,36,36,36,36,40,36,4,20,16,20,16,12,4,12,12,16,20,20,12,44,36,36,36,36,36,40,36,36,36,40,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,4,4,4,12,4,8,8,8,8,36,40,36,36,36,40,8,16,20,16,12,12,12,4,0,4,0,24,4,44,40,44,36,40,36,36,40,36,40,36,40,36,40,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,8,4,4,4,0,4,8,8,8,8,44,40,36,36,36,44,8,28,16,12,16,16,20,28,20,20,12,20,4,44,36,40,36,36,36,36,40,36,40,36,40,44,8,4,4,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	16,16,0,0,0,12,12,4,8,8,8,8,44,40,40,36,36,40,4,24,20,16,12,0,12,12,16,20,20,24,4,44,36,36,44,36,36,36,36,36,36,44,8,4,12,16,12,0,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,12,12,12,12,12,16,12,8,8,8,8,8,36,40,36,36,40,0,24,20,20,16,16,12,12,12,16,20,24,4,40,44,36,36,36,36,36,40,36,44,4,12,12,12,12,12,20,12,12,48,36,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,4,0,0,0,12,16,12,8,8,8,8,8,44,36,36,40,44,12,24,16,16,16,20,20,12,16,20,20,24,8,36,36,36,44,44,36,40,36,36,8,4,4,12,0,12,24,24,24,20,20,8,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,4,0,12,12,20,8,8,48,8,8,44,40,40,36,36,12,24,20,16,20,20,16,20,20,24,20,4,44,40,40,36,36,40,36,36,44,8,4,0,12,0,16,24,24,24,24,16,20,20,8,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,4,4,4,12,12,4,48,48,48,8,48,36,36,40,40,44,24,28,24,20,24,28,24,24,28,12,44,40,40,36,36,40,36,40,40,8,4,4,4,4,0,12,20,24,20,12,20,12,16,20,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,4,4,4,0,12,16,8,8,48,8,8,36,40,40,40,44,8,24,24,24,24,24,20,20,24,24,12,40,40,36,36,36,40,36,40,8,4,4,4,4,12,20,20,16,4,8,8,4,12,20,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	0,4,4,8,8,4,4,4,16,0,48,48,8,8,36,36,36,36,40,44,12,24,24,28,24,24,16,12,28,20,44,40,40,36,40,40,40,44,40,4,4,4,4,4,12,16,12,12,12,12,12,12,12,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	0,4,4,8,4,4,4,4,12,20,8,8,8,8,44,40,36,44,44,8,20,24,24,24,12,20,24,16,24,20,44,40,36,40,36,44,4,4,44,44,8,4,4,8,12,24,28,20,20,20,24,20,20,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,4,4,8,8,8,4,4,0,20,12,8,48,8,44,40,36,36,44,16,24,16,16,20,20,28,28,24,24,16,44,40,36,36,36,44,4,4,4,8,48,4,4,4,20,16,16,20,20,16,16,24,28,20,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,4,4,8,4,8,4,4,12,0,20,12,8,8,44,40,40,44,8,24,20,12,16,20,24,24,24,24,24,8,36,36,40,36,36,36,8,4,4,4,4,4,4,12,24,16,20,24,16,20,20,20,24,24,12,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,0,4,4,8,4,8,4,0,0,0,16,12,4,8,36,44,8,4,20,20,12,20,24,24,28,28,24,16,8,36,36,36,8,4,8,8,4,8,8,4,4,4,4,20,20,24,20,16,24,24,24,16,16,12,48,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	20,16,12,4,4,8,4,4,12,0,0,0,12,12,4,12,4,4,4,12,28,20,28,24,12,12,20,16,16,12,36,40,36,8,0,0,4,4,4,8,44,8,4,48,20,20,20,4,12,20,12,12,16,24,20,48,40,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,20,12,4,4,4,4,56,0,4,12,12,12,4,0,0,12,4,4,4,4,4,4,4,4,4,24,28,20,20,44,44,8,4,4,8,8,4,4,4,44,40,40,44,4,20,16,4,44,4,16,16,20,20,4,44,36,36,40,36,36,36,36,36,0,0,0,0
	dc.b	44,4,20,12,4,4,4,0,0,4,4,4,12,0,4,4,4,4,4,52,8,8,12,16,12,20,24,16,16,20,44,4,4,4,0,8,40,8,4,4,44,40,40,44,44,4,0,4,4,44,44,8,8,8,44,40,36,40,40,40,36,36,36,36,0,0,0,0
	dc.b	44,44,4,20,0,0,0,0,4,0,12,4,4,0,8,4,4,4,8,8,8,16,24,20,24,24,20,20,24,20,12,4,0,4,4,0,44,36,48,8,36,36,8,12,20,20,20,20,20,12,48,44,36,40,36,40,40,36,40,44,36,36,36,36,0,0,0,0
	dc.b	4,4,8,0,20,12,0,0,12,4,4,4,0,4,4,8,8,8,8,8,4,16,24,16,20,12,20,20,20,12,20,0,4,4,4,0,4,44,44,36,36,36,20,24,24,28,20,16,24,24,24,12,4,44,8,48,44,8,44,36,40,40,36,36,0,0,0,0
	dc.b	4,4,4,4,4,16,20,12,0,0,4,12,12,8,8,4,8,8,8,4,12,24,20,28,20,20,20,16,16,16,16,12,4,8,4,12,4,44,40,36,36,44,12,20,20,20,12,12,12,24,24,16,20,12,8,48,48,8,4,4,44,44,36,36,0,0,0,0
	dc.b	8,4,8,8,8,4,12,20,12,12,12,0,4,4,8,8,4,4,4,4,4,16,24,24,24,20,12,4,16,12,12,4,12,4,8,4,8,36,40,40,36,40,8,12,24,24,16,16,12,20,16,16,24,20,8,44,44,4,8,4,8,44,40,36,0,0,0,0
	dc.b	8,8,4,8,8,8,8,8,12,16,12,12,12,4,4,4,4,12,4,8,36,48,4,12,12,12,4,16,16,16,12,12,0,4,8,36,36,40,36,36,40,36,36,44,4,20,20,20,20,24,24,20,16,20,8,44,4,4,4,4,8,8,56,44,0,0,0,0
	dc.b	4,8,8,8,8,4,48,48,8,4,0,0,12,12,12,12,4,8,48,36,40,36,40,8,16,20,20,16,12,16,12,12,12,4,40,36,36,44,44,40,44,8,8,44,44,4,12,12,12,8,12,4,4,8,4,8,8,4,4,8,12,12,0,4,0,0,0,0
	dc.b	4,8,8,4,8,8,8,8,4,4,8,36,36,44,44,44,36,40,36,40,36,40,36,48,20,20,16,20,16,12,12,4,8,40,36,40,36,36,40,44,4,24,20,12,4,8,12,12,16,4,8,8,8,8,8,8,8,4,4,4,12,4,4,4,0,0,0,0
	dc.b	4,8,8,4,8,8,8,4,4,8,36,36,40,40,36,36,36,36,36,36,36,36,40,40,4,16,12,12,12,12,4,36,36,40,36,36,40,40,44,8,16,20,28,16,12,4,48,4,16,12,4,8,8,8,4,8,8,4,4,0,8,4,12,4,0,0,0,0
	dc.b	4,4,8,4,0,4,4,4,36,40,36,40,40,36,36,36,40,36,36,36,36,36,36,40,40,44,36,36,8,48,36,40,36,36,40,36,40,36,40,8,24,24,24,28,24,20,4,12,24,24,16,44,8,8,8,4,4,4,8,12,8,12,4,8,0,0,0,0
	dc.b	12,12,4,12,4,8,44,36,36,36,36,36,36,36,36,36,36,40,36,40,36,36,40,36,36,40,36,40,40,40,36,36,36,40,36,36,40,36,44,12,24,24,20,16,24,24,28,24,24,28,20,44,8,8,44,8,8,4,4,0,4,4,4,12,0,0,0,0
	dc.b	48,44,8,48,48,48,36,40,36,36,36,40,36,36,40,36,40,36,40,36,36,36,36,36,40,36,40,36,36,36,36,36,36,36,40,36,44,44,12,12,16,20,28,20,16,20,16,20,20,24,4,44,40,36,36,36,36,40,4,4,0,12,0,12,0,0,0,0
	dc.b	48,48,48,48,8,48,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,8,20,16,12,4,12,20,28,24,24,20,28,12,48,40,36,36,36,36,36,36,36,4,0,12,4,4,0,0,0,0
	dc.b	48,48,48,8,8,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,36,36,36,36,40,36,36,12,20,20,16,8,4,0,12,16,20,12,8,44,40,36,36,36,36,36,36,36,36,44,12,12,12,12,0,0,0,0
	dc.b	48,48,44,8,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,44,12,20,12,16,16,12,20,20,16,16,4,44,40,36,36,36,40,36,36,36,36,36,44,4,12,12,12,0,0,0,0
	dc.b	48,44,8,44,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,40,36,36,44,4,20,20,12,16,20,20,20,16,12,44,36,36,36,36,36,36,36,36,36,36,36,40,8,4,0,8,0,0,0,0
	dc.b	8,8,44,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,36,40,4,12,16,20,20,24,20,20,12,8,40,36,40,40,40,40,36,40,36,36,36,36,44,12,16,16,0,0,0,0,0
	dc.b	4,48,40,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,40,36,36,44,4,12,16,16,20,12,8,44,40,36,40,44,44,48,48,8,44,44,44,44,40,8,20,12,16,12,0,0,0,0
	dc.b	44,48,44,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,44,40,36,36,36,36,36,36,36,36,36,36,44,8,8,8,44,44,44,40,36,44,48,8,8,8,44,8,48,8,8,8,44,12,12,12,16,12,0,0,0,0
	dc.b	48,44,44,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,44,36,36,36,36,36,36,44,36,36,36,36,36,36,40,36,36,40,36,40,40,36,48,8,8,8,8,8,8,44,44,8,8,48,48,4,12,20,20,16,0,0,0,0
	dc.b	4,4,4,12,12,16,4,40,36,36,36,36,36,36,40,36,36,44,4,20,4,4,56,12,0,12,0,0,20,16,44,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,4,4,16,16,4,40,36,36,36,36,40,36,36,40,44,20,12,4,4,4,12,12,12,0,4,12,20,44,44,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	0,12,4,4,4,16,16,0,8,40,36,36,36,36,36,36,44,8,16,12,4,4,56,0,0,12,4,0,0,20,8,36,40,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,0,12,20,16,12,4,44,36,36,40,36,36,36,40,8,24,16,4,4,4,12,12,16,12,0,12,20,52,40,36,36,36,36,40,44,40,40,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,12,4,4,0,20,12,4,4,8,36,40,36,36,36,36,36,8,20,20,12,20,20,16,16,16,20,24,20,20,8,44,36,36,36,36,36,40,36,36,40,40,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,4,0,12,8,4,8,4,44,36,36,36,36,36,40,44,16,20,20,16,12,0,4,12,12,12,24,12,44,40,40,44,36,40,36,36,40,36,40,36,36,40,36,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,8,4,4,12,4,8,8,4,8,36,40,36,40,36,44,44,20,24,12,16,12,20,20,20,20,12,20,12,44,44,36,40,36,36,36,36,40,36,40,40,40,44,4,4,4,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,4,12,12,8,8,4,8,8,44,36,36,36,36,40,44,28,24,16,12,12,0,12,12,16,20,20,20,44,40,36,36,44,36,36,36,36,36,44,44,8,12,16,16,12,0,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,16,12,12,16,16,8,8,8,8,8,44,36,36,40,36,40,4,28,24,20,16,12,12,12,12,16,16,24,20,44,36,40,36,36,36,36,36,36,36,8,4,0,12,12,4,12,20,16,12,44,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	0,4,0,0,16,20,8,8,8,8,8,8,36,36,36,36,36,0,28,16,16,20,20,12,12,12,16,20,24,16,44,40,36,36,44,44,36,40,36,36,4,12,12,0,4,16,24,28,24,16,20,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,12,4,0,20,0,8,8,8,8,8,44,40,40,36,40,4,28,20,16,20,20,28,20,20,24,24,12,8,36,36,36,36,40,36,36,36,8,8,4,4,12,4,20,16,24,28,28,20,16,16,8,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,4,0,12,20,8,8,8,8,8,44,40,36,40,36,8,28,24,24,16,24,28,28,28,28,12,44,40,40,36,36,36,36,36,40,44,4,4,0,4,0,0,12,20,24,20,16,16,20,16,20,44,40,40,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,4,0,0,20,4,8,44,8,8,44,36,36,36,40,44,4,28,28,28,28,20,28,20,24,24,4,44,40,36,36,36,36,40,40,40,8,4,4,4,4,12,20,20,20,4,4,8,4,16,20,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,4,4,0,12,16,8,8,48,8,8,36,36,36,36,36,40,4,16,20,28,28,24,24,16,24,24,4,36,40,36,36,36,36,36,36,8,4,4,4,4,4,12,20,12,4,4,4,4,12,12,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,8,4,4,4,20,4,44,8,8,8,40,40,36,40,44,44,4,12,28,28,24,16,24,20,20,28,12,36,40,36,40,36,8,4,8,36,44,4,4,4,4,12,16,24,20,20,24,24,20,12,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,52,8,4,4,4,12,20,8,44,8,8,44,36,36,36,40,8,20,20,24,28,12,0,20,28,24,28,4,36,36,40,36,36,4,4,4,4,44,8,4,4,8,20,24,16,16,16,16,16,24,28,16,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,52,8,52,4,4,12,4,16,16,8,8,8,40,36,40,40,44,12,24,16,12,20,28,24,24,24,28,24,44,36,40,36,36,36,44,4,4,4,4,4,4,4,4,24,20,24,16,20,16,12,20,24,24,12,40,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,52,8,52,8,4,12,0,16,12,4,8,44,36,40,44,4,20,28,12,16,24,28,28,28,28,24,4,44,36,40,40,52,8,8,8,8,4,4,4,4,8,4,24,12,24,24,24,24,24,24,12,24,20,8,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,8,8,4,0,0,0,0,12,16,4,8,44,8,4,4,16,24,20,24,28,28,24,20,20,12,12,44,40,36,44,4,4,4,4,4,4,44,44,4,8,4,28,20,24,4,16,20,16,12,20,24,20,8,40,36,36,36,36,36,36,36,0,0,0,0
	dc.b	0,4,4,4,8,52,0,0,0,0,12,12,16,12,12,4,12,4,4,20,20,20,20,4,4,4,20,12,16,4,36,44,8,4,4,8,4,4,4,8,40,36,40,44,12,20,12,4,44,12,16,16,20,24,12,44,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,12,4,4,52,4,0,12,12,4,0,0,0,4,12,4,4,4,4,4,8,8,4,4,4,12,24,24,24,12,44,4,4,0,4,44,44,4,4,8,36,36,36,40,44,4,12,12,8,44,8,4,4,4,44,40,40,40,40,44,36,36,36,36,0,0,0,0
	dc.b	16,16,12,4,4,0,0,4,4,12,12,0,4,4,4,4,4,4,8,8,8,12,12,0,12,20,24,16,24,12,4,4,4,4,4,8,36,44,8,44,40,40,36,8,8,4,16,4,4,4,44,40,40,40,40,36,36,40,40,40,36,36,36,36,0,0,0,0
	dc.b	8,12,16,12,0,12,0,4,4,4,4,4,4,8,4,8,52,8,8,8,12,24,16,24,24,20,20,24,24,16,12,4,4,4,4,12,8,40,44,36,36,36,4,24,28,24,24,20,24,24,16,4,8,48,8,48,44,48,44,36,40,36,36,36,0,0,0,0
	dc.b	4,4,16,20,16,0,0,12,4,4,4,4,4,8,8,52,8,8,8,4,20,24,16,24,16,20,20,16,20,16,16,4,8,4,4,4,8,36,36,36,40,44,20,24,16,24,12,16,24,24,28,24,16,4,8,48,48,8,4,4,44,44,36,36,0,0,0,0
	dc.b	4,4,4,12,20,16,12,0,0,0,4,4,4,52,8,8,4,4,4,4,16,24,24,20,20,20,20,12,12,20,0,0,4,4,4,4,44,40,40,40,40,36,4,24,16,24,16,12,12,16,24,12,20,20,4,44,8,4,8,4,44,44,36,36,0,0,0,0
	dc.b	8,4,8,8,4,12,16,12,0,0,4,4,8,8,8,4,4,4,4,8,4,24,28,24,24,16,4,16,12,12,12,12,4,4,44,40,40,40,36,36,36,40,44,4,20,20,24,20,16,16,24,20,20,24,52,44,8,4,4,4,8,8,12,44,0,0,0,0
	dc.b	4,8,8,4,8,8,4,16,16,16,12,0,4,12,0,0,12,4,44,36,36,8,4,16,16,4,4,20,16,12,0,12,12,4,36,36,36,44,44,40,36,40,40,36,44,12,12,20,20,12,24,20,20,12,4,44,52,8,4,8,4,12,4,4,0,0,0,0
	dc.b	8,4,8,4,8,8,8,8,4,4,4,12,4,4,4,4,44,44,36,40,40,40,44,12,20,20,20,12,20,12,12,4,4,40,36,36,36,36,40,36,8,12,4,4,8,4,12,4,12,4,8,8,8,8,4,8,8,4,4,4,12,4,4,4,0,0,0,0
	dc.b	8,8,8,4,52,8,8,52,4,44,36,36,44,40,40,36,36,36,36,36,36,36,36,12,16,16,20,20,16,16,4,44,44,40,36,36,36,36,44,44,20,24,24,16,4,8,8,12,12,12,8,4,4,8,8,8,8,4,4,0,8,4,12,4,0,0,0,0
	dc.b	4,8,8,4,4,8,4,4,44,40,40,40,40,40,36,40,36,40,36,36,40,40,36,44,12,12,4,4,4,4,44,36,36,36,36,36,40,36,40,52,24,20,24,16,12,4,44,4,20,20,12,8,8,8,8,52,4,4,8,4,8,4,4,8,0,0,0,0
	dc.b	4,4,4,4,4,4,8,40,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,40,36,36,44,36,40,36,36,36,36,36,40,40,44,4,24,24,24,24,24,24,16,16,24,24,16,44,8,8,44,8,8,4,8,4,4,4,4,4,0,0,0,0
	dc.b	4,0,4,4,8,40,40,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,36,40,36,36,36,36,40,40,44,40,8,12,24,24,20,16,20,24,24,24,24,20,24,44,40,36,36,40,36,36,4,0,0,12,12,0,0,0,0,0
	dc.b	48,48,48,8,44,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,44,12,16,12,20,24,24,20,24,24,16,16,24,12,44,36,36,36,36,36,36,36,4,0,12,4,4,0,0,0,0
	dc.b	48,48,48,8,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,40,40,12,20,16,4,8,4,20,20,24,24,24,24,12,44,40,36,36,36,36,36,36,40,44,12,12,4,0,0,0,0,0
	dc.b	48,48,8,44,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,40,36,36,44,12,20,20,12,4,4,4,16,20,16,4,44,36,40,36,36,36,40,36,36,36,36,44,4,12,12,12,0,0,0,0
	dc.b	44,48,8,44,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,36,36,40,36,36,36,36,36,36,36,36,40,44,12,24,12,16,12,12,20,16,12,16,4,40,36,36,40,36,36,36,36,36,36,36,40,8,4,4,4,0,0,0,0
	dc.b	8,8,44,40,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,44,0,16,20,16,12,20,16,20,16,12,44,36,36,36,36,36,36,40,36,40,36,36,36,8,12,12,4,0,0,0,0
	dc.b	8,44,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,40,36,36,4,12,16,16,24,24,24,20,12,44,40,44,44,48,48,48,8,48,8,44,44,40,8,12,16,12,16,0,0,0,0
	dc.b	44,36,36,36,36,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,44,36,36,36,36,36,36,36,36,36,40,44,4,12,12,16,16,4,8,40,40,44,44,8,8,44,8,8,48,8,8,8,44,4,12,0,12,12,0,0,0,0
	dc.b	44,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,44,36,36,36,36,36,36,44,36,36,36,36,40,36,44,44,8,44,44,36,40,36,44,8,8,8,44,8,8,48,48,44,44,8,44,4,12,16,16,12,0,0,0,0
	dc.b	4,12,12,16,12,44,36,40,36,36,36,36,40,40,36,36,44,4,20,0,56,4,0,12,12,56,12,16,20,8,44,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,12,16,12,44,40,36,36,36,40,36,36,40,36,44,16,12,4,4,4,12,12,12,4,4,4,20,4,40,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,12,16,12,4,44,36,36,36,36,36,36,36,36,8,20,12,4,4,56,4,56,0,0,4,12,16,12,44,36,40,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,12,4,16,20,4,4,8,40,40,36,36,36,40,36,40,8,20,16,4,4,4,4,4,0,4,12,4,16,12,36,40,36,36,36,36,40,44,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,16,16,0,4,4,44,36,40,36,36,36,40,44,4,20,20,12,12,20,20,20,24,20,20,16,16,12,44,36,36,36,36,36,36,40,36,36,36,40,36,36,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,20,4,4,4,4,4,40,36,36,40,36,36,36,44,20,20,20,24,20,12,12,12,16,16,24,20,4,44,40,40,44,36,40,36,36,40,36,40,36,36,40,40,44,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,8,4,16,4,8,8,8,8,44,40,40,36,36,40,40,44,0,24,20,16,12,12,16,16,12,4,16,20,8,36,40,36,40,36,36,36,36,40,36,40,36,44,44,4,4,4,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,12,4,8,8,8,8,8,40,36,36,40,36,36,44,16,28,20,12,12,12,56,12,16,20,24,24,4,40,40,36,36,44,36,36,36,36,36,44,8,4,12,16,16,12,0,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,16,12,16,4,8,8,8,8,8,44,40,40,36,36,36,8,28,24,24,12,12,12,12,12,12,16,20,24,0,36,36,40,40,36,36,36,36,40,36,4,4,12,12,12,0,12,20,12,12,48,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,12,12,16,12,8,8,8,8,4,44,36,40,40,36,36,4,28,16,20,16,16,12,28,12,12,16,16,28,4,36,36,36,36,44,44,40,36,36,44,12,4,12,0,4,16,24,28,24,20,20,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,0,0,16,16,8,8,8,8,8,8,36,36,36,36,36,0,24,20,12,20,24,28,28,24,20,20,24,20,44,36,36,40,36,36,36,36,48,8,8,0,4,12,4,20,12,20,24,32,16,16,16,8,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,0,12,20,4,44,8,8,8,8,44,40,36,36,36,4,28,24,20,16,28,28,28,24,20,4,8,44,40,40,36,36,36,40,40,36,8,12,4,4,4,12,4,16,20,20,20,20,16,16,16,16,40,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,0,16,12,8,8,8,8,8,44,40,40,36,36,44,16,28,28,28,24,12,4,20,24,20,4,44,40,40,36,36,36,36,36,40,8,4,4,4,4,0,16,16,20,16,12,8,8,12,20,12,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,0,0,20,8,44,8,8,8,44,36,36,36,36,44,44,12,24,28,20,12,20,28,24,28,28,4,36,40,36,36,40,36,36,36,40,4,4,4,4,4,0,12,20,12,4,8,4,4,12,12,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,4,0,12,12,8,44,44,8,8,36,40,36,40,36,48,8,8,4,12,28,28,24,20,16,24,20,44,40,40,40,40,36,4,8,44,36,8,4,4,4,4,12,16,20,16,16,20,20,16,12,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,4,0,0,16,0,44,8,8,8,36,36,36,36,44,44,4,4,20,28,28,20,12,24,24,16,24,8,36,40,40,36,44,4,4,4,8,44,8,12,4,8,16,24,24,20,20,20,20,24,20,16,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,4,4,4,4,0,12,16,4,44,8,8,36,36,40,36,44,4,16,20,20,28,24,20,12,24,24,28,24,44,36,40,36,36,36,8,4,0,8,4,4,8,4,4,24,20,20,20,16,16,12,20,28,24,12,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,8,8,4,4,0,0,16,16,8,8,8,40,36,36,36,8,12,24,12,12,20,28,24,28,24,28,24,4,36,36,36,40,8,8,8,8,8,4,4,4,4,8,4,24,16,20,24,20,20,20,24,20,20,20,8,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,8,4,4,0,12,12,16,12,4,8,44,36,44,4,4,16,24,16,16,24,28,28,28,28,20,12,44,36,40,40,8,12,12,8,4,8,8,44,8,8,44,12,24,20,24,16,16,20,20,20,20,20,20,8,40,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,8,4,8,4,0,12,0,0,12,16,12,4,4,4,4,4,4,24,20,24,28,24,20,12,16,12,12,12,40,36,44,8,0,4,8,4,12,4,48,36,40,36,44,16,20,16,4,8,12,20,12,16,28,20,8,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,8,8,4,12,4,12,0,0,12,12,12,0,0,12,4,4,16,20,20,12,4,4,4,12,20,12,16,8,44,4,12,4,8,44,4,4,4,44,36,40,40,36,4,16,12,12,44,44,8,12,4,4,8,44,40,40,40,44,36,36,36,36,0,0,0,0
	dc.b	0,4,4,4,0,12,0,4,0,12,0,4,0,4,4,4,4,4,8,8,8,4,12,4,4,20,24,24,20,4,4,4,4,4,8,44,36,8,8,44,36,36,36,36,40,4,0,4,12,8,44,40,40,40,40,40,36,36,40,44,36,36,36,36,0,0,0,0
	dc.b	12,4,4,0,12,12,4,4,4,4,0,4,4,4,4,8,8,8,8,8,12,16,4,4,12,24,24,20,20,12,4,0,8,12,0,4,44,40,44,40,40,36,8,0,12,12,16,16,12,16,4,44,44,48,8,48,44,48,44,36,40,36,36,36,0,0,0,0
	dc.b	20,12,0,0,0,4,12,4,4,0,4,4,8,4,4,8,52,8,8,4,20,20,16,24,24,16,20,24,20,16,0,4,4,8,0,4,44,40,36,40,36,44,16,24,24,28,20,20,24,28,28,16,4,4,8,48,8,8,8,4,44,44,36,36,0,0,0,0
	dc.b	12,20,12,12,0,0,0,0,4,4,0,8,4,8,8,8,8,4,4,12,24,20,28,20,16,20,20,20,16,16,12,4,4,4,12,8,44,36,40,36,36,44,20,24,16,20,12,4,16,20,24,20,20,20,8,44,8,8,8,4,44,44,40,36,0,0,0,0
	dc.b	8,0,16,20,12,12,12,4,4,12,4,4,8,8,8,4,4,4,4,12,24,20,24,20,20,20,12,12,12,20,4,12,12,8,8,40,40,40,36,40,40,36,4,12,20,28,16,16,12,12,20,20,12,20,4,44,8,4,4,4,44,8,4,4,0,0,0,0
	dc.b	4,8,4,0,20,16,12,0,0,0,4,8,8,4,8,4,4,4,8,8,20,28,28,24,20,4,12,20,0,12,12,12,12,8,36,36,40,36,44,36,36,40,44,44,0,20,28,24,20,20,24,24,20,20,4,44,8,8,4,8,4,12,4,4,0,0,0,0
	dc.b	8,4,8,8,8,12,16,16,16,0,12,0,0,0,12,0,4,44,40,36,8,0,12,16,20,4,16,12,16,0,12,12,56,40,36,36,36,40,36,36,40,44,44,44,8,4,12,0,16,0,12,16,12,4,8,8,8,4,4,8,12,4,4,8,0,0,0,0
	dc.b	8,8,4,8,44,8,8,12,12,0,12,0,0,4,8,44,40,36,36,40,40,36,8,20,20,20,16,16,16,12,4,8,44,40,36,36,36,36,44,36,4,20,20,12,4,8,4,12,12,0,8,8,8,8,8,8,8,4,4,8,8,4,12,4,0,0,0,0
	dc.b	8,8,8,8,8,8,4,8,36,36,44,36,36,40,40,40,36,36,36,36,36,36,8,20,20,16,16,12,16,4,44,36,36,36,36,36,36,36,40,8,20,24,24,12,0,8,44,12,12,16,4,44,8,8,8,8,8,4,8,4,8,56,4,8,0,0,0,0
	dc.b	8,8,8,8,8,4,8,44,36,40,36,36,40,36,36,36,40,36,36,36,40,40,36,8,12,4,4,4,4,44,36,40,36,40,36,36,36,36,36,4,20,20,24,20,16,12,8,8,20,20,20,44,8,8,44,8,4,8,4,4,4,4,8,4,0,0,0,0
	dc.b	4,4,12,4,4,8,40,40,36,36,40,36,36,36,40,36,40,36,36,36,36,36,36,36,36,36,40,40,36,36,40,40,36,36,40,36,44,40,44,12,28,24,24,20,24,24,20,24,24,20,24,8,36,36,36,36,36,40,8,0,0,12,12,12,0,0,0,0
	dc.b	0,12,4,8,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,12,12,20,24,20,16,20,20,20,24,16,20,24,8,36,40,36,36,36,36,36,4,4,12,12,4,0,0,0,0
	dc.b	48,44,8,40,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,36,36,36,36,36,36,36,4,16,16,56,12,24,24,16,20,24,20,20,24,12,36,36,36,36,36,40,36,36,44,4,12,12,4,0,0,0,0
	dc.b	44,8,8,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,40,44,12,20,20,56,44,4,16,20,24,28,24,20,4,44,36,36,36,36,36,36,40,36,44,4,4,0,12,0,0,0,0
	dc.b	44,8,48,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,8,20,20,12,20,4,4,0,16,16,12,0,44,40,40,40,36,36,36,36,36,36,40,40,4,4,12,4,0,0,0,0
	dc.b	8,8,36,36,40,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,40,36,44,12,20,12,16,16,20,20,20,12,12,4,40,36,40,40,36,40,40,36,36,36,40,40,44,4,0,8,0,0,0,0
	dc.b	8,40,40,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,44,12,16,20,16,16,16,16,16,16,12,44,40,44,44,44,44,8,44,8,44,44,40,44,4,16,16,16,0,0,0,0
	dc.b	36,36,36,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,40,44,40,36,36,36,36,36,36,36,36,40,4,12,16,20,24,24,20,16,4,44,40,44,44,8,8,8,8,48,8,44,8,44,8,12,12,12,12,0,0,0,0
	dc.b	36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,44,36,36,36,36,36,36,44,36,36,36,36,36,40,4,12,16,16,0,8,44,44,44,8,8,8,44,44,44,44,44,44,44,8,44,4,12,12,12,12,0,0,0,0
	dc.b	12,12,16,8,40,36,36,36,36,36,36,36,36,36,40,44,0,24,0,0,4,4,0,12,4,12,12,24,4,44,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,12,16,12,8,36,40,36,36,36,36,36,36,40,36,44,16,16,56,52,4,12,12,12,4,4,4,20,12,44,40,36,36,40,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,0,16,16,12,8,36,40,36,36,36,36,36,40,36,44,20,16,56,4,4,12,12,12,12,4,4,12,20,44,40,36,40,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,0,20,16,4,4,44,36,36,36,36,36,36,36,40,52,24,20,56,4,4,4,4,4,4,4,4,12,20,8,40,36,36,36,36,36,40,44,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,12,24,12,4,4,8,44,36,40,36,36,36,36,36,4,24,24,12,4,4,12,16,16,20,20,12,16,20,8,40,36,36,36,36,36,36,40,36,36,36,40,36,36,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,12,16,4,4,8,8,8,40,40,36,36,40,36,36,8,16,24,20,16,24,24,24,24,24,24,24,20,12,44,36,36,40,44,36,40,36,36,40,36,40,36,40,40,36,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,12,8,8,8,8,8,44,40,36,36,36,40,40,44,12,20,24,28,12,4,4,0,4,4,20,24,4,44,40,36,36,40,36,36,36,36,40,36,40,36,44,8,12,4,4,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,0,0,4,8,8,8,8,44,36,36,40,36,36,36,36,4,28,28,16,0,12,16,16,16,16,24,24,16,44,40,36,36,36,44,36,36,36,36,36,8,8,4,16,16,16,12,4,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,12,12,8,8,8,8,8,8,36,40,40,36,40,36,44,16,28,28,28,24,24,24,12,12,12,16,24,20,44,40,36,40,40,36,36,36,36,40,44,0,4,16,12,4,0,12,20,16,4,48,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	16,16,16,8,8,8,8,8,8,40,36,36,36,36,36,8,28,24,24,16,28,32,28,28,12,12,16,24,24,44,36,36,36,36,44,44,36,36,36,8,12,4,12,0,4,16,24,28,28,20,24,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,16,20,4,8,44,8,8,8,44,36,36,40,40,36,4,28,24,20,20,24,28,28,28,16,20,24,24,12,44,36,36,40,40,36,36,40,8,4,4,56,4,12,4,16,12,16,24,28,16,16,12,8,36,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	0,12,20,12,44,8,44,8,8,8,40,36,36,36,36,4,28,24,20,16,28,28,28,28,20,4,56,4,44,36,40,36,36,36,36,40,36,4,4,4,4,4,12,0,20,24,20,16,20,12,20,12,20,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,4,20,16,8,8,44,8,8,8,40,36,36,36,40,8,24,28,24,28,24,12,4,16,12,56,44,40,36,40,36,36,36,36,40,40,36,4,4,4,4,4,12,12,16,20,20,12,4,4,12,12,12,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,0,12,20,4,44,8,44,8,8,44,36,36,36,36,40,4,24,28,28,20,12,12,20,24,24,16,4,36,40,36,36,36,40,36,40,40,44,4,4,4,4,4,12,20,24,12,8,8,8,4,12,12,12,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,0,16,16,8,8,44,44,8,44,36,36,36,36,36,44,4,0,12,16,16,16,24,28,24,28,24,4,40,40,36,36,36,8,4,8,36,44,4,4,4,4,4,12,16,12,12,16,16,16,12,4,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,0,20,12,44,8,44,8,8,36,36,36,36,40,48,8,8,8,4,12,28,28,16,24,16,28,12,36,36,36,40,36,4,4,4,8,44,44,4,4,52,8,12,24,24,24,16,24,24,24,24,16,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,12,12,20,8,8,44,8,8,36,36,40,36,36,8,4,4,16,28,28,28,12,12,28,24,24,12,36,40,36,36,36,44,4,4,4,4,8,8,4,8,4,24,24,20,20,16,16,16,20,28,24,12,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,4,0,20,16,8,44,8,8,36,36,36,36,44,4,12,16,24,28,20,24,20,20,16,24,28,4,40,36,36,36,8,44,8,8,4,4,4,4,4,44,4,24,16,20,20,16,20,12,24,16,24,20,8,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,4,4,12,0,16,16,4,8,8,40,40,36,44,4,4,24,20,12,16,28,24,24,28,28,32,4,44,40,36,44,4,12,4,4,8,8,8,8,4,8,40,12,24,16,24,24,16,24,24,24,16,16,20,4,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,4,4,4,0,12,0,16,20,4,8,44,44,8,4,4,12,24,16,16,24,28,28,24,28,20,16,4,48,40,36,8,4,4,4,4,4,4,8,40,36,40,40,4,20,20,24,4,8,16,20,16,16,24,24,4,36,40,36,40,36,36,36,36,0,0,0,0
	dc.b	4,8,4,0,0,0,12,0,12,12,12,4,12,0,4,4,0,24,24,24,28,24,20,4,4,20,12,16,4,36,44,4,4,8,44,8,4,4,4,36,36,40,36,40,56,16,16,56,44,8,4,12,12,20,4,44,40,40,40,44,36,36,36,36,0,0,0,0
	dc.b	8,4,4,0,12,12,4,12,12,0,12,12,12,0,4,4,4,12,16,16,12,0,4,4,4,20,20,20,12,4,4,4,4,4,8,40,8,8,44,36,36,36,40,40,44,4,12,12,4,44,40,36,44,44,44,40,40,36,40,40,36,36,36,36,0,0,0,0
	dc.b	4,4,4,12,0,0,0,4,0,0,4,4,4,4,4,8,52,8,4,8,4,12,12,4,4,24,24,24,12,4,4,4,4,4,4,44,40,36,44,36,40,40,36,44,44,8,4,0,4,12,8,44,44,48,8,48,44,44,44,40,36,40,36,36,0,0,0,0
	dc.b	4,4,12,12,4,4,12,4,4,0,4,4,8,4,4,8,8,8,8,12,16,4,4,56,20,24,16,24,20,12,4,4,8,4,12,8,40,36,36,36,36,40,4,20,20,24,24,24,24,20,20,12,8,8,44,48,8,8,4,8,44,44,36,36,0,0,0,0
	dc.b	0,0,12,0,12,4,4,12,4,0,4,4,4,8,4,8,8,4,4,16,24,16,20,24,20,16,24,24,16,12,4,4,4,4,12,8,36,36,36,36,36,44,20,24,16,24,16,12,20,24,28,24,16,16,8,44,8,8,8,4,40,44,40,36,0,0,0,0
	dc.b	12,12,0,12,4,12,4,4,4,4,8,4,8,8,8,8,4,4,4,24,24,24,24,20,20,20,20,12,20,12,12,4,4,8,4,40,40,36,36,40,40,44,12,24,16,24,16,0,12,12,24,16,16,24,56,44,8,4,52,8,44,8,4,4,0,0,0,0
	dc.b	20,20,16,12,4,0,0,12,4,4,4,8,8,8,8,4,4,4,4,24,20,24,16,20,20,20,16,0,16,12,12,0,12,44,36,36,36,40,36,36,36,40,8,4,20,28,24,16,12,12,20,16,16,24,12,44,8,8,4,8,4,12,4,4,0,0,0,0
	dc.b	8,0,20,20,12,0,12,0,4,4,4,4,4,4,4,0,4,44,44,16,28,28,24,24,12,4,16,12,16,4,12,12,12,36,36,40,36,40,40,36,40,36,40,44,4,16,24,28,24,24,28,28,20,20,4,44,8,8,4,8,12,4,4,8,0,0,0,0
	dc.b	8,8,8,12,20,20,16,12,0,0,0,12,12,56,12,8,44,40,36,44,4,12,16,16,4,16,20,12,16,4,12,4,44,40,36,40,36,40,44,40,44,4,4,4,8,8,12,4,12,4,4,4,4,8,8,8,8,4,8,4,8,4,12,4,0,0,0,0
	dc.b	8,8,8,44,8,4,12,0,0,12,0,4,4,8,36,36,36,40,36,40,36,44,16,16,20,16,16,16,12,12,44,44,36,36,36,40,36,40,36,44,12,24,28,12,56,44,8,12,4,16,8,8,8,8,8,8,8,8,8,4,8,56,4,8,0,0,0,0
	dc.b	8,8,8,8,8,8,8,36,36,36,44,40,36,40,36,36,36,40,36,36,40,44,12,16,20,20,16,12,12,8,40,36,36,40,36,36,40,36,40,8,24,16,24,12,0,4,44,4,16,16,12,44,8,44,44,8,8,8,8,12,4,4,8,4,0,0,0,0
	dc.b	8,8,8,4,4,8,40,40,40,36,36,36,36,36,36,36,36,36,40,36,36,36,44,12,12,8,8,8,44,40,36,36,40,36,36,36,44,40,36,4,24,24,24,24,16,16,4,8,16,24,24,4,40,36,36,36,36,40,4,4,0,4,0,12,0,0,0,0
	dc.b	4,4,4,4,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,40,36,36,36,4,12,24,24,20,20,24,24,24,24,24,20,24,4,36,36,36,36,36,36,36,4,4,12,12,4,0,0,0,0
	dc.b	4,4,44,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,36,36,36,36,36,36,36,8,16,12,20,24,16,20,16,24,20,16,20,24,24,8,36,40,36,36,36,36,36,44,4,12,4,4,0,0,0,0
	dc.b	8,8,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,44,4,20,16,4,0,24,24,20,20,24,24,20,24,12,40,36,36,36,36,36,36,40,44,4,12,12,12,0,0,0,0
	dc.b	8,44,40,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,8,16,20,16,56,8,4,16,20,24,24,24,20,4,44,36,40,36,40,36,40,36,40,40,4,4,0,4,0,0,0,0
	dc.b	8,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,8,20,16,12,20,12,4,0,16,12,12,4,44,40,40,36,36,40,36,40,40,36,40,36,44,12,4,8,0,0,0,0
	dc.b	44,36,36,36,36,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,8,12,20,16,12,16,20,24,20,12,16,4,40,44,44,44,44,8,8,44,44,44,40,36,8,12,16,12,0,0,0,0
	dc.b	36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,44,40,36,36,36,36,36,36,36,40,44,12,12,24,16,20,20,20,16,16,12,44,44,44,44,44,44,8,48,8,44,44,44,8,12,20,12,12,0,0,0,0
	dc.b	36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,44,36,36,36,36,36,36,44,36,40,36,40,36,4,12,12,24,24,24,24,20,4,44,8,8,8,44,44,44,44,44,44,44,8,44,4,12,0,12,12,0,0,0,0
	dc.b	16,4,44,40,36,36,36,36,36,36,40,36,36,36,44,12,24,20,4,4,4,0,4,4,12,12,24,12,44,40,36,40,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	16,12,4,36,36,36,36,40,40,36,36,36,40,40,44,16,24,4,4,4,4,4,12,12,4,4,12,20,48,44,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,16,16,8,40,36,36,36,36,36,40,36,40,36,8,24,24,4,4,4,12,12,12,4,4,0,4,20,4,36,36,36,36,36,36,36,36,40,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	16,20,12,4,8,36,40,40,36,36,36,40,36,44,8,24,24,0,4,4,4,4,4,4,12,4,12,20,4,44,36,36,36,40,36,36,40,44,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,20,12,4,4,48,40,40,36,40,40,36,36,40,4,24,20,16,12,4,4,0,12,12,12,12,12,20,12,44,36,36,36,40,36,36,36,36,36,36,36,40,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,12,4,4,4,8,40,36,36,36,40,36,40,44,8,24,24,24,16,12,16,24,24,24,24,20,20,24,8,44,36,40,36,44,36,40,36,36,40,36,40,36,40,36,36,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,4,8,8,8,4,44,40,36,40,36,36,40,40,8,20,24,16,24,28,28,28,20,12,16,24,20,12,44,36,40,36,40,36,36,36,40,36,40,36,36,44,44,4,12,0,4,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	16,4,8,8,8,8,8,44,36,36,36,36,36,40,44,4,20,28,28,28,28,24,12,16,20,16,24,20,48,44,36,40,36,36,44,40,36,40,40,48,8,4,12,16,16,16,12,4,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,8,8,8,8,8,8,44,36,40,36,36,36,36,44,8,28,28,28,28,28,28,20,12,16,16,24,24,4,40,36,36,40,36,40,40,36,36,40,8,0,4,16,12,12,4,0,16,12,4,48,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,8,8,8,8,8,8,8,36,36,36,36,36,40,44,24,28,24,24,28,28,28,24,24,12,12,20,28,4,36,40,36,40,40,44,44,36,44,44,12,0,12,12,0,12,16,24,24,24,28,24,8,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,4,8,8,8,44,8,8,44,40,36,36,36,40,8,28,24,20,24,24,28,24,28,28,20,16,24,24,4,36,40,36,40,36,36,36,44,8,4,0,4,12,0,12,12,12,24,24,24,24,20,16,8,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,12,8,8,8,8,8,8,44,36,40,36,36,36,4,28,24,20,16,24,28,28,28,28,24,20,20,12,44,40,36,36,36,36,36,36,48,4,4,4,4,4,0,4,24,20,16,12,20,20,20,12,20,40,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,20,8,8,48,8,44,8,8,36,36,36,36,36,8,28,24,20,24,28,24,20,20,0,8,44,44,44,40,36,36,40,36,36,36,36,8,4,4,4,4,4,12,12,12,20,20,12,4,8,12,16,12,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,20,0,44,8,44,8,8,8,40,36,36,36,36,48,20,28,28,28,20,4,12,20,20,12,4,44,36,40,40,36,36,36,36,36,40,36,4,4,4,4,4,4,16,20,24,16,8,8,4,12,12,12,16,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	0,16,20,8,48,48,8,48,8,44,36,36,36,36,40,44,12,24,20,20,16,12,20,24,28,28,20,8,36,36,36,36,36,44,8,4,44,40,8,12,4,4,4,12,12,16,12,0,12,12,12,4,4,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	0,12,20,4,8,48,48,8,8,44,40,36,36,36,40,48,8,4,4,4,4,12,16,24,28,24,28,20,44,40,40,36,40,44,4,4,4,48,40,8,4,4,8,4,16,20,24,20,20,24,24,24,20,12,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,12,12,20,4,48,48,8,8,48,40,36,40,36,36,8,8,4,8,8,4,16,28,24,16,24,24,24,4,36,40,36,36,40,8,12,4,4,4,8,8,4,8,8,16,24,24,20,16,16,16,20,28,24,12,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,0,16,16,8,48,8,8,48,40,36,36,40,44,4,8,8,4,24,28,28,28,0,16,20,24,28,8,36,36,36,48,44,8,8,4,8,4,56,4,8,44,4,24,20,20,20,20,12,16,16,16,24,20,4,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,12,12,20,12,8,44,8,48,36,40,40,44,8,8,4,20,24,28,24,28,16,20,20,24,24,16,44,36,40,8,12,4,8,4,8,8,44,8,4,44,36,16,24,20,24,24,24,24,24,24,16,12,20,12,40,40,36,36,36,36,36,36,0,0,0,0
	dc.b	8,4,12,12,12,20,16,8,8,48,36,36,44,8,4,4,28,24,12,20,28,24,24,28,28,28,20,48,36,40,40,4,4,4,4,8,4,4,44,36,36,36,40,4,24,20,24,12,4,20,20,20,12,24,24,4,44,36,40,36,36,36,36,36,0,0,0,0
	dc.b	8,4,0,0,0,12,20,12,12,8,48,8,8,12,4,0,32,16,12,24,28,28,28,32,24,12,12,4,40,40,48,4,4,8,48,4,4,4,48,40,36,40,40,48,16,20,20,4,44,8,56,16,16,20,20,48,36,40,40,40,36,36,36,36,0,0,0,0
	dc.b	4,4,12,0,12,12,0,12,16,12,12,0,12,4,4,0,24,24,24,28,24,20,12,4,12,16,12,12,8,4,4,4,4,8,40,44,8,4,44,36,36,36,36,40,8,16,12,12,8,44,36,8,8,48,44,44,40,36,40,44,36,36,36,36,0,0,0,0
	dc.b	8,0,0,0,12,4,4,12,0,12,4,0,4,4,4,8,56,20,20,16,0,0,12,4,12,24,16,20,4,4,4,4,4,0,8,40,44,40,44,36,36,40,40,36,36,8,12,4,12,4,44,44,48,48,8,8,44,48,8,36,36,40,36,36,0,0,0,0
	dc.b	4,4,12,0,4,4,12,4,0,4,4,4,4,4,4,8,8,4,8,4,56,56,4,4,12,24,24,24,12,4,4,4,4,56,4,44,40,36,36,36,36,36,44,8,8,4,4,16,12,12,12,8,48,8,44,48,48,8,8,8,44,44,36,36,0,0,0,0
	dc.b	0,12,0,4,4,0,4,12,12,4,8,4,8,8,4,8,8,4,4,16,12,4,4,16,24,24,24,24,12,12,4,4,4,4,56,8,36,36,36,40,36,44,16,24,28,28,20,24,20,24,24,24,12,12,48,44,8,8,8,8,40,44,40,36,0,0,0,0
	dc.b	12,4,0,4,4,4,4,4,12,4,8,8,4,8,8,8,4,4,12,24,20,16,20,24,16,16,24,16,12,12,4,4,4,4,8,44,36,40,36,36,40,44,20,20,16,20,12,12,12,16,24,24,12,24,12,44,4,4,8,8,48,4,4,4,0,0,0,0
	dc.b	12,4,12,4,4,0,4,12,12,8,4,8,8,8,8,4,4,4,20,24,24,20,24,20,20,20,20,12,16,4,12,4,4,44,36,40,36,36,36,36,40,36,4,20,20,24,20,12,12,12,12,20,12,24,20,44,8,8,4,8,4,12,8,8,0,0,0,0
	dc.b	12,12,0,0,4,0,12,4,4,8,4,8,4,8,4,4,4,48,20,24,24,24,20,24,24,16,12,0,20,12,12,12,8,40,36,36,36,40,36,36,40,40,44,4,20,28,28,20,20,16,24,24,20,20,12,44,8,8,8,8,4,4,4,4,0,0,0,0
	dc.b	20,20,12,0,0,0,0,4,4,4,4,4,4,4,12,4,44,44,0,28,24,24,24,20,4,12,12,12,12,4,4,4,44,40,40,40,36,36,44,36,36,44,44,48,48,4,12,20,20,20,20,24,20,12,8,8,8,8,8,8,8,4,4,4,0,0,0,0
	dc.b	4,0,20,20,20,16,0,0,0,4,12,0,56,4,8,44,40,40,44,4,20,20,16,16,0,20,16,12,12,12,4,44,36,36,36,36,40,40,36,44,8,12,16,4,8,8,8,12,12,12,8,8,8,48,8,8,8,8,4,4,8,4,4,8,0,0,0,0
	dc.b	8,48,8,4,12,12,20,12,12,12,4,4,8,36,36,40,40,36,36,40,36,4,16,20,20,12,20,12,12,4,36,36,36,36,40,36,36,40,36,48,20,24,24,12,12,4,44,56,12,16,4,44,8,44,44,8,8,4,8,4,4,4,8,4,0,0,0,0
	dc.b	8,8,8,8,4,44,44,44,44,36,36,36,36,36,36,36,36,36,40,40,36,8,20,20,20,20,12,12,4,36,36,36,36,36,40,40,44,36,40,8,24,16,24,12,0,12,8,48,16,20,20,4,40,36,36,36,36,40,8,4,4,4,12,12,0,0,0,0
	dc.b	8,8,8,52,48,40,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,40,8,12,4,8,48,44,40,36,36,36,36,36,36,40,36,36,48,12,24,20,24,24,24,16,12,4,16,24,24,4,36,36,36,36,36,36,36,4,4,0,0,4,0,0,0,0
	dc.b	4,4,52,48,36,36,40,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,40,40,36,36,36,36,36,36,40,36,40,48,12,16,24,24,20,20,24,24,24,24,24,28,24,12,40,36,36,36,36,36,40,48,4,12,12,4,0,0,0,0
	dc.b	4,48,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,40,36,40,36,36,40,40,36,36,36,36,40,36,36,44,4,20,12,16,24,20,20,16,24,20,20,16,16,24,4,36,36,40,36,36,36,36,44,4,0,0,0,0,0,0,0
	dc.b	44,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,8,12,20,16,4,4,24,24,20,24,24,20,20,24,12,36,40,36,36,40,36,36,40,36,4,4,12,4,0,0,0,0
	dc.b	44,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,36,40,40,36,36,36,36,36,36,36,36,36,36,40,40,4,20,16,20,4,8,4,16,20,24,24,24,12,4,44,40,40,44,40,36,36,40,40,36,44,0,4,8,0,0,0,0
	dc.b	36,36,40,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,40,36,36,36,40,4,16,12,12,20,12,4,12,16,12,12,4,44,36,44,44,48,44,44,48,48,48,40,40,44,12,12,0,0,0,0,0
	dc.b	36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,36,40,40,44,36,36,36,36,36,36,36,40,36,4,12,20,12,12,20,24,20,20,12,16,4,44,48,44,44,48,48,8,8,44,48,48,44,4,16,12,16,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,44,36,36,36,36,36,36,44,36,40,36,40,48,12,16,24,20,20,20,20,12,16,16,48,8,48,44,44,48,48,44,48,44,8,44,8,12,0,0,12,0,0,0,0
	dc.b	44,36,40,40,36,36,36,36,36,36,36,40,36,48,12,24,20,4,4,4,4,4,4,4,12,20,20,48,36,40,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,44,36,36,40,36,36,36,36,36,36,36,44,44,16,28,12,4,4,12,4,12,4,4,4,12,20,4,36,36,40,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,4,44,36,36,36,36,36,36,36,36,40,36,44,24,28,12,4,4,4,12,4,4,4,4,0,16,12,44,40,36,36,36,36,36,36,36,36,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,12,4,40,36,36,36,36,36,36,36,36,44,4,24,24,16,4,4,4,4,12,12,0,4,12,20,20,44,44,40,36,36,36,36,36,36,44,40,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,4,4,8,36,36,36,36,36,36,36,40,36,4,24,24,20,12,4,4,4,12,12,12,12,20,20,20,48,44,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	0,4,8,4,44,36,36,40,36,40,36,44,40,4,24,24,24,20,12,12,20,24,20,20,20,20,20,12,44,40,36,40,36,44,40,36,36,36,40,36,40,36,40,44,44,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,8,4,8,36,40,36,40,36,36,40,36,8,24,24,20,20,16,28,28,28,24,28,24,20,12,8,44,44,36,36,36,40,40,36,40,40,36,40,44,44,48,12,12,12,12,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,8,8,8,8,48,36,36,40,36,36,36,40,44,12,24,16,24,28,28,28,16,12,20,16,24,20,8,40,40,36,36,40,36,44,40,36,36,40,4,4,4,16,16,16,16,0,0,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,8,8,8,8,36,40,36,36,36,36,40,36,48,16,28,32,28,28,24,20,12,16,20,20,24,16,44,40,36,40,36,36,36,40,36,36,48,56,4,4,12,0,0,0,0,20,12,4,48,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,8,8,8,8,44,36,40,36,36,36,36,44,4,28,28,20,24,28,28,20,24,16,16,20,24,24,48,40,36,40,36,36,44,44,36,36,8,12,4,12,12,0,12,16,20,20,24,28,24,8,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,8,8,8,8,8,40,36,40,36,36,40,48,24,28,24,24,24,28,24,24,24,24,12,20,24,24,44,40,40,36,40,36,36,36,8,4,4,4,4,12,4,0,4,12,20,24,20,24,20,16,8,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,8,8,8,8,8,36,40,40,36,40,36,8,28,28,24,24,28,28,24,24,28,28,20,20,20,12,36,36,40,36,36,40,36,44,4,8,4,4,8,12,0,12,24,20,16,16,20,20,20,0,20,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,48,8,48,8,8,44,36,40,40,36,40,4,28,28,16,24,28,28,28,24,16,4,4,8,44,44,40,40,36,36,36,36,36,40,4,4,4,4,4,12,12,0,12,20,24,12,4,4,12,16,16,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	0,48,48,8,8,8,8,48,36,40,36,36,40,8,28,24,24,28,20,12,20,16,12,4,44,44,36,36,40,36,40,36,36,40,36,36,44,4,4,4,4,4,12,20,20,20,16,8,8,4,4,12,12,12,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	16,8,8,48,48,48,8,8,40,36,36,44,36,44,16,28,28,28,16,0,12,16,20,20,12,4,44,40,36,36,40,40,40,44,4,48,40,48,4,4,4,4,4,12,12,20,12,4,4,12,0,4,12,4,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,12,8,48,48,48,8,8,36,36,36,36,40,36,44,4,16,16,20,16,16,12,20,24,28,28,16,48,36,40,36,40,36,4,4,4,8,44,44,4,4,8,4,4,16,16,16,20,20,24,20,24,20,4,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	16,20,8,48,48,8,8,8,44,36,36,36,36,36,8,4,8,8,4,4,4,4,16,28,28,24,28,12,44,36,40,40,36,8,4,12,4,8,8,4,4,4,8,8,4,24,24,24,16,20,20,24,28,24,12,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,20,12,8,48,8,8,8,44,36,40,40,36,44,8,4,4,8,8,8,4,16,28,20,24,24,24,20,44,40,40,36,40,44,8,4,4,4,4,4,4,44,40,8,20,24,20,16,16,12,12,16,24,20,20,4,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,12,20,12,44,44,8,8,44,40,36,40,36,48,4,4,8,4,12,16,28,28,16,12,16,20,28,16,44,40,44,4,4,8,8,8,8,8,8,4,8,40,36,16,24,20,20,20,20,24,20,24,16,16,16,12,44,40,36,36,36,36,36,36,0,0,0,0
	dc.b	0,12,16,20,0,8,48,8,48,36,36,40,8,4,8,4,12,24,28,28,24,24,24,24,24,24,20,4,40,36,8,4,56,4,8,4,4,8,44,40,36,36,36,0,24,20,24,20,16,20,20,24,20,16,20,16,44,40,40,36,36,36,36,36,0,0,0,0
	dc.b	0,4,12,12,20,0,8,8,48,36,40,44,4,4,8,20,24,16,20,28,24,28,24,28,28,24,4,40,40,36,8,4,8,8,8,12,4,4,36,36,40,36,36,8,20,24,24,4,44,4,12,16,12,24,28,4,44,36,40,40,36,36,36,36,0,0,0,0
	dc.b	0,12,0,12,12,16,16,4,4,8,4,4,12,4,4,28,24,16,20,28,24,24,28,28,20,12,16,4,48,4,4,4,4,44,44,8,4,8,40,36,36,36,40,40,4,16,20,12,48,44,44,8,8,8,44,44,36,40,40,44,36,36,36,36,0,0,0,0
	dc.b	12,0,4,12,0,12,12,16,16,12,12,4,4,4,4,24,28,24,28,24,24,20,12,12,20,12,16,12,4,4,4,4,12,8,40,36,48,40,44,36,36,36,36,40,44,4,12,12,12,8,40,44,8,44,8,48,44,44,8,36,40,36,40,36,0,0,0,0
	dc.b	12,4,12,4,0,0,0,0,4,12,4,4,4,4,8,12,20,24,24,16,16,12,4,4,16,24,20,20,4,4,4,4,0,12,8,36,36,36,36,36,36,36,40,44,44,44,4,56,0,12,4,8,8,48,44,48,8,8,8,48,44,44,36,36,0,0,0,0
	dc.b	0,0,4,0,0,12,0,0,4,4,4,8,4,8,4,8,4,4,4,0,56,4,4,4,24,24,24,20,4,4,4,4,4,4,4,40,40,36,40,40,40,44,44,12,12,16,12,20,20,16,16,16,56,8,44,44,8,8,8,8,40,44,40,36,0,0,0,0
	dc.b	12,0,12,4,4,12,0,12,8,4,4,8,4,8,8,4,4,8,12,12,56,56,12,16,24,20,24,20,12,4,4,4,4,4,8,40,36,36,36,36,36,44,16,24,20,28,20,20,20,24,24,28,20,20,12,44,4,4,4,48,44,8,4,8,0,0,0,0
	dc.b	0,4,0,4,4,4,12,4,8,8,8,4,4,8,8,4,4,12,20,20,20,16,20,20,20,24,24,16,12,12,4,4,8,44,36,40,36,36,36,36,40,44,12,24,16,20,16,12,12,12,20,24,12,24,20,8,8,8,8,48,4,4,8,4,0,0,0,0
	dc.b	0,0,0,4,4,4,12,4,4,4,8,8,8,8,4,4,4,4,28,24,24,24,24,20,16,20,12,12,16,4,12,12,44,40,36,36,36,36,36,36,36,40,8,16,20,28,24,20,12,12,12,20,20,20,20,8,8,8,8,8,4,4,4,4,0,0,0,0
	dc.b	0,12,0,0,4,0,4,4,8,4,4,8,4,4,12,4,48,0,24,16,28,24,24,16,20,16,12,12,12,12,12,4,44,40,36,36,36,40,44,36,40,36,44,8,4,20,28,28,20,20,24,28,24,24,12,44,8,8,8,4,8,4,12,4,0,0,0,0
	dc.b	12,4,0,0,0,0,4,4,4,8,8,4,12,56,8,44,36,4,20,24,24,16,24,16,0,16,12,12,4,12,4,44,36,36,36,36,36,36,40,44,44,4,4,8,8,44,4,16,20,20,12,16,12,4,8,48,8,8,8,4,8,4,8,8,0,0,0,0
	dc.b	20,20,12,0,0,0,4,4,0,0,12,4,12,8,36,36,40,44,4,24,24,24,16,4,16,16,12,16,4,4,44,36,36,36,36,36,36,40,36,44,4,20,20,16,4,48,44,12,4,12,8,48,8,40,44,8,8,8,8,4,4,4,8,8,0,0,0,0
	dc.b	4,12,20,20,20,16,16,12,12,12,4,8,40,36,36,40,36,36,40,44,8,16,16,20,16,16,20,12,12,44,40,40,36,36,36,36,44,36,40,8,20,24,24,12,12,56,48,8,16,16,12,4,36,36,36,36,36,36,8,4,4,4,12,16,0,0,0,0
	dc.b	8,8,4,8,48,48,48,48,44,40,36,36,36,36,36,36,36,36,40,36,44,16,20,20,20,16,12,8,44,36,36,36,36,36,36,36,36,40,48,4,24,16,24,20,4,4,4,44,0,20,20,16,36,36,36,36,36,40,36,4,8,4,12,4,0,0,0,0
	dc.b	8,8,4,44,36,40,40,40,40,36,36,36,36,36,36,36,36,40,36,36,36,8,12,12,8,44,44,40,40,36,36,36,40,36,36,36,36,48,4,16,24,20,24,24,20,24,20,4,20,24,20,12,44,40,36,36,40,36,36,48,4,12,4,4,0,0,0,0
	dc.b	4,8,44,36,36,36,40,40,36,36,36,36,36,36,36,36,36,36,36,40,40,36,40,36,40,36,36,36,36,36,36,36,36,36,36,36,44,4,16,12,24,20,20,20,20,24,24,24,24,20,24,12,44,36,36,36,36,36,36,44,4,4,12,0,0,0,0,0
	dc.b	48,40,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,8,12,20,16,16,20,20,20,16,16,24,16,20,20,24,4,40,40,40,36,40,36,40,36,4,4,4,0,0,0,0,0
	dc.b	40,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,40,40,4,16,20,16,4,4,20,24,20,20,24,24,20,24,12,44,36,44,44,36,36,36,36,40,44,4,4,8,0,0,0,0
	dc.b	36,36,40,36,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,4,20,20,16,4,4,4,12,20,24,24,20,12,4,48,44,48,44,44,48,48,44,48,40,44,4,12,4,0,0,0,0
	dc.b	36,40,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,40,36,40,36,36,40,36,36,40,44,36,36,36,36,40,36,36,36,44,4,16,12,12,16,16,12,12,16,12,12,12,48,44,44,44,48,8,48,48,48,44,48,44,8,12,16,12,0,0,0,0
	dc.b	36,40,36,36,36,40,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,40,36,44,36,40,36,36,36,36,44,36,36,40,44,4,12,20,16,16,20,20,20,16,0,20,4,48,48,44,44,48,44,44,44,44,8,44,48,12,0,0,12,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,40,36,36,44,48,16,20,28,20,0,4,4,4,4,4,12,16,24,4,40,40,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,40,40,48,20,28,28,56,4,4,4,4,4,4,4,12,20,4,44,40,36,36,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	44,36,36,36,36,36,36,36,36,36,36,44,48,24,24,20,56,4,4,56,4,4,4,4,4,16,20,48,44,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,36,40,36,36,36,36,36,40,36,36,44,4,28,28,24,4,4,4,4,4,4,12,12,12,20,20,4,40,40,36,40,36,36,36,36,40,44,40,36,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,36,36,36,36,36,36,36,36,36,44,12,28,20,24,16,4,4,12,20,16,16,12,16,20,20,4,44,36,36,40,36,40,36,36,36,40,36,36,40,36,40,36,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,8,36,36,36,36,36,40,36,40,36,12,24,16,20,24,16,20,28,20,20,28,24,20,20,20,8,44,36,36,36,40,44,36,36,36,36,40,40,40,36,36,8,8,8,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,4,52,44,36,36,36,36,40,36,36,44,4,28,24,20,16,24,20,4,4,12,20,16,20,20,0,44,36,36,36,36,40,40,36,36,36,36,40,44,48,48,8,12,12,0,4,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,8,8,36,36,40,36,36,36,40,44,48,24,24,24,16,20,20,20,28,24,20,20,20,16,8,44,40,36,36,40,36,36,44,36,36,40,44,4,4,4,16,12,16,16,0,0,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,4,8,4,44,36,36,36,36,40,36,36,44,4,16,16,24,28,28,28,28,20,12,16,20,24,16,48,36,40,36,36,36,40,36,40,40,36,8,12,4,12,12,12,0,4,12,20,0,4,48,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,8,8,48,36,36,36,36,36,40,40,44,44,0,28,28,28,28,28,28,16,16,16,12,24,28,4,44,40,36,36,40,36,44,44,44,44,4,4,4,12,0,12,12,16,16,20,24,28,20,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,8,8,8,36,40,36,36,36,36,36,44,4,28,28,24,24,24,32,28,16,24,16,16,20,24,12,40,36,36,36,40,36,36,48,8,4,4,0,4,12,12,0,4,12,20,24,16,24,24,16,8,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,8,8,8,48,36,36,36,36,40,44,44,28,28,28,28,28,24,24,24,24,28,24,20,24,28,4,40,40,36,36,36,36,40,8,4,4,4,4,8,12,4,12,28,12,16,20,20,20,20,4,20,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,48,48,8,8,8,36,36,40,36,36,36,8,28,28,24,28,28,28,28,24,24,28,20,12,12,4,44,36,36,36,36,36,36,36,8,4,4,4,4,4,12,0,4,12,20,24,12,4,4,16,16,12,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	48,8,48,8,8,8,44,36,36,36,40,44,4,28,24,16,20,28,28,28,20,4,4,44,44,36,44,40,36,40,36,36,36,36,40,36,4,4,4,4,4,4,12,20,20,20,16,8,8,4,12,12,12,16,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	48,8,8,8,8,8,48,36,36,40,36,36,4,28,28,24,24,16,12,16,20,16,0,8,44,40,40,36,36,36,36,40,44,8,8,44,40,8,4,4,4,4,4,12,12,20,12,0,4,12,4,4,12,4,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	48,48,48,44,8,8,8,36,36,36,36,36,36,0,28,28,28,20,12,12,12,12,20,20,16,4,44,36,36,36,36,36,48,4,4,4,44,44,8,4,4,4,8,4,16,16,12,56,16,20,16,20,12,4,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,48,48,48,8,8,48,36,36,36,36,36,36,8,4,4,4,12,12,12,16,16,20,24,28,28,12,36,36,36,40,36,44,4,4,4,8,8,8,4,4,8,8,8,4,16,24,20,20,20,20,24,28,20,12,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	0,48,48,48,44,8,8,40,36,40,36,36,36,4,52,4,8,8,8,4,4,4,16,28,24,24,28,4,36,36,36,40,40,8,8,4,4,4,4,4,8,44,40,48,12,28,20,20,16,16,12,16,28,20,16,4,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	20,4,48,48,48,8,8,44,40,36,36,40,48,4,4,8,4,44,8,4,4,20,28,24,24,20,28,4,40,36,4,4,8,8,8,8,8,8,4,4,48,44,36,12,24,20,20,20,20,16,16,20,20,12,16,12,44,40,36,36,36,36,36,36,0,0,0,0
	dc.b	16,20,8,48,8,8,8,44,36,36,36,36,8,4,4,8,8,4,4,20,28,24,20,20,24,24,28,4,40,36,4,4,56,8,4,4,4,44,44,36,36,40,40,12,24,12,20,24,24,24,24,28,24,12,12,20,48,40,40,40,36,36,36,36,0,0,0,0
	dc.b	0,20,20,4,44,8,8,44,36,36,36,4,4,4,4,4,12,28,28,28,24,24,24,24,24,28,12,36,36,44,4,4,8,52,4,4,4,8,36,40,40,40,36,4,24,20,28,12,8,12,12,16,12,20,28,12,44,36,40,40,36,36,36,36,0,0,0,0
	dc.b	0,12,16,20,4,8,8,44,36,44,8,4,4,4,12,24,20,24,28,24,24,24,24,28,28,20,8,44,48,52,4,4,8,36,8,4,4,48,36,36,36,36,40,44,12,20,20,4,44,44,48,8,4,12,4,44,36,44,40,44,36,36,36,36,0,0,0,0
	dc.b	12,12,12,20,16,12,12,8,4,4,12,4,4,4,24,24,16,16,28,24,24,24,28,28,16,0,12,4,4,4,4,4,4,44,36,44,48,40,36,36,36,36,36,40,44,16,20,12,56,44,36,48,8,44,40,40,48,44,8,36,40,40,36,36,0,0,0,0
	dc.b	0,0,12,0,12,12,16,16,12,12,4,4,4,4,24,28,24,28,28,20,24,24,12,16,16,12,16,4,4,4,4,4,12,4,44,40,40,36,36,36,36,36,36,36,40,8,12,4,12,12,8,8,8,44,44,44,8,8,8,8,44,44,36,36,0,0,0,0
	dc.b	0,12,0,0,0,12,0,0,0,4,4,8,4,4,0,28,28,28,24,24,16,4,4,4,20,20,24,12,4,4,4,4,4,4,48,36,40,36,40,36,36,36,44,44,48,48,8,4,4,12,12,4,8,48,44,48,8,8,8,8,36,44,8,36,0,0,0,0
	dc.b	12,0,12,0,12,4,12,4,4,4,4,8,4,8,8,4,4,4,4,0,4,4,4,12,24,20,24,20,4,4,4,4,4,4,48,36,40,36,36,40,36,36,4,20,20,24,20,20,20,24,20,24,20,16,8,48,8,4,8,44,48,4,52,8,0,0,0,0
	dc.b	0,12,0,0,0,0,4,4,4,4,8,4,4,8,4,8,4,4,20,4,4,12,12,24,24,24,24,16,12,4,4,4,8,8,40,40,36,36,36,36,40,48,20,24,12,24,20,16,16,16,20,28,16,20,24,8,8,8,8,44,4,4,8,4,0,0,0,0
	dc.b	4,4,12,4,4,12,4,4,4,8,4,8,8,8,4,56,4,16,20,20,12,12,24,16,16,24,20,16,12,12,4,4,36,36,36,36,36,40,40,36,40,44,4,24,16,20,20,12,12,12,12,20,16,20,24,4,8,4,8,8,4,4,4,4,0,0,0,0
	dc.b	4,12,0,4,4,4,4,8,8,8,8,4,8,4,4,8,8,24,24,24,24,24,24,16,12,20,12,16,4,12,12,4,44,40,36,36,40,36,44,36,40,36,8,12,20,28,24,24,12,12,12,20,24,24,20,8,8,8,8,8,8,4,12,8,0,0,0,0
	dc.b	0,4,4,0,12,4,8,4,8,4,4,8,4,56,4,44,8,24,24,24,24,20,20,20,20,16,12,16,4,12,4,44,36,36,40,36,36,36,40,44,44,48,8,48,4,12,24,28,24,28,24,28,28,20,12,8,8,8,8,4,8,4,4,8,0,0,0,0
	dc.b	0,12,0,0,4,8,4,8,4,4,4,4,4,4,44,36,48,24,24,20,20,24,24,16,12,12,4,16,12,4,48,36,36,36,36,36,36,36,36,48,8,56,56,56,48,44,4,12,12,12,0,4,8,8,44,8,8,8,8,4,4,4,8,8,0,0,0,0
	dc.b	12,12,0,12,12,4,4,4,0,0,12,0,8,40,36,36,44,4,24,28,24,24,16,4,16,16,20,12,4,44,40,36,36,36,40,36,44,40,36,8,12,24,20,16,4,4,44,56,12,12,12,44,40,40,36,44,40,8,8,4,4,8,4,56,0,0,0,0
	dc.b	20,16,16,12,12,12,12,12,12,56,8,40,36,36,36,36,40,36,8,4,12,12,16,20,12,20,16,12,8,36,36,36,36,36,36,40,40,36,8,4,20,20,24,12,0,12,8,44,12,12,20,4,36,40,36,36,36,40,36,4,8,12,0,4,0,0,0,0
	dc.b	4,0,4,4,4,4,4,48,44,40,36,36,36,36,36,36,36,40,40,36,12,20,16,16,20,12,8,44,36,36,36,36,36,36,36,36,36,48,8,12,24,20,24,20,12,4,4,44,4,20,20,20,44,36,36,36,36,36,36,48,4,12,4,8,0,0,0,0
	dc.b	8,8,44,36,36,36,40,36,40,36,36,36,36,36,36,36,36,36,36,36,44,12,12,12,8,44,36,36,40,40,36,36,36,36,36,40,44,8,12,16,24,20,24,20,20,20,20,12,20,24,20,20,48,40,36,36,36,36,40,44,4,0,0,0,0,0,0,0
	dc.b	8,44,40,36,40,36,36,36,36,36,36,36,36,40,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,40,36,40,36,36,8,12,16,12,24,20,20,20,12,24,24,24,24,20,20,20,44,40,36,36,36,36,36,40,4,4,4,12,0,0,0,0
	dc.b	44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,40,36,36,36,36,36,40,4,16,16,12,12,20,20,20,16,20,16,20,16,16,24,12,44,44,44,36,40,40,36,36,44,56,4,8,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,0,20,12,16,8,4,20,24,20,24,24,20,20,24,20,44,44,44,44,44,48,40,44,40,44,4,4,4,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,44,36,40,36,36,36,36,36,40,8,4,16,12,12,12,4,4,12,16,24,24,24,20,4,44,44,48,44,44,44,44,44,44,44,8,12,12,12,0,0,0,0
	dc.b	36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,44,36,40,36,36,36,36,44,36,36,40,44,12,16,16,12,16,16,12,12,16,12,12,12,48,48,44,44,44,48,44,44,44,8,44,44,12,12,0,0,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,40,4,12,12,28,28,28,12,4,4,12,4,12,20,24,12,44,36,40,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,44,4,20,28,28,28,4,4,4,52,4,4,4,12,20,12,48,36,40,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,44,44,8,28,28,32,28,56,4,4,4,4,4,4,12,24,20,4,36,36,36,36,40,40,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,4,28,24,28,32,4,4,12,12,4,0,12,12,24,20,4,44,36,36,36,36,36,36,40,36,36,44,40,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,36,36,36,36,36,36,36,36,40,40,12,28,16,24,28,20,20,28,28,24,20,16,20,24,20,12,44,40,36,36,36,36,36,36,36,36,40,36,40,36,36,40,36,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,36,40,36,36,36,36,36,36,36,44,20,24,24,20,24,24,28,28,24,20,28,28,24,16,20,12,44,44,36,36,36,40,44,36,36,36,36,40,36,40,36,44,8,8,8,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,44,40,40,36,36,36,36,36,44,44,20,24,16,16,24,24,12,12,20,12,20,24,24,20,20,8,44,36,36,36,36,36,36,36,36,36,36,44,48,8,48,12,12,12,12,4,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,36,36,36,36,36,36,36,36,44,4,28,24,24,24,24,4,0,20,12,12,12,12,12,4,44,36,36,36,36,36,40,36,44,36,36,40,8,4,4,12,12,12,16,0,0,4,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,44,36,40,36,36,36,36,36,44,44,20,28,24,20,20,20,16,32,28,28,20,20,20,12,44,36,40,40,36,36,36,36,40,40,36,44,4,0,4,12,4,12,12,4,4,20,4,4,48,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,8,44,36,40,36,36,36,36,40,40,44,12,20,20,28,32,32,28,28,12,16,20,24,28,12,40,36,36,36,36,36,36,44,44,44,44,12,0,4,12,4,12,0,20,20,20,28,24,20,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,8,44,40,36,40,36,36,40,36,36,44,4,28,28,28,28,28,32,28,20,20,12,20,24,24,44,36,40,36,36,36,36,44,8,4,4,4,4,0,12,12,12,8,20,24,24,16,24,24,20,8,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,8,8,36,36,40,36,36,36,44,44,4,28,28,24,24,16,28,28,28,28,24,12,20,24,24,48,40,36,36,36,36,40,44,4,8,4,4,4,4,12,4,12,24,0,12,20,12,16,24,12,20,40,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,8,8,44,36,36,40,40,36,40,44,28,28,28,28,28,24,20,20,24,24,28,28,20,20,0,44,40,36,36,36,36,36,40,52,4,4,4,4,8,12,12,0,20,20,24,12,12,4,20,12,12,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,8,8,44,36,40,36,36,44,36,4,28,28,28,32,28,28,24,24,24,24,4,4,4,48,44,36,36,36,36,36,40,36,40,48,4,4,4,4,4,4,12,20,12,20,20,8,8,8,12,12,12,12,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	48,8,8,8,8,36,36,36,36,44,36,4,28,24,16,24,28,28,24,20,4,8,44,40,36,44,36,36,40,36,36,40,8,8,44,36,8,4,4,4,4,4,12,12,20,24,12,12,12,12,4,4,12,4,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	48,48,48,8,8,44,36,36,36,40,40,4,28,28,24,24,20,12,12,20,20,12,4,44,44,36,36,36,36,36,36,44,8,4,4,8,44,44,4,4,4,4,4,12,12,20,0,4,12,12,12,12,12,8,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	48,48,48,8,8,44,36,36,36,36,36,44,4,28,28,28,16,20,12,20,12,12,20,24,20,8,44,36,40,36,36,36,8,56,12,8,8,8,8,4,4,4,8,56,12,12,20,20,20,16,24,24,24,20,0,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	48,48,48,8,8,48,36,36,36,36,40,44,8,4,4,0,0,0,56,12,12,20,16,24,28,24,4,36,36,40,36,40,44,8,8,4,4,4,4,4,48,36,40,44,4,24,24,20,20,12,12,16,24,24,20,4,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	48,48,48,48,8,44,40,36,36,36,40,44,52,4,8,8,8,8,8,4,4,4,24,32,24,24,24,44,36,40,8,8,48,8,8,8,8,4,4,8,44,44,36,8,24,16,20,20,20,20,12,20,24,12,20,12,48,40,36,36,36,36,36,36,0,0,0,0
	dc.b	8,48,48,48,8,8,36,36,36,36,36,8,4,52,8,8,8,8,8,8,4,12,28,24,24,24,24,8,36,8,4,12,52,4,4,8,8,36,44,40,40,36,40,12,24,16,16,16,20,24,24,24,24,12,0,20,8,36,40,40,36,36,36,36,0,0,0,0
	dc.b	4,8,48,44,8,48,36,40,36,40,48,4,4,4,8,8,4,4,12,20,24,28,24,20,24,24,20,36,40,8,4,4,8,4,4,4,4,36,36,36,40,40,36,0,24,20,24,24,12,20,20,20,20,20,24,24,48,36,40,44,36,36,36,36,0,0,0,0
	dc.b	20,12,8,48,8,8,44,36,36,44,4,4,4,4,4,12,20,28,28,28,24,24,24,24,24,24,8,44,44,4,4,4,44,8,4,4,8,44,40,36,36,36,40,8,20,24,24,4,44,48,8,4,56,4,4,8,44,44,40,44,36,36,36,36,0,0,0,0
	dc.b	12,20,12,4,44,8,36,40,48,4,4,52,4,0,24,24,28,28,28,24,28,24,28,28,28,12,44,8,4,4,4,4,48,40,40,8,48,36,36,36,36,36,36,44,4,20,20,12,4,44,40,48,8,48,44,44,48,8,8,36,40,36,36,36,0,0,0,0
	dc.b	12,12,12,20,12,4,4,0,12,56,4,4,4,20,24,16,12,28,24,16,24,24,28,24,12,12,0,4,4,4,4,4,4,44,40,36,40,36,36,36,36,40,40,36,44,4,12,12,12,4,8,44,8,48,36,44,8,8,8,44,44,44,36,36,0,0,0,0
	dc.b	12,0,12,12,12,20,12,12,0,4,4,8,4,24,28,24,24,28,16,20,24,20,12,20,16,20,12,4,4,4,4,4,4,52,40,36,36,36,36,36,40,36,36,44,36,44,4,56,4,12,12,4,8,44,44,48,8,8,8,44,40,44,48,36,0,0,0,0
	dc.b	0,12,12,12,12,0,0,4,12,4,4,8,8,12,28,28,28,28,28,24,12,4,4,20,24,20,20,12,4,52,8,4,4,8,44,36,40,36,36,36,40,44,44,8,4,4,4,4,12,12,12,12,12,4,48,8,8,8,8,36,8,8,4,8,0,0,0,0
	dc.b	0,12,4,12,4,4,4,12,4,4,8,4,4,4,12,12,12,12,12,4,4,56,0,24,24,16,24,12,4,4,4,4,4,8,40,36,36,36,40,36,40,44,56,20,20,28,24,24,20,24,24,28,24,20,20,8,8,8,44,44,4,52,8,4,0,0,0,0
	dc.b	4,4,12,0,0,12,8,4,8,8,4,8,8,8,4,4,4,20,4,56,12,4,20,20,24,24,24,12,4,4,4,8,40,36,36,36,36,36,36,36,36,44,12,24,12,16,20,12,12,12,12,24,20,20,24,12,8,8,44,8,4,4,4,4,0,0,0,0
	dc.b	4,12,4,0,12,4,4,8,8,4,8,4,8,4,4,8,0,20,12,12,4,20,24,16,20,24,20,12,4,12,4,8,44,40,36,36,40,36,44,36,40,44,12,24,12,24,16,20,12,12,12,20,20,20,20,12,8,8,48,4,8,4,4,8,0,0,0,0
	dc.b	12,4,4,12,0,8,8,4,8,8,8,4,4,12,4,44,12,24,24,20,20,24,16,12,20,20,0,16,56,4,4,44,40,36,40,36,36,36,36,44,44,8,48,4,20,28,24,28,20,12,12,24,28,24,24,4,8,8,8,4,8,4,8,8,0,0,0,0
	dc.b	4,4,0,12,8,8,4,8,8,8,4,4,12,4,44,44,24,24,24,24,24,24,12,20,24,0,4,20,12,4,4,36,36,36,36,40,36,36,40,48,8,8,8,8,8,4,12,24,24,24,24,24,24,20,4,44,8,8,8,4,8,4,8,48,0,0,0,0
	dc.b	0,0,0,4,4,8,8,4,4,4,4,0,4,44,36,44,20,24,16,24,24,20,24,20,20,0,12,12,56,48,36,36,36,40,36,36,44,40,36,8,4,12,12,56,4,48,44,12,12,12,12,44,44,44,44,40,40,8,8,4,8,8,8,4,0,0,0,0
	dc.b	12,12,4,4,4,4,4,4,4,12,56,48,36,36,36,36,0,28,24,24,24,24,20,12,12,12,20,12,8,40,36,36,36,36,36,36,40,36,8,8,12,24,20,12,12,4,44,8,12,12,12,4,36,36,36,44,36,36,36,4,8,4,12,4,0,0,0,0
	dc.b	12,12,12,0,0,4,12,12,12,8,44,36,36,36,36,36,44,8,20,20,20,12,20,12,12,20,12,4,44,40,36,36,36,36,36,36,36,48,4,4,24,20,24,12,4,12,8,36,0,12,12,20,44,36,40,36,36,36,40,8,4,0,4,8,0,0,0,0
	dc.b	20,20,12,20,12,12,8,8,44,36,36,40,36,36,36,36,40,36,40,8,12,20,12,20,20,0,8,40,36,36,36,36,40,36,36,36,44,8,4,12,24,20,24,24,20,4,12,44,8,20,20,24,8,40,36,36,36,36,40,44,4,4,4,4,0,0,0,0
	dc.b	8,44,48,44,44,40,36,36,36,36,36,36,36,36,36,36,36,36,36,44,4,20,20,0,48,36,40,36,36,36,36,36,36,36,36,40,8,12,12,20,24,20,16,24,24,20,20,20,20,24,20,24,8,36,40,36,36,40,36,36,4,4,4,12,0,0,0,0
	dc.b	40,36,40,36,36,36,36,40,36,36,36,40,36,36,36,36,36,40,36,40,40,44,44,40,36,36,36,36,36,36,36,36,36,36,40,36,4,12,12,12,24,20,20,20,12,24,24,24,20,20,16,24,8,44,44,40,36,36,40,40,44,4,4,4,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,40,40,40,36,36,40,36,36,40,36,36,36,36,36,36,40,12,20,12,12,0,20,20,20,16,16,16,24,12,20,24,12,44,48,44,44,44,44,44,36,44,8,4,8,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,40,36,36,36,36,36,36,36,44,36,36,36,36,36,36,36,40,8,4,20,12,20,4,4,20,24,20,20,24,24,20,24,20,8,44,44,44,36,44,44,44,44,48,4,12,12,0,0,0,0
	dc.b	36,36,40,36,36,36,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,44,40,36,36,36,36,40,44,36,36,40,48,0,20,0,12,12,8,4,12,20,24,24,24,20,4,8,44,48,44,44,44,44,44,44,44,4,12,0,0,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,44,56,12,4,24,28,28,28,28,24,20,20,20,24,20,12,48,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,44,12,12,28,28,28,32,28,24,4,4,4,12,24,24,20,48,44,40,36,36,40,40,36,36,36,36,40,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,44,4,24,28,28,32,28,32,28,4,56,4,4,20,24,24,4,44,36,36,36,36,36,36,40,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,44,44,4,32,32,28,32,32,24,28,12,56,56,4,20,24,24,20,48,40,36,36,36,36,40,36,40,36,36,44,40,40,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,44,20,28,24,24,28,24,24,28,28,28,20,20,16,24,24,20,8,40,36,36,36,36,36,36,36,40,40,36,36,36,40,36,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,44,24,24,24,28,20,24,28,28,24,16,16,28,24,24,24,20,48,40,40,36,36,36,36,44,40,36,36,40,40,40,40,36,48,8,8,8,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,40,48,24,24,20,24,24,24,20,20,12,12,12,24,20,20,20,12,44,44,36,36,36,40,40,36,36,36,36,44,44,8,8,8,12,12,12,12,56,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,44,24,24,16,24,24,24,4,20,20,12,12,4,12,12,56,48,40,40,36,36,40,36,36,40,44,36,36,44,4,4,4,20,12,12,12,0,0,8,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	48,36,40,36,36,36,36,36,40,44,4,28,20,16,24,24,4,4,20,20,12,20,20,12,8,44,44,36,36,36,36,40,36,36,36,40,36,8,12,4,0,12,12,12,12,4,4,12,4,4,48,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,36,36,36,36,36,36,36,36,40,44,12,24,24,12,20,20,24,28,28,28,24,20,24,24,12,44,36,36,36,36,36,36,40,36,44,44,4,0,0,0,12,4,12,4,12,20,24,28,24,16,8,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,40,36,36,36,36,36,36,40,44,44,4,20,24,28,28,32,32,24,28,12,20,20,24,32,4,36,36,36,36,36,36,36,48,4,4,4,4,4,12,12,12,4,8,24,24,24,12,28,24,20,8,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,44,36,36,36,36,36,36,36,40,44,8,24,28,24,28,28,28,28,28,20,20,12,16,28,12,40,36,36,40,36,36,36,8,4,4,8,4,8,4,4,4,20,20,0,12,24,12,24,32,12,24,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,8,36,40,36,36,36,36,36,44,4,28,28,32,24,20,24,24,32,28,20,24,20,24,28,12,36,36,36,36,40,36,36,48,4,4,4,4,4,4,12,4,12,24,20,24,12,56,4,20,12,12,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,8,36,36,36,36,36,36,40,44,28,28,28,28,24,20,20,12,20,20,28,28,20,12,4,44,36,40,36,40,40,36,36,40,4,4,4,4,4,4,12,4,20,12,20,20,4,8,4,12,12,12,12,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	44,8,8,44,36,36,36,36,36,44,4,28,28,32,28,28,28,20,24,20,20,0,8,44,44,44,40,36,36,36,36,44,8,48,36,36,8,12,4,4,4,0,0,20,24,24,12,0,12,12,4,4,12,4,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,8,48,36,36,36,36,36,36,56,28,24,24,16,28,28,28,20,0,4,44,44,40,40,36,40,36,36,36,36,8,4,4,8,48,44,8,4,4,8,4,4,0,12,20,4,8,4,4,0,4,56,48,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	48,48,8,44,36,36,36,36,36,36,4,28,28,24,24,24,20,12,12,12,20,12,4,8,44,40,36,36,36,36,40,44,4,56,4,8,8,8,52,4,4,4,8,12,20,12,12,12,20,20,24,24,20,12,4,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	48,48,8,8,44,40,36,36,36,36,44,12,28,28,28,20,16,12,20,12,56,12,20,24,12,44,40,44,36,40,36,40,8,8,4,4,4,4,4,8,44,36,40,44,8,12,24,24,20,16,16,16,28,20,20,4,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	48,48,8,8,44,36,36,36,36,36,44,4,4,4,4,4,56,12,12,12,12,20,20,24,28,24,44,36,40,36,48,48,44,8,8,4,8,4,4,8,40,44,40,44,20,24,20,20,20,16,12,12,24,20,12,12,48,40,36,36,36,36,36,36,0,0,0,0
	dc.b	48,48,8,8,48,36,36,36,36,40,48,52,4,8,8,8,8,8,8,8,48,4,24,32,24,28,4,44,44,4,4,4,8,4,8,8,44,36,44,36,36,36,40,56,28,20,20,16,20,20,20,20,24,4,12,20,4,40,40,36,36,36,36,36,0,0,0,0
	dc.b	48,48,48,8,48,36,36,36,40,44,8,4,4,8,8,8,8,4,4,48,8,20,28,24,24,28,12,36,48,4,4,4,4,4,4,4,48,36,40,36,36,40,36,12,24,16,16,24,24,24,24,24,28,16,20,24,8,36,36,40,36,36,36,36,0,0,0,0
	dc.b	48,44,48,8,8,40,36,36,36,48,56,4,4,4,8,8,4,4,12,20,28,28,24,24,16,28,12,44,48,4,4,48,8,52,4,4,8,36,36,36,36,40,36,4,24,28,24,20,8,8,8,12,4,12,20,4,48,44,40,44,36,36,36,36,0,0,0,0
	dc.b	8,48,44,8,8,40,36,36,8,56,4,4,8,4,4,20,20,32,28,28,24,24,24,24,28,20,44,8,4,4,4,8,36,44,48,8,44,40,36,36,36,36,36,44,12,24,24,12,48,44,44,8,8,48,48,44,8,8,8,40,40,36,36,36,0,0,0,0
	dc.b	20,4,8,8,48,36,44,8,56,12,52,4,4,24,28,24,28,32,24,28,24,28,24,28,24,4,4,4,4,4,4,4,8,36,40,40,36,40,36,36,36,40,40,36,8,12,12,12,12,8,48,8,48,44,44,48,8,8,8,36,44,44,36,36,0,0,0,0
	dc.b	20,20,12,12,4,4,0,12,0,4,4,8,20,28,20,20,28,28,24,16,20,24,28,24,12,12,4,4,4,4,4,4,56,44,36,36,36,36,36,36,36,36,36,40,40,8,12,12,4,12,56,8,48,44,36,8,8,8,48,44,40,48,8,36,0,0,0,0
	dc.b	0,12,20,12,12,12,12,4,12,52,4,8,20,28,20,16,24,20,20,20,24,20,20,20,20,20,12,56,4,8,4,4,4,48,40,36,36,40,36,36,36,40,36,44,44,8,8,4,12,4,12,12,12,8,44,8,8,8,44,36,8,8,8,8,0,0,0,0
	dc.b	12,0,0,12,12,4,0,4,4,4,8,4,12,28,28,28,28,24,24,28,12,0,0,20,20,20,20,4,52,52,4,4,4,44,36,40,36,36,36,36,36,36,48,56,4,12,4,12,12,20,20,20,20,20,12,8,8,8,44,8,56,8,8,4,0,0,0,0
	dc.b	12,4,0,0,4,4,4,4,52,8,4,8,4,20,28,28,28,24,12,4,56,12,12,24,24,24,24,12,4,52,4,48,40,40,36,36,40,36,36,36,40,44,12,24,20,24,28,20,20,20,24,28,20,20,24,0,8,8,44,4,8,4,4,4,0,0,0,0
	dc.b	0,12,0,4,4,8,4,8,8,4,8,4,4,4,4,8,4,12,4,4,20,4,20,24,16,24,20,56,4,56,4,44,44,40,36,36,36,40,44,36,36,8,12,24,12,16,20,12,12,12,12,24,20,12,24,16,8,8,8,4,8,4,4,8,0,0,0,0
	dc.b	4,0,0,12,4,8,8,4,4,8,8,4,4,4,8,8,20,12,12,12,4,12,24,12,24,24,20,12,56,12,4,44,36,36,36,36,36,36,36,44,44,8,4,20,20,24,24,24,12,12,12,20,24,24,24,20,8,8,8,8,8,4,8,8,0,0,0,0
	dc.b	12,4,0,0,8,8,4,8,8,8,4,4,4,4,44,4,20,20,20,4,24,20,20,12,24,20,20,12,12,4,8,36,36,40,36,36,36,36,40,48,4,8,8,0,20,28,24,24,24,20,20,16,28,28,24,4,48,8,4,4,4,8,48,44,0,0,0,0
	dc.b	0,0,0,8,4,8,8,4,4,4,4,4,4,44,40,12,24,24,28,28,24,20,12,20,20,4,12,12,4,8,40,36,36,36,36,36,44,36,36,8,8,8,8,8,48,8,12,20,24,24,24,20,16,0,8,44,36,48,8,8,8,8,48,8,0,0,0,0
	dc.b	4,4,4,4,8,4,4,8,4,4,4,4,44,36,44,12,24,20,24,24,24,20,20,20,12,12,20,12,8,36,36,36,40,36,36,36,36,40,8,8,4,20,20,12,12,8,44,4,12,0,12,48,44,36,36,44,36,36,36,4,8,4,12,4,0,0,0,0
	dc.b	0,12,4,4,4,8,4,4,12,12,8,36,36,40,36,8,28,24,20,20,20,24,20,20,12,20,12,12,44,36,40,36,40,36,36,36,40,44,8,12,20,20,20,12,12,4,48,44,12,12,12,12,44,40,36,36,36,40,40,8,8,12,4,8,0,0,0,0
	dc.b	0,4,4,4,12,0,4,12,4,48,40,36,36,36,36,44,12,28,28,28,24,20,20,12,12,20,4,44,36,36,36,36,36,40,36,36,44,8,4,4,24,20,24,12,4,4,4,44,4,12,20,20,4,36,36,36,36,36,40,44,4,4,4,4,0,0,0,0
	dc.b	12,12,12,12,20,12,4,44,36,40,36,36,36,36,36,36,44,8,8,12,12,12,12,16,20,8,44,40,36,36,36,36,36,36,36,40,8,4,12,20,24,20,24,24,12,0,4,8,44,24,16,20,4,36,40,36,36,36,36,36,52,4,4,4,0,0,0,0
	dc.b	12,56,12,8,48,44,40,36,36,40,40,40,36,36,36,40,36,36,40,8,20,20,20,0,44,36,36,40,36,40,36,36,36,36,36,36,12,12,12,12,24,20,20,20,20,20,20,20,24,24,20,20,12,44,44,44,44,40,36,36,44,8,4,8,0,0,0,0
	dc.b	36,40,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,44,8,48,40,36,36,36,36,36,36,40,36,36,36,40,40,4,12,12,12,20,24,20,20,12,28,24,24,20,20,20,20,12,48,44,44,44,44,44,36,44,4,4,8,0,0,0,0
	dc.b	40,40,40,36,40,36,36,36,36,36,36,36,40,40,36,36,36,36,36,36,36,36,40,40,36,36,36,36,36,36,36,40,36,36,36,8,12,12,12,12,4,20,20,20,20,16,16,24,20,20,20,20,8,44,44,44,44,44,44,44,44,4,4,0,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,40,36,36,40,8,4,20,0,20,4,4,20,24,20,20,24,24,20,20,24,4,44,44,44,44,44,44,44,44,4,12,12,0,0,0,0,0
	dc.b	36,36,36,36,36,36,40,44,48,12,20,12,0,24,28,28,32,28,28,28,28,28,20,16,4,36,40,36,36,40,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,48,16,12,20,28,28,28,28,28,28,28,28,32,28,24,24,4,40,36,36,36,36,36,36,36,40,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,40,44,48,12,20,28,28,24,32,24,24,24,20,20,20,24,28,24,12,44,36,36,36,36,36,36,36,40,36,36,36,36,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,36,36,36,44,4,28,28,24,28,24,20,24,16,0,0,20,24,24,24,24,8,36,36,36,36,36,36,40,36,40,36,40,44,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,40,44,44,20,24,24,24,24,20,24,28,24,28,20,12,20,24,24,24,12,40,36,36,36,36,36,36,40,36,36,36,36,36,40,36,36,36,36,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,8,24,24,20,24,24,24,28,28,20,24,24,24,28,24,24,20,4,40,40,36,36,36,36,36,44,36,36,36,36,40,36,40,36,8,4,4,8,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,40,44,4,24,24,20,20,24,28,28,20,12,16,16,20,24,20,20,20,8,44,40,36,36,36,36,40,40,36,36,36,44,8,4,8,4,20,16,12,12,12,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,40,4,28,20,20,24,28,12,20,16,12,12,16,20,20,12,16,4,44,40,36,36,36,36,36,36,36,44,36,36,8,56,4,0,16,12,20,0,12,4,4,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,36,48,24,24,20,24,28,20,4,20,16,12,12,4,12,12,4,44,40,36,40,36,36,36,36,36,36,36,40,44,12,4,4,12,12,0,12,12,4,4,12,4,4,48,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,36,36,44,40,4,28,20,16,20,12,4,0,20,20,12,20,20,16,12,8,44,44,40,36,36,36,36,36,40,44,48,44,12,4,4,12,0,0,12,4,12,12,24,24,24,24,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,40,36,36,36,36,36,40,36,44,56,24,20,16,12,16,24,28,28,28,28,16,20,24,24,4,36,36,40,36,36,36,40,44,52,4,4,4,4,4,12,4,0,12,8,28,24,20,12,28,24,24,8,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,40,40,36,36,44,44,4,12,20,28,28,28,28,32,28,24,16,20,20,28,24,44,36,36,36,40,36,36,44,4,4,4,4,4,8,12,4,4,12,12,0,16,24,12,24,24,20,24,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	48,36,40,36,36,36,36,40,36,44,44,4,20,28,28,24,32,28,32,28,32,16,16,20,24,24,48,40,36,36,36,36,40,44,8,4,12,8,4,4,0,0,4,12,20,20,20,12,12,12,16,16,20,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,36,36,36,36,36,36,44,44,44,8,28,28,28,20,16,12,20,20,24,24,28,24,20,24,12,44,36,36,40,36,36,40,36,8,4,4,0,4,4,4,12,12,0,12,16,24,4,8,4,12,12,12,12,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,44,36,36,36,36,36,36,40,48,28,28,32,28,24,20,20,16,16,20,28,28,24,0,8,44,36,36,40,36,40,8,8,44,36,8,4,4,4,4,4,12,12,20,24,20,0,12,12,12,4,0,12,4,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,48,36,36,36,36,36,36,44,4,28,32,28,28,28,24,16,24,24,20,0,44,44,44,44,44,40,36,36,40,44,4,4,4,48,48,48,4,4,8,4,4,12,12,12,20,12,8,4,4,4,4,12,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,44,36,36,36,36,44,44,56,28,32,16,20,28,28,28,24,16,4,48,44,44,44,40,40,36,36,36,36,44,8,4,4,4,8,8,8,4,4,4,52,48,12,20,20,12,4,12,16,20,20,12,4,8,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,44,40,36,36,36,36,44,4,28,28,24,20,28,20,12,0,12,12,12,12,4,48,44,36,36,36,36,36,40,8,8,4,4,4,4,4,4,48,36,40,40,8,8,0,20,24,24,20,20,20,28,24,20,4,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,8,48,36,36,36,36,36,36,48,20,28,28,28,20,16,16,12,12,12,56,12,20,24,4,44,40,36,40,44,44,48,8,8,8,8,4,4,4,44,36,44,36,44,4,28,20,20,16,16,12,16,20,16,12,20,8,36,36,36,36,36,36,36,0,0,0,0
	dc.b	48,8,8,36,36,40,36,36,44,44,4,4,12,12,0,12,4,12,12,12,16,20,24,32,28,12,44,44,8,4,4,8,4,8,8,48,44,40,44,40,36,36,40,8,24,20,20,20,20,20,20,16,20,12,12,16,4,40,36,40,36,36,36,36,0,0,0,0
	dc.b	48,48,8,44,36,36,36,36,44,8,52,4,8,8,8,8,8,8,48,44,8,12,32,24,24,28,8,44,4,4,12,8,4,4,4,8,40,36,40,36,36,36,36,12,24,20,20,20,20,20,16,24,28,20,12,20,4,44,40,40,36,36,36,36,0,0,0,0
	dc.b	8,8,8,44,36,36,40,36,48,4,4,8,8,8,8,8,4,4,48,44,52,28,28,24,16,28,8,44,8,4,8,8,4,4,4,4,44,36,36,36,36,36,40,12,24,16,24,24,20,16,12,16,20,12,20,20,8,44,40,44,36,36,36,36,0,0,0,0
	dc.b	48,8,8,44,40,36,36,44,4,4,4,4,4,8,8,4,4,12,12,16,28,28,24,20,24,24,48,8,4,4,8,40,40,8,8,8,36,36,36,36,36,36,36,8,24,24,24,12,48,44,44,8,8,8,48,48,48,8,48,36,40,40,36,36,0,0,0,0
	dc.b	48,48,8,44,40,36,44,4,4,4,8,8,8,4,12,16,16,32,28,32,28,28,24,24,28,12,8,4,4,0,12,48,36,36,40,40,40,36,36,36,36,36,36,36,8,20,20,12,4,48,48,48,48,44,44,48,44,8,48,40,44,44,36,36,0,0,0,0
	dc.b	8,8,8,36,36,44,8,12,4,4,8,8,12,28,24,28,32,28,24,32,28,24,24,28,24,4,4,4,4,4,4,0,8,40,36,36,36,36,36,36,36,36,36,40,44,4,16,12,12,12,8,8,8,44,36,8,8,8,44,44,44,48,8,36,0,0,0,0
	dc.b	12,4,4,4,4,56,12,0,4,4,4,12,28,32,16,24,28,32,24,20,24,28,28,20,12,20,4,4,8,4,12,4,4,44,36,36,40,36,40,36,36,36,40,40,44,8,0,12,12,4,12,12,8,44,44,8,8,8,44,40,8,8,8,8,0,0,0,0
	dc.b	16,16,16,12,12,12,12,4,4,4,8,20,28,20,20,28,24,16,16,20,24,24,20,20,16,20,0,4,4,8,4,12,8,44,36,36,36,36,36,40,40,44,44,44,8,44,48,8,12,12,12,0,12,12,4,8,8,8,40,8,4,8,8,4,0,0,0,0
	dc.b	12,12,12,12,12,0,4,4,4,8,8,12,28,24,28,28,24,20,24,28,20,12,20,20,20,20,12,4,8,52,8,8,36,36,36,36,36,36,40,36,36,48,8,16,16,16,20,20,16,20,20,24,24,24,24,12,8,44,44,4,8,4,8,4,0,0,0,0
	dc.b	0,4,12,4,4,4,4,8,8,4,8,0,24,28,28,28,28,28,20,0,0,12,20,20,20,24,16,12,4,12,8,36,44,40,36,40,36,36,44,36,40,8,12,24,16,20,20,20,20,20,20,24,24,16,16,20,52,8,8,4,8,4,8,8,0,0,0,0
	dc.b	4,12,4,4,4,4,8,4,4,8,4,8,4,20,16,16,16,0,4,12,12,12,24,20,20,28,16,0,0,12,4,44,36,36,36,36,36,40,36,44,44,8,12,24,16,16,24,16,12,12,12,20,20,16,20,20,4,8,8,4,8,4,8,44,0,0,0,0
	dc.b	12,4,4,8,8,8,4,4,8,8,4,4,4,8,44,12,12,12,16,12,4,16,16,16,24,20,16,0,4,12,8,36,36,36,36,36,36,40,40,8,8,8,8,20,20,24,24,24,20,12,12,20,24,28,24,20,8,44,8,4,8,8,44,40,0,0,0,0
	dc.b	4,12,4,4,4,8,8,4,4,8,0,12,8,44,48,20,16,20,12,0,20,20,16,12,28,16,16,12,12,8,36,40,36,36,36,40,44,36,8,8,8,8,8,8,12,24,28,24,24,24,16,20,28,32,20,4,40,48,8,8,8,8,48,8,0,0,0,0
	dc.b	4,4,4,8,4,8,4,8,4,8,12,8,44,36,8,24,20,24,20,24,24,12,12,20,20,12,20,12,4,36,36,36,36,36,36,36,36,36,8,8,8,8,12,4,8,8,4,16,20,24,24,20,12,4,48,44,36,44,48,8,8,8,4,4,0,0,0,0
	dc.b	12,4,8,8,4,8,4,4,0,12,4,44,36,40,4,24,24,24,28,24,20,16,20,20,12,12,16,12,44,40,36,36,36,36,36,36,40,8,4,4,0,20,20,16,12,8,36,8,12,0,12,8,44,36,40,36,36,36,40,8,8,0,4,8,0,0,0,0
	dc.b	12,4,4,4,4,4,4,4,56,8,44,36,36,40,8,24,20,24,16,20,20,24,20,16,12,16,12,44,40,36,36,36,36,40,36,36,44,8,4,8,16,20,20,12,12,12,8,44,56,12,12,16,4,36,36,36,36,40,36,44,8,4,4,4,0,0,0,0
	dc.b	4,4,4,4,4,0,12,12,8,44,36,40,40,36,44,16,24,24,24,24,24,20,16,12,16,12,8,44,36,36,36,36,36,36,36,36,4,4,0,12,24,20,24,16,0,4,56,48,8,16,12,20,12,44,40,40,40,36,40,36,4,4,4,4,0,0,0,0
	dc.b	12,4,12,12,12,56,8,44,36,36,36,36,40,40,36,44,12,20,20,20,16,12,12,16,12,48,36,36,36,40,36,36,36,40,36,36,4,4,12,12,20,12,24,28,20,0,12,8,44,16,20,20,16,48,44,44,44,44,40,36,4,8,4,8,0,0,0,0
	dc.b	16,16,12,4,8,36,40,36,40,36,40,36,36,40,36,36,40,44,44,16,16,20,20,12,44,36,36,36,40,36,36,40,36,40,36,8,12,12,12,0,24,20,16,20,20,24,24,20,24,24,16,20,20,48,44,44,44,44,44,36,44,4,4,48,0,0,0,0
	dc.b	8,48,44,40,40,36,40,36,36,36,36,40,36,36,40,36,40,36,40,8,12,4,44,36,36,36,36,36,36,36,40,36,36,36,36,8,4,16,12,12,16,20,16,16,16,20,24,24,20,16,16,24,12,44,44,44,44,44,44,44,44,8,4,4,0,0,0,0
	dc.b	40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,40,36,40,36,36,36,36,36,36,44,36,36,40,8,12,12,12,12,0,20,20,16,16,16,20,24,20,16,20,20,4,44,44,44,44,44,44,44,8,12,12,4,0,0,0,0
	dc.b	36,40,36,36,40,36,44,8,20,20,20,0,12,20,32,28,28,32,28,28,28,20,12,4,36,36,36,40,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,44,52,16,16,12,20,32,28,28,32,32,28,28,32,32,28,24,4,44,44,40,36,36,40,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,40,36,40,44,44,4,12,12,28,28,28,24,28,24,24,28,32,28,28,28,28,16,44,36,36,36,36,36,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,40,36,40,44,48,16,28,28,28,24,20,20,24,28,24,12,24,28,24,28,24,4,36,36,40,36,36,36,40,36,36,36,36,36,44,40,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,40,36,48,20,28,24,24,24,20,24,24,24,24,20,16,20,24,24,28,16,44,40,36,36,36,36,36,36,36,36,40,36,40,40,36,36,36,36,40,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,36,36,36,40,36,44,8,28,24,20,24,24,24,28,28,24,24,24,24,24,20,24,24,16,44,40,36,36,36,36,36,36,44,36,36,36,36,36,44,40,44,8,12,4,4,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,40,44,56,28,24,20,24,28,28,28,12,12,12,12,20,28,24,24,24,12,44,40,40,36,36,36,36,40,36,36,40,36,48,4,52,8,4,20,20,12,12,4,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,36,36,40,36,36,44,12,28,20,20,20,28,24,20,12,12,12,12,16,20,20,20,20,44,44,40,36,36,36,36,36,36,40,44,40,48,56,4,4,12,16,12,12,0,12,4,4,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,40,44,56,28,20,16,24,32,16,24,12,12,20,12,20,20,20,12,8,44,36,36,40,36,36,36,36,36,36,36,40,8,12,4,4,16,0,4,12,4,0,0,0,4,4,48,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,36,48,28,24,20,24,20,4,12,20,12,0,0,4,4,4,48,44,36,40,36,36,40,36,36,36,40,44,48,48,4,4,4,0,12,4,12,12,8,12,12,24,24,24,20,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,40,44,4,28,24,16,20,12,4,12,16,16,12,16,20,20,16,12,8,40,40,40,36,36,36,36,36,8,4,4,4,12,4,12,12,4,4,4,4,24,24,16,12,24,20,24,8,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,36,36,36,36,36,40,44,44,4,20,20,12,12,12,16,28,28,28,28,28,12,20,28,24,8,36,40,36,36,36,36,36,8,4,4,4,4,4,4,12,4,4,12,4,12,16,24,12,24,20,24,24,40,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,36,36,36,36,36,40,40,44,48,56,12,16,24,28,28,32,28,24,28,24,16,16,24,28,0,36,36,40,36,36,36,36,8,4,4,4,8,4,8,12,4,4,20,24,20,16,16,16,20,20,20,20,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,36,40,36,40,48,52,12,28,28,24,28,28,32,32,32,28,16,16,24,28,12,44,36,36,36,40,40,36,44,4,4,4,4,4,4,0,12,4,0,20,20,24,4,8,12,12,12,12,12,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,40,36,36,36,36,36,40,44,48,24,32,28,20,16,16,20,16,20,20,24,28,20,24,20,8,36,36,36,40,44,8,44,40,36,8,4,4,4,4,4,0,16,24,20,20,12,4,12,12,0,12,12,4,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,40,40,44,44,20,32,28,32,20,16,20,20,12,20,20,28,28,16,4,44,40,40,36,36,40,8,4,4,8,44,44,8,12,4,8,4,4,0,12,16,20,4,8,4,4,4,0,4,48,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	44,40,36,36,36,36,40,36,4,28,28,28,32,28,20,20,20,24,24,20,4,48,44,44,36,36,36,36,36,36,8,4,4,4,8,8,8,52,4,4,4,8,8,20,20,20,12,4,4,4,12,12,4,8,8,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	48,36,40,40,36,40,36,44,20,28,28,24,12,32,28,28,28,20,0,4,8,44,40,40,40,36,36,36,36,40,44,8,4,12,8,8,4,4,8,44,40,36,40,4,0,0,12,12,20,24,20,24,24,24,12,4,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	8,40,40,36,36,36,36,44,12,28,32,20,20,28,28,16,12,12,12,12,16,12,4,48,36,40,36,36,40,36,36,8,8,8,8,4,4,4,8,40,36,44,36,44,8,20,24,24,20,16,12,16,24,20,20,20,8,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,44,36,36,36,40,40,44,8,28,28,28,32,24,16,12,12,12,4,0,12,16,28,20,4,44,36,44,4,4,8,8,8,8,8,44,48,40,44,36,40,36,40,44,12,28,20,20,20,20,16,20,20,12,0,16,12,44,40,40,36,36,36,36,0,0,0,0
	dc.b	8,48,36,36,36,36,40,40,8,4,12,20,20,12,12,12,0,12,12,20,20,20,28,28,28,8,40,8,4,12,4,8,4,4,4,44,36,36,36,36,36,36,36,4,24,20,20,20,16,20,20,20,24,16,0,20,12,44,40,40,36,36,36,36,0,0,0,0
	dc.b	8,48,36,36,40,36,36,44,4,4,4,8,8,8,8,8,4,48,44,44,4,24,28,20,28,20,44,8,8,4,8,8,4,4,4,8,36,36,36,36,36,36,36,12,24,20,20,24,24,24,24,24,24,20,20,28,4,44,40,44,36,36,36,36,0,0,0,0
	dc.b	8,48,36,36,36,40,44,8,4,52,52,8,8,48,8,4,8,48,44,44,0,32,28,20,24,24,44,8,4,8,44,44,8,4,8,44,36,36,36,36,36,36,40,4,24,24,24,24,12,8,8,4,8,8,8,8,48,8,48,40,40,36,36,36,0,0,0,0
	dc.b	8,8,40,36,36,36,44,4,4,4,8,8,8,8,8,4,4,4,56,20,28,28,20,20,32,20,4,4,4,4,8,44,40,44,36,40,36,36,40,36,36,40,36,44,12,24,20,12,8,40,48,48,48,44,48,48,44,8,44,36,44,44,36,36,0,0,0,0
	dc.b	48,8,36,36,36,44,56,0,52,4,8,8,8,0,12,16,16,28,28,28,32,24,24,24,24,4,52,4,4,4,4,8,40,36,36,36,36,36,36,40,36,36,36,36,8,12,16,12,12,4,8,8,48,44,44,8,8,48,44,44,48,48,8,36,0,0,0,0
	dc.b	8,48,36,36,48,4,12,4,4,8,8,4,20,24,24,28,28,28,32,28,28,24,28,28,20,4,4,4,8,4,4,4,48,40,36,36,36,36,40,36,36,36,44,36,48,8,12,12,0,12,12,4,8,36,44,8,8,48,36,40,8,8,8,8,0,0,0,0
	dc.b	8,8,8,8,12,12,4,4,52,8,4,24,28,32,28,28,28,28,20,24,28,24,28,20,12,12,4,52,8,8,4,4,44,36,36,36,36,40,36,40,36,44,44,44,48,44,8,4,12,12,4,12,12,4,48,48,8,44,40,8,4,8,8,4,0,0,0,0
	dc.b	20,12,16,12,4,4,4,4,8,8,12,28,24,16,16,32,20,12,20,24,24,28,24,16,16,20,4,4,12,8,4,4,40,40,40,36,36,36,36,36,40,48,8,8,8,8,48,8,4,0,12,12,12,20,24,4,8,48,44,4,8,4,4,8,0,0,0,0
	dc.b	12,12,12,4,4,4,4,8,8,4,12,28,24,20,32,24,20,20,28,28,20,12,20,16,20,20,12,4,4,4,44,36,44,40,36,36,36,36,44,40,48,48,4,20,20,20,24,20,20,20,24,20,24,20,24,24,4,48,8,8,8,4,8,8,0,0,0,0
	dc.b	4,0,0,4,4,4,8,4,4,4,0,28,28,28,32,28,24,28,28,16,12,12,24,20,20,24,12,4,12,56,8,44,36,36,36,40,36,36,36,44,48,48,12,24,16,16,24,16,20,16,20,20,24,12,20,20,12,48,8,4,8,8,44,44,0,0,0,0
	dc.b	12,4,4,4,4,8,4,4,8,4,4,16,28,28,28,28,28,16,12,12,12,12,24,24,24,24,12,12,4,56,40,40,36,40,36,36,36,36,40,8,8,8,4,24,16,16,24,20,20,12,12,12,24,20,24,24,12,44,8,8,8,44,44,40,0,0,0,0
	dc.b	56,4,4,4,4,8,8,52,4,8,4,4,4,0,16,16,0,12,12,0,0,16,20,20,24,20,12,12,4,44,40,36,36,40,40,36,44,36,8,4,8,8,8,12,20,24,24,24,24,20,12,16,20,32,20,20,4,44,8,8,8,48,44,56,0,0,0,0
	dc.b	4,4,4,8,4,8,4,8,4,8,4,52,44,44,56,16,12,20,4,4,20,20,12,20,28,20,16,12,4,36,40,36,36,40,36,36,36,8,8,8,8,8,8,8,0,20,24,28,24,24,20,24,24,28,20,4,36,36,48,8,8,8,56,4,0,0,0,0
	dc.b	4,8,4,8,4,8,4,8,4,4,4,44,44,44,20,20,24,20,12,20,20,12,16,20,20,12,12,12,44,36,36,36,36,36,36,36,40,8,8,4,8,4,12,0,4,48,8,4,20,24,24,16,12,4,8,36,44,40,36,8,8,4,4,8,0,0,0,0
	dc.b	8,8,8,8,4,4,4,4,56,4,44,36,40,44,24,20,24,24,28,28,20,12,20,20,0,20,12,8,36,36,40,36,36,36,36,36,44,4,8,8,12,24,16,12,12,4,44,44,12,12,12,12,44,36,36,40,36,36,40,44,4,4,4,4,0,0,0,0
	dc.b	4,4,4,8,4,4,4,4,4,44,40,40,40,48,24,16,24,24,20,24,16,20,24,12,12,16,4,44,36,36,36,36,36,36,36,36,4,8,4,4,20,20,20,20,4,4,4,44,8,12,12,12,12,40,40,36,40,40,40,36,4,8,4,56,0,0,0,0
	dc.b	4,4,4,4,4,12,12,4,44,36,40,40,36,36,20,24,20,20,20,24,24,20,16,12,20,12,44,36,36,36,36,36,36,36,36,40,8,4,4,16,24,20,20,20,12,4,12,8,44,12,20,20,16,48,44,44,44,44,44,36,8,8,4,8,0,0,0,0
	dc.b	4,4,4,4,12,56,8,40,40,36,36,36,36,40,4,24,28,24,24,24,20,12,12,16,56,44,36,36,36,36,36,40,36,40,36,8,4,12,12,12,20,16,20,20,20,12,4,0,44,12,20,20,20,48,44,44,40,40,44,40,8,8,4,8,0,0,0,0
	dc.b	12,12,12,12,8,44,40,36,36,36,36,40,40,36,44,48,4,12,20,12,20,16,20,4,40,36,36,36,36,36,36,36,36,36,36,8,12,12,12,0,24,16,16,20,20,24,24,20,24,24,20,16,24,8,44,44,44,44,40,44,48,8,8,4,0,0,0,0
	dc.b	20,0,8,44,36,36,40,36,40,36,36,36,36,36,40,40,36,40,8,16,20,20,8,40,36,40,36,36,36,36,40,44,36,40,36,8,4,20,0,0,16,20,12,20,12,20,24,28,20,20,16,20,20,44,44,44,44,44,44,44,48,56,12,4,0,0,0,0
	dc.b	36,40,36,40,44,44,12,20,20,20,16,0,0,20,32,28,28,32,28,24,12,12,4,44,36,36,40,36,36,40,36,36,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,40,36,36,40,44,12,20,16,16,16,20,28,28,28,32,32,28,32,28,28,20,12,44,40,36,36,36,36,36,36,36,40,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,36,36,36,44,44,16,20,16,20,32,28,28,24,28,28,24,32,28,28,28,28,16,44,36,40,40,36,36,36,36,40,36,36,40,36,36,36,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,36,36,40,40,44,12,12,24,28,28,24,20,20,20,24,32,28,28,28,32,28,28,12,40,40,40,36,40,36,36,36,36,36,36,36,36,44,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,40,36,40,40,4,24,28,24,24,24,20,20,20,28,28,20,12,24,20,24,28,20,44,36,40,36,36,36,36,36,36,36,36,36,40,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,40,36,40,36,40,8,28,28,24,32,28,24,24,28,28,28,28,24,20,24,28,24,24,8,40,36,36,36,36,36,36,36,44,40,36,36,40,44,44,40,8,0,0,12,4,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,36,44,12,28,24,24,24,24,28,28,20,16,20,12,12,24,28,24,28,20,8,40,40,36,36,36,36,36,36,40,36,36,44,4,4,4,8,20,20,16,12,0,4,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,36,36,40,36,44,24,24,20,20,24,28,28,16,0,12,12,12,16,20,20,24,24,12,44,36,40,36,36,36,36,36,36,36,44,36,4,56,4,4,16,16,12,0,12,0,4,8,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,36,36,36,40,48,24,32,20,20,24,24,24,12,12,12,0,12,12,16,20,24,12,44,36,36,36,40,36,36,36,36,36,36,36,44,12,4,4,0,16,0,12,12,12,12,4,0,8,4,48,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,36,36,36,40,44,20,32,20,20,24,24,20,16,12,12,16,20,20,16,12,8,44,44,36,36,40,36,36,40,36,36,36,8,8,48,4,4,4,4,0,4,4,12,8,4,12,24,24,20,24,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,36,36,36,40,44,4,28,24,16,16,20,12,16,20,4,4,4,8,48,48,48,48,44,40,40,40,40,36,36,40,36,44,4,4,4,0,4,4,4,0,4,0,4,4,24,20,20,16,24,20,20,8,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,36,36,36,40,40,44,12,24,24,16,16,0,12,12,20,16,12,12,24,20,20,20,12,48,44,36,40,36,36,36,36,48,4,8,4,4,4,8,12,12,4,0,4,4,16,20,24,12,24,20,20,20,44,36,40,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,36,44,44,0,24,20,16,12,12,12,20,32,32,32,32,16,16,24,32,16,44,40,40,36,36,36,36,44,4,4,12,8,4,4,4,12,0,0,20,24,12,16,20,20,20,20,24,20,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,40,36,36,36,40,36,8,4,0,12,20,24,28,32,28,28,28,28,20,16,20,24,24,44,40,36,40,36,36,40,40,8,4,4,4,4,4,4,12,4,4,0,20,24,24,4,8,12,4,12,12,56,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,40,36,36,36,36,36,44,8,4,4,24,28,28,28,24,24,28,28,32,24,16,24,28,24,48,36,36,36,44,8,8,36,40,8,4,4,4,4,12,4,4,20,20,12,20,12,4,4,4,12,0,12,8,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,40,36,36,36,36,40,44,8,12,28,28,20,16,16,16,16,16,20,20,28,24,20,24,4,44,36,40,36,8,8,8,8,44,44,8,4,4,8,4,4,4,16,16,20,28,4,8,4,4,0,4,4,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,40,36,36,36,40,36,44,12,28,28,28,28,20,16,20,12,16,20,28,28,24,4,44,44,40,36,40,40,48,4,4,4,4,8,44,8,4,4,4,8,8,8,16,16,20,12,4,4,4,4,4,8,44,44,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,36,40,40,44,4,28,28,28,28,32,20,20,20,20,24,28,16,8,44,40,44,36,36,36,36,40,36,8,4,4,8,8,4,4,4,48,36,36,36,48,12,16,16,12,4,12,20,20,24,24,20,12,4,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,36,36,36,36,36,44,20,32,32,20,20,20,28,32,28,28,20,12,44,44,40,36,44,36,36,40,36,36,40,44,8,8,4,4,4,4,52,44,36,40,44,40,44,8,0,20,24,24,20,20,20,24,20,16,20,8,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,36,36,36,36,36,44,20,28,28,20,16,32,28,24,16,12,12,12,12,20,12,48,44,40,36,36,44,8,8,48,8,8,8,44,44,8,36,44,36,36,36,36,40,4,28,24,24,16,16,20,16,20,20,12,16,12,44,40,36,36,36,36,36,0,0,0,0
	dc.b	40,40,40,36,40,40,44,12,28,32,28,28,24,20,12,12,12,12,0,0,12,20,28,12,48,40,48,4,12,4,4,4,4,4,8,40,36,40,36,40,36,36,36,8,24,24,16,20,20,20,20,16,20,20,0,12,20,44,40,40,36,36,36,36,0,0,0,0
	dc.b	40,36,40,36,36,40,44,4,12,28,28,24,20,12,16,16,12,12,12,20,20,20,24,28,20,44,48,4,8,4,8,8,4,52,4,36,36,36,36,36,36,40,36,12,24,20,20,20,16,20,20,24,28,24,20,24,12,44,40,44,36,36,36,36,0,0,0,0
	dc.b	40,36,36,36,36,40,8,52,8,4,4,8,8,8,8,8,44,44,48,4,20,28,28,20,28,4,44,8,8,44,44,8,8,4,8,40,40,36,36,36,36,36,36,12,24,20,20,24,24,20,20,12,12,4,4,4,8,48,48,40,40,36,36,36,0,0,0,0
	dc.b	44,40,36,40,36,44,52,4,4,4,8,8,8,52,4,8,44,44,44,44,12,28,24,20,32,12,8,4,4,8,36,36,44,48,36,36,36,36,36,36,36,36,40,8,20,24,24,20,8,8,44,48,44,44,44,48,48,48,44,40,36,44,36,36,0,0,0,0
	dc.b	44,40,36,36,36,8,4,4,8,8,8,8,8,8,4,4,4,4,4,16,28,28,20,20,28,12,4,4,4,12,8,44,40,40,40,36,36,36,36,36,36,36,36,44,4,20,20,16,4,8,48,8,48,40,44,8,8,44,40,44,44,8,8,36,0,0,0,0
	dc.b	44,40,40,40,8,4,4,4,8,8,8,4,8,12,20,16,12,20,32,28,24,28,24,24,28,4,52,4,4,4,4,8,40,36,40,36,36,36,36,36,40,40,44,44,48,4,16,12,12,12,12,8,48,36,48,8,8,44,40,8,8,8,8,8,0,0,0,0
	dc.b	48,36,36,48,4,56,4,4,8,8,8,4,16,20,16,20,28,28,28,32,24,24,28,28,12,4,4,48,8,4,4,8,44,40,36,40,36,36,36,36,40,40,44,44,48,48,8,12,0,12,12,12,4,48,48,8,8,44,40,8,8,8,8,4,0,0,0,0
	dc.b	48,44,8,12,12,4,4,8,4,8,12,28,28,28,28,32,28,28,24,20,32,32,28,24,20,4,4,4,8,4,4,8,40,36,36,36,36,36,36,40,44,8,8,48,48,44,44,8,4,4,0,0,12,12,12,8,44,44,48,8,8,4,8,8,0,0,0,0
	dc.b	12,12,12,0,4,4,8,4,8,4,28,32,24,20,28,24,20,20,20,20,28,28,24,12,20,12,8,52,4,48,44,36,44,40,36,36,36,36,44,36,8,44,8,56,4,8,8,8,8,0,12,12,12,20,28,24,4,48,8,8,8,8,8,44,0,0,0,0
	dc.b	12,12,4,4,4,4,4,4,4,12,28,24,20,20,24,20,16,24,24,24,28,20,20,20,20,16,12,4,12,8,40,44,36,40,36,36,36,40,36,48,48,44,8,24,20,20,28,24,24,24,24,28,28,16,16,20,20,44,8,8,4,8,44,36,0,0,0,0
	dc.b	0,0,4,4,4,8,4,4,8,12,32,28,24,28,28,24,28,28,28,24,16,12,20,20,20,20,0,4,56,8,44,36,40,36,36,36,36,36,40,8,8,8,12,24,20,12,24,16,16,16,12,20,24,12,20,20,20,44,8,8,8,48,36,44,0,0,0,0
	dc.b	4,4,4,4,4,8,8,4,4,4,24,28,28,28,28,32,28,32,20,12,12,16,24,20,24,24,0,0,4,48,40,36,36,40,36,40,44,36,8,8,8,8,8,20,16,16,24,24,20,20,4,12,20,24,24,24,20,8,8,8,8,44,44,4,0,0,0,0
	dc.b	4,4,4,8,4,8,4,8,4,4,0,28,28,28,28,24,16,16,12,4,12,20,20,20,24,20,12,0,4,36,36,36,36,40,36,40,36,8,8,8,8,8,48,12,24,28,24,20,24,20,12,12,16,28,32,24,4,36,48,8,8,8,4,4,0,0,0,0
	dc.b	4,8,4,8,4,4,8,8,4,4,8,48,4,0,16,12,12,12,4,4,16,20,12,24,24,16,12,4,44,40,36,36,36,36,36,40,48,8,8,8,8,48,8,8,8,16,24,28,24,24,24,24,24,28,20,8,44,40,44,8,8,4,8,8,0,0,0,0
	dc.b	8,8,8,8,4,8,8,4,0,4,48,44,44,4,20,16,20,0,12,16,20,12,16,24,20,16,16,52,36,40,36,36,36,36,36,36,48,4,4,8,8,16,16,16,12,8,48,8,12,16,24,20,12,8,44,44,40,36,40,48,8,4,4,4,0,0,0,0
	dc.b	4,8,8,8,4,4,4,8,4,8,36,40,44,12,20,20,24,16,24,24,12,12,20,24,12,20,56,44,40,36,36,36,36,36,36,36,4,8,4,8,12,20,16,12,12,4,8,40,8,12,4,12,4,36,40,40,36,40,40,36,4,8,4,4,0,0,0,0
	dc.b	8,8,4,8,8,12,12,12,48,36,40,40,44,16,20,20,24,28,24,20,12,16,24,12,12,16,48,36,36,36,36,36,40,36,36,8,4,4,4,12,20,16,20,20,0,4,56,48,48,16,12,12,12,44,44,36,44,44,44,40,8,8,4,48,0,0,0,0
	dc.b	4,4,4,4,12,12,4,48,36,40,40,40,44,16,24,20,20,20,20,20,20,24,16,12,16,8,40,36,40,36,36,36,36,36,40,8,4,4,4,16,28,16,20,20,12,4,4,4,40,12,20,16,20,4,44,44,36,40,44,44,8,8,4,8,0,0,0,0
	dc.b	4,4,12,4,12,8,40,36,40,40,36,36,36,4,28,24,20,20,28,24,24,12,12,16,4,40,40,36,36,36,36,36,36,36,40,4,12,4,12,0,24,16,20,24,20,12,0,0,8,12,20,16,20,12,44,44,40,44,40,44,44,8,8,4,0,0,0,0
	dc.b	0,4,12,12,8,40,36,36,36,36,40,40,36,44,16,28,28,28,24,20,12,16,16,12,40,36,36,36,36,36,36,44,40,36,44,4,4,12,12,0,20,16,16,16,20,24,24,24,20,24,20,16,24,8,44,44,40,44,44,44,48,4,4,4,0,0,0,0
	dc.b	40,36,36,40,48,24,20,20,20,20,12,12,20,20,16,20,24,20,12,12,12,12,44,40,40,40,40,40,40,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,40,40,40,4,24,20,20,16,12,12,24,24,32,28,28,28,32,28,24,12,12,44,40,40,40,40,40,40,36,36,36,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,40,36,44,4,20,20,12,12,20,28,28,28,28,28,28,32,28,32,28,28,20,8,36,40,40,40,40,40,36,36,36,36,40,36,40,40,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,40,40,40,4,24,12,20,28,28,28,20,20,24,20,24,28,28,28,32,28,28,12,44,40,40,40,40,36,36,36,36,36,40,40,36,36,44,40,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,36,44,48,12,20,28,28,24,24,20,16,20,20,32,28,24,24,24,24,28,28,8,40,40,40,40,36,36,36,36,40,36,36,36,40,36,36,36,40,44,44,44,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,40,40,44,44,4,28,28,32,28,32,16,20,24,28,28,28,24,16,24,24,24,24,4,40,40,40,40,36,36,36,36,36,44,36,36,40,44,48,44,44,8,4,12,12,4,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,36,40,40,44,20,28,24,32,28,28,24,28,28,28,24,20,20,24,24,24,24,28,0,40,40,40,40,36,36,36,36,36,40,36,44,8,4,4,4,0,20,20,16,0,4,4,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,40,40,40,48,28,24,24,24,24,28,28,24,20,20,12,12,12,20,24,24,28,24,8,40,40,40,40,36,36,36,36,40,36,44,48,56,4,4,4,20,12,12,0,0,12,4,8,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,40,40,4,28,24,20,24,24,28,20,0,4,4,12,4,12,12,20,20,24,56,44,40,40,36,36,40,36,36,40,40,36,40,8,12,4,4,12,12,12,20,12,56,0,12,4,8,4,8,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,40,44,4,28,24,20,24,24,28,12,12,20,12,12,12,12,20,24,20,4,44,40,36,40,40,40,36,40,40,36,44,8,8,8,4,4,4,12,0,4,12,4,8,4,12,24,24,24,24,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,40,40,36,8,28,24,16,24,24,24,20,0,56,0,12,12,12,4,8,48,44,40,40,40,36,40,40,36,36,36,44,8,4,4,4,12,4,0,12,0,12,12,8,12,24,20,20,20,24,20,20,8,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,40,40,40,44,20,28,16,20,20,24,20,20,12,4,4,4,48,44,48,48,8,44,44,36,40,40,36,40,36,36,44,4,8,4,8,4,4,8,12,4,4,4,8,4,20,20,24,12,16,20,24,20,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,40,40,36,44,20,32,20,12,12,12,12,20,20,20,20,12,12,24,20,24,20,4,44,40,40,36,36,36,36,44,8,12,4,4,8,4,8,4,12,4,12,20,20,12,12,16,20,20,24,24,20,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,36,40,40,40,44,44,20,24,24,12,12,4,12,12,24,28,32,28,28,20,20,32,28,8,36,40,40,36,40,36,40,48,4,4,4,4,4,4,4,12,4,4,12,24,24,24,12,4,4,12,12,12,4,44,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,40,36,40,40,40,44,4,56,12,20,20,20,28,28,32,28,32,32,24,20,20,24,28,12,44,40,36,40,8,8,44,36,8,8,4,4,4,4,56,12,4,12,12,12,20,20,0,12,4,4,4,12,8,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,40,36,36,40,40,44,4,48,52,12,28,28,24,24,28,28,28,28,24,16,16,24,28,12,44,36,36,44,4,4,8,44,44,44,4,4,4,8,4,0,12,20,24,24,20,0,8,4,4,0,12,4,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,40,36,36,40,40,44,4,12,32,32,24,20,20,12,20,12,20,20,24,28,32,24,12,48,40,40,40,44,4,8,4,4,8,48,8,4,4,4,4,8,48,4,12,12,20,12,4,4,4,4,4,44,36,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,40,36,40,36,40,44,12,28,28,28,20,20,20,20,12,20,12,20,32,32,20,4,44,40,44,40,36,36,8,4,4,4,8,4,8,4,8,44,40,36,40,8,20,20,20,12,4,4,12,12,12,12,12,4,8,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	36,40,36,36,40,44,4,28,28,28,28,24,20,12,20,20,20,24,28,12,8,44,44,44,40,36,36,36,40,44,8,8,52,4,4,12,4,8,40,36,36,44,40,8,4,0,12,12,20,24,24,24,28,24,20,20,8,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,36,40,40,36,44,24,32,28,28,16,24,24,28,28,24,28,20,4,48,44,44,40,40,40,40,40,8,48,48,8,48,8,8,44,8,8,36,44,36,40,36,40,36,0,20,28,24,20,20,20,12,24,20,12,20,12,44,40,40,36,36,36,36,0,0,0,0
	dc.b	36,40,36,40,40,48,28,28,24,16,12,24,28,32,28,24,12,12,12,20,12,4,48,44,40,44,8,4,12,4,8,4,8,8,44,40,36,36,36,36,36,36,40,44,4,28,24,16,20,20,20,12,20,24,12,12,20,8,36,40,36,36,36,36,0,0,0,0
	dc.b	36,40,40,36,40,44,24,32,32,24,24,28,28,16,12,0,4,4,0,12,12,24,20,8,36,44,8,4,4,4,4,4,4,4,48,40,36,36,36,36,36,36,36,8,24,24,20,12,12,20,20,20,24,24,12,20,20,48,40,44,40,36,36,36,0,0,0,0
	dc.b	40,40,36,36,44,48,12,28,28,32,28,20,20,20,20,12,20,12,12,20,20,16,24,32,4,36,8,4,8,48,8,8,4,4,44,36,36,40,36,36,36,40,40,12,24,16,24,24,16,24,20,24,24,20,20,20,56,44,48,40,40,36,36,36,0,0,0,0
	dc.b	40,40,36,40,40,8,4,4,20,4,12,4,4,4,4,48,48,8,4,20,28,32,20,28,24,8,8,8,8,44,36,44,44,8,40,40,36,36,36,36,36,36,40,4,24,24,20,24,24,12,12,8,48,44,48,48,48,44,44,40,44,48,36,36,0,0,0,0
	dc.b	36,36,40,36,48,4,4,4,8,8,8,4,8,4,8,44,40,40,36,44,24,28,20,24,32,4,52,56,4,4,44,40,40,36,36,36,36,36,40,36,36,36,40,48,20,24,24,20,4,48,44,48,44,40,48,48,48,44,36,44,8,8,8,36,0,0,0,0
	dc.b	36,36,36,44,4,4,4,8,8,8,8,4,4,8,8,48,4,52,4,12,28,24,16,24,28,4,52,4,4,12,8,44,40,36,36,36,36,36,36,40,36,36,40,48,8,12,16,12,12,56,8,8,44,44,48,8,48,36,40,8,8,48,8,8,0,0,0,0
	dc.b	40,40,40,4,4,4,4,4,8,8,8,8,8,12,20,12,12,12,28,28,28,24,24,24,24,4,8,52,4,4,4,44,36,36,36,36,36,36,36,36,40,44,44,44,44,48,4,12,4,12,12,56,8,48,48,8,48,44,36,8,8,8,8,8,0,0,0,0
	dc.b	40,36,8,4,4,4,8,8,8,4,4,4,20,20,12,0,20,28,28,32,32,24,28,28,0,52,8,48,8,4,4,48,40,40,36,36,36,40,40,36,48,8,8,8,48,44,44,56,12,12,0,12,12,12,8,8,48,44,8,8,8,4,8,44,0,0,0,0
	dc.b	44,52,12,4,4,4,4,8,8,8,20,24,20,20,20,28,28,28,24,24,24,28,28,24,4,4,52,4,8,8,8,40,44,40,36,36,40,36,44,8,8,48,8,48,44,44,44,44,8,12,0,0,12,12,24,20,8,48,8,8,8,8,48,40,0,0,0,0
	dc.b	12,12,12,4,4,4,8,4,4,12,28,28,28,32,28,32,28,24,24,24,28,28,28,12,20,4,4,4,52,44,36,44,36,36,36,36,36,40,40,48,8,44,48,12,12,12,8,8,4,0,12,20,20,16,24,24,20,44,8,8,52,48,44,36,0,0,0,0
	dc.b	12,12,4,4,4,4,4,4,4,28,28,24,20,24,24,16,16,16,20,24,28,28,20,20,20,12,56,56,56,44,44,36,36,36,40,40,36,36,40,8,8,44,8,24,24,20,28,24,24,24,24,24,28,20,20,16,24,8,8,8,8,44,40,44,0,0,0,0
	dc.b	4,4,4,4,8,8,8,4,0,28,28,16,20,28,24,24,24,24,24,28,24,20,20,20,24,12,4,4,4,44,40,40,36,36,36,36,44,8,8,8,8,48,12,24,16,12,24,16,12,12,12,12,20,20,20,20,24,4,8,8,8,44,44,4,0,0,0,0
	dc.b	4,4,4,8,8,8,52,4,56,28,32,24,28,32,24,28,32,28,28,20,12,20,20,24,24,12,4,4,8,36,40,36,36,36,36,36,36,8,8,8,8,8,8,20,20,20,24,24,24,20,0,12,20,24,28,24,20,48,48,8,8,8,4,4,0,0,0,0
	dc.b	4,4,4,8,52,4,8,8,4,28,32,32,32,28,24,32,28,20,12,4,0,20,24,20,24,20,12,56,44,36,36,36,36,36,40,36,8,8,8,8,8,8,44,4,24,28,24,16,20,24,20,12,20,24,28,28,4,40,44,8,8,4,4,8,0,0,0,0
	dc.b	4,8,8,8,8,4,8,4,4,12,24,28,28,28,28,16,20,0,4,0,12,20,20,24,24,12,12,8,36,36,36,40,40,36,36,36,8,4,8,4,8,8,4,4,4,12,28,24,28,24,24,24,28,24,20,8,44,44,40,44,52,4,8,4,0,0,0,0
	dc.b	4,8,8,8,8,4,4,4,52,48,48,4,12,20,12,12,20,4,4,12,24,12,20,28,24,12,12,44,40,36,36,36,36,36,36,40,8,8,8,8,8,20,20,12,12,4,44,8,12,20,20,20,12,8,44,44,40,40,40,36,8,8,4,8,0,0,0,0
	dc.b	8,8,8,4,52,4,4,4,48,36,40,44,4,20,20,20,12,4,20,20,20,12,24,24,12,20,8,40,36,36,36,36,36,40,36,8,4,4,4,4,12,20,20,12,0,0,4,44,44,0,12,12,12,44,44,40,44,44,44,40,8,8,4,48,0,0,0,0
	dc.b	4,8,4,4,4,56,12,8,44,40,40,36,4,24,20,24,20,24,24,20,12,12,24,12,12,4,44,36,40,40,40,40,36,40,40,8,8,4,4,0,24,12,20,20,12,4,4,8,36,12,12,12,20,8,44,44,36,40,44,44,8,8,4,48,0,0,0,0
	dc.b	8,4,4,4,56,12,8,36,40,36,40,36,12,24,20,24,24,24,20,20,12,24,20,12,12,44,40,36,36,36,36,36,36,36,44,4,12,4,12,12,20,20,24,20,12,4,4,4,48,8,24,12,20,56,44,44,36,44,36,44,44,8,8,8,0,0,0,0
	dc.b	4,4,4,0,12,8,40,40,40,40,36,40,4,24,20,20,16,20,24,20,24,20,12,20,8,40,40,36,36,36,36,44,36,36,8,4,0,0,0,0,24,12,20,24,20,12,0,12,48,8,24,16,20,12,44,44,36,44,44,44,44,8,4,12,0,0,0,0
	dc.b	40,40,44,4,24,20,16,20,20,16,20,20,12,12,16,12,12,0,12,12,12,48,40,40,40,40,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,40,44,12,24,16,20,20,16,16,12,4,0,16,24,28,28,28,16,12,12,8,40,40,40,40,40,40,40,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,40,44,20,20,20,16,12,12,20,24,28,28,28,32,28,32,28,28,28,16,8,44,40,40,40,40,40,40,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,40,48,16,20,12,16,20,32,28,28,28,24,24,20,24,28,28,28,32,28,12,44,40,40,40,40,40,36,36,36,36,36,40,36,36,36,44,40,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,36,44,12,20,12,20,28,28,20,16,24,20,20,20,28,32,28,32,20,32,28,4,40,40,40,40,40,36,36,36,36,36,36,36,36,40,36,36,40,36,44,44,8,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,40,36,4,16,24,28,32,28,24,16,20,24,16,28,28,28,20,28,24,24,28,20,44,40,40,40,40,36,36,36,36,36,44,36,40,44,8,48,44,48,12,4,12,12,4,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,40,44,44,16,28,32,28,28,32,28,20,24,28,28,28,28,24,24,24,24,28,20,48,40,40,40,40,36,36,36,36,36,40,36,48,4,4,4,4,12,16,20,0,0,12,4,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,40,44,8,28,28,24,28,32,28,32,32,32,28,20,12,12,16,24,28,24,32,16,44,40,40,40,40,36,36,36,36,36,36,40,4,12,4,4,12,20,12,12,0,12,0,12,44,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,40,44,0,28,24,24,24,24,28,28,24,12,0,0,12,12,12,16,20,28,24,4,40,40,40,36,40,36,36,40,36,40,40,44,12,12,4,4,12,12,4,16,12,12,0,4,4,8,4,48,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,40,44,20,28,16,20,24,32,28,16,12,12,12,0,0,12,12,20,20,24,12,44,36,40,40,36,36,36,36,36,40,8,8,48,4,12,4,4,12,4,4,12,4,8,4,12,24,24,24,24,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,40,44,20,32,20,16,24,32,20,4,12,20,12,12,12,16,12,16,12,48,36,40,36,36,40,40,36,36,36,36,8,4,4,4,4,4,4,4,12,4,4,0,8,4,20,20,20,20,20,16,12,8,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,40,44,12,28,24,20,24,28,24,12,4,4,4,4,12,4,48,44,44,44,44,40,40,40,40,40,36,40,36,40,8,8,4,8,4,12,8,4,12,4,12,4,8,12,24,24,24,12,24,20,20,20,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,36,40,8,28,28,20,20,20,20,20,20,12,4,4,4,8,48,44,44,8,8,44,40,40,40,40,40,36,36,36,48,4,4,4,8,4,4,8,0,12,0,12,20,12,12,12,20,20,20,24,20,20,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,36,40,44,4,28,24,20,20,16,12,12,20,20,16,12,12,20,20,24,24,24,20,8,40,36,40,36,36,40,36,40,8,4,4,56,4,4,4,12,12,0,12,16,24,24,20,0,12,4,12,12,16,4,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,40,40,40,44,8,20,28,24,12,12,12,12,16,20,32,28,28,28,20,20,24,32,24,48,40,40,36,44,8,44,36,40,8,56,8,4,4,12,4,0,12,0,12,12,20,20,12,4,4,12,4,12,8,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,40,40,40,36,44,4,4,20,20,12,20,24,28,32,28,28,32,28,16,20,20,28,32,8,36,36,40,8,4,8,48,44,44,8,12,4,8,4,4,0,0,20,24,24,20,12,8,4,4,0,12,4,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,40,40,40,40,48,8,8,8,4,20,28,32,24,24,32,28,28,28,20,20,24,28,24,8,40,36,40,8,4,4,4,8,48,48,8,4,4,4,4,8,8,12,12,16,20,12,4,4,4,0,4,44,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,40,36,40,48,4,4,12,28,32,20,20,16,16,12,20,16,24,32,28,24,24,4,44,44,40,40,44,4,4,4,8,4,4,4,8,44,44,36,36,40,8,20,20,20,12,4,4,4,8,8,4,8,8,8,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	36,40,40,40,44,48,4,24,28,28,20,20,20,20,20,12,12,20,24,28,28,16,8,44,44,40,36,36,40,48,8,8,4,4,4,4,4,44,40,40,36,44,48,12,4,12,12,4,4,20,24,24,28,20,20,20,8,40,36,36,36,36,36,36,0,0,0,0
	dc.b	36,40,36,40,44,8,28,32,32,32,24,16,12,16,12,16,20,24,24,20,4,44,40,40,40,40,40,44,40,48,8,8,8,48,8,8,48,40,44,36,36,40,40,36,12,12,20,24,24,20,16,20,24,24,12,20,20,44,40,40,36,36,36,36,0,0,0,0
	dc.b	36,40,40,36,44,16,28,32,32,24,28,24,24,32,24,28,28,24,4,48,40,40,40,40,36,48,4,4,4,8,4,8,4,48,36,40,36,36,36,36,36,36,36,44,4,24,24,20,20,16,16,16,20,24,20,12,24,8,40,40,36,36,36,36,0,0,0,0
	dc.b	36,36,40,44,8,28,28,32,20,16,24,28,28,32,28,20,16,12,20,16,0,8,44,40,40,8,4,4,4,8,4,4,4,8,40,40,36,40,36,36,36,36,36,48,20,24,16,16,16,20,20,20,16,24,20,12,24,4,40,44,36,36,36,36,0,0,0,0
	dc.b	40,40,40,40,4,28,32,24,20,16,28,32,28,24,12,0,12,0,12,12,20,24,12,48,36,8,4,4,8,8,8,4,4,8,40,36,36,36,36,36,36,40,36,4,24,24,20,20,16,20,20,16,24,28,24,24,20,48,48,36,40,40,36,36,0,0,0,0
	dc.b	40,40,40,44,8,28,28,32,28,20,28,24,20,20,20,12,12,12,12,12,20,20,32,20,48,48,8,8,48,44,44,48,8,8,36,40,36,36,36,36,36,36,40,0,24,20,24,24,24,24,24,20,12,8,8,8,44,44,44,40,48,48,36,36,0,0,0,0
	dc.b	36,40,40,44,4,12,24,28,28,20,12,0,12,56,8,8,4,4,20,24,28,24,24,32,12,8,4,4,8,44,40,40,40,36,40,36,36,36,36,36,36,36,44,8,24,24,24,20,12,8,8,48,36,44,8,48,48,44,36,48,8,8,8,36,0,0,0,0
	dc.b	36,36,40,8,4,8,8,0,8,8,8,8,8,8,44,40,36,44,44,12,28,24,20,24,20,4,4,4,4,4,40,40,40,40,36,40,36,36,36,40,40,40,44,44,12,20,24,16,12,8,8,44,44,44,48,48,48,40,40,8,48,48,8,8,0,0,0,0
	dc.b	40,40,44,4,4,4,4,4,4,8,8,4,4,48,44,44,8,8,8,20,28,20,20,28,20,4,4,4,4,4,8,36,40,40,36,36,36,36,40,40,40,44,44,44,44,4,16,12,12,12,12,4,8,44,48,8,48,44,8,8,8,8,8,48,0,0,0,0
	dc.b	36,40,8,12,4,4,8,8,8,4,4,8,4,4,12,12,12,12,24,28,32,24,20,28,12,44,44,4,4,4,4,40,40,36,36,40,36,36,40,48,48,8,8,48,44,40,8,12,12,12,12,12,16,8,8,48,48,40,8,8,8,8,48,40,0,0,0,0
	dc.b	44,8,12,4,4,8,8,8,8,8,8,12,20,20,4,4,12,24,28,28,20,32,28,28,12,4,4,48,8,4,8,40,44,40,36,36,36,40,44,8,8,8,48,48,48,44,40,8,12,12,0,4,12,16,16,0,8,48,8,8,8,8,40,40,0,0,0,0
	dc.b	4,12,4,4,4,8,8,8,8,4,20,24,16,0,12,24,28,28,32,24,20,32,32,24,4,4,4,52,48,44,36,44,36,36,36,36,36,36,44,48,8,44,48,8,8,44,36,40,44,8,0,12,0,12,24,28,20,8,8,8,8,44,40,40,0,0,0,0
	dc.b	12,0,4,4,8,4,8,4,4,20,28,24,16,24,28,28,28,32,24,28,32,28,28,16,0,4,4,12,8,40,44,36,36,40,36,36,36,40,48,8,8,40,48,20,20,12,12,12,0,12,12,20,24,24,20,20,20,8,44,8,8,40,40,44,0,0,0,0
	dc.b	0,4,4,4,8,8,8,4,20,28,28,28,28,28,24,20,20,20,20,20,28,24,16,20,20,4,4,4,8,36,36,36,36,36,36,36,44,8,8,8,8,8,8,20,20,16,24,24,24,20,20,20,24,20,12,20,24,12,8,8,48,44,8,4,0,0,0,0
	dc.b	0,4,4,4,4,8,4,4,24,28,24,20,24,24,20,24,24,24,24,24,28,16,16,20,24,12,4,4,8,40,36,36,36,36,40,36,48,8,8,8,8,8,4,20,20,12,20,20,20,12,56,16,20,24,20,24,20,4,8,8,48,8,4,8,0,0,0,0
	dc.b	4,4,4,8,8,4,8,12,32,28,24,20,32,28,20,24,24,24,28,24,12,24,20,20,24,12,4,4,44,36,40,36,36,36,40,40,8,8,8,8,8,48,8,20,20,20,24,20,24,20,12,0,12,24,28,28,20,8,44,8,8,4,8,8,0,0,0,0
	dc.b	4,8,8,8,8,4,8,12,32,32,24,28,28,20,32,24,28,24,20,4,12,24,20,20,24,12,56,48,40,36,36,40,36,36,36,44,8,8,8,8,8,8,8,8,20,28,24,24,24,24,20,16,16,16,28,24,12,44,40,44,4,8,8,4,0,0,0,0
	dc.b	4,8,4,8,8,52,4,4,24,28,28,32,28,32,28,28,24,4,4,4,16,16,20,24,24,12,4,44,36,40,36,36,36,36,36,48,4,4,8,8,8,4,12,0,4,12,20,24,24,24,24,24,24,28,20,4,40,36,40,44,8,8,4,8,0,0,0,0
	dc.b	8,8,8,4,8,4,4,4,4,20,28,28,28,28,24,16,12,4,12,12,20,20,20,28,20,12,4,36,40,36,36,40,36,36,40,8,4,4,4,4,4,20,16,12,12,0,8,8,12,20,20,16,12,8,44,40,44,44,40,44,8,8,8,44,0,0,0,0
	dc.b	4,8,4,8,4,4,56,8,44,48,4,4,16,12,16,20,4,4,12,20,20,12,24,24,12,12,48,36,36,36,36,40,36,36,40,4,8,4,4,4,20,16,20,12,12,4,4,8,36,0,12,12,12,48,44,44,40,40,40,44,8,8,8,48,0,0,0,0
	dc.b	8,4,4,4,4,4,8,44,40,44,44,44,20,16,20,20,0,16,28,16,12,20,28,12,12,8,40,40,36,36,36,36,36,36,8,8,4,4,4,12,20,20,20,16,0,4,4,4,48,56,16,12,20,4,44,44,36,44,44,40,48,8,8,8,0,0,0,0
	dc.b	4,8,4,4,4,12,44,40,40,40,40,4,24,16,24,24,24,28,16,20,12,20,24,12,12,44,36,40,36,36,36,44,36,36,8,4,4,4,12,12,24,12,20,20,12,0,4,12,48,8,16,16,20,12,44,44,36,44,44,44,44,8,12,12,0,0,0,0
	dc.b	40,44,20,24,20,20,20,20,20,20,20,12,12,20,16,12,20,20,20,20,48,40,40,36,40,40,40,40,40,36,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	44,48,24,20,20,16,16,20,20,16,16,12,4,4,12,16,12,12,0,12,4,40,40,40,40,40,40,40,40,36,36,36,40,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	44,4,28,16,12,20,20,20,16,16,24,28,28,28,28,28,28,28,20,12,8,44,40,36,40,40,40,40,40,36,36,36,36,36,40,36,36,36,40,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	44,4,24,16,20,12,20,20,20,28,28,24,24,24,28,32,32,28,32,28,12,44,36,40,40,40,40,40,36,36,36,36,36,40,36,36,36,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,4,28,12,12,20,20,28,28,28,16,20,16,20,20,28,28,28,32,32,28,12,44,40,40,40,40,40,36,36,36,36,36,36,36,36,36,36,36,40,36,44,8,8,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,48,20,16,16,28,32,24,16,20,16,20,20,20,32,28,32,28,32,28,28,24,44,40,40,40,40,40,36,36,36,36,36,44,40,36,8,8,48,44,8,12,12,12,12,4,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,44,56,20,28,32,32,28,24,20,24,20,20,24,28,32,24,20,24,24,32,24,8,40,40,40,40,40,36,36,36,36,40,36,36,4,4,4,4,4,20,20,16,0,4,12,8,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,44,48,28,28,28,24,32,32,28,20,24,28,32,32,28,24,24,28,24,28,28,8,40,40,40,40,40,36,36,36,36,36,36,8,56,4,4,4,20,20,12,12,0,12,4,56,48,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	44,44,12,28,24,24,32,28,24,32,32,28,28,20,12,12,12,20,28,24,24,20,8,36,40,40,36,36,36,36,40,40,40,36,8,12,4,4,4,20,4,12,12,4,0,4,4,8,8,4,48,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,44,24,28,24,24,24,24,28,28,20,12,4,4,12,0,12,20,16,24,24,12,44,40,40,40,40,36,36,36,36,48,8,8,8,12,4,12,4,12,12,12,12,8,4,8,12,24,24,24,24,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,8,32,28,20,20,24,32,28,12,12,12,4,12,0,12,12,20,24,12,4,40,40,40,40,40,40,36,40,40,44,8,4,4,4,4,8,4,12,12,4,12,4,44,4,24,20,20,20,20,16,20,8,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	44,8,28,24,20,20,32,32,20,4,12,12,20,12,20,12,12,12,8,44,44,36,40,40,36,40,40,40,36,36,44,4,8,4,8,4,4,8,4,12,12,12,4,8,12,24,24,20,12,20,20,16,16,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,48,28,28,20,20,28,32,24,0,8,8,8,4,4,8,44,44,44,44,40,40,40,36,40,40,40,40,40,36,44,4,4,4,4,8,4,8,4,12,0,4,12,12,12,12,16,20,20,20,20,20,20,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,44,12,28,24,24,20,24,20,24,16,12,0,8,4,8,44,44,48,48,8,8,44,40,36,40,40,36,40,40,36,8,4,4,4,4,4,4,8,12,12,0,0,20,20,20,20,12,12,4,12,20,16,4,44,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,36,8,20,28,24,16,16,12,20,20,16,16,20,16,12,16,20,20,20,28,28,12,44,40,40,36,40,44,48,36,40,8,4,4,4,4,4,12,4,12,4,0,0,20,28,24,4,4,4,4,4,56,8,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,40,44,48,12,32,24,20,20,12,12,12,0,16,20,28,32,32,28,16,24,24,28,12,44,40,36,8,4,4,8,40,44,8,4,4,4,8,4,12,4,0,20,24,16,20,12,8,4,4,56,56,4,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,40,40,44,48,4,12,24,24,20,12,16,24,28,28,32,28,32,24,20,20,24,28,20,44,36,40,8,8,8,4,8,48,44,8,4,4,4,4,8,8,4,12,16,20,20,12,4,4,4,12,8,44,40,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,36,40,40,8,8,8,8,8,0,28,28,28,28,32,28,28,28,32,20,24,28,28,12,44,44,40,44,8,4,4,8,8,4,4,8,8,44,44,40,40,36,4,16,20,20,12,4,0,4,8,44,48,48,8,44,36,44,36,36,36,36,36,36,0,0,0,0
	dc.b	36,40,36,40,8,8,8,8,20,28,28,20,20,12,12,16,20,20,24,32,28,28,20,48,40,40,36,40,48,8,8,4,8,4,4,4,8,40,40,36,36,44,8,20,20,12,12,8,48,8,12,16,24,20,16,16,8,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,36,40,44,8,8,0,28,28,24,20,20,20,20,12,12,16,20,24,28,32,12,48,44,40,40,40,36,44,8,8,8,8,8,4,8,44,40,44,40,36,36,40,48,0,20,12,12,20,24,24,24,24,20,20,20,24,44,40,36,36,36,36,36,0,0,0,0
	dc.b	36,40,40,44,8,12,28,28,28,20,16,16,20,12,12,12,16,32,28,20,8,44,40,40,36,8,8,8,8,8,8,8,8,40,36,40,36,36,36,36,36,36,36,44,12,12,24,24,20,16,20,16,20,24,16,12,20,4,40,40,36,36,36,36,0,0,0,0
	dc.b	40,40,40,44,12,32,32,32,28,28,24,20,20,20,24,24,32,20,4,48,40,44,36,40,44,4,4,4,8,8,4,4,4,44,36,40,36,36,36,36,36,40,36,44,4,24,24,16,16,20,16,20,16,20,20,12,24,0,40,44,36,36,36,36,0,0,0,0
	dc.b	40,36,44,8,28,32,28,28,20,28,28,28,28,32,28,28,20,12,12,4,8,44,44,40,8,8,8,4,4,4,4,8,4,48,40,40,36,36,36,36,36,36,36,8,24,24,20,16,20,20,12,16,20,24,24,20,24,8,40,40,40,40,36,36,0,0,0,0
	dc.b	36,40,44,4,32,32,28,20,20,28,32,32,28,32,20,12,56,12,12,20,24,20,8,40,44,8,4,8,40,44,8,8,8,44,40,40,36,40,36,36,36,36,40,12,24,20,24,24,20,20,24,24,28,20,16,0,8,44,40,40,8,8,36,36,0,0,0,0
	dc.b	40,44,36,0,28,32,32,20,20,28,28,28,20,16,12,12,12,0,12,12,20,24,28,4,48,8,8,8,44,40,40,40,40,36,40,36,36,36,40,36,36,40,44,0,24,20,20,24,28,20,12,4,8,48,48,48,48,44,36,8,48,48,8,44,0,0,0,0
	dc.b	40,40,48,12,28,28,32,28,24,24,20,20,12,12,12,4,12,20,24,20,24,20,24,24,4,4,4,4,4,44,40,36,36,40,36,36,36,36,40,36,40,36,44,8,16,24,24,20,4,8,48,48,40,44,48,8,44,40,44,8,8,48,8,44,0,0,0,0
	dc.b	40,44,8,8,0,20,28,20,12,8,4,8,8,44,40,44,44,48,12,28,28,20,24,32,12,4,4,4,4,8,44,40,36,40,36,36,36,40,36,40,36,44,44,44,8,12,20,12,12,12,4,8,44,48,8,8,48,44,8,8,8,8,48,40,0,0,0,0
	dc.b	40,48,4,4,4,8,8,4,8,8,8,8,48,40,44,44,48,48,44,24,32,16,20,32,0,8,8,4,4,4,48,40,40,36,36,40,36,36,36,48,8,8,8,48,44,48,4,20,0,4,12,12,0,8,48,48,44,44,8,8,8,8,44,40,0,0,0,0
	dc.b	44,4,4,4,4,8,8,8,8,8,8,8,44,4,56,12,12,12,24,28,32,20,20,32,4,48,48,8,4,4,44,40,44,40,36,36,36,40,48,8,8,8,8,8,48,40,44,8,12,12,12,0,12,20,56,8,48,48,8,8,8,44,36,40,0,0,0,0
	dc.b	4,4,4,4,8,8,8,8,8,8,8,12,20,12,0,4,4,20,28,28,32,28,24,24,4,4,8,48,48,44,36,44,36,36,36,36,36,40,48,48,44,44,8,48,8,44,40,44,8,4,12,56,12,12,20,24,12,44,8,8,48,40,40,36,0,0,0,0
	dc.b	12,12,4,4,8,8,8,4,4,4,20,20,12,12,4,12,24,32,32,24,24,28,28,20,8,4,4,4,44,40,44,36,36,36,36,40,36,36,48,8,44,36,44,8,4,8,44,40,40,44,48,56,0,12,24,24,24,4,8,8,48,36,40,8,0,0,0,0
	dc.b	4,4,4,8,8,8,8,4,4,24,20,20,4,12,20,28,28,32,28,24,24,28,32,16,4,4,12,4,44,40,36,40,36,36,40,36,44,8,8,8,8,48,8,20,20,20,20,16,20,12,20,20,28,24,16,20,20,12,8,8,48,44,8,8,0,0,0,0
	dc.b	12,4,8,8,4,8,4,4,24,32,24,16,20,32,28,24,24,20,20,28,32,28,16,20,12,4,4,56,44,40,36,36,36,36,36,36,8,8,8,8,8,8,4,24,20,12,24,24,20,20,20,20,20,24,16,20,24,20,8,48,48,4,8,8,0,0,0,0
	dc.b	4,4,8,8,8,4,8,20,28,28,28,28,28,28,20,20,20,24,16,24,32,20,20,24,20,0,4,8,40,40,36,36,36,36,36,48,8,8,8,48,8,48,4,24,20,12,24,20,20,20,12,12,12,24,24,24,20,12,48,48,8,8,8,8,0,0,0,0
	dc.b	4,8,8,8,8,52,4,24,28,28,24,20,28,24,20,24,24,24,24,28,28,16,16,20,20,0,56,48,40,36,36,36,36,36,36,48,8,8,8,8,8,48,48,20,24,24,24,20,24,20,20,0,12,20,24,28,24,8,40,44,8,8,8,52,0,0,0,0
	dc.b	4,8,4,8,8,4,0,28,28,20,24,28,32,24,20,20,24,28,24,12,16,20,16,24,20,0,8,44,36,36,36,36,36,36,36,8,8,8,8,8,8,8,8,8,16,28,24,20,20,24,24,16,16,24,28,24,56,40,40,48,8,8,8,8,0,0,0,0
	dc.b	8,8,8,4,8,4,4,28,32,24,28,28,24,32,32,32,28,24,12,4,20,20,20,24,24,0,8,40,40,36,36,36,36,36,36,8,4,8,8,8,8,4,16,12,12,4,20,24,24,24,28,24,24,24,16,8,44,36,40,48,8,8,8,40,0,0,0,0
	dc.b	8,4,8,8,4,8,4,24,28,28,32,32,28,28,32,28,20,4,4,4,20,20,24,24,20,4,8,36,36,36,36,40,36,36,8,8,8,4,4,4,0,20,12,12,4,0,8,8,4,20,20,12,20,8,44,44,36,40,44,44,8,8,4,44,0,0,0,0
	dc.b	8,4,8,4,4,4,8,8,28,28,28,28,28,32,24,0,4,0,4,20,20,16,24,24,20,4,36,40,36,36,40,40,36,36,8,8,4,4,4,4,20,20,20,20,12,4,4,8,48,4,12,0,12,12,44,44,40,44,44,40,48,8,8,8,0,0,0,0
	dc.b	8,8,4,4,4,12,48,44,44,12,16,28,16,12,12,4,12,4,20,20,12,20,28,16,12,44,40,36,36,36,40,40,36,40,8,4,12,4,4,12,20,12,20,20,0,4,0,12,48,8,20,12,12,16,44,44,36,44,44,44,44,8,4,12,0,0,0,0
	dc.b	8,24,20,20,16,16,20,20,24,20,20,16,20,20,20,20,20,20,20,8,36,40,36,40,40,40,40,40,40,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,24,20,20,16,20,24,24,20,16,20,20,8,12,12,12,12,20,20,4,40,40,40,40,40,40,40,40,40,36,36,36,36,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,20,16,16,12,20,24,16,4,4,4,12,12,16,24,20,20,12,0,4,44,40,36,40,40,40,40,40,40,36,36,36,36,36,40,40,36,36,44,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	28,20,20,20,20,20,16,16,12,20,28,32,28,28,32,32,28,28,24,4,44,40,40,36,40,40,40,40,36,36,36,36,36,36,36,36,40,44,36,36,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,20,16,12,12,20,20,28,28,32,24,20,24,24,24,24,28,32,28,28,8,44,36,40,40,40,40,40,36,36,36,36,36,36,40,36,36,40,40,40,44,8,8,8,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,20,16,12,16,28,28,24,24,16,20,24,20,20,28,28,28,28,32,28,28,8,36,36,40,40,40,40,36,36,36,36,40,44,40,8,8,52,44,44,4,12,12,12,12,4,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,24,12,20,32,28,32,20,20,20,20,24,20,24,28,28,24,32,24,32,28,12,40,40,40,40,40,40,36,36,36,36,36,40,8,4,4,4,4,12,20,16,4,0,12,12,8,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,12,20,32,32,32,28,24,20,24,20,20,24,28,32,28,20,24,24,32,28,12,44,40,40,40,40,40,36,36,36,36,40,36,4,56,4,4,4,20,12,12,0,0,12,4,4,40,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	44,0,28,28,28,20,24,28,32,24,24,28,28,32,32,24,20,28,28,24,28,0,36,40,40,40,40,36,36,36,36,40,40,44,4,12,4,4,4,12,4,12,16,12,56,4,4,8,8,4,48,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	48,24,28,24,28,32,32,28,32,28,28,24,20,12,12,12,16,24,24,28,24,8,44,36,40,36,40,36,36,36,48,8,4,48,4,4,4,4,0,12,0,16,12,8,4,8,12,20,24,24,24,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	0,28,24,20,24,24,32,28,28,20,12,0,4,4,12,12,12,20,24,20,12,36,36,40,40,40,36,40,36,44,8,4,4,4,4,4,4,4,12,4,4,12,4,44,4,20,16,20,20,28,20,20,8,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,32,24,20,20,24,32,28,20,12,12,12,4,12,12,16,20,20,12,48,44,40,44,36,36,40,40,36,40,40,8,8,8,4,8,4,8,4,12,12,4,12,4,8,20,24,24,20,12,20,20,20,20,36,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	28,28,24,20,20,28,28,0,4,12,12,12,12,12,12,4,52,48,40,44,40,40,40,40,40,36,40,40,36,40,8,4,4,4,8,4,4,8,12,4,12,4,0,0,0,16,16,24,20,20,20,16,20,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,28,24,24,24,28,28,20,4,8,52,4,4,52,8,44,40,44,40,40,40,44,40,40,36,40,40,36,40,36,48,4,8,4,4,4,4,4,4,20,12,56,12,24,24,12,12,12,16,0,12,20,16,4,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,32,28,24,24,24,24,28,24,16,12,4,4,52,52,44,44,44,48,8,8,44,40,40,44,36,40,44,8,36,36,8,4,4,4,4,4,4,4,4,12,0,4,0,20,24,24,4,4,4,8,12,12,8,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	44,12,32,28,24,20,20,12,20,20,16,20,20,16,12,12,12,16,20,24,28,24,4,40,40,40,44,8,8,8,44,40,48,8,4,4,8,4,56,12,12,4,20,20,12,20,20,4,4,56,0,12,8,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	44,44,12,28,28,24,20,12,12,20,12,12,12,12,24,28,28,28,20,20,28,28,28,48,40,40,48,4,8,4,4,48,44,48,4,4,4,4,4,8,8,4,16,24,24,20,12,4,4,4,12,8,40,40,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	40,40,44,4,12,20,24,24,20,20,12,12,20,28,32,28,32,28,20,20,20,28,28,4,44,44,40,8,4,4,4,8,8,4,8,8,8,48,44,40,36,40,4,12,16,20,4,4,12,4,48,44,40,44,44,44,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	40,40,44,4,8,8,4,4,0,12,28,28,28,32,32,32,32,28,20,20,32,28,28,52,40,36,40,44,8,4,4,8,8,12,4,4,44,36,40,40,36,44,4,24,20,20,4,8,44,44,48,8,12,12,12,12,8,36,36,36,36,36,36,36,0,0,0,0
	dc.b	36,40,44,52,52,4,8,4,12,28,28,24,20,12,20,20,20,28,32,32,28,28,12,44,44,40,36,40,48,8,8,8,8,4,8,8,36,40,44,36,36,36,44,8,56,16,12,4,8,12,24,28,32,24,20,24,24,44,40,36,36,36,36,36,0,0,0,0
	dc.b	40,40,44,4,8,8,8,24,28,32,16,20,20,12,12,12,16,24,28,28,32,12,48,44,44,8,8,8,48,8,8,8,44,40,40,40,36,36,36,36,36,36,40,8,12,12,4,24,28,24,20,16,20,24,12,12,24,4,40,40,36,36,36,36,0,0,0,0
	dc.b	40,36,48,4,8,20,28,28,24,20,20,20,12,12,12,12,16,24,28,28,0,44,44,40,8,4,4,8,8,4,4,4,8,40,36,36,40,36,36,36,36,40,36,44,8,12,28,20,20,16,20,16,16,24,20,12,20,12,40,44,40,36,36,36,0,0,0,0
	dc.b	40,44,48,12,20,32,28,32,24,16,16,16,20,16,20,20,28,28,12,44,40,44,44,44,8,4,4,4,8,4,4,8,8,40,40,36,36,36,36,36,36,40,36,8,12,24,24,12,20,20,12,20,12,20,24,20,24,12,40,40,44,44,36,36,0,0,0,0
	dc.b	40,40,8,24,32,28,32,28,28,28,28,28,28,28,32,28,32,16,0,8,44,40,40,44,8,4,8,48,8,4,4,8,8,36,36,40,36,36,40,36,36,40,44,4,24,24,24,20,20,12,20,20,24,24,24,24,12,44,44,44,8,8,36,36,0,0,0,0
	dc.b	40,44,4,28,28,24,24,20,24,28,32,32,32,28,28,20,4,12,20,24,20,4,44,44,8,8,8,8,36,40,44,44,40,36,36,36,36,36,36,36,40,44,44,12,24,20,24,24,24,28,24,24,20,4,8,8,44,40,44,8,48,48,48,40,0,0,0,0
	dc.b	44,44,20,32,32,24,20,16,20,28,28,32,28,20,12,0,12,4,12,12,20,28,12,44,4,4,4,4,44,40,40,40,40,40,36,36,36,40,36,40,40,44,8,4,24,20,20,20,20,12,4,48,44,48,8,44,44,36,44,8,8,8,8,40,0,0,0,0
	dc.b	44,8,20,28,28,24,20,16,28,28,28,28,20,16,12,20,20,20,20,20,20,20,28,12,4,52,52,4,4,8,36,40,40,36,40,36,36,36,40,44,40,44,44,8,12,24,28,20,12,4,8,48,44,48,8,48,44,44,8,8,8,8,44,40,0,0,0,0
	dc.b	44,4,12,28,28,28,28,28,28,12,12,4,48,48,44,8,4,12,28,24,20,20,28,24,4,4,4,4,8,8,36,40,40,40,36,36,36,40,44,8,8,8,48,44,44,4,12,16,12,12,12,12,8,8,48,48,44,8,8,48,8,44,40,40,0,0,0,0
	dc.b	8,52,4,12,28,28,24,0,4,44,4,48,40,40,44,36,44,44,0,28,32,20,24,28,8,48,8,4,4,8,44,36,44,40,40,36,40,36,8,8,8,8,8,48,44,40,8,12,12,0,4,12,12,12,8,8,48,48,48,8,8,40,36,40,0,0,0,0
	dc.b	56,52,4,4,4,4,8,8,8,4,52,44,44,48,4,56,4,4,20,28,20,20,20,28,4,44,44,4,4,44,36,44,36,36,36,36,36,44,8,48,44,48,48,8,48,36,40,48,4,12,12,4,0,12,16,12,8,8,8,8,44,36,40,40,0,0,0,0
	dc.b	4,52,4,8,8,52,4,4,4,4,8,4,4,12,12,56,12,12,28,28,28,20,24,28,0,4,4,44,40,36,44,36,36,36,40,36,36,44,48,44,40,40,44,8,48,44,40,40,40,48,4,12,0,12,16,24,24,4,8,8,44,36,44,8,0,0,0,0
	dc.b	4,4,4,8,8,8,8,4,4,4,12,20,12,4,4,4,12,28,28,28,32,32,28,12,4,4,56,48,40,40,36,36,36,36,36,36,44,8,8,8,8,44,44,8,12,8,48,44,40,44,48,8,12,20,24,24,24,20,8,8,44,48,4,8,0,0,0,0
	dc.b	4,4,8,4,4,8,4,8,4,20,20,0,0,4,0,20,28,28,28,24,24,28,28,12,4,4,12,8,40,40,36,36,40,36,40,36,8,8,8,8,8,8,8,20,20,20,20,24,16,20,20,24,28,24,12,20,20,20,4,48,8,8,8,8,0,0,0,0
	dc.b	4,4,4,8,8,4,8,4,24,24,12,12,4,20,28,28,28,24,28,24,32,28,24,16,12,4,4,48,40,36,36,36,40,36,40,44,8,8,8,8,8,48,12,20,20,20,20,24,20,16,16,20,16,24,20,20,24,20,8,48,8,8,8,8,0,0,0,0
	dc.b	8,4,8,8,8,4,4,24,32,28,24,20,24,28,24,24,20,20,16,28,32,28,16,20,4,12,8,48,36,36,36,36,40,40,36,8,8,48,48,8,8,8,8,20,24,16,20,20,24,20,12,0,12,20,28,24,24,20,44,44,4,8,8,12,0,0,0,0
	dc.b	8,8,4,8,8,4,20,28,28,28,28,28,32,24,24,20,24,24,24,24,28,16,20,24,12,4,8,44,40,36,36,36,36,36,8,8,8,8,8,8,8,8,44,0,24,24,24,20,20,20,24,12,12,16,20,28,24,4,40,48,8,8,8,48,0,0,0,0
	dc.b	4,8,8,4,8,4,24,32,32,32,20,28,24,24,24,24,24,24,24,32,20,16,16,24,12,4,44,40,36,36,36,36,40,36,44,8,4,8,8,8,8,8,4,4,20,28,24,20,20,24,28,16,20,20,32,28,12,44,36,8,8,8,8,36,0,0,0,0
	dc.b	8,8,4,8,52,0,28,32,24,24,32,28,24,24,24,24,24,24,24,12,20,20,16,24,20,4,48,36,36,36,36,36,36,40,8,4,52,8,4,4,8,12,20,12,0,12,20,24,24,24,28,24,28,24,20,8,40,44,44,44,8,8,8,48,0,0,0,0
	dc.b	8,8,8,4,4,4,28,28,24,24,28,28,28,32,32,32,28,20,4,12,20,24,20,24,20,52,40,40,36,36,36,40,36,36,4,8,4,4,4,4,12,20,12,12,0,4,4,8,4,12,20,20,12,4,44,44,44,44,44,40,48,8,48,8,0,0,0,0
	dc.b	4,8,4,4,4,4,24,32,28,24,28,20,24,24,28,28,16,8,4,20,20,20,24,32,12,8,40,36,36,36,36,40,36,8,8,8,4,4,4,12,20,12,12,20,12,56,4,4,40,8,12,0,12,12,44,44,36,44,40,44,8,8,8,12,0,0,0,0
	dc.b	28,20,16,20,20,20,24,24,24,24,20,20,20,20,20,16,20,20,8,40,40,36,40,40,40,40,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,20,20,20,16,24,24,20,12,12,20,16,20,16,20,20,16,20,52,44,40,40,40,40,40,40,40,40,40,36,36,36,36,40,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,20,20,20,20,24,16,4,8,48,8,12,4,12,12,12,12,16,12,44,40,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,40,36,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,20,20,20,24,20,4,48,4,12,16,24,24,24,28,24,20,16,4,44,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,36,40,44,36,40,36,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,20,16,20,20,16,4,20,32,28,28,28,32,32,28,32,28,28,24,8,40,36,40,40,40,40,40,40,36,36,36,36,40,36,40,40,44,36,40,40,44,8,4,8,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,16,20,16,16,24,28,28,24,16,20,20,20,20,24,28,28,28,28,24,8,40,40,40,40,40,40,40,36,36,36,36,36,36,44,8,4,8,48,8,12,12,12,0,12,4,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	16,12,12,20,28,28,24,16,20,24,24,24,24,24,24,28,28,24,32,28,12,44,40,36,40,40,40,40,36,36,36,36,36,44,4,4,4,4,4,12,16,20,0,0,4,12,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	16,20,24,28,28,24,24,20,20,24,24,24,20,24,28,24,32,24,24,28,24,48,40,36,40,40,40,40,36,36,36,36,40,8,56,4,4,4,0,16,12,12,0,0,12,4,8,40,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	16,32,28,24,28,28,24,24,20,20,20,20,24,32,28,28,24,32,24,28,24,44,40,40,40,40,36,36,40,36,40,40,40,8,12,56,4,8,12,12,4,12,20,0,12,4,4,48,8,4,44,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	28,32,32,32,24,24,24,28,28,28,28,28,32,28,20,20,28,28,24,28,20,44,40,40,36,40,40,36,36,40,8,4,8,8,4,4,12,4,12,4,12,20,4,8,4,8,0,20,20,28,24,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,28,32,28,32,24,20,28,28,28,28,24,12,12,12,16,20,24,24,20,4,40,36,36,40,40,36,40,36,8,4,8,4,8,12,8,4,4,12,4,4,12,8,8,4,12,20,20,24,20,16,20,8,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	28,24,20,28,28,28,32,32,24,12,12,4,4,4,12,12,20,20,16,4,44,40,44,40,36,36,40,36,40,8,8,8,4,8,4,4,8,12,12,0,4,12,4,8,20,24,24,20,12,20,16,20,20,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,20,20,24,28,28,28,20,12,12,12,12,20,20,20,20,20,4,44,44,40,36,40,36,40,36,40,40,40,8,4,4,4,4,8,4,8,4,0,0,4,12,4,4,12,20,16,24,16,20,24,20,20,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,20,24,28,28,0,4,0,12,12,4,4,4,8,48,44,40,36,40,40,40,40,40,36,40,40,40,40,36,8,56,4,4,4,4,4,8,4,20,12,4,12,24,16,12,12,12,20,12,16,12,20,4,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,24,24,32,28,12,4,4,8,8,8,8,8,44,40,44,40,36,36,40,40,40,40,44,40,36,8,36,40,44,4,4,4,4,4,4,12,4,12,12,12,4,16,24,24,24,0,12,4,4,12,12,8,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,24,24,24,28,24,24,20,12,0,4,4,4,8,44,44,44,44,48,8,8,44,40,40,40,36,8,8,8,44,40,36,8,4,4,8,8,4,12,0,12,4,12,12,12,20,20,0,4,4,0,0,8,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,28,32,24,24,20,20,20,20,24,20,16,16,16,12,12,12,12,24,24,32,12,48,44,40,44,8,8,8,4,8,44,44,8,4,4,4,4,8,8,8,12,24,24,24,20,4,4,4,12,4,8,40,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	16,32,28,24,20,16,12,20,16,20,12,12,12,12,24,28,28,24,24,24,28,32,12,44,40,44,8,4,4,4,8,4,8,8,8,8,8,48,44,40,36,44,0,20,20,20,12,56,56,4,48,36,40,40,44,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	44,4,20,24,28,24,20,20,20,12,12,12,16,28,28,32,32,24,20,24,28,28,20,44,40,40,40,8,8,4,8,8,4,4,4,8,40,36,40,36,36,44,4,20,20,20,4,8,48,40,36,44,8,8,4,4,8,36,36,36,36,36,36,36,0,0,0,0
	dc.b	44,48,4,8,4,12,20,20,16,20,20,28,28,32,28,32,32,24,20,24,28,28,24,44,44,40,36,44,8,8,8,4,4,4,8,44,36,40,44,40,36,36,8,4,0,16,12,8,44,48,12,16,24,24,24,24,24,48,40,36,36,36,36,36,0,0,0,0
	dc.b	44,48,4,8,8,8,8,8,0,24,28,24,20,20,20,20,24,28,32,28,32,32,4,44,44,48,44,44,8,8,8,8,40,40,40,40,36,36,36,36,36,36,40,8,16,20,4,12,20,20,24,24,16,24,16,16,20,12,40,40,36,36,36,36,0,0,0,0
	dc.b	36,8,4,8,4,8,4,20,28,24,24,20,16,12,12,20,24,32,28,32,32,16,44,48,8,4,4,8,8,8,8,8,44,40,40,40,36,36,36,36,36,36,36,44,8,8,12,28,24,20,20,20,20,20,20,12,20,20,48,40,36,36,36,36,0,0,0,0
	dc.b	44,8,4,8,4,12,28,28,24,20,20,12,12,12,12,12,20,24,28,28,0,44,40,8,8,4,4,8,8,4,8,4,44,40,40,36,36,36,36,36,36,36,40,48,8,20,24,20,20,20,16,20,16,20,24,20,20,16,44,44,48,44,36,36,0,0,0,0
	dc.b	44,8,8,4,20,28,28,24,20,16,16,12,12,12,16,20,24,28,24,4,44,44,44,8,4,4,8,8,4,4,4,8,44,36,40,36,36,40,36,36,36,40,48,8,20,24,24,16,12,12,12,16,16,20,24,24,24,4,44,48,8,8,36,36,0,0,0,0
	dc.b	44,4,4,20,28,28,28,32,24,24,24,24,32,24,28,28,28,24,4,40,40,44,40,8,8,8,48,40,40,44,48,48,40,36,36,36,36,36,36,36,40,48,8,4,24,24,24,24,16,16,16,24,28,28,20,0,8,44,48,48,48,48,48,40,0,0,0,0
	dc.b	48,12,20,32,24,20,24,28,28,28,32,32,28,28,28,32,24,20,20,20,4,44,44,48,8,8,4,44,40,36,40,40,40,40,36,36,36,36,36,40,36,44,44,4,20,24,20,20,28,28,24,16,4,8,48,48,40,44,48,8,8,8,44,36,0,0,0,0
	dc.b	8,20,32,28,24,20,12,24,28,28,32,28,28,32,20,12,0,12,12,20,24,24,8,4,4,4,4,4,44,40,40,40,36,40,36,40,40,36,40,48,44,44,44,8,20,24,24,20,16,4,8,44,44,48,8,48,36,44,8,8,8,48,36,40,0,0,0,0
	dc.b	4,28,32,28,20,16,20,20,28,32,28,28,20,16,12,12,12,12,12,16,20,24,24,4,4,4,4,4,4,44,40,36,40,36,36,40,36,40,44,8,44,8,44,44,8,20,24,16,12,0,56,8,8,44,48,48,44,8,8,48,44,40,36,40,0,0,0,0
	dc.b	4,32,28,32,24,20,20,60,32,28,24,12,12,4,4,12,20,24,20,20,16,20,28,12,8,4,4,4,4,44,40,40,44,44,36,36,40,48,48,48,8,48,48,44,40,8,0,12,12,4,12,12,12,4,8,44,48,48,48,8,44,36,36,40,0,0,0,0
	dc.b	8,60,28,28,28,24,60,28,24,12,8,44,44,44,40,44,48,12,28,24,20,20,28,16,44,36,8,4,4,36,40,44,36,36,36,36,40,48,8,48,44,8,8,48,44,40,40,8,12,12,4,4,0,16,12,4,48,8,48,8,40,40,40,44,0,0,0,0
	dc.b	8,4,20,32,28,24,16,4,8,8,48,36,40,44,44,8,8,4,24,28,20,20,24,24,4,8,44,48,40,36,44,36,36,36,40,36,40,44,44,44,40,40,48,48,48,40,40,40,44,12,12,4,0,0,12,20,16,8,8,48,40,36,8,8,0,0,0,0
	dc.b	4,4,4,4,12,4,8,8,8,8,44,48,4,12,12,12,12,12,28,24,24,20,24,24,4,4,8,40,40,40,36,36,36,36,36,36,44,8,8,8,48,40,40,44,8,44,40,40,40,36,44,12,12,0,16,28,20,24,8,48,48,8,8,8,0,0,0,0
	dc.b	4,4,8,8,8,8,4,8,4,48,4,16,12,4,4,4,4,24,32,28,28,24,28,16,4,4,12,44,40,40,36,36,36,36,40,48,8,44,8,8,8,44,44,12,20,0,8,44,44,44,44,8,4,20,20,20,20,20,56,44,8,8,8,8,0,0,0,0
	dc.b	4,8,4,4,8,4,8,4,4,16,20,12,4,4,4,4,24,28,28,28,24,28,28,4,8,4,4,44,40,36,36,36,36,40,40,8,8,8,8,8,8,48,4,20,20,20,20,28,24,20,24,24,24,28,12,20,20,20,12,48,8,8,8,8,0,0,0,0
	dc.b	8,8,8,8,8,4,4,4,24,16,12,4,4,0,12,24,28,28,24,24,24,28,28,12,56,8,8,44,36,36,40,36,40,36,48,8,48,44,44,8,8,48,4,20,20,16,20,24,20,20,16,16,16,20,20,24,24,24,4,48,8,8,8,4,0,0,0,0
	dc.b	8,8,4,8,8,4,4,24,24,16,12,12,16,20,32,24,24,28,28,28,32,28,20,16,0,4,8,44,36,36,36,36,40,36,8,8,8,8,8,8,8,48,44,20,24,16,20,20,20,20,20,12,12,20,24,24,24,20,8,44,8,8,8,44,0,0,0,0
	dc.b	4,4,8,4,8,4,20,28,24,20,16,16,28,32,20,24,20,20,24,28,28,24,20,20,0,4,36,40,36,36,36,40,36,36,48,4,8,8,8,8,8,48,44,4,24,28,24,20,20,20,20,20,12,16,20,24,24,12,44,44,8,8,44,36,0,0,0,0
	dc.b	8,8,8,8,4,12,28,28,28,28,24,28,28,24,24,24,24,24,16,28,24,16,16,24,12,8,48,36,36,36,40,36,36,36,8,8,4,8,8,8,8,8,4,0,16,28,24,20,20,24,20,24,16,20,28,32,12,44,44,8,8,8,8,8,0,0,0,0
	dc.b	8,8,8,4,4,20,28,32,32,24,28,32,24,24,20,24,24,20,24,28,20,16,20,24,12,8,40,40,36,36,40,40,36,8,8,4,8,8,4,4,4,20,20,0,0,4,16,24,24,24,28,24,24,28,20,4,44,36,44,40,48,44,8,8,0,0,0,0
	dc.b	8,8,4,4,4,28,32,28,24,24,28,32,24,24,24,24,20,24,24,16,20,20,16,24,12,8,40,36,36,36,36,40,40,8,8,4,4,4,4,4,12,16,12,12,0,0,0,8,4,4,20,16,12,56,44,40,40,44,40,44,48,8,8,4,0,0,0,0
	dc.b	20,20,20,16,20,20,24,24,24,24,20,24,20,16,20,24,20,48,40,40,36,36,40,40,40,40,40,40,40,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,20,20,20,24,24,24,16,12,16,20,20,20,20,16,20,24,4,44,36,40,40,36,36,40,40,40,40,40,36,36,36,40,36,40,40,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,20,20,24,28,12,4,44,8,4,12,12,20,20,20,20,20,12,44,40,40,36,40,40,40,40,40,40,40,36,36,36,36,36,36,36,36,40,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	28,20,20,20,12,4,0,4,44,8,4,0,12,12,12,12,12,0,44,40,40,40,36,40,40,40,40,40,36,36,36,36,36,36,40,36,40,44,40,36,36,44,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,20,24,24,4,4,12,4,12,20,28,28,32,28,28,32,24,12,44,44,36,40,36,40,40,40,40,40,36,36,36,36,36,36,36,44,44,36,36,40,8,4,4,4,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,16,24,20,4,12,24,28,28,28,24,24,24,32,32,28,28,32,12,44,40,40,40,36,40,40,40,40,36,36,36,36,40,40,8,4,4,4,8,4,12,12,12,0,12,4,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,20,20,20,24,28,28,24,20,24,24,24,24,24,32,28,32,28,28,12,44,40,40,40,40,40,40,40,36,36,36,36,40,8,56,4,4,4,4,20,20,12,12,4,12,56,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,20,24,28,28,20,24,24,24,24,24,24,24,28,28,28,32,28,32,24,8,40,40,40,40,40,40,40,36,36,36,36,44,4,56,4,4,4,12,12,12,12,0,12,12,56,8,40,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,28,32,32,32,24,20,20,24,16,24,24,24,32,28,24,24,24,32,28,4,40,40,40,40,36,40,40,40,40,44,40,44,12,56,4,4,4,20,4,0,12,12,12,12,4,8,44,8,4,44,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	28,28,32,32,32,24,28,20,24,20,20,24,32,28,28,20,28,32,28,28,4,36,40,40,40,40,36,40,40,8,8,4,48,56,4,12,0,4,12,4,0,12,4,8,8,8,12,20,24,20,28,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	28,32,28,32,24,24,32,28,32,28,28,32,28,24,20,24,28,28,28,24,48,40,40,36,40,36,40,36,44,4,8,4,8,56,4,4,4,12,12,4,4,12,8,8,4,4,16,24,24,20,16,20,8,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,28,32,24,28,24,28,32,32,28,32,16,12,12,12,20,20,24,24,4,44,40,44,36,36,36,36,36,44,8,8,4,8,8,4,8,4,12,12,4,0,12,8,4,20,24,20,20,12,20,20,16,20,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,28,32,32,28,28,32,16,12,4,0,0,12,12,20,24,20,8,44,40,40,36,36,40,40,40,40,44,4,4,4,12,8,4,4,8,4,12,4,4,4,8,8,20,20,20,24,20,20,24,20,20,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,20,24,32,28,28,24,16,12,12,12,12,20,20,20,12,8,44,36,40,40,36,40,40,40,40,40,36,40,8,4,8,4,4,4,12,4,4,12,12,4,12,12,16,12,12,0,20,20,12,12,20,20,4,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,24,24,32,28,0,4,12,12,12,4,12,4,44,44,44,36,40,40,36,40,40,36,36,44,40,48,44,36,40,8,4,4,4,4,4,12,4,12,12,4,4,0,20,24,20,24,0,12,4,0,12,56,8,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,32,32,24,8,4,8,48,8,8,8,8,40,44,40,40,44,36,44,36,40,40,40,40,48,4,8,44,36,40,8,4,4,8,8,4,4,4,12,12,56,0,0,16,24,20,4,4,4,4,4,8,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,32,28,32,24,20,4,4,8,8,4,48,44,44,44,44,44,48,48,44,44,40,36,40,8,8,8,4,8,44,40,8,56,4,4,4,4,8,4,4,12,24,20,20,20,0,4,0,12,56,48,40,40,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,24,28,24,24,24,24,20,20,20,20,12,4,12,0,12,12,20,28,20,8,44,40,40,8,4,4,4,8,4,8,8,8,8,8,8,48,44,36,40,8,16,20,20,24,0,12,56,8,8,40,36,40,40,44,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,28,24,20,16,16,20,12,12,16,20,12,12,20,20,24,24,28,28,28,32,28,48,44,40,44,8,8,4,4,8,8,4,8,8,44,40,36,40,40,36,44,12,16,20,20,4,8,48,40,40,40,40,44,8,8,48,40,36,36,36,36,36,36,0,0,0,0
	dc.b	28,32,28,20,16,16,16,20,20,12,0,12,12,24,28,32,24,16,20,24,28,32,4,40,44,36,44,8,8,8,4,4,4,4,8,40,36,40,44,36,40,44,4,20,12,20,0,8,44,44,8,8,12,20,24,24,16,48,40,40,36,36,36,36,0,0,0,0
	dc.b	0,12,20,24,24,24,20,20,16,20,12,24,28,28,32,32,24,20,28,28,32,32,12,44,44,44,36,8,8,8,8,44,44,40,40,36,36,36,36,36,36,40,44,8,20,16,12,56,4,4,20,28,24,24,16,20,24,12,44,40,36,36,36,36,0,0,0,0
	dc.b	4,8,8,8,4,4,0,4,0,16,28,28,32,24,24,24,28,24,28,32,32,28,4,8,8,8,8,8,8,8,8,44,40,40,40,40,36,36,36,36,36,36,36,8,12,4,4,20,24,28,20,16,20,20,24,20,20,20,48,40,40,36,36,36,0,0,0,0
	dc.b	4,4,4,8,8,8,8,4,24,28,32,20,20,16,20,20,24,28,32,32,28,12,48,8,8,4,8,4,4,8,4,8,40,40,36,40,36,40,36,36,40,36,48,44,40,8,24,24,20,16,20,20,20,20,20,20,20,24,8,44,48,44,36,36,0,0,0,0
	dc.b	4,8,4,8,8,4,20,28,28,20,20,12,12,12,12,20,20,32,28,32,20,48,48,4,8,4,4,8,4,4,8,48,40,40,40,40,36,40,36,36,36,48,44,48,4,24,24,16,20,12,12,20,12,20,20,24,24,20,8,48,8,8,36,36,0,0,0,0
	dc.b	4,8,8,4,20,28,28,32,20,20,12,12,12,12,12,16,24,32,28,20,44,44,48,8,4,48,44,48,8,8,8,44,40,36,36,36,36,36,36,36,40,48,44,8,24,24,24,20,12,12,12,20,16,20,32,24,12,8,48,48,48,8,44,36,0,0,0,0
	dc.b	4,8,4,20,28,32,28,20,20,20,12,20,20,28,20,24,32,28,0,44,44,44,44,8,8,8,44,40,40,40,36,40,40,40,36,36,36,36,40,40,44,44,44,56,24,24,24,24,24,20,20,24,32,24,12,8,44,44,48,8,8,8,40,40,0,0,0,0
	dc.b	8,4,20,28,28,32,32,32,28,28,32,28,28,28,32,28,28,20,0,8,44,44,8,8,4,4,8,44,40,40,40,40,40,36,36,36,40,40,44,48,44,44,44,4,20,20,20,16,28,24,20,4,8,48,44,44,44,48,8,8,8,36,36,40,0,0,0,0
	dc.b	0,24,32,20,20,20,32,32,32,28,24,32,32,28,32,20,12,12,20,24,20,4,4,4,4,4,4,4,48,40,40,40,36,40,40,36,40,44,48,8,8,44,44,44,12,20,24,20,12,0,4,8,44,44,44,48,44,8,8,8,44,40,40,36,0,0,0,0
	dc.b	24,28,28,24,20,20,24,32,32,32,32,28,28,28,12,0,12,12,12,16,24,28,4,4,4,4,4,8,8,36,36,36,44,40,36,40,44,48,48,8,48,8,48,44,48,12,24,20,12,0,12,56,4,8,44,44,44,8,48,8,36,36,40,40,0,0,0,0
	dc.b	28,28,28,20,16,16,24,28,32,28,32,28,28,20,16,20,20,12,20,20,20,28,24,8,48,8,4,4,48,40,40,44,36,36,36,36,44,48,48,44,48,48,8,44,40,40,48,12,12,12,4,0,12,12,0,8,44,48,8,44,40,40,40,44,0,0,0,0
	dc.b	32,28,32,24,20,20,24,32,28,28,12,8,8,8,8,4,20,28,20,20,16,20,32,4,44,44,8,4,44,40,44,36,36,36,40,36,44,44,44,40,40,48,48,48,44,40,40,44,8,12,12,0,0,0,12,20,0,8,48,48,40,44,8,8,0,0,0,0
	dc.b	28,32,28,32,24,20,28,32,24,4,44,44,44,44,44,44,44,20,28,20,16,20,28,16,4,48,36,40,40,36,40,36,36,36,40,40,48,8,8,44,44,40,40,48,44,40,36,40,40,44,4,12,12,12,12,20,20,16,48,48,48,8,8,8,0,0,0,0
	dc.b	28,28,28,28,28,24,20,4,48,44,40,44,48,4,4,12,12,20,28,24,20,16,32,20,4,12,48,40,36,40,36,36,36,40,36,8,8,8,48,8,8,44,40,44,8,48,40,40,40,40,40,48,4,0,16,24,20,24,0,48,8,8,8,8,0,0,0,0
	dc.b	4,12,20,20,12,4,8,4,48,44,8,56,12,12,12,4,0,20,28,24,24,20,28,12,4,4,8,40,40,36,36,36,40,36,44,8,8,8,8,8,8,48,44,12,24,20,4,8,44,48,44,8,4,20,20,16,20,20,12,48,8,8,8,8,0,0,0,0
	dc.b	8,8,8,4,8,8,8,8,44,4,20,12,12,4,4,4,12,28,32,28,32,28,28,0,8,4,8,40,36,36,36,36,36,36,8,8,44,44,44,8,8,44,8,20,20,16,20,28,24,24,24,24,24,24,20,20,20,20,20,8,8,8,4,8,0,0,0,0
	dc.b	8,8,8,4,4,4,8,4,12,20,0,4,4,4,4,12,28,32,28,24,24,28,24,4,4,8,8,44,40,36,36,36,40,44,8,8,44,8,8,8,48,44,44,24,24,16,12,24,16,20,20,12,16,20,24,24,20,24,12,8,8,8,48,44,0,0,0,0
	dc.b	4,4,8,4,8,4,4,20,20,4,12,12,4,12,20,24,28,32,28,24,32,28,24,12,12,8,40,36,36,36,36,40,40,44,8,4,8,8,8,4,8,44,44,16,28,20,20,20,20,20,20,12,12,12,20,24,24,24,4,48,8,8,44,40,0,0,0,0
	dc.b	8,8,8,8,4,4,20,24,20,12,12,12,20,20,28,28,20,24,32,28,28,28,20,12,4,48,48,36,36,36,40,40,36,44,8,8,8,8,8,8,8,44,44,4,24,28,24,20,20,20,20,20,12,12,20,20,24,20,44,48,48,8,44,48,0,0,0,0
	dc.b	8,8,8,4,4,20,32,20,20,16,12,20,24,32,24,24,20,24,24,32,32,24,20,20,4,8,40,36,36,36,36,40,40,8,4,8,8,8,4,4,8,4,12,12,12,24,24,20,20,20,20,24,20,20,24,28,20,8,36,44,48,48,8,8,0,0,0,0
	dc.b	8,8,52,4,4,24,28,24,28,20,20,28,28,28,24,24,24,20,20,28,28,12,20,20,4,48,40,40,36,36,36,40,36,8,8,8,4,4,4,8,4,20,12,4,0,0,24,28,24,24,24,24,24,28,28,12,48,40,40,40,48,8,8,4,0,0,0,0
	dc.b	20,20,16,16,20,24,24,24,24,24,24,20,20,20,20,20,48,36,40,40,36,40,40,40,40,40,40,40,40,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,20,16,20,24,24,24,24,24,20,20,20,20,16,20,24,4,40,40,36,40,40,36,40,40,40,40,40,40,36,36,36,40,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,16,24,24,20,12,4,4,8,16,20,16,20,20,20,20,12,44,40,40,36,36,40,40,40,40,40,40,36,36,36,36,40,36,36,36,36,36,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	16,24,24,16,48,4,52,4,4,4,12,20,12,12,20,20,12,44,40,40,40,36,40,36,40,40,40,40,36,36,36,36,40,36,40,36,40,44,40,36,40,44,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,24,20,12,4,52,4,4,4,4,12,20,20,20,20,12,4,44,44,40,40,40,36,40,40,40,40,40,36,36,36,36,40,40,44,48,44,40,36,48,4,12,4,4,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,28,4,20,0,8,12,16,24,28,32,28,28,28,32,32,16,4,44,40,40,40,40,40,40,40,40,40,36,36,36,36,40,8,4,4,4,8,48,12,12,12,0,0,12,8,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,4,0,16,32,28,32,32,24,24,24,32,32,32,32,32,28,4,36,40,40,36,40,40,40,40,40,36,36,36,36,44,12,4,8,4,4,12,16,16,0,4,4,12,4,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	16,20,20,28,32,28,24,24,24,24,24,24,24,32,28,32,32,32,28,8,36,36,40,36,40,40,40,40,36,36,36,36,8,56,4,4,4,4,16,12,12,12,4,12,12,56,8,40,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	16,28,28,24,24,24,24,24,24,24,24,24,28,32,28,28,32,32,32,12,40,40,40,40,40,40,36,40,36,44,44,36,4,12,4,4,4,4,12,12,12,16,12,4,4,4,48,44,8,4,48,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	28,28,28,24,20,24,20,20,24,24,24,24,32,24,20,24,24,32,32,16,44,40,40,36,40,40,40,36,44,8,4,48,8,56,4,4,8,12,12,4,12,12,4,8,4,8,4,20,20,20,24,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,28,32,32,28,24,24,20,20,20,24,32,28,28,24,24,32,32,28,12,36,40,40,36,40,36,40,44,8,4,4,4,8,4,4,4,4,12,12,4,4,56,8,4,4,4,20,24,24,20,20,16,8,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	28,28,32,24,24,24,32,32,32,28,32,28,28,24,24,28,32,28,32,4,44,36,44,36,36,40,36,44,8,8,4,8,8,56,4,8,4,12,4,4,12,56,8,4,24,24,20,16,12,24,20,16,16,40,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	28,32,24,32,28,32,32,32,28,32,28,12,12,12,20,24,24,24,4,36,40,40,40,40,36,40,40,44,8,56,4,4,8,4,12,8,8,12,12,4,0,4,8,8,20,24,20,24,16,20,24,20,20,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,32,32,28,32,28,28,32,20,0,4,12,12,20,24,20,12,8,44,40,40,36,40,40,40,36,36,40,44,56,4,4,4,8,4,4,4,4,20,12,4,12,0,12,4,12,12,20,20,12,20,20,20,4,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,32,24,32,28,32,20,12,12,12,20,20,20,12,12,8,44,40,44,40,40,40,40,40,44,44,48,44,36,8,4,4,4,4,4,12,4,4,12,12,4,0,20,24,24,20,16,0,12,4,4,12,4,8,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,32,28,28,20,0,0,12,4,12,4,8,48,44,44,40,40,40,40,40,36,36,40,40,44,8,8,48,40,40,44,4,4,4,8,8,4,0,0,12,12,56,4,12,20,24,24,4,8,4,4,4,8,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,28,28,24,8,48,8,48,8,8,52,48,44,40,40,44,40,36,40,40,40,40,40,40,48,8,8,4,8,44,40,44,4,4,4,8,4,4,8,56,4,12,20,20,20,20,12,12,12,12,56,48,40,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,32,28,24,12,4,4,8,8,8,4,44,44,36,40,44,44,44,44,44,44,40,40,44,48,4,4,4,4,8,8,8,8,4,8,44,8,48,44,40,48,4,20,20,24,20,0,4,4,8,44,40,40,40,40,36,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	32,28,28,32,24,24,20,20,12,12,4,4,4,4,4,0,12,12,20,12,4,44,40,40,40,8,4,4,4,8,8,4,4,4,8,40,36,40,40,40,36,44,0,20,16,20,4,8,48,40,40,40,44,44,44,44,44,40,36,36,36,36,36,36,0,0,0,0
	dc.b	24,32,24,20,20,16,20,20,20,20,20,20,20,20,20,20,28,28,28,32,28,4,44,36,44,40,8,8,4,4,4,4,4,8,44,40,40,36,44,36,36,44,16,20,12,20,4,48,44,40,44,44,8,8,20,20,12,48,40,40,36,36,36,36,0,0,0,0
	dc.b	32,24,20,16,20,20,20,12,12,12,12,0,12,20,24,28,24,24,32,32,32,24,8,44,40,36,48,8,8,8,48,48,48,40,40,40,36,36,36,40,40,40,8,4,12,20,12,4,4,48,8,20,24,28,24,20,24,20,44,40,36,36,36,36,0,0,0,0
	dc.b	28,32,24,24,20,20,20,16,12,12,12,20,24,28,28,28,20,20,24,32,28,28,8,8,8,48,8,8,8,8,48,40,36,36,40,40,36,36,36,36,40,44,40,4,20,12,12,12,12,20,28,28,24,20,20,16,20,20,8,44,44,36,36,36,0,0,0,0
	dc.b	12,12,20,20,20,20,20,20,16,20,20,28,28,28,28,32,20,24,28,32,32,28,4,4,4,4,8,4,8,4,8,44,40,40,36,40,36,36,40,36,40,44,44,44,8,48,12,20,28,20,16,16,16,20,20,20,16,24,4,48,48,44,36,36,0,0,0,0
	dc.b	8,8,4,8,8,4,8,4,0,24,28,32,24,20,20,32,28,28,32,32,28,12,4,8,4,8,4,4,4,8,8,44,40,40,40,40,40,36,36,40,44,48,44,44,44,56,24,24,16,16,12,20,12,20,20,24,32,24,4,48,8,48,36,36,0,0,0,0
	dc.b	4,4,8,8,8,8,4,20,32,28,20,20,20,20,20,20,32,32,32,32,24,4,52,4,8,8,8,4,8,8,8,40,40,36,36,36,36,36,36,36,48,48,48,48,0,24,24,20,16,12,12,12,20,20,20,24,28,12,8,48,48,48,40,40,0,0,0,0
	dc.b	4,8,8,8,4,12,28,28,24,20,20,20,20,24,12,20,24,32,28,32,8,44,8,8,8,44,40,40,44,40,36,40,40,36,36,36,36,36,36,40,44,44,44,8,24,24,24,24,16,12,12,20,24,24,28,16,8,8,48,8,48,44,40,36,0,0,0,0
	dc.b	52,4,8,4,20,28,28,24,20,16,12,12,12,12,16,20,24,28,28,52,44,44,48,8,8,8,44,40,40,40,40,40,36,36,36,36,40,36,48,44,44,44,40,56,24,20,20,20,24,20,24,24,24,16,4,44,44,48,48,8,44,40,40,36,0,0,0,0
	dc.b	8,8,12,28,32,32,24,24,20,20,20,28,24,28,24,28,28,28,8,48,44,52,4,4,4,4,4,44,36,40,40,36,40,36,36,36,40,44,48,8,48,44,44,8,20,20,20,16,28,24,20,8,48,44,44,48,48,48,8,8,40,40,36,40,0,0,0,0
	dc.b	4,20,28,28,28,32,32,28,32,28,28,28,32,32,28,32,28,20,20,0,4,4,4,52,4,4,4,8,44,36,36,36,44,40,40,36,44,48,8,48,48,8,48,36,4,24,28,20,12,0,4,4,8,44,44,44,44,8,48,44,40,36,40,40,0,0,0,0
	dc.b	24,20,20,20,28,28,32,32,28,24,32,32,32,28,32,20,12,12,20,24,24,12,8,4,4,4,4,4,36,40,36,44,36,40,36,40,48,8,44,44,48,48,48,44,36,8,12,12,0,4,0,12,12,4,4,44,44,48,8,44,40,40,44,48,0,0,0,0
	dc.b	32,24,24,20,12,24,32,32,32,32,32,32,32,28,12,12,12,12,12,16,24,24,4,44,44,8,52,8,40,40,44,36,36,36,40,44,48,44,40,40,40,48,48,48,44,40,40,8,0,12,0,0,4,12,12,12,4,48,48,44,36,44,8,8,0,0,0,0
	dc.b	28,32,20,20,20,20,32,32,32,32,32,28,32,20,20,20,16,12,16,20,20,32,20,48,44,44,44,40,40,40,40,36,36,40,40,44,48,8,8,44,40,40,44,44,40,40,36,40,44,8,12,56,12,0,12,12,20,12,48,44,8,8,8,8,0,0,0,0
	dc.b	28,24,20,20,20,24,28,32,28,28,16,8,48,48,8,56,24,24,20,20,20,24,32,4,4,48,36,40,36,36,36,40,36,36,44,8,8,8,8,8,48,40,40,40,40,40,40,40,40,40,48,56,12,12,12,20,20,20,4,44,8,8,8,8,0,0,0,0
	dc.b	32,28,24,20,20,32,28,32,24,8,8,44,44,8,48,8,12,28,24,16,20,16,28,0,4,4,40,40,36,40,40,36,36,40,48,48,8,8,8,8,48,48,44,44,4,4,48,44,40,36,40,36,44,12,12,24,20,20,20,8,8,8,8,8,0,0,0,0
	dc.b	32,32,32,24,20,28,24,4,8,44,44,8,56,12,16,12,12,20,28,24,20,20,28,0,8,4,44,40,36,36,36,36,40,44,8,8,48,48,48,8,8,44,40,12,24,28,16,4,8,44,48,8,4,16,20,20,20,20,20,4,8,8,4,8,0,0,0,0
	dc.b	32,28,28,32,24,16,4,44,44,48,12,12,0,4,4,4,4,32,32,28,28,24,28,4,8,8,48,44,40,36,36,36,36,8,8,44,40,44,8,48,48,40,44,20,20,20,20,24,24,24,24,24,24,24,24,16,20,20,20,4,48,8,44,44,0,0,0,0
	dc.b	20,20,12,4,4,4,48,48,4,20,12,4,4,4,4,4,16,28,32,28,24,28,32,4,4,8,40,36,36,36,36,40,40,48,8,8,8,8,4,8,48,40,44,24,24,20,12,24,16,20,20,12,12,20,24,24,20,20,20,4,48,48,44,40,0,0,0,0
	dc.b	52,8,4,8,8,4,48,12,20,12,4,4,4,0,12,16,28,28,24,24,32,32,24,4,4,44,48,40,36,36,36,40,36,48,8,8,8,8,8,8,8,44,44,12,24,24,20,20,20,20,20,20,12,12,20,24,24,24,20,48,48,48,44,48,0,0,0,0
	dc.b	4,4,52,4,4,8,12,20,12,0,0,0,12,20,16,28,28,32,24,24,32,28,20,4,8,44,36,40,36,36,40,36,36,4,4,8,4,8,8,8,8,36,8,4,20,28,24,16,20,20,16,20,20,12,12,20,32,20,4,36,44,48,48,48,0,0,0,0
	dc.b	4,8,4,4,52,4,24,12,0,12,4,20,20,12,24,32,20,28,32,28,32,32,20,12,8,44,40,36,36,36,40,40,44,8,8,8,8,4,4,4,8,4,16,4,12,24,24,20,16,20,20,24,20,16,20,24,28,0,44,40,48,8,8,4,0,0,0,0
	dc.b	20,20,20,20,20,24,24,24,20,24,16,20,24,24,12,44,40,36,40,40,36,40,40,36,40,40,40,36,40,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,20,20,24,28,28,28,28,24,20,24,20,20,20,24,4,36,40,36,40,40,40,40,40,40,40,40,36,36,36,36,36,36,36,36,36,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	16,24,24,24,20,12,12,0,20,20,20,16,20,20,24,0,44,40,40,40,36,40,40,36,40,40,40,40,36,36,36,36,36,40,36,36,36,40,36,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,28,20,4,4,4,4,8,0,20,20,20,20,20,20,12,44,40,40,36,40,40,40,40,40,40,40,36,36,36,36,36,40,36,36,36,40,44,40,36,44,44,8,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	28,12,8,4,4,12,12,4,4,4,20,12,12,12,12,12,44,40,40,36,40,36,40,40,40,40,36,36,36,36,36,36,40,44,8,8,44,36,40,8,12,4,4,4,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,4,8,52,56,12,4,4,0,20,20,24,20,20,12,12,48,36,40,40,36,40,40,40,40,40,40,36,36,36,36,40,48,4,4,4,4,48,4,20,12,12,4,12,4,8,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,12,0,4,8,4,20,24,28,28,32,32,32,32,32,28,12,44,40,40,36,40,36,40,40,40,40,36,36,36,36,44,4,4,4,4,4,4,12,20,12,12,4,12,12,8,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,12,20,24,32,32,32,24,32,28,32,32,32,32,32,28,20,44,40,40,40,40,36,40,40,40,36,40,36,40,44,4,4,4,4,4,4,12,12,12,4,12,12,12,4,44,36,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	0,16,32,32,32,24,24,24,32,24,24,24,32,32,32,32,32,32,4,40,40,40,40,36,36,40,40,40,44,44,40,8,4,4,4,4,8,12,12,12,20,20,4,4,4,4,44,44,8,4,44,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,32,24,24,24,24,24,24,24,24,24,28,32,32,32,32,32,28,24,48,40,40,40,36,40,40,36,44,4,4,8,8,4,4,4,4,8,12,12,4,12,12,8,4,4,8,4,12,24,20,24,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	28,28,28,16,24,20,24,24,24,20,24,32,24,20,24,24,24,32,28,8,40,40,40,36,36,40,40,8,8,4,4,8,12,4,4,12,4,12,4,4,12,0,8,4,8,4,20,24,24,20,20,16,8,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,32,28,24,24,24,16,24,20,24,24,32,32,16,24,32,32,28,24,44,40,40,44,40,40,40,40,8,8,8,4,8,4,4,8,4,12,12,4,4,12,12,4,4,20,24,20,12,20,20,20,20,20,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,24,24,32,32,32,32,28,32,32,32,28,32,24,32,32,32,28,12,36,40,36,40,40,40,40,44,8,4,4,4,4,8,4,4,8,4,12,0,4,0,4,8,4,16,32,24,24,12,20,24,20,20,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,32,24,24,32,28,28,32,32,32,28,16,12,20,24,24,28,4,40,36,40,40,40,36,40,36,40,44,4,4,8,4,4,4,4,4,4,12,12,0,56,12,8,4,4,12,12,24,20,20,24,12,12,4,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,32,32,24,32,32,32,32,20,12,0,12,20,24,24,12,8,44,44,40,40,36,36,40,44,44,44,40,44,4,4,4,4,4,4,56,4,4,20,12,4,0,20,24,12,12,12,12,20,0,4,4,4,8,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,28,32,32,32,20,12,20,12,20,20,12,4,8,44,44,40,40,44,40,40,40,36,8,8,8,40,40,8,8,4,4,8,8,4,4,4,12,12,12,0,56,20,24,24,24,12,8,4,12,8,8,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,32,32,32,28,12,12,12,4,4,4,48,48,40,44,40,40,36,36,40,40,40,40,48,8,8,4,8,44,40,40,8,0,4,4,4,4,8,4,4,4,12,12,0,12,20,20,4,4,0,4,44,40,36,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,28,32,4,8,4,8,52,4,4,44,40,40,40,40,36,40,40,40,36,40,40,40,48,4,8,4,4,8,8,8,8,8,8,8,8,8,48,44,48,8,12,28,20,24,20,4,12,12,8,44,40,36,40,40,40,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	32,32,20,8,8,8,8,8,4,8,40,44,44,44,40,40,44,44,40,40,36,40,36,36,8,52,4,8,8,8,4,4,8,8,44,40,40,40,36,40,40,48,0,20,20,24,4,8,48,40,40,40,44,44,40,36,44,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,32,24,16,12,12,4,4,4,8,48,48,48,48,8,4,4,4,4,8,44,40,44,36,44,8,4,4,4,4,4,4,4,8,40,36,36,36,44,40,36,8,20,20,20,20,4,44,40,40,44,44,44,8,8,12,4,48,36,40,36,36,36,36,0,0,0,0
	dc.b	32,32,32,24,24,24,16,24,20,16,20,24,20,24,16,24,32,32,32,28,20,44,36,40,36,8,8,8,8,8,8,8,48,40,40,36,36,36,40,36,40,44,4,12,12,20,12,4,8,48,44,8,4,20,28,28,24,20,44,40,36,36,36,36,0,0,0,0
	dc.b	28,24,20,12,12,20,20,12,12,12,12,12,12,20,20,32,32,32,28,32,28,0,48,48,44,44,8,8,8,8,40,40,36,40,40,40,36,36,36,36,36,44,40,4,20,12,12,12,12,4,20,24,32,24,20,16,24,24,4,44,44,36,36,36,0,0,0,0
	dc.b	24,20,12,20,20,20,16,12,12,4,12,12,20,20,28,24,24,24,24,32,32,20,8,8,4,4,8,4,4,8,44,40,36,40,36,36,36,36,36,36,44,44,44,8,4,4,12,12,12,24,24,20,20,20,20,20,24,24,12,8,8,44,36,36,0,0,0,0
	dc.b	32,24,24,24,20,20,20,20,20,20,20,20,28,28,32,20,24,24,28,32,28,24,8,52,8,4,8,4,8,4,44,40,40,36,40,40,36,40,36,44,44,44,8,44,36,8,12,24,24,16,16,20,20,20,20,20,24,28,12,48,8,44,36,36,0,0,0,0
	dc.b	12,20,20,12,20,12,12,12,0,12,24,32,32,32,32,24,32,32,32,32,28,20,4,52,52,4,52,4,8,8,44,40,40,36,36,36,36,36,40,44,44,8,44,48,48,12,24,24,16,12,12,12,20,12,20,20,24,24,56,48,8,44,40,36,0,0,0,0
	dc.b	4,8,8,8,52,8,8,4,12,24,32,24,16,16,28,28,32,32,32,32,32,4,8,8,48,36,44,48,48,40,40,36,40,40,36,36,36,40,40,44,44,44,44,8,12,24,24,24,20,12,12,12,20,20,24,24,24,12,48,8,44,40,40,40,0,0,0,0
	dc.b	4,8,52,8,4,8,4,24,32,32,20,20,20,20,20,24,32,32,32,28,12,44,8,8,8,44,40,36,40,36,36,40,36,36,40,36,40,36,48,48,44,40,40,4,20,24,24,24,20,12,20,12,24,32,32,12,8,48,48,48,44,40,36,40,0,0,0,0
	dc.b	8,8,4,8,8,12,28,32,24,20,12,12,20,12,20,20,32,32,32,24,48,48,8,4,52,8,44,40,40,36,36,40,40,36,40,36,48,8,8,8,48,44,40,4,16,16,20,12,24,24,24,24,20,4,8,44,48,48,8,44,36,40,40,40,0,0,0,0
	dc.b	8,52,8,4,24,28,28,20,20,12,12,12,20,12,20,24,32,28,20,8,52,4,52,4,4,4,8,8,40,40,40,36,44,36,36,40,48,48,8,48,48,8,44,44,20,20,16,20,24,24,20,4,48,44,44,44,8,8,48,44,36,40,40,44,0,0,0,0
	dc.b	44,4,20,32,32,32,20,24,24,24,28,24,24,32,28,32,28,32,4,8,4,52,4,8,4,4,8,8,40,40,40,44,36,40,36,44,48,44,44,8,44,48,44,44,48,20,24,20,4,0,4,0,4,4,8,44,48,48,48,40,40,40,44,8,0,0,0,0
	dc.b	0,24,28,28,32,32,32,32,28,32,32,24,32,32,32,32,28,20,24,20,4,4,8,4,4,8,4,48,40,40,44,36,36,36,40,44,8,40,40,36,40,48,48,44,40,44,8,12,12,12,4,4,12,12,12,8,8,44,48,44,44,8,8,8,0,0,0,0
	dc.b	24,24,32,32,32,32,32,32,24,32,28,32,32,28,32,16,12,12,12,24,24,4,44,40,44,8,8,40,40,40,36,36,36,40,40,44,8,8,44,44,40,44,44,40,36,40,40,44,8,4,12,4,4,0,12,20,12,4,48,44,48,8,8,8,0,0,0,0
	dc.b	20,20,20,16,32,32,32,32,32,32,32,28,28,28,20,12,12,12,12,20,24,24,8,48,44,40,40,40,40,36,36,36,40,40,44,8,8,8,8,8,44,40,40,40,40,36,40,36,40,44,8,12,12,0,4,12,12,20,4,44,8,8,8,8,0,0,0,0
	dc.b	32,24,20,20,28,32,32,32,28,32,32,28,32,20,20,24,20,12,20,12,20,28,20,56,52,44,40,40,36,40,36,36,40,44,8,8,8,8,8,8,8,36,40,36,36,40,36,40,40,40,36,44,4,12,12,20,24,20,24,8,8,8,8,4,0,0,0,0
	dc.b	24,20,20,12,20,28,32,28,32,32,28,12,48,44,4,12,24,24,20,12,20,24,24,4,56,48,36,40,40,36,36,36,40,8,8,8,8,8,44,8,8,44,36,44,12,20,4,8,44,36,40,36,40,8,0,28,20,20,20,4,8,8,8,44,0,0,0,0
	dc.b	24,20,20,24,24,32,32,32,32,16,8,48,48,52,4,0,24,32,24,20,20,16,28,4,8,8,44,44,36,36,36,36,44,8,8,44,40,44,8,44,44,40,44,12,24,24,20,12,4,8,44,8,52,12,24,20,20,20,16,20,8,8,44,44,0,0,0,0
	dc.b	32,24,24,24,32,32,28,28,4,44,8,4,12,12,12,12,12,28,28,24,20,16,28,4,4,8,40,36,36,36,36,40,44,8,8,8,8,8,52,8,44,36,44,20,20,20,12,24,32,24,24,24,24,24,24,20,20,16,20,20,8,8,44,40,0,0,0,0
	dc.b	32,32,24,24,32,32,12,8,48,56,12,12,4,4,4,4,12,32,32,24,24,24,32,4,8,44,48,40,36,40,40,40,40,8,4,8,8,8,8,8,8,36,36,20,24,20,12,28,16,20,20,16,12,16,20,24,24,20,28,12,44,48,44,48,0,0,0,0
	dc.b	32,28,32,24,12,4,44,8,20,12,4,4,4,4,12,12,16,32,28,24,32,32,24,4,48,36,40,36,36,36,36,40,36,8,4,8,4,8,8,8,8,40,36,4,24,24,20,20,20,20,16,20,12,12,12,24,24,24,24,8,44,48,48,8,0,0,0,0
	dc.b	24,16,12,4,48,48,8,20,12,0,4,4,4,12,20,20,32,32,24,24,28,32,20,4,48,44,40,36,36,36,40,40,44,4,8,8,8,8,4,4,8,44,4,4,24,24,24,20,20,20,20,20,20,12,12,20,24,24,12,44,8,8,8,8,0,0,0,0
	dc.b	20,20,20,20,20,24,20,20,20,20,20,24,24,4,40,40,40,40,40,40,40,40,40,40,40,36,40,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,20,20,24,24,24,24,24,24,20,20,20,24,24,44,40,40,40,40,40,40,40,40,40,40,40,40,36,36,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,24,28,32,24,24,24,24,24,24,20,20,20,24,4,44,40,40,40,40,40,40,40,40,40,40,40,40,36,36,36,36,36,36,40,36,40,40,40,40,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	28,32,20,4,0,4,8,12,24,20,20,20,20,20,12,44,40,40,40,40,40,40,40,40,40,40,40,36,36,36,36,36,40,40,36,40,40,44,36,44,44,8,8,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	20,4,4,4,4,4,12,4,16,20,20,20,16,16,16,44,40,40,40,40,40,40,40,40,40,40,40,40,36,36,36,40,44,8,8,8,44,40,48,56,12,12,12,4,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,4,4,4,12,12,4,4,12,12,12,16,12,20,12,44,44,40,40,40,40,40,36,40,40,40,36,36,36,36,40,44,12,4,4,4,8,48,12,12,56,4,4,12,4,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	48,48,4,12,4,4,4,0,16,20,24,60,20,16,4,48,44,36,36,40,40,40,40,40,40,40,36,36,36,36,40,8,4,4,4,56,4,4,16,20,0,4,0,12,12,48,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	56,4,4,4,4,20,20,32,32,32,32,32,32,32,32,16,8,40,40,40,40,40,40,36,40,40,36,36,36,36,40,4,12,4,4,4,4,12,12,12,12,0,12,12,12,8,44,40,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,12,16,24,32,32,32,32,32,24,24,32,32,32,32,32,24,8,44,40,36,36,40,40,40,40,40,44,8,44,44,56,4,12,56,8,4,20,4,0,12,12,4,4,4,8,40,44,8,4,48,40,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,32,32,28,32,24,24,28,28,24,32,32,32,32,32,32,28,24,44,40,40,36,36,40,36,40,44,8,4,4,44,4,12,4,56,4,4,12,4,4,12,0,8,4,4,8,8,16,20,20,24,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,32,24,24,32,24,24,24,24,24,28,32,32,24,32,32,32,28,8,36,36,36,40,40,40,44,44,4,8,4,8,4,0,8,4,4,0,12,4,4,12,4,4,4,8,8,20,24,24,24,20,20,8,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,24,20,24,24,20,24,24,20,24,32,20,20,24,28,32,32,32,12,36,40,40,44,40,40,44,8,8,8,4,8,8,4,4,52,4,4,12,4,56,12,4,4,4,16,12,20,20,16,20,20,16,16,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	28,32,24,24,24,24,20,20,24,24,32,32,20,24,24,32,32,32,8,44,36,36,40,40,44,44,44,4,4,4,4,8,4,4,8,4,4,12,4,4,12,4,4,4,24,24,24,20,12,20,24,20,20,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,24,24,32,28,32,32,32,32,32,32,32,24,28,32,32,32,12,48,36,36,40,40,36,40,40,40,4,4,8,4,4,8,4,8,4,4,20,20,0,12,4,8,8,4,20,20,24,20,20,24,20,12,4,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,24,24,32,32,32,32,32,28,32,20,16,20,28,32,16,44,44,40,36,36,36,40,44,44,40,44,4,4,4,4,4,4,56,4,4,0,20,12,0,12,20,16,4,12,12,12,20,12,4,12,4,8,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,32,24,32,28,32,32,32,24,20,12,20,20,20,20,0,44,40,44,44,40,36,40,48,4,44,36,40,44,8,4,4,4,8,4,56,0,4,12,12,12,4,12,24,32,20,24,12,4,4,56,8,8,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,32,32,32,32,32,24,20,20,16,20,16,12,4,48,40,44,40,40,40,40,40,48,8,8,4,8,44,36,40,8,4,4,4,4,4,4,4,4,12,0,12,0,0,20,24,24,0,4,56,8,44,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,28,32,32,24,12,16,56,4,8,48,44,44,40,40,40,36,40,40,40,36,44,52,8,4,4,52,8,48,8,8,4,8,8,8,8,48,40,8,4,12,24,20,20,20,0,4,56,8,44,40,40,40,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,32,28,24,8,8,8,4,48,44,44,40,40,36,40,40,40,40,40,40,36,36,44,48,8,4,4,8,8,4,4,8,8,44,40,36,40,40,40,44,44,4,20,20,24,20,12,8,44,40,40,48,48,44,44,40,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	28,24,4,8,12,8,8,4,48,40,40,40,36,40,40,40,40,40,40,40,40,40,36,44,8,8,4,4,4,8,4,4,8,44,40,40,40,36,44,40,40,44,12,12,20,20,8,36,40,40,44,48,48,44,44,8,4,44,40,40,36,36,36,36,0,0,0,0
	dc.b	24,4,4,8,8,4,52,52,44,44,40,44,44,44,48,48,48,48,44,44,40,40,40,40,48,8,8,8,8,8,4,8,44,36,40,40,36,36,40,36,40,44,20,20,16,20,12,8,48,44,48,48,8,8,16,24,20,20,48,40,36,36,36,36,0,0,0,0
	dc.b	28,24,24,20,20,12,12,12,4,0,12,56,12,12,20,24,28,24,20,12,48,44,44,44,36,8,48,8,8,44,36,40,40,36,40,36,36,36,36,36,40,44,44,12,20,20,12,16,12,4,4,4,24,24,28,32,32,24,12,48,44,36,36,36,0,0,0,0
	dc.b	32,20,20,20,20,20,20,16,20,20,20,20,24,24,24,32,32,32,32,32,20,4,8,8,8,8,8,4,8,8,40,40,40,40,36,36,40,36,40,44,44,44,44,4,20,0,12,0,4,12,24,28,24,20,24,16,32,28,16,8,48,44,36,36,0,0,0,0
	dc.b	24,16,16,16,16,20,16,12,12,4,12,12,20,20,20,32,32,32,32,32,28,0,8,4,4,8,4,8,8,8,36,36,40,40,40,40,36,40,44,44,44,44,44,44,44,8,12,0,16,24,24,20,20,20,20,16,24,32,20,8,48,40,36,36,0,0,0,0
	dc.b	20,16,20,16,16,20,12,12,12,12,12,20,20,24,28,24,24,24,32,32,32,12,4,52,4,4,4,8,8,48,36,40,36,36,36,40,36,40,44,44,44,44,48,44,44,8,0,24,24,16,20,12,20,20,16,16,24,32,16,48,44,40,36,36,0,0,0,0
	dc.b	24,24,24,24,24,20,24,20,20,20,16,20,32,28,32,20,28,24,32,32,28,12,48,8,48,8,48,8,8,40,40,36,36,36,36,36,40,40,40,44,44,44,44,48,8,12,32,24,20,12,12,12,20,20,16,20,24,24,4,48,40,40,40,36,0,0,0,0
	dc.b	20,16,16,20,12,12,12,4,8,12,24,28,32,32,32,32,32,32,32,32,32,4,44,8,44,36,36,40,36,36,36,36,36,40,40,36,44,44,44,44,44,44,44,8,12,24,32,24,16,12,12,12,16,24,24,28,20,4,48,44,44,40,40,36,0,0,0,0
	dc.b	8,8,8,8,8,48,52,48,12,28,28,24,20,24,32,32,32,28,32,32,24,8,8,8,48,44,40,40,40,40,40,36,36,36,40,44,44,8,8,8,48,40,40,8,20,20,20,20,24,16,12,16,24,28,24,12,48,48,48,44,40,36,40,40,0,0,0,0
	dc.b	8,8,8,8,4,8,4,60,32,32,20,16,20,16,20,24,32,32,28,28,12,4,4,4,4,8,48,40,40,36,40,36,44,40,36,44,48,48,48,48,44,48,36,8,20,16,16,12,20,24,28,24,20,4,48,44,48,48,48,44,40,40,36,48,0,0,0,0
	dc.b	8,8,4,8,4,12,28,32,20,16,16,20,16,20,20,24,32,32,28,20,4,4,4,8,4,4,8,44,36,40,36,44,36,36,44,44,48,48,44,8,8,44,44,44,0,24,20,16,20,20,20,12,8,8,44,44,48,48,44,40,44,44,8,48,0,0,0,0
	dc.b	4,8,4,4,20,28,32,20,20,20,20,12,20,20,60,24,32,28,24,4,4,4,4,4,4,8,8,36,40,40,44,36,36,40,44,44,44,40,40,40,44,48,44,44,44,4,12,20,0,4,4,4,12,56,4,8,48,44,44,44,44,48,8,48,0,0,0,0
	dc.b	8,8,0,32,32,24,20,24,20,24,32,28,24,32,32,24,32,32,4,8,8,48,48,48,8,4,8,36,40,36,36,36,36,36,44,44,48,48,44,44,40,44,44,36,40,40,44,8,4,12,12,4,4,0,12,20,56,8,44,44,8,8,8,8,0,0,0,0
	dc.b	4,32,32,28,32,32,32,32,32,32,32,32,32,32,32,32,28,16,24,20,8,44,44,40,44,48,40,40,40,36,36,36,40,36,48,8,8,8,44,48,40,40,40,40,36,40,36,40,40,8,4,12,12,0,0,12,12,20,8,48,8,8,8,8,0,0,0,0
	dc.b	28,32,32,32,32,32,32,32,32,32,28,32,28,32,32,24,12,12,20,24,20,4,8,48,40,40,40,36,40,40,36,36,40,8,48,44,8,8,8,48,48,40,40,40,36,36,40,40,40,36,40,4,12,12,12,12,12,20,20,4,8,8,8,8,0,0,0,0
	dc.b	24,20,32,32,28,32,32,32,32,32,32,28,32,32,24,12,12,12,12,20,28,20,0,4,8,40,40,40,36,36,36,36,48,8,8,8,8,8,8,44,44,36,40,36,44,44,44,44,40,40,40,40,44,4,12,12,24,20,16,20,8,8,48,44,0,0,0,0
	dc.b	20,20,20,32,32,32,32,32,32,32,32,32,28,28,20,16,16,12,12,16,20,32,12,4,52,44,36,44,36,36,36,36,44,8,48,36,40,44,44,44,44,40,36,8,20,24,20,4,48,40,40,40,40,40,4,20,20,20,20,20,8,48,44,44,0,0,0,0
	dc.b	20,16,16,20,32,28,32,32,32,32,28,32,4,4,12,24,24,16,20,12,16,28,20,8,8,44,36,36,40,40,36,36,44,44,44,44,8,52,8,44,40,40,40,56,20,20,20,20,12,4,48,48,8,12,20,20,12,20,20,20,4,48,44,44,0,0,0,0
	dc.b	20,20,16,20,28,28,32,32,32,32,24,8,4,4,12,20,28,32,20,16,16,20,24,4,8,44,48,40,36,36,40,44,8,8,8,4,8,8,8,4,44,36,44,12,20,20,12,20,32,24,24,24,24,32,24,24,20,20,20,20,4,44,44,44,0,0,0,0
	dc.b	20,20,20,20,32,32,28,32,32,0,12,12,12,12,0,4,24,28,28,24,20,20,20,4,8,40,40,36,36,36,40,36,44,8,8,8,8,8,8,8,44,44,40,12,24,20,12,20,20,16,20,16,16,12,20,24,24,20,24,16,8,48,48,8,0,0,0,0
	dc.b	24,24,24,32,28,32,32,24,0,16,12,0,4,4,4,0,16,28,24,28,32,24,32,8,44,44,40,36,36,36,36,40,48,4,8,4,8,8,8,8,44,40,44,8,24,24,24,20,20,20,20,20,20,4,12,20,20,24,24,12,48,8,8,8,0,0,0,0
	dc.b	20,20,16,20,20,20,20,20,20,24,24,20,48,40,36,36,40,40,40,40,40,40,40,40,36,40,40,36,40,36,36,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	16,20,20,24,24,24,24,20,24,20,24,24,12,44,40,36,40,40,40,40,40,40,40,40,40,36,36,40,40,40,36,36,36,36,40,36,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,32,24,24,24,24,24,20,20,20,24,28,52,36,40,40,40,40,40,40,40,40,40,40,40,40,40,36,36,40,36,40,40,40,36,40,36,40,40,36,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	28,28,24,20,20,20,24,24,24,20,16,20,20,4,44,40,40,40,40,40,40,40,40,40,40,40,36,40,40,40,40,40,40,44,44,40,36,44,40,48,4,8,8,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	16,4,4,8,4,4,4,28,20,20,20,16,24,12,44,40,40,40,40,40,40,40,40,40,40,40,36,36,40,36,40,44,8,4,8,8,44,44,52,12,4,12,12,4,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,4,12,4,4,16,16,20,20,20,20,12,44,44,40,40,40,40,40,40,40,40,36,40,40,40,40,40,44,4,4,4,4,4,48,4,12,0,4,4,0,12,8,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	8,4,4,16,12,4,4,12,20,12,12,12,12,4,44,40,40,40,40,40,40,40,40,40,40,40,36,36,40,36,44,4,4,8,12,4,4,12,16,12,4,4,12,12,12,44,40,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,0,4,4,4,20,16,16,20,24,16,16,0,48,44,40,40,40,40,40,40,40,40,40,40,40,40,36,40,8,12,4,4,4,8,56,20,12,12,12,0,12,12,12,44,44,40,44,36,36,36,36,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	4,4,4,4,12,24,32,32,32,32,32,32,32,32,32,0,40,40,40,40,36,40,40,40,40,36,44,44,8,44,8,4,4,12,4,8,12,12,0,12,12,12,4,4,4,44,40,44,8,4,48,36,36,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	12,12,20,32,32,32,32,32,32,32,32,32,32,32,32,32,12,44,44,36,40,36,40,40,36,44,8,4,4,8,8,0,4,4,4,8,12,12,4,12,20,4,8,8,4,44,4,12,20,20,24,8,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,32,32,32,32,32,32,24,24,32,32,32,32,32,32,32,32,8,44,40,36,40,40,40,44,8,8,4,4,8,8,56,4,4,56,8,12,12,4,4,12,4,4,4,8,44,20,24,24,20,16,16,8,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,32,32,24,24,28,24,24,24,28,32,32,32,24,32,32,32,12,44,40,40,36,44,40,40,8,4,8,8,4,8,4,4,4,4,4,12,12,4,12,12,8,4,8,12,0,20,16,20,20,20,20,20,40,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,24,24,24,24,24,20,24,32,24,20,24,24,32,32,32,20,44,40,40,36,40,40,40,48,4,4,4,4,8,8,4,4,8,4,12,4,4,12,12,4,8,4,24,24,24,20,12,20,24,16,20,44,40,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,20,24,24,24,20,20,20,24,32,24,16,24,24,32,24,32,4,40,40,40,40,40,40,36,40,8,4,8,4,4,4,4,4,4,4,4,20,20,0,12,4,8,8,12,24,20,24,20,16,24,20,20,4,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	28,32,24,32,32,32,28,32,32,32,32,32,32,32,32,32,20,8,44,40,36,40,40,40,44,36,44,4,4,4,4,4,4,4,4,4,4,12,12,0,4,12,12,0,8,12,16,20,20,12,4,4,8,8,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,24,24,24,32,32,32,32,32,32,32,24,24,32,32,32,8,44,44,40,40,44,44,8,8,40,40,36,8,4,4,4,8,52,4,12,4,12,12,12,12,4,20,24,24,20,20,4,12,0,0,8,8,44,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,24,32,32,32,32,28,32,32,24,12,16,20,60,12,48,44,36,40,36,36,44,8,4,4,8,44,40,40,48,4,4,8,4,4,8,4,4,4,12,4,4,4,12,24,24,32,12,4,4,8,44,40,36,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	24,32,32,32,28,32,32,24,20,20,20,12,12,48,36,44,40,40,36,40,36,44,52,8,8,4,52,8,44,48,8,4,4,8,4,8,8,44,44,56,4,12,20,12,12,20,12,0,4,8,44,48,40,40,36,36,36,36,36,36,36,36,36,36,0,0,0,0
	dc.b	32,32,32,32,32,24,20,12,4,4,8,44,44,40,44,40,36,40,36,40,40,44,8,8,4,8,8,4,4,4,8,8,8,36,36,40,40,40,40,44,8,12,24,20,24,20,4,8,48,40,44,48,44,44,44,40,36,40,36,36,36,36,36,36,0,0,0,0
	dc.b	24,32,32,28,12,4,8,48,44,44,40,40,36,40,36,36,40,40,40,36,36,36,40,8,4,4,4,8,8,4,4,4,44,40,40,40,36,40,44,36,36,48,20,16,24,20,8,40,40,40,44,44,44,40,44,44,8,48,36,40,36,36,36,36,0,0,0,0
	dc.b	28,32,20,8,8,8,8,44,44,40,40,44,40,36,36,40,40,36,40,40,36,40,40,44,48,8,8,4,8,4,4,48,40,40,36,36,36,36,36,40,40,8,24,20,16,20,4,48,44,44,44,48,8,48,4,20,20,20,44,40,36,36,36,36,0,0,0,0
	dc.b	24,4,8,8,4,4,8,40,40,44,40,40,44,40,40,44,40,44,36,40,40,40,44,40,48,8,8,8,48,40,40,40,40,40,40,36,36,36,36,48,44,44,4,12,20,20,12,12,56,4,4,8,4,12,24,32,32,24,12,48,44,36,36,36,0,0,0,0
	dc.b	4,4,4,4,52,4,8,44,44,44,48,48,48,8,4,4,0,4,8,44,44,8,48,48,48,8,8,8,8,36,40,40,40,40,36,36,36,40,44,44,44,44,44,12,20,12,12,12,4,0,12,12,24,24,24,28,32,28,20,4,44,44,36,36,0,0,0,0
	dc.b	24,24,20,16,24,24,16,20,16,20,20,24,32,20,32,32,32,32,28,16,4,8,4,4,4,4,4,52,8,40,36,36,40,40,40,40,36,36,44,44,44,44,44,48,8,4,16,4,4,16,24,28,24,24,20,32,28,32,24,4,44,40,36,36,0,0,0,0
	dc.b	24,20,20,20,16,20,20,20,12,20,16,20,20,24,32,32,32,32,32,32,20,48,52,52,8,4,4,8,8,40,40,40,36,40,36,36,36,36,44,44,44,44,48,44,44,44,8,4,24,24,20,20,20,20,20,20,24,24,28,8,36,40,36,40,0,0,0,0
	dc.b	20,16,20,20,20,16,4,0,0,12,12,20,20,24,32,32,32,32,32,32,28,52,8,52,4,52,8,8,48,40,40,40,40,40,36,40,40,40,44,44,44,48,44,48,44,8,12,24,20,20,20,16,20,20,12,20,24,24,20,44,44,40,40,40,0,0,0,0
	dc.b	16,20,20,16,20,12,12,12,12,20,16,16,20,28,28,24,32,32,32,32,28,4,44,44,44,40,44,40,40,40,36,40,40,40,40,36,44,44,44,44,44,44,48,44,8,20,24,24,20,12,12,12,20,20,20,20,32,20,8,44,44,40,40,40,0,0,0,0
	dc.b	24,20,24,20,20,20,24,20,20,20,20,20,32,32,20,32,24,32,32,32,32,4,8,8,44,40,40,40,40,40,40,40,40,40,44,44,44,48,8,48,48,40,40,48,12,20,24,24,24,20,12,12,16,24,24,32,16,8,48,44,40,40,40,44,0,0,0,0
	dc.b	20,24,20,12,12,56,8,8,48,52,20,32,32,32,32,32,32,32,32,32,28,4,8,8,48,44,36,40,40,40,36,36,44,40,48,44,48,48,44,48,48,44,40,8,20,20,20,12,20,16,20,20,24,32,16,0,48,44,44,44,40,36,44,48,0,0,0,0
	dc.b	4,8,52,48,4,8,40,44,52,24,28,24,32,32,32,32,32,32,32,32,24,4,52,4,4,8,44,40,40,36,36,44,40,40,44,44,48,44,48,8,48,44,36,8,16,20,20,12,20,32,24,28,20,4,44,44,48,48,44,44,44,48,8,48,0,0,0,0
	dc.b	8,8,4,4,52,48,48,56,28,28,24,20,20,20,24,24,32,28,32,32,4,4,4,4,8,4,8,36,40,40,44,36,40,36,44,44,40,36,40,44,48,48,48,36,8,20,20,20,20,20,20,0,4,4,8,48,48,44,48,40,44,8,8,48,0,0,0,0
	dc.b	8,8,4,8,4,4,20,28,24,20,20,20,20,20,20,24,24,32,32,20,8,4,4,4,4,8,44,40,40,40,36,36,36,40,44,44,44,44,44,44,40,44,40,40,40,44,4,4,12,4,56,4,0,0,20,12,8,48,44,44,8,8,8,8,0,0,0,0
	dc.b	8,8,8,8,12,32,28,24,16,16,16,20,20,20,20,24,32,32,20,8,44,44,44,48,8,48,40,40,40,36,36,36,40,48,8,8,8,8,8,44,40,40,40,36,40,44,44,44,8,4,12,12,4,4,12,12,12,12,8,44,8,8,8,8,0,0,0,0
	dc.b	52,8,4,24,32,32,32,24,24,32,32,28,32,32,32,32,32,32,4,48,44,44,44,36,36,44,36,40,36,40,40,36,36,8,8,8,8,8,48,48,44,40,40,40,36,40,40,40,40,40,48,56,12,12,4,4,12,12,12,4,44,8,8,8,0,0,0,0
	dc.b	8,0,28,28,32,32,32,32,28,32,32,32,32,32,32,32,32,20,24,16,4,4,8,48,40,36,40,40,36,40,36,36,48,44,8,8,48,8,48,48,44,40,40,40,40,36,40,40,40,36,40,44,8,16,12,12,20,12,12,20,8,48,36,44,0,0,0,0
	dc.b	20,32,32,32,32,32,28,32,32,32,32,32,32,32,32,32,24,20,20,24,20,4,56,4,44,40,40,44,36,36,36,40,48,8,44,40,44,44,48,44,40,40,40,36,8,4,8,44,40,40,40,40,40,48,4,12,24,20,16,20,8,44,44,44,0,0,0,0
	dc.b	32,32,32,32,32,28,32,32,32,32,32,24,32,32,32,24,4,12,20,20,24,20,4,52,8,40,36,36,36,36,40,44,8,44,36,44,44,8,48,40,40,40,40,44,20,20,24,12,4,44,40,40,40,40,8,12,24,20,20,20,4,44,44,44,0,0,0,0
	dc.b	20,32,32,32,32,32,32,32,32,32,32,32,32,32,24,16,12,12,12,20,24,32,0,8,8,40,48,36,40,36,40,48,44,8,8,8,8,4,8,8,40,36,40,4,20,20,20,20,12,4,8,48,8,4,16,20,12,16,20,20,12,8,44,44,0,0,0,0
	dc.b	20,20,28,32,32,32,32,28,32,32,32,28,24,16,20,24,16,20,16,12,20,24,20,4,48,40,40,36,36,36,40,44,8,8,8,8,8,8,8,48,40,44,40,4,20,20,20,12,24,24,24,24,24,24,24,24,24,16,20,20,12,44,48,8,0,0,0,0
	dc.b	16,20,20,32,32,32,32,24,20,32,32,32,12,12,16,32,24,20,20,16,20,24,20,8,44,40,40,36,36,40,36,40,8,8,8,8,8,8,8,44,44,40,44,4,20,24,12,20,24,20,20,20,20,20,16,20,24,20,20,20,4,8,8,8,0,0,0,0
