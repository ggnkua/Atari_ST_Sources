	dc.b	1,0,0,1,1,1,3,1,0,0,2,2,2,3,0,0,0,2,2,1,2,0,0,0,2,1,2,2,0,0,0,3,1,2,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,1,1,0,0,0,3,0,1,1,0,0,0,2,0,2,1,0,0,1,2,0,2,1,0,0,2,2,0,2,0,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,2,3,0,0,0,2,1,2,2,0,0,1,4,2,2,2,0,0,1,4,2,2,1,0,0,1,2,2,2,1,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,1,2,1,0,0,2,1,0,2,0,0,0,2,1,0,2,0,0,0,2,0,1,2,0,0,0,2,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,2,4,0,0,0,2,2,2,2,0,0,0,2,2,1,4,0,0,0,2,2,2,2,0,0,0,2,1,2,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,1,2,0,0,0,2,0,1,1,0,0,0,2,1,2,1,0,0,1,2,0,2,1,0,0,2,2,0,2,1,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,2,2,0,0,0,4,2,2,2,0,0,0,4,2,2,2,0,0,1,2,1,2,1,0,0,1,2,1,4,1,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,1,0,2,1,0,0,2,2,1,2,0,0,0,2,1,1,4,0,0,0,2,1,1,2,0,0,0,2,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,4,0,0,0,2,2,1,4,0,0,0,2,2,1,2,0,0,0,2,2,2,2,0,0,0,4,2,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,1,2,0,0,0,4,0,1,2,0,0,0,2,1,2,1,0,0,1,2,1,2,2,0,0,1,2,1,2,1,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,4,2,2,2,0,0,0,4,1,2,2,0,0,1,4,2,2,1,0,0,1,2,2,4,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,2,1,0,0,2,1,1,2,0,0,0,2,1,1,2,0,0,0,2,1,1,2,0,0,0,2,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,1,2,0,0,0,2,2,2,4,0,0,0,2,2,1,4,0,0,0,2,1,2,2,0,0,0,4,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,1,2,0,0,0,4,1,1,2,0,0,0,2,1,2,2,0,0,1,2,1,2,2,0,0,2,2,1,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,2,2,0,0,0,2,1,2,2,0,0,1,4,1,2,2,0,0,0,4,1,2,1,0,0,1,2,1,4,1,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,4,0,0,0,2,1,1,2,0,0,0,2,1,1,4,0,0,0,2,1,1,2,0,0,0,2,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,0,0,0,2,2,1,2,0,0,0,2,1,1,2,0,0,0,4,1,2,2,0,0,0,4,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,2,2,0,0,0,4,1,1,2,0,0,1,2,1,2,2,0,0,1,2,1,2,1,0,0,1,2,1,4,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,4,1,1,2,0,0,0,4,1,2,2,0,0,0,4,1,2,1,0,0,1,2,1,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,1,4,0,0,0,2,2,1,2,0,0,0,2,1,1,4,0,0,0,2,2,1,2,0,0,0,4,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,0,0,0,2,1,1,4,0,0,0,2,1,1,4,0,0,0,2,2,1,4,0,0,0,4,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,1,2,0,0,0,4,1,2,2,0,0,0,2,1,2,1,0,0,1,2,1,2,1,0,0,1,2,1,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,1,2,0,0,0,4,1,1,2,0,0,0,2,1,2,1,0,0,1,2,1,2,1,0,0,1,2,2,2,1,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,2,2,1,0,0,2,2,2,2,0,0,0,2,1,1,2,0,0,0,2,2,1,2,0,0,0,4,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,1,2,1,0,0,2,1,1,2,0,0,0,2,1,1,2,0,0,0,4,1,1,2,0,0,0,2,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,2,1,2,2,0,0,1,4,1,1,1,0,0,1,2,1,2,1,0,0,2,2,2,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,1,1,4,0,0,0,4,1,1,2,0,0,0,2,1,2,2,0,0,1,2,1,2,1,0,0,1,2,1,2,1,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,4,0,0,0,2,2,1,4,0,0,0,2,1,1,2,0,0,0,2,1,2,2,0,0,0,2,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,1,0,0,2,1,1,2,0,0,0,2,1,1,2,0,0,0,4,1,1,2,0,0,0,4,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,4,1,2,2,0,0,1,4,1,2,1,0,0,1,2,1,2,1,0,0,1,2,1,4,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,1,2,0,0,0,4,0,1,2,0,0,0,2,1,2,2,0,0,1,4,1,2,2,0,0,2,2,1,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,0,0,0,2,2,1,4,0,0,0,2,1,1,2,0,0,0,2,2,1,2,0,0,0,2,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,1,0,0,2,1,1,4,0,0,0,2,1,1,2,0,0,0,2,1,2,2,0,0,0,2,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,1,2,0,0,0,4,1,2,2,0,0,0,4,1,2,1,0,0,1,4,1,2,1,0,0,1,2,1,4,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,1,2,0,0,0,2,0,2,2,0,0,0,2,1,2,2,0,0,1,2,1,2,2,0,0,1,2,1,2,1,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,4,1,0,0,2,2,2,2,0,0,0,2,2,1,4,0,0,0,2,1,2,2,0,0,0,4,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,1,1,0,4,0,0,0,2,1,0,4,0,0,0,2,1,1,4,0,0,0,4,1,1,2,0,0,0,2,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,2,2,0,0,0,4,1,2,2,0,0,1,4,2,2,2,0,0,1,2,1,2,1,0,0,1,2,2,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,1,1,2,0,0,0,4,0,1,2,0,0,0,2,1,1,2,0,0,1,2,0,2,1,0,0,1,2,0,2,1,0,0,2,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,4,0,0,0,2,2,1,4,0,0,0,2,2,1,4,0,0,0,4,1,2,4,0,0,0,4,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,1,2,0,2,1,0,0,2,1,0,2,0,0,0,2,1,0,4,0,0,0,2,1,1,2,0,0,0,2,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,2,2,0,0,0,4,2,2,2,0,0,1,4,1,4,1,0,0,0,4,1,4,1,0,0,0,4,1,4,1,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,1,1,2,0,0,0,2,0,1,2,0,0,1,2,1,1,2,0,0,1,2,1,2,2,0,0,2,2,0,2,1,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,1,4,1,0,0,2,2,1,2,0,0,0,2,2,1,2,0,0,0,2,2,1,3,0,0,0,2,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,1,1,0,2,1,0,0,2,1,1,2,0,0,0,2,1,0,2,0,0,0,2,1,1,2,0,0,0,2,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,1,3,0,0,0,2,1,2,1,0,0,1,2,2,2,2,0,0,1,4,1,2,1,0,0,0,3,1,3,1,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,1,1,0,0,1,2,0,1,2,0,0,0,2,0,1,2,0,0,1,1,1,2,2,0,0,1,1,1,1,1,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,1,1,2,0,0,0,2,1,1,4,0,0,0,2,2,2,2,0,0,0,2,1,1,2,0,0,0,3,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	1,0,0,1,2,1,3,1,0,0,2,2,2,3,0,0,0,2,2,2,2,0,0,0,2,2,1,2,0,0,0,2,1,2,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,1,2,0,0,0,2,0,1,1,0,0,0,2,0,1,2,0,0,1,2,1,2,1,0,0,2,2,0,2,1,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,2,2,0,0,0,4,2,2,2,0,0,1,4,2,2,1,0,0,1,4,1,2,1,0,0,1,2,2,2,1,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,1,2,0,0,0,2,1,0,2,0,0,0,2,1,1,2,0,0,0,2,1,1,2,0,0,0,2,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,2,2,1,0,0,2,2,2,4,0,0,0,2,2,2,4,0,0,0,2,2,2,4,0,0,0,4,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,1,1,2,0,0,1,2,0,1,2,0,0,0,2,1,1,2,0,0,1,2,0,2,1,0,0,1,2,0,2,1,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,2,2,0,0,0,4,2,2,2,0,0,1,2,2,2,2,0,0,1,2,1,4,1,0,0,1,2,1,4,1,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,1,1,1,2,0,0,0,2,1,1,2,0,0,0,2,1,0,4,0,0,0,2,1,1,2,0,0,0,2,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,4,0,0,0,2,2,1,4,0,0,0,2,2,1,2,0,0,0,2,2,1,4,0,0,0,4,2,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,1,2,0,0,0,4,0,1,2,0,0,0,2,1,2,1,0,0,1,2,0,2,1,0,0,1,2,1,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,1,2,0,0,0,4,2,1,2,0,0,1,2,2,2,2,0,0,1,4,1,2,1,0,0,1,2,2,4,0,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,2,1,0,0,2,2,1,2,0,0,0,2,1,1,4,0,0,0,4,1,1,2,0,0,0,2,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,0,0,0,2,2,1,4,0,0,0,2,2,1,4,0,0,0,2,1,2,2,0,0,0,4,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,1,2,0,0,0,4,1,1,2,0,0,0,2,1,1,2,0,0,0,2,1,2,2,0,0,1,4,0,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,2,2,0,0,0,4,1,2,2,0,0,1,4,1,2,2,0,0,1,4,1,2,1,0,0,1,4,1,4,0,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,0,0,0,2,1,1,2,0,0,0,2,1,1,4,0,0,0,2,1,1,4,0,0,0,2,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,1,4,0,0,0,1,2,1,2,0,0,0,2,1,1,2,0,0,0,4,1,1,4,0,0,0,4,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,1,4,0,0,0,4,1,1,2,0,0,1,2,1,2,2,0,0,1,2,1,2,1,0,0,1,2,1,4,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,4,1,2,2,0,0,0,4,1,2,1,0,0,1,2,1,2,1,0,0,1,2,1,2,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,1,4,0,0,0,2,2,1,2,0,0,0,2,1,1,4,0,0,0,4,1,1,2,0,0,0,4,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,0,0,0,2,1,1,2,0,0,0,2,1,1,2,0,0,0,4,1,1,4,0,0,0,4,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,2,2,0,0,0,4,1,2,2,0,0,1,2,1,1,1,0,0,1,2,1,2,1,0,0,1,2,0,4,1,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,1,2,0,0,0,4,1,1,2,0,0,0,2,1,2,1,0,0,0,2,1,2,1,0,0,2,2,2,4,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,1,0,0,2,2,1,2,0,0,0,1,1,1,3,0,0,0,2,1,1,2,0,0,0,2,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,0,0,0,2,2,1,2,0,0,0,2,1,1,2,0,0,0,2,1,1,2,0,0,0,4,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,1,2,0,0,0,4,1,2,2,0,0,1,2,1,1,1,0,0,1,2,1,2,1,0,0,1,2,1,2,1,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,1,2,0,0,1,4,1,1,2,0,0,0,2,1,2,1,0,0,1,2,1,2,1,0,0,1,2,1,4,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,0,0,0,2,2,1,4,0,0,0,2,1,1,2,0,0,0,4,1,1,4,0,0,0,4,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,1,4,0,0,0,2,1,1,2,0,0,0,2,1,1,2,0,0,0,2,1,1,4,0,0,0,4,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,4,1,1,2,0,0,0,2,1,2,1,0,0,1,2,1,2,1,0,0,1,2,1,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,1,2,0,0,0,2,1,1,2,0,0,0,4,1,2,2,0,0,1,2,1,2,2,0,0,2,2,1,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,1,0,0,2,2,1,4,0,0,0,2,1,1,2,0,0,0,2,2,1,2,0,0,0,2,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,4,0,0,0,2,1,1,4,0,0,0,2,1,1,4,0,0,0,2,1,1,4,0,0,0,4,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,1,4,0,0,0,4,1,2,2,0,0,0,4,1,2,1,0,0,0,2,1,2,1,0,0,1,2,1,4,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,1,2,0,0,0,4,1,1,2,0,0,0,2,1,2,2,0,0,2,2,1,2,1,0,0,1,2,1,2,1,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,1,2,1,0,0,2,2,2,2,0,0,0,2,2,1,4,0,0,0,4,1,2,2,0,0,0,4,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,2,1,1,2,0,0,0,2,1,1,4,0,0,0,2,1,1,4,0,0,0,4,1,1,2,0,0,0,4,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,2,2,0,0,0,4,1,2,2,0,0,0,4,2,2,1,0,0,1,4,1,2,1,0,0,1,2,1,4,0,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,1,1,2,0,0,0,2,1,1,2,0,0,0,2,1,2,2,0,0,0,2,1,2,1,0,0,1,2,1,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,4,0,0,0,2,2,1,4,0,0,0,2,2,1,4,0,0,0,2,2,1,4,0,0,0,4,2,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,2,2,0,2,1,0,0,2,1,1,2,0,0,0,2,1,0,2,0,0,0,2,1,1,2,0,0,0,2,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,2,2,0,0,0,2,2,2,2,0,0,0,4,1,2,1,0,0,1,4,2,2,1,0,0,1,4,1,2,1,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,1,1,2,0,0,1,2,0,1,2,0,0,1,2,1,2,2,0,0,1,2,0,2,1,0,0,1,2,0,2,2,0,0,2,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,2,4,0,0,0,2,2,1,2,0,0,0,2,2,1,4,0,0,0,2,2,2,2,0,0,0,2,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,2,1,0,2,1,0,0,2,1,1,4,0,0,0,2,0,1,2,0,0,0,2,1,1,2,0,0,0,2,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,1,1,2,0,0,0,2,1,2,2,0,0,0,4,1,2,2,0,0,0,4,1,4,1,0,0,1,2,1,3,1,0,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,1,1,2,0,0,1,2,0,1,2,0,0,0,2,1,1,2,0,0,1,2,0,2,2,0,0,1,2,1,1,1,0,0,2,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,1,1,2,1,0,0,2,2,2,2,0,0,0,2,2,1,2,0,0,0,2,1,1,2,0,0,0,3,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,0,0,1,2,2,2,1,0,0,2,2,2,2,1,0,0,2,2,1,2,0,0,0,2,2,2,2,0,0,0,2,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,1,2,0,0,0,2,0,1,2,0,0,0,2,0,1,2,0,0,1,2,1,2,1,0,0,1,2,0,2,1,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,2,2,0,0,0,4,2,2,2,0,0,0,4,2,2,2,0,0,1,4,2,2,1,0,0,1,4,1,4,0,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,2,1,0,0,2,1,1,2,0,0,0,2,1,1,2,0,0,0,2,1,1,2,0,0,0,4,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,2,4,0,0,0,2,2,2,4,0,0,0,2,2,1,4,0,0,0,4,2,2,2,0,0,0,2,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,1,1,2,0,0,1,2,0,1,2,0,0,0,2,1,1,2,0,0,1,2,0,2,1,0,0,2,2,1,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,2,2,0,0,0,4,2,2,2,0,0,1,2,2,2,2,0,0,0,4,1,4,1,0,0,1,2,1,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,2,1,1,2,0,0,0,2,1,1,2,0,0,0,2,1,1,4,0,0,0,2,1,1,2,0,0,0,4,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,4,0,0,0,2,2,1,4,0,0,0,2,2,1,2,0,0,0,2,2,2,2,0,0,0,4,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,1,1,2,0,0,0,4,0,1,2,0,0,0,2,1,2,1,0,0,1,2,0,2,1,0,0,2,2,0,2,2,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,4,2,2,2,0,0,1,4,1,2,2,0,0,1,4,1,2,1,0,0,1,2,2,4,0,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,2,1,0,0,2,1,1,2,0,0,0,2,1,1,4,0,0,0,2,1,1,2,0,0,0,2,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,0,0,0,2,2,1,4,0,0,0,2,2,1,4,0,0,0,4,1,2,4,0,0,0,4,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,1,2,0,0,1,2,0,2,2,0,0,0,2,1,2,2,0,0,0,2,1,2,1,0,0,1,2,1,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,2,2,0,0,0,2,2,2,2,0,0,0,4,1,2,1,0,0,1,4,1,2,1,0,0,1,2,1,4,1,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,4,0,0,0,2,2,1,2,0,0,0,2,1,1,4,0,0,0,4,1,1,2,0,0,0,2,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,0,0,0,2,2,1,2,0,0,0,2,1,1,2,0,0,0,2,2,1,2,0,0,0,4,2,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,2,2,0,0,0,4,1,1,2,0,0,1,4,1,2,2,0,0,1,2,1,2,1,0,0,2,2,1,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,2,2,0,0,1,2,1,2,2,0,0,0,2,1,2,1,0,0,1,2,1,2,2,0,0,1,2,1,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,4,0,0,0,2,2,1,2,0,0,0,2,1,1,2,0,0,0,2,1,1,2,0,0,0,4,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,0,0,0,2,1,1,2,0,0,0,2,1,1,2,0,0,0,2,2,1,4,0,0,0,4,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,1,2,0,0,0,4,1,2,2,0,0,1,2,1,1,1,0,0,1,2,1,2,1,0,0,1,2,1,4,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,1,2,0,0,0,4,1,1,2,0,0,0,2,1,1,1,0,0,0,2,1,2,1,0,0,1,2,1,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,2,1,0,0,2,2,1,2,0,0,0,1,1,1,3,0,0,0,4,1,1,2,0,0,0,4,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,0,0,0,2,1,1,2,0,0,0,1,1,1,2,0,0,0,2,1,1,2,0,0,0,4,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,1,2,0,0,0,4,1,2,2,0,0,1,2,1,1,1,0,0,1,2,1,2,1,0,0,2,2,1,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,1,2,2,0,0,0,4,1,1,2,0,0,0,2,1,3,1,0,0,1,2,0,2,1,0,0,1,2,1,4,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,4,0,0,0,2,2,1,2,0,0,0,2,1,1,2,0,0,0,2,1,2,2,0,0,0,4,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,2,2,1,2,1,0,0,2,1,1,2,0,0,0,2,1,0,3,0,0,0,2,2,1,2,0,0,0,4,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,2,2,0,0,0,4,1,2,2,0,0,1,2,1,1,2,0,0,1,2,1,2,1,0,0,1,2,1,4,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,1,2,0,0,0,2,1,1,2,0,0,0,2,1,2,2,0,0,1,2,1,2,1,0,0,2,2,1,2,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,1,0,0,2,2,1,2,1,0,0,2,1,1,2,0,0,0,4,1,1,2,0,0,0,4,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,4,0,0,0,2,1,1,4,0,0,0,2,1,1,4,0,0,0,2,1,1,4,0,0,0,4,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,2,2,0,0,0,4,1,2,2,0,0,0,4,2,2,1,0,0,0,4,1,2,1,0,0,1,2,1,4,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,1,2,0,0,0,4,1,1,2,0,0,0,2,1,2,2,0,0,1,2,1,1,1,0,0,1,2,1,2,2,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,1,4,0,0,0,2,2,2,2,0,0,0,2,2,1,4,0,0,0,2,2,2,2,0,0,0,2,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,2,1,0,0,2,1,1,4,0,0,0,2,1,1,4,0,0,0,4,1,1,2,0,0,0,4,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,4,1,2,2,0,0,0,4,1,2,2,0,0,0,4,1,4,1,0,0,1,2,2,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,1,1,4,0,0,0,2,1,1,2,0,0,0,2,1,2,2,0,0,1,2,0,2,2,0,0,2,2,0,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,2,4,0,0,0,2,2,1,4,0,0,0,2,2,1,4,0,0,0,2,1,2,2,0,0,0,4,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,2,2,0,2,1,0,0,2,1,1,2,0,0,0,2,1,0,4,0,0,0,2,1,1,2,0,0,0,4,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,2,2,0,0,0,4,1,2,2,0,0,0,4,1,2,1,0,0,1,2,2,2,1,0,0,1,4,1,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,1,2,0,0,0,4,0,2,2,0,0,1,2,1,2,2,0,0,1,2,0,2,2,0,0,2,2,0,2,2,0,0,2,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,2,4,0,0,0,2,2,1,4,0,0,0,2,2,1,4,0,0,0,2,2,1,4,0,0,0,2,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,2,1,0,2,1,0,0,2,1,1,2,0,0,0,2,1,0,2,0,0,0,2,1,0,2,0,0,0,2,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,1,2,2,0,0,0,4,1,2,2,0,0,0,4,1,2,2,0,0,1,4,2,2,1,0,0,1,2,2,3,1,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,1,1,2,0,0,0,2,1,1,2,0,0,1,2,1,1,2,0,0,1,2,0,2,2,0,0,1,2,1,1,1,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,1,2,1,0,0,2,2,1,2,0,0,0,2,2,2,2,0,0,0,2,1,2,2,0,0,0,3,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,0,0,1,2,1,4,1,0,0,2,2,1,4,0,0,0,2,2,1,3,0,0,0,2,2,1,2,0,0,0,4,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,1,2,0,0,0,2,0,1,2,0,0,0,2,0,1,2,0,0,1,2,0,2,2,0,0,2,2,0,2,1,0,0,2,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,1,2,2,0,0,0,4,2,2,2,0,0,1,4,2,2,2,0,0,0,4,2,2,1,0,0,1,2,2,4,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,2,2,1,2,1,0,0,2,1,1,2,0,0,0,2,1,1,4,0,0,0,2,1,1,2,0,0,0,2,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,4,0,0,0,2,2,1,4,0,0,0,2,2,1,4,0,0,0,4,2,2,2,0,0,0,4,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,1,2,0,0,0,2,0,2,2,0,0,0,2,1,1,2,0,0,1,2,0,2,1,0,0,1,2,1,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,2,2,0,0,0,4,2,2,2,0,0,0,4,1,2,2,0,0,1,3,1,2,1,0,0,2,2,1,3,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,2,1,0,2,1,0,0,2,1,1,3,0,0,0,2,1,1,2,0,0,0,2,1,1,2,0,0,0,2,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,4,0,0,0,2,2,1,4,0,0,0,2,2,1,2,0,0,0,2,2,2,2,0,0,0,4,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,1,1,2,0,0,1,2,0,1,2,0,0,0,2,0,2,2,0,0,1,2,1,2,2,0,0,2,2,1,2,0,0,0,2,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,4,2,2,2,0,0,0,4,2,2,1,0,0,1,3,1,2,1,0,0,1,2,2,4,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,2,1,0,0,2,1,1,2,0,0,0,2,1,1,3,0,0,0,2,0,1,2,0,0,0,2,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,1,0,0,2,2,2,4,0,0,0,2,2,1,2,0,0,0,4,1,2,2,0,0,0,3,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,1,2,0,0,0,2,0,2,2,0,0,0,2,1,2,2,0,0,1,2,1,2,2,0,0,2,2,1,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,2,2,0,0,0,4,1,2,2,0,0,0,3,1,2,2,0,0,1,2,2,2,1,0,0,1,2,2,2,1,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,0,0,0,2,2,1,2,0,0,0,2,1,1,4,0,0,0,2,1,1,2,0,0,0,4,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,0,0,0,2,1,1,4,0,0,0,2,1,1,2,0,0,0,3,1,2,2,0,0,0,4,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,2,2,0,0,0,3,1,1,2,0,0,0,2,1,1,2,0,0,1,2,1,2,1,0,0,1,2,1,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,4,1,2,2,0,0,0,2,1,2,1,0,0,0,2,1,2,1,0,0,2,2,1,3,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,1,2,1,0,0,2,1,1,2,1,0,0,2,1,1,2,0,0,0,2,1,1,2,0,0,0,3,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,4,0,0,0,1,2,1,3,0,0,0,1,1,1,3,0,0,0,2,1,1,2,0,0,0,4,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,2,2,0,0,0,4,1,1,2,0,0,1,1,1,1,1,0,0,1,2,1,2,1,0,0,2,2,2,2,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,1,2,0,0,0,4,1,2,1,0,0,0,2,1,1,1,0,0,1,2,0,2,2,0,0,2,2,1,4,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,1,0,0,2,2,1,1,0,0,1,1,1,1,1,0,0,0,2,1,1,2,0,0,0,2,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,0,4,1,0,0,2,1,1,2,0,0,0,1,1,0,3,0,0,0,2,1,1,2,0,0,0,4,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,2,1,2,2,0,0,0,2,1,1,1,0,0,1,1,1,2,1,0,0,1,2,1,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,1,2,2,0,0,0,4,1,2,2,0,0,0,2,0,1,1,0,0,1,2,0,1,1,0,0,1,2,1,4,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,3,0,0,0,2,1,1,2,1,0,0,2,1,1,2,0,0,0,2,1,2,2,0,0,0,4,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,2,2,1,2,1,0,0,2,1,1,2,0,0,0,1,1,0,2,0,0,0,2,2,1,3,0,0,0,4,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,2,2,0,0,1,2,1,1,2,0,0,0,2,1,2,2,0,0,1,2,1,2,1,0,0,1,2,1,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,1,2,0,0,0,4,1,1,2,0,0,1,2,1,1,1,0,0,1,2,1,2,1,0,0,1,2,1,2,1,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,0,0,0,2,2,1,2,0,0,0,3,1,1,2,0,0,0,3,1,2,2,0,0,0,2,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,4,0,0,0,2,2,1,3,0,0,0,2,2,0,4,0,0,0,2,1,1,2,0,0,0,4,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,2,2,0,0,0,4,1,2,2,0,0,0,3,1,2,1,0,0,1,2,1,2,2,0,0,1,2,1,4,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,1,2,0,0,1,2,0,2,2,0,0,0,2,1,2,2,0,0,1,2,1,2,1,0,0,2,2,1,2,1,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,4,0,0,0,2,2,1,4,0,0,0,2,2,2,2,0,0,0,2,2,1,3,0,0,0,4,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,1,0,2,1,0,0,2,1,1,2,0,0,0,2,1,1,3,0,0,0,2,1,1,2,0,0,0,4,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,4,1,2,2,0,0,0,4,2,2,2,0,0,1,2,1,2,2,0,0,2,2,1,3,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,1,2,0,0,0,2,1,1,2,0,0,0,2,1,2,2,0,0,2,2,0,2,2,0,0,1,2,1,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,4,0,0,0,2,2,2,3,0,0,0,2,2,1,2,0,0,0,2,2,2,2,0,0,0,4,2,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,2,1,0,2,1,0,0,2,1,1,2,0,0,0,2,1,0,2,0,0,0,2,1,1,2,0,0,0,2,1,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,3,0,0,0,4,2,2,2,0,0,0,4,2,2,1,0,0,1,3,2,2,1,0,0,1,2,2,3,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,1,2,0,0,0,3,0,1,2,0,0,1,2,0,2,2,0,0,1,2,0,2,2,0,0,2,2,0,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,2,4,0,0,0,2,2,1,3,0,0,0,2,2,1,3,0,0,0,2,1,2,4,0,0,0,4,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,2,1,0,0,2,1,0,3,0,0,0,2,1,0,2,0,0,0,2,1,0,2,0,0,0,2,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,2,2,0,0,0,2,2,2,2,0,0,0,4,1,2,2,0,0,1,2,2,3,1,0,0,1,2,2,4,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,1,1,2,0,0,1,2,0,2,2,0,0,1,2,1,1,2,0,0,1,2,0,2,2,0,0,2,2,0,2,1,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,2,4,0,0,0,2,2,1,4,0,0,0,2,2,2,2,0,0,0,2,2,1,2,0,0,0,2,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,0,0,1,2,2,2,0,0,0,2,2,2,3,0,0,0,2,2,1,2,0,0,0,2,2,2,2,0,0,0,3,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,1,2,0,0,0,3,0,2,2,0,0,0,2,0,2,2,0,0,2,2,1,2,2,0,0,2,2,0,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,2,2,0,0,0,3,2,2,2,0,0,1,4,2,2,2,0,0,0,4,2,2,1,0,0,1,3,2,4,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,3,2,0,0,2,1,0,2,0,0,0,2,1,0,2,0,0,0,2,2,0,2,0,0,0,2,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,2,4,0,0,0,2,2,2,4,0,0,0,2,2,2,3,0,0,0,3,2,1,2,0,0,0,3,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,2,2,0,0,0,2,0,2,2,0,0,0,3,0,2,2,0,0,1,2,0,2,1,0,0,2,2,0,2,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,2,2,0,0,0,3,2,2,2,0,0,0,4,2,2,2,0,0,0,4,2,2,2,0,0,2,3,2,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,1,0,2,1,0,0,2,2,1,2,0,0,0,2,1,1,3,0,0,0,2,1,1,2,0,0,0,2,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,3,0,0,0,2,2,1,3,0,0,0,2,2,1,3,0,0,0,2,2,2,3,0,0,0,3,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,1,2,0,0,0,3,0,1,2,0,0,0,2,1,2,2,0,0,1,2,0,2,2,0,0,1,2,0,3,2,0,0,2,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,3,2,2,2,0,0,0,3,2,2,2,0,0,0,3,2,2,0,0,0,1,2,2,3,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,3,1,0,0,2,1,1,2,0,0,0,2,1,0,3,0,0,0,2,2,2,2,0,0,0,2,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,1,2,0,0,0,2,2,2,3,0,0,0,2,2,1,3,0,0,0,2,1,2,3,0,0,0,3,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,3,0,1,2,0,0,0,2,1,2,2,0,0,1,2,0,2,2,0,0,1,2,0,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,2,2,0,0,0,2,2,2,2,0,0,0,3,2,2,1,0,0,1,2,1,3,0,0,0,1,3,2,3,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,3,0,0,0,2,2,2,2,0,0,0,2,1,2,3,0,0,0,3,1,2,2,0,0,0,2,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,0,0,0,2,2,1,2,0,0,0,2,1,1,2,0,0,0,2,2,2,2,0,0,0,3,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,2,2,0,0,0,3,0,2,2,0,0,0,2,0,1,2,0,0,1,2,1,2,1,0,0,1,2,1,2,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,2,2,0,0,0,4,1,2,2,0,0,0,2,1,2,1,0,0,1,2,0,2,1,0,0,2,2,2,2,1,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,2,1,0,0,2,1,1,2,1,0,0,1,1,1,2,0,0,0,2,1,1,2,0,0,0,2,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,0,0,0,1,2,1,1,0,0,0,1,1,1,2,0,0,0,2,1,1,2,0,0,0,3,2,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,2,2,0,0,0,3,1,1,2,0,0,1,1,1,1,1,0,0,1,1,1,2,1,0,0,2,2,2,2,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,1,2,0,0,0,3,1,2,1,0,0,0,1,1,1,0,0,0,1,1,0,1,1,0,0,2,2,1,3,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,3,1,0,0,2,2,1,1,0,0,1,1,1,1,1,0,0,0,2,1,1,2,0,0,0,2,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,1,2,0,0,0,1,1,0,3,0,0,0,1,1,0,1,0,0,0,3,1,1,2,0,0,0,3,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,3,2,2,2,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,1,2,1,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,1,2,2,0,0,0,4,1,2,2,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,0,1,2,1,2,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,3,0,0,0,2,1,1,1,1,0,0,1,1,1,2,0,0,0,2,1,2,2,0,0,0,2,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,1,1,2,1,0,0,1,2,0,3,0,0,0,1,1,0,2,0,0,0,2,2,1,2,0,0,0,3,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,2,2,0,0,0,4,1,1,2,0,0,0,2,1,1,1,0,0,1,2,1,2,1,0,0,1,2,2,3,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,2,2,0,0,0,4,1,2,2,0,0,0,3,1,2,1,0,0,0,2,1,1,1,0,0,1,2,0,2,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,0,0,0,2,2,1,2,0,0,0,2,1,2,3,0,0,0,2,2,2,2,0,0,0,4,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,3,0,0,0,2,1,1,4,0,0,0,2,1,0,3,0,0,0,2,2,0,3,0,0,0,3,2,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,2,2,0,0,0,3,1,2,2,0,0,0,2,2,2,2,0,0,1,2,2,2,2,0,0,1,2,2,3,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,1,2,0,0,0,3,0,2,2,0,0,0,2,1,2,1,0,0,0,3,0,2,1,0,0,1,2,0,2,2,0,0,2,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,3,1,0,0,2,2,2,3,0,0,0,2,2,2,3,0,0,0,2,2,2,3,0,0,0,2,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,1,0,3,0,0,0,2,2,2,2,0,0,0,2,2,0,3,0,0,0,2,0,2,2,0,0,0,3,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,3,1,2,2,0,0,0,4,2,2,2,0,0,0,3,2,2,2,0,0,2,2,2,3,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,1,2,0,0,1,2,0,1,2,0,0,0,2,1,2,2,0,0,1,2,0,2,2,0,0,1,2,0,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,3,0,0,0,2,2,2,3,0,0,0,2,2,1,3,0,0,0,2,2,2,2,0,0,0,3,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,2,2,0,2,1,0,0,2,1,0,3,0,0,0,2,1,0,2,0,0,0,2,1,0,2,0,0,0,3,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,2,2,0,0,0,3,2,2,2,0,0,0,2,2,2,1,0,0,1,3,2,2,1,0,0,2,2,2,3,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,2,2,0,0,0,3,0,1,2,0,0,1,2,1,2,2,0,0,1,2,1,2,2,0,0,2,2,0,2,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,2,4,0,0,0,2,2,2,2,0,0,0,2,2,2,3,0,0,0,2,1,2,3,0,0,0,4,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,2,1,0,0,2,1,2,2,0,0,0,2,1,0,2,0,0,0,2,0,1,2,0,0,0,2,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,3,2,2,2,0,0,0,4,2,2,2,0,0,0,4,2,3,1,0,0,2,2,2,4,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,1,1,2,0,0,0,3,0,1,2,0,0,0,2,0,2,2,0,0,1,2,0,2,2,0,0,2,2,1,2,2,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,4,0,0,0,2,2,2,3,0,0,0,2,2,2,3,0,0,0,2,2,2,2,0,0,0,2,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,0,0,1,2,1,3,0,0,0,2,2,2,3,0,0,0,2,2,1,3,0,0,0,2,2,2,2,0,0,0,2,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,1,2,0,0,0,3,0,1,2,0,0,0,2,0,1,2,0,0,1,2,1,2,2,0,0,1,2,0,2,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,2,2,0,0,0,3,2,2,2,0,0,1,4,2,2,2,0,0,0,4,2,2,1,0,0,1,3,2,3,0,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,2,0,0,2,2,0,2,0,0,0,2,1,1,3,0,0,0,2,1,1,2,0,0,0,3,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,2,3,0,0,0,2,2,2,4,0,0,0,2,2,1,4,0,0,0,3,2,2,2,0,0,0,3,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,2,2,0,0,0,2,0,2,2,0,0,0,2,1,2,2,0,0,1,2,0,2,2,0,0,2,2,0,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,3,2,2,2,0,0,0,3,2,2,2,0,0,1,3,1,2,1,0,0,1,3,2,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,1,1,2,1,0,0,2,2,1,2,0,0,0,2,1,2,2,0,0,0,2,2,1,2,0,0,0,2,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,3,2,4,0,0,0,2,2,2,3,0,0,0,2,2,1,2,0,0,0,2,2,2,2,0,0,0,3,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,1,2,0,0,0,2,0,1,2,0,0,0,2,1,2,2,0,0,1,2,1,2,2,0,0,1,2,1,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,1,2,0,0,0,4,2,2,2,0,0,0,3,2,2,2,0,0,1,3,2,2,1,0,0,1,2,2,4,1,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,1,0,0,2,1,1,2,0,0,0,2,1,1,3,0,0,0,2,1,2,2,0,0,0,2,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,1,3,0,0,0,2,2,2,3,0,0,0,2,1,1,3,0,0,0,3,1,2,2,0,0,0,3,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,3,1,1,2,0,0,0,2,1,2,2,0,0,1,2,1,2,2,0,0,2,2,1,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,2,2,0,0,0,3,1,2,2,0,0,0,2,2,2,1,0,0,0,3,1,2,1,0,0,1,2,2,3,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,0,0,0,2,2,1,2,0,0,0,2,1,2,2,0,0,0,2,2,1,2,0,0,0,3,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,0,0,0,2,2,1,2,0,0,0,1,1,1,2,0,0,0,2,2,1,3,0,0,0,3,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,2,2,0,0,0,3,1,1,2,0,0,1,2,1,1,2,0,0,1,2,1,2,1,0,0,1,2,1,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,2,2,0,0,0,4,1,2,1,0,0,0,2,0,2,1,0,0,0,3,0,2,1,0,0,2,2,1,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,2,2,1,0,0,2,2,1,1,1,0,0,1,1,1,2,0,0,0,2,1,1,2,0,0,0,3,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,2,1,1,2,0,0,0,2,2,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,1,3,0,0,0,3,1,1,2,0,0,1,1,1,1,1,0,0,1,1,1,2,1,0,0,1,2,2,3,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,1,2,0,0,0,2,1,1,1,0,0,0,1,1,1,0,0,0,1,1,1,1,1,0,0,1,2,1,3,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,3,1,0,0,3,1,1,1,1,0,1,1,1,1,1,1,0,0,2,1,1,2,0,0,0,2,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,1,2,0,0,0,1,1,1,1,0,0,0,1,1,0,1,1,0,0,1,1,1,3,0,0,0,3,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,3,1,2,2,0,0,1,1,1,1,1,1,0,1,1,1,1,1,0,0,1,2,2,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,2,2,0,0,0,3,1,1,2,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,1,2,1,2,1,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,3,1,0,0,2,1,1,1,1,0,0,1,1,1,1,1,0,0,2,1,1,2,0,0,0,3,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,3,0,0,0,1,1,1,2,0,0,0,1,1,0,1,0,0,0,2,1,1,2,0,0,0,3,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,2,2,0,0,0,3,1,1,2,0,0,1,2,1,1,1,0,0,1,2,1,2,1,0,0,1,2,1,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,2,2,0,0,0,2,1,1,2,0,0,0,2,0,1,1,0,0,1,1,1,1,1,0,0,1,2,1,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,1,2,1,0,0,2,2,1,2,1,0,0,2,1,2,2,1,0,0,3,1,2,2,0,0,0,3,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,3,0,0,0,2,1,1,4,0,0,0,1,1,0,2,0,0,0,2,1,1,2,0,0,0,2,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,2,2,0,0,0,3,1,2,2,0,0,0,2,2,2,2,0,0,1,2,2,2,2,0,0,1,2,2,3,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,1,2,0,0,0,3,1,1,2,0,0,0,2,1,1,2,0,0,1,2,1,2,2,0,0,2,2,1,2,1,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,3,1,0,0,2,2,2,2,0,0,0,2,2,2,3,0,0,0,2,2,2,2,0,0,0,3,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,1,1,2,0,0,0,2,2,1,3,0,0,0,2,1,1,2,0,0,0,2,1,1,2,0,0,0,3,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,4,1,2,2,0,0,0,3,2,2,2,0,0,1,2,2,2,1,0,0,2,2,2,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,1,1,2,0,0,0,3,0,1,2,0,0,0,2,1,2,2,0,0,1,2,1,2,1,0,0,2,2,0,2,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,4,0,0,0,2,2,2,3,0,0,0,2,2,1,3,0,0,0,2,2,2,2,0,0,0,4,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,2,2,0,2,1,0,0,2,1,0,2,0,0,0,2,1,0,3,0,0,0,2,1,1,2,0,0,0,2,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,2,2,0,0,0,3,2,2,2,0,0,1,2,2,2,1,0,0,1,2,2,3,1,0,0,1,3,2,3,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,1,2,0,0,0,3,0,2,2,0,0,1,2,1,2,2,0,0,1,2,0,2,2,0,0,1,2,0,2,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,4,0,0,0,2,2,2,2,0,0,0,2,2,2,3,0,0,0,2,2,2,3,0,0,0,4,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,2,1,0,0,2,1,2,2,0,0,0,2,0,1,2,0,0,0,2,1,0,2,0,0,0,3,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,3,2,2,2,0,0,0,4,2,2,2,0,0,0,4,2,3,1,0,0,2,2,2,3,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,1,1,2,0,0,0,3,0,1,2,0,0,0,2,0,2,2,0,0,1,2,0,2,2,0,0,1,2,1,2,1,0,0,2,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,4,0,0,0,2,2,2,3,0,0,0,2,2,2,3,0,0,0,2,2,2,3,0,0,0,3,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,0,0,2,2,2,2,1,0,0,2,2,2,3,0,0,0,2,2,2,2,0,0,0,2,2,2,2,0,0,0,3,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,1,1,2,0,0,0,2,0,1,2,0,0,0,2,0,1,2,0,0,1,2,0,2,2,0,0,2,2,0,2,1,0,0,2,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,2,2,0,0,0,3,2,2,2,0,0,0,4,2,3,2,0,0,0,4,2,3,2,0,0,1,3,2,4,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,2,0,0,2,2,1,2,0,0,0,2,1,0,3,0,0,0,2,1,0,2,0,0,0,3,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,4,0,0,0,2,2,2,4,0,0,0,2,2,1,3,0,0,0,2,2,2,2,0,0,0,3,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,2,2,0,0,0,2,0,2,2,0,0,0,2,1,2,2,0,0,1,2,1,2,2,0,0,2,2,0,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,2,2,2,2,0,0,0,3,2,3,2,0,0,0,3,1,2,1,0,0,1,3,2,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,1,0,2,2,0,0,2,2,1,2,0,0,0,2,1,1,3,0,0,0,2,2,0,3,0,0,0,2,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,4,0,0,0,2,2,1,3,0,0,0,2,2,1,3,0,0,0,2,2,2,2,0,0,0,3,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,1,2,0,0,0,2,0,1,2,0,0,0,2,1,1,2,0,0,1,2,1,2,1,0,0,2,2,1,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,3,2,2,2,0,0,0,3,2,2,2,0,0,0,3,2,2,1,0,0,1,2,2,3,0,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,3,1,0,0,2,2,1,2,0,0,0,2,1,1,3,0,0,0,3,1,2,2,0,0,0,3,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,1,3,0,0,0,2,2,2,2,0,0,0,2,2,1,2,0,0,0,2,2,1,2,0,0,0,2,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,2,0,1,2,0,0,0,2,1,1,2,0,0,2,2,1,2,2,0,0,2,2,0,2,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,2,2,0,0,0,4,1,2,2,0,0,0,2,2,2,1,0,0,0,3,1,2,1,0,0,1,2,2,3,0,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,2,0,0,0,2,2,1,2,0,0,0,2,1,1,2,0,0,0,2,0,2,2,0,0,0,3,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,0,0,0,2,1,2,2,0,0,0,1,1,1,1,0,0,0,3,1,2,2,0,0,0,3,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,2,2,0,0,0,3,1,1,2,0,0,0,1,1,1,1,0,0,1,2,1,1,1,0,0,1,2,1,2,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,2,2,0,0,0,3,1,2,1,0,0,0,2,0,1,0,0,0,1,1,0,2,0,0,0,1,2,1,2,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,2,2,1,0,0,2,1,1,1,1,0,1,1,1,1,1,1,0,0,2,1,1,3,0,0,0,3,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,0,0,0,1,1,1,1,0,0,0,1,1,0,1,0,0,0,1,1,1,2,0,0,0,3,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,1,2,0,0,0,2,1,1,2,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,1,2,1,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,2,2,0,0,0,4,1,1,1,0,0,0,1,1,0,0,0,1,1,1,0,1,1,0,0,1,2,1,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,1,0,0,1,1,1,1,1,0,1,1,1,1,0,1,0,0,2,1,1,2,0,0,0,3,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,0,3,1,0,0,1,1,1,1,0,0,0,1,1,0,1,0,0,0,1,1,1,2,0,0,0,2,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,2,1,1,2,0,0,1,1,1,1,1,1,0,1,1,1,1,1,0,0,1,2,2,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,2,2,0,0,0,2,1,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,1,2,0,3,0,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,2,1,0,0,2,1,1,1,1,0,0,1,1,1,1,1,0,0,2,1,1,2,0,0,0,3,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,4,1,0,0,1,1,1,2,0,0,0,1,1,0,1,0,0,0,2,1,0,2,0,0,0,3,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,2,1,1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,2,2,1,3,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,2,2,0,0,0,3,0,2,2,0,0,0,1,0,1,1,0,0,1,1,1,1,1,0,0,1,2,0,3,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,0,0,0,2,2,1,2,1,0,0,1,1,1,1,1,0,0,2,2,1,2,0,0,0,3,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,4,0,0,0,2,1,1,2,0,0,0,2,1,0,2,0,0,0,2,1,0,2,0,0,0,3,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,2,2,0,0,0,4,1,1,2,0,0,1,2,2,1,1,0,0,2,2,1,2,2,0,0,2,2,2,3,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,1,2,0,0,0,4,1,2,2,0,0,0,2,0,2,2,0,0,1,2,0,2,2,0,0,1,2,0,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,4,0,0,0,2,2,2,2,0,0,0,2,2,2,2,0,0,0,2,1,2,3,0,0,0,3,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,2,1,1,2,0,0,0,2,1,1,3,0,0,0,2,1,0,3,0,0,0,3,0,1,3,0,0,0,3,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,2,2,0,0,0,3,1,2,2,0,0,0,3,2,2,2,0,0,0,2,2,2,2,0,0,2,3,2,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,1,2,0,0,0,2,0,2,2,0,0,0,3,0,2,2,0,0,2,2,0,2,1,0,0,1,2,0,3,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,4,0,0,0,2,2,2,4,0,0,0,2,2,1,4,0,0,0,2,2,2,2,0,0,0,3,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,2,2,0,2,1,0,0,2,1,0,3,0,0,0,2,1,0,3,0,0,0,2,1,0,2,0,0,0,3,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,2,2,0,0,0,3,2,2,2,0,0,0,3,2,2,2,0,0,0,3,2,2,1,0,0,2,2,2,3,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,2,2,0,0,0,3,0,2,2,0,0,1,2,0,2,2,0,0,1,2,1,2,2,0,0,2,2,0,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,4,0,0,0,2,2,2,2,0,0,0,2,2,1,3,0,0,0,3,1,2,3,0,0,0,3,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,2,1,0,0,2,1,1,2,0,0,0,2,1,0,2,0,0,0,2,0,2,3,0,0,0,3,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,3,2,2,2,0,0,0,3,2,2,2,0,0,0,4,2,3,1,0,0,0,2,2,3,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,0,2,0,0,0,3,0,2,2,0,0,0,2,1,2,2,0,0,1,2,0,2,2,0,0,2,2,0,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,4,0,0,0,2,2,2,4,0,0,0,2,2,2,3,0,0,0,2,2,2,3,0,0,0,2,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,0,0,3,3,3,3,0,0,0,3,3,3,4,0,0,0,3,3,3,3,0,0,0,4,3,3,3,0,0,0,3,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,1,0,3,0,0,0,4,0,3,3,0,0,0,3,0,3,3,0,0,1,3,0,3,3,0,0,3,3,0,3,3,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,3,3,3,0,0,0,4,3,3,3,0,0,0,5,3,3,3,0,0,0,5,3,3,3,0,0,0,4,3,5,0,0,0,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,3,3,0,3,3,0,0,3,3,3,3,0,0,0,3,0,0,5,0,0,0,3,0,3,3,0,0,0,4,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,3,3,3,5,0,0,0,3,3,3,4,0,0,0,3,3,3,4,0,0,0,4,3,3,3,0,0,0,4,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,3,3,0,0,0,4,0,3,3,0,0,0,3,0,3,3,0,0,3,3,0,3,3,0,0,0,3,0,3,3,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,3,3,3,0,0,0,5,3,3,3,0,0,0,5,3,3,3,0,0,0,5,3,3,0,0,0,3,5,3,3,0,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,3,3,0,3,0,0,0,3,3,1,4,0,0,0,3,1,3,3,0,0,0,4,1,3,3,0,0,0,4,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,3,3,3,5,0,0,0,3,3,3,3,0,0,0,3,3,1,3,0,0,0,3,3,3,3,0,0,0,4,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,0,1,4,0,0,0,3,0,1,3,0,0,0,3,1,3,3,0,0,3,3,0,3,3,0,0,3,3,0,3,3,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,3,3,3,0,0,0,4,3,3,3,0,0,0,4,3,3,3,0,0,0,5,3,3,0,0,0,0,4,3,4,0,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,3,3,0,3,3,0,0,3,3,3,3,0,0,0,3,1,1,3,0,0,0,3,3,3,3,0,0,0,4,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,3,3,1,3,0,0,0,3,3,1,3,0,0,0,3,1,1,3,0,0,0,3,1,3,3,0,0,0,3,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,3,1,3,0,0,0,5,0,1,3,0,0,0,3,3,3,1,0,0,1,3,1,3,3,0,0,3,3,0,3,3,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,3,3,3,0,0,0,3,3,3,3,0,0,0,3,1,3,1,0,0,0,3,1,3,0,0,0,0,3,3,5,0,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,3,3,3,3,0,0,0,3,1,1,3,0,0,0,1,1,1,4,0,0,0,3,1,3,3,0,0,0,4,1,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,3,3,3,0,0,0,1,1,1,3,0,0,0,1,1,1,1,0,0,0,3,1,1,3,0,0,0,3,3,1,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,3,3,0,0,0,3,1,3,3,0,0,1,1,1,1,1,0,0,1,1,1,1,3,0,0,1,3,1,3,3,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,3,3,3,0,0,0,3,0,3,1,0,0,0,1,0,1,0,0,0,0,1,0,1,0,0,0,3,3,0,3,1,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,3,3,3,3,1,0,0,3,1,1,1,1,0,0,1,1,1,1,1,0,0,1,1,1,3,0,0,0,5,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,3,3,1,3,0,0,0,1,1,1,1,0,0,0,1,1,0,1,0,0,0,1,1,0,3,0,0,0,3,3,1,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,0,3,3,0,0,0,3,1,1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,1,3,1,4,3,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,3,1,3,0,0,0,4,1,1,1,0,0,0,1,1,0,0,0,2,1,1,0,1,1,0,0,1,3,0,4,0,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,3,3,1,3,1,0,0,1,1,1,0,2,0,2,2,2,2,0,1,0,0,1,1,1,3,0,0,0,3,1,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,3,0,4,0,0,0,1,1,0,1,0,0,0,2,2,0,1,0,0,0,1,1,1,1,0,0,0,3,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,3,3,3,0,0,0,4,1,1,1,0,0,1,1,1,2,0,2,0,1,1,1,1,1,0,0,1,3,3,3,1,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,0,3,3,0,0,0,4,1,1,1,0,0,0,1,0,1,0,0,0,0,1,0,1,0,0,0,1,3,0,3,1,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,3,3,3,3,0,0,0,1,1,1,1,1,0,1,1,2,1,0,1,0,0,3,1,1,3,0,0,0,5,1,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,3,0,4,1,0,0,1,1,0,1,0,0,0,1,0,0,1,0,0,0,1,1,0,3,0,0,0,3,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,3,3,3,0,0,0,4,1,1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,1,3,3,3,1,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,3,3,3,0,0,0,3,0,3,3,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,0,1,3,0,3,3,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,3,3,3,3,0,0,0,3,3,1,1,1,0,0,1,1,1,1,1,0,0,3,1,3,3,0,0,0,3,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,3,3,0,4,1,0,0,3,1,1,4,0,0,0,1,1,0,3,0,0,0,3,0,0,3,0,0,0,4,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,3,3,3,0,0,0,3,3,1,3,0,0,0,3,3,3,1,0,0,1,3,1,3,3,0,0,3,3,3,4,0,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,3,1,3,0,0,0,4,0,3,3,0,0,0,3,0,1,3,0,0,0,3,0,3,3,0,0,1,3,0,3,3,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,3,3,3,3,3,0,0,3,3,3,3,0,0,0,3,3,1,4,0,0,0,3,3,3,3,0,0,0,4,3,1,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,3,3,0,3,0,0,0,3,1,1,4,0,0,0,3,0,1,4,0,0,0,3,0,3,3,0,0,0,4,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,3,3,3,0,0,0,5,1,3,3,0,0,0,4,3,3,3,0,0,1,3,3,3,3,0,0,3,3,3,3,1,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,0,4,0,0,0,4,0,3,3,0,0,0,4,0,3,3,0,0,3,3,0,3,3,0,0,1,3,0,3,3,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,3,3,3,5,0,0,0,3,3,3,5,0,0,0,3,3,1,3,0,0,0,3,3,3,3,0,0,0,4,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,3,3,0,3,0,0,0,3,3,0,3,0,0,0,3,1,0,4,0,0,0,4,1,3,4,0,0,0,4,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,3,3,3,0,0,0,5,3,3,3,0,0,0,5,3,3,3,0,0,0,5,3,4,0,0,0,0,3,3,4,0,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,3,3,0,0,1,4,0,3,3,0,0,0,5,0,3,3,0,0,3,3,0,3,3,0,0,3,3,0,3,3,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,3,3,3,5,0,0,0,3,3,3,3,0,0,0,3,3,3,3,0,0,0,3,3,3,3,0,0,0,5,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,3,3,0,3,1,0,0,3,1,0,5,0,0,0,3,3,0,4,0,0,0,4,1,0,4,0,0,0,4,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,3,3,3,0,0,0,5,3,3,3,0,0,0,5,3,3,1,0,0,0,5,3,4,0,0,0,3,3,3,4,0,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,0,0,4,0,0,0,5,0,3,3,0,0,3,3,0,3,3,0,0,3,3,0,3,3,0,0,3,3,0,3,3,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,3,3,3,5,0,0,0,3,3,3,3,0,0,0,3,3,3,3,0,0,0,3,3,3,4,0,0,0,3,1,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,0,0,4,4,4,6,0,0,0,4,4,4,6,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,2,0,4,0,0,0,4,0,4,4,0,0,0,5,0,4,4,0,0,4,4,0,4,4,0,0,4,4,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,6,4,4,4,0,0,0,6,4,6,4,0,0,0,6,4,4,0,0,0,4,6,4,6,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,0,4,2,0,0,4,4,0,4,0,0,0,4,0,0,4,0,0,0,6,4,0,4,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,6,0,0,0,4,4,4,4,0,0,0,4,4,4,6,0,0,0,4,4,4,4,0,0,0,6,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,4,4,0,0,0,6,0,4,4,0,0,4,6,0,4,4,0,0,2,4,0,4,4,0,0,4,4,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,6,4,4,4,0,0,0,6,4,4,4,0,0,0,6,4,4,0,0,0,4,4,4,4,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,0,4,0,0,0,4,4,4,4,0,0,0,4,0,4,6,0,0,0,5,4,0,4,0,0,0,6,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,6,0,0,0,4,4,2,6,0,0,0,4,4,2,4,0,0,0,4,4,4,4,0,0,0,6,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,4,4,0,0,0,4,0,2,4,0,0,0,4,0,4,4,0,0,4,4,2,4,4,0,0,4,4,4,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,6,4,4,4,0,0,0,6,4,4,4,0,0,0,6,4,4,0,0,0,2,4,4,6,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,2,4,4,0,0,4,4,2,4,0,0,0,4,0,2,4,0,0,0,4,4,2,4,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,2,5,0,0,0,2,4,4,4,0,0,0,4,2,2,4,0,0,0,4,2,4,4,0,0,0,4,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,0,4,0,0,0,4,0,4,4,0,0,0,4,2,2,4,0,0,2,2,2,4,4,0,0,4,4,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,4,4,4,0,0,0,4,4,4,2,0,0,0,4,2,2,2,0,0,0,4,2,4,0,0,0,0,4,4,6,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,4,0,0,0,4,2,2,4,0,0,0,2,2,2,5,0,0,0,4,2,4,4,0,0,0,5,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,4,0,6,0,0,0,2,2,2,2,0,0,0,2,2,2,2,0,0,0,4,2,2,4,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,4,4,4,0,0,2,4,2,4,4,0,0,2,2,2,2,2,0,0,2,2,2,2,2,0,0,2,4,2,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,4,2,2,0,0,0,0,2,0,0,2,0,0,0,2,0,2,0,0,0,2,4,0,4,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,4,2,0,0,2,2,2,2,2,0,2,3,2,1,2,2,0,0,2,2,2,5,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,4,0,5,0,0,0,2,2,2,2,0,0,0,2,2,0,0,2,0,0,2,2,0,4,0,0,0,4,4,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,4,4,0,0,2,4,2,2,2,0,0,3,2,2,1,2,1,0,2,3,2,0,2,0,0,2,4,2,4,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,4,2,2,2,0,0,0,2,1,0,0,1,1,0,3,1,2,0,0,0,2,4,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,2,2,2,0,0,2,2,2,0,2,1,3,3,3,1,0,2,0,2,2,2,2,2,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,4,0,5,0,0,0,2,2,0,2,0,0,0,3,3,0,2,1,0,0,2,2,0,2,0,0,0,4,2,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,5,2,2,2,0,1,2,2,3,1,0,3,0,2,3,2,2,2,0,0,2,2,4,4,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,4,4,0,0,0,4,0,2,2,0,0,0,3,0,2,0,0,1,0,2,0,2,0,0,0,2,4,0,4,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,2,4,2,0,0,2,2,2,2,2,0,2,3,2,2,0,1,0,0,2,2,2,4,0,0,0,5,2,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,0,5,2,0,0,2,2,0,2,0,0,0,1,1,0,2,0,0,0,2,2,0,4,0,0,0,4,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,5,2,2,2,0,0,2,2,2,2,2,0,0,2,2,2,2,2,0,0,2,4,2,4,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,2,4,0,0,0,4,0,4,2,0,0,0,2,0,2,2,0,0,2,2,0,2,2,0,0,2,4,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,2,4,0,0,0,4,2,2,2,2,0,0,2,2,2,2,2,0,0,4,2,2,5,0,0,0,4,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,5,0,0,0,2,2,0,2,0,0,0,2,2,0,4,0,0,0,4,0,2,4,0,0,0,6,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,6,4,2,4,0,0,2,5,2,2,2,0,0,2,4,2,2,4,0,0,0,4,4,4,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,2,4,0,0,0,4,0,4,4,0,0,0,4,0,2,2,0,0,0,4,0,4,2,0,0,4,4,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,2,4,4,0,0,4,4,4,4,0,0,0,4,4,2,5,0,0,0,4,4,4,4,0,0,0,5,4,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,0,4,4,0,4,0,0,0,4,2,2,5,0,0,0,4,2,0,4,0,0,0,4,0,4,4,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,6,2,4,4,0,0,0,6,4,4,4,0,0,2,4,4,4,2,0,0,4,6,4,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,0,4,0,0,0,4,0,4,4,0,0,0,4,0,2,4,0,0,4,4,0,4,4,0,0,2,4,0,4,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,6,0,0,0,4,4,4,6,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,6,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,0,4,4,0,4,0,0,0,4,4,0,4,0,0,0,4,0,2,5,0,0,0,4,4,4,6,0,0,0,4,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,4,4,0,0,0,6,4,4,4,0,0,0,6,4,4,4,0,0,0,6,4,5,0,0,0,0,4,4,6,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,4,4,0,0,2,6,0,4,4,0,0,0,6,0,4,4,0,0,4,4,0,4,4,0,0,4,4,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,6,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,5,0,0,0,6,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,0,4,4,0,0,4,2,4,4,0,0,0,4,4,0,4,0,0,0,4,4,0,4,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,4,4,4,4,0,0,0,6,4,4,4,0,0,0,6,4,6,0,0,0,4,4,4,6,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,0,5,0,0,0,6,0,4,4,0,0,0,4,0,4,4,0,0,4,4,0,4,4,0,0,4,4,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,6,0,0,0,4,4,4,6,0,0,0,4,4,4,4,0,0,0,4,4,4,6,0,0,0,5,2,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,0,0,2,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,6,4,4,4,0,0,0,4,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,4,4,0,0,0,4,0,4,4,0,0,0,4,2,4,4,0,0,2,4,0,4,4,0,0,4,4,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,4,4,0,0,0,4,4,4,4,0,0,0,6,4,6,4,0,0,0,6,4,4,0,0,0,0,6,4,6,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,4,4,0,0,4,4,4,4,0,0,0,4,0,0,6,0,0,0,4,4,4,4,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,6,0,0,0,4,4,4,6,0,0,0,4,4,4,6,0,0,0,6,4,4,4,0,0,0,6,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,4,4,0,0,0,6,0,2,4,0,0,0,6,0,4,4,0,0,4,4,0,4,4,0,0,4,4,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,6,4,4,4,0,0,0,6,4,4,4,0,0,0,4,4,4,2,0,0,4,4,4,4,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,0,4,0,0,0,4,4,4,4,0,0,0,4,0,4,6,0,0,0,4,0,4,4,0,0,0,6,4,0,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,6,0,0,0,4,4,4,4,0,0,0,4,4,2,4,0,0,0,4,4,4,4,0,0,0,6,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,4,4,0,0,0,6,0,4,4,0,0,0,4,2,2,4,0,0,4,4,4,4,4,0,0,4,4,2,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,6,4,4,4,0,0,0,4,4,4,2,0,0,0,4,2,4,0,0,0,2,4,4,6,0,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,2,4,2,0,0,2,4,2,4,0,0,0,4,2,2,4,0,0,0,4,0,4,4,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,2,6,0,0,0,2,4,4,4,0,0,0,4,2,2,2,0,0,0,5,2,4,4,0,0,0,4,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,2,4,0,0,0,4,2,4,4,0,0,0,2,2,2,2,0,0,2,2,2,4,4,0,0,2,4,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,4,4,0,0,0,4,0,4,2,0,0,0,4,2,2,0,0,0,0,5,2,2,0,0,0,0,4,4,4,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,4,2,0,0,2,2,2,2,0,0,2,2,2,2,2,0,0,0,2,2,4,4,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,0,5,0,0,0,2,2,0,2,0,0,0,2,2,0,2,0,0,0,2,2,2,4,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,2,4,0,0,2,4,2,2,2,0,0,2,3,2,2,2,0,0,2,2,2,2,2,0,0,2,4,2,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,4,2,2,2,0,0,0,2,0,0,0,0,0,0,2,0,2,0,0,0,2,2,0,4,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,2,2,2,0,0,2,2,2,2,2,0,3,3,3,3,0,2,0,2,2,2,2,4,0,0,0,5,2,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,4,0,5,0,0,0,0,2,0,0,0,1,0,3,3,0,0,0,2,0,2,2,0,2,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,4,4,0,0,2,2,2,2,2,0,3,3,3,3,0,0,2,1,3,3,3,0,2,0,0,2,2,2,4,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,2,0,2,0,0,0,0,3,0,0,0,1,1,0,3,0,3,0,0,0,2,2,2,4,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,4,4,2,2,0,2,2,2,2,0,3,0,1,1,1,0,0,3,0,0,2,2,2,2,0,0,0,4,2,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,4,0,0,0,2,2,0,0,1,0,1,1,1,1,0,1,0,0,2,2,0,2,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,4,2,2,2,0,2,3,3,3,0,0,1,0,3,3,3,0,3,0,0,2,2,2,4,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,4,4,0,0,0,2,0,2,0,0,0,0,3,1,0,0,1,0,0,3,0,2,0,0,0,2,4,0,4,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,4,2,4,2,0,2,2,2,2,0,3,0,3,3,3,1,0,3,0,0,2,2,2,2,0,0,0,4,2,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,4,0,4,0,0,0,2,2,0,2,2,0,0,3,3,0,2,0,0,0,2,2,0,4,0,0,0,4,4,0,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,2,4,2,2,2,0,0,2,2,2,2,0,3,0,2,2,2,2,2,0,0,2,4,2,4,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,4,4,0,0,0,4,0,2,2,0,0,0,2,0,2,0,0,0,0,2,0,2,2,0,0,2,2,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,4,0,0,0,4,2,2,0,2,0,0,2,2,2,2,2,0,0,2,2,2,5,0,0,0,4,2,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,2,4,2,0,0,2,2,0,4,0,0,0,2,2,0,2,0,0,0,2,0,0,4,0,0,0,6,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,6,2,4,2,0,0,2,2,2,2,2,0,0,2,2,2,2,2,0,0,4,4,4,4,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,0,4,0,0,0,4,0,4,2,0,0,0,4,0,2,2,0,0,0,4,0,4,4,0,0,2,4,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,6,0,0,0,4,4,2,4,0,0,0,4,2,2,4,0,0,0,4,2,4,4,0,0,0,6,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,0,6,0,0,0,2,4,2,4,0,0,0,4,2,0,4,0,0,0,4,2,0,4,0,0,0,6,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,6,4,4,4,0,0,0,6,4,4,2,0,0,4,4,2,4,4,0,0,4,4,4,6,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,4,4,0,0,0,6,0,2,4,0,0,0,4,0,4,4,0,0,0,4,0,4,2,0,0,4,4,0,6,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,6,0,0,0,4,4,4,6,0,0,0,4,4,2,6,0,0,0,4,4,4,4,0,0,0,6,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,0,4,4,0,4,2,0,0,4,4,0,4,0,0,0,4,0,2,6,0,0,0,4,0,4,4,0,0,0,6,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,6,4,4,4,0,0,0,6,4,4,2,0,0,0,6,4,6,4,0,0,0,4,4,6,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,4,4,0,0,0,6,0,4,4,0,0,0,6,0,4,4,0,0,2,4,0,4,4,0,0,4,4,0,6,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,6,0,0,0,4,4,4,4,0,0,0,4,4,4,6,0,0,0,4,4,4,6,0,0,0,6,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,0,6,0,0,0,4,4,0,6,0,0,0,4,4,0,4,0,0,0,4,4,4,4,0,0,0,6,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,6,4,4,4,0,0,0,6,4,4,4,0,0,0,6,4,6,0,0,0,0,4,4,6,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,0,6,0,0,0,6,0,4,4,0,0,0,4,0,4,4,0,0,4,4,0,4,4,0,0,4,4,0,4,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,6,0,0,0,4,4,4,6,0,0,0,4,4,4,4,0,0,0,4,4,4,6,0,0,0,4,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,0,0,4,4,4,4,0,0,0,4,4,4,6,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,2,4,0,0,0,6,0,4,4,0,0,0,4,0,4,4,0,0,0,4,0,4,4,0,0,4,4,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,4,4,4,4,0,0,0,6,4,6,4,0,0,2,6,4,6,4,0,0,0,6,4,6,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,4,4,0,0,4,4,4,4,0,0,0,4,0,0,4,0,0,0,4,0,4,6,0,0,0,6,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,6,0,0,0,4,4,4,6,0,0,0,4,4,4,6,0,0,0,4,4,4,6,0,0,0,6,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,4,4,0,0,0,6,0,4,4,0,0,0,4,0,4,4,0,0,4,4,0,4,4,0,0,0,4,0,4,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,6,4,4,4,0,0,0,6,4,4,4,0,0,0,4,2,4,0,0,0,4,6,4,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,0,4,0,0,0,4,2,4,4,0,0,0,4,0,4,6,0,0,0,6,0,4,4,0,0,0,4,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,6,0,0,0,4,4,4,4,0,0,0,4,4,2,4,0,0,0,4,4,4,4,0,0,0,6,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,2,4,0,0,0,4,0,2,4,0,0,0,4,2,4,2,0,0,2,4,2,4,2,0,0,4,4,4,4,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,6,4,4,4,0,0,0,4,2,4,2,0,0,0,4,2,4,0,0,0,0,4,2,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,0,4,4,0,0,2,2,2,4,0,0,0,4,0,2,4,0,0,0,4,2,4,4,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,2,4,0,0,0,4,2,2,2,0,0,0,2,2,2,2,0,0,0,4,2,2,4,0,0,0,6,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,4,2,2,2,0,0,2,2,2,2,2,0,0,2,2,2,2,4,0,0,2,2,4,4,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,4,4,0,0,0,4,0,4,2,0,0,0,2,0,2,0,0,0,0,2,0,2,0,0,0,0,4,2,4,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,4,4,2,4,2,0,0,2,2,2,2,2,0,2,2,2,2,2,2,0,2,2,2,2,4,0,0,0,5,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,4,0,5,0,0,0,2,2,0,0,0,0,0,2,2,0,2,0,0,0,2,2,2,2,0,0,0,4,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,4,4,0,0,2,2,2,2,2,0,0,3,2,3,2,2,0,0,3,2,2,2,2,0,0,2,2,2,4,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,2,0,0,0,4,0,2,2,0,0,0,3,0,0,0,0,1,0,2,0,2,0,0,0,2,2,0,4,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,2,2,2,0,2,2,2,2,2,2,0,3,3,3,3,0,3,0,2,2,2,2,2,0,0,0,5,2,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,4,0,0,0,2,2,0,0,0,1,1,3,3,0,0,0,1,1,2,2,0,2,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,4,4,0,0,2,2,2,2,0,0,3,3,3,3,0,0,1,3,3,3,3,0,2,0,0,2,2,2,4,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,4,2,0,0,0,2,0,2,0,0,0,0,3,0,0,0,1,1,1,3,0,0,0,0,0,2,2,0,4,2,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,2,2,2,2,0,3,2,2,3,0,3,1,1,1,1,0,0,3,0,2,2,3,2,2,0,0,0,4,2,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,2,0,0,0,2,2,0,0,0,3,1,1,1,0,0,1,1,0,3,2,0,2,0,0,0,4,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,2,4,0,0,2,2,2,2,0,1,1,3,3,3,0,0,1,1,3,3,3,0,2,0,0,2,2,2,2,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,4,4,0,0,0,2,0,2,0,0,0,2,3,0,0,0,0,1,0,3,0,2,0,0,0,0,2,0,4,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,4,2,2,2,0,2,2,2,2,0,3,1,3,3,3,1,0,3,0,2,2,2,2,2,2,0,0,5,2,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,4,0,4,0,0,0,2,2,0,0,0,0,0,3,3,0,0,0,0,0,2,2,0,2,0,0,0,4,2,0,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,2,2,2,2,2,0,0,3,3,2,2,0,3,0,2,3,3,0,2,0,0,2,2,2,4,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,4,4,0,0,0,4,0,2,2,0,0,0,2,0,0,0,0,0,2,2,0,2,2,0,0,2,4,0,4,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,4,2,2,2,0,0,2,2,2,2,3,0,2,3,2,2,0,3,0,2,2,2,2,2,0,0,0,4,2,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,4,2,0,0,2,2,0,2,0,0,0,2,2,0,2,0,0,0,2,0,0,4,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,4,2,2,2,0,0,2,2,2,2,2,0,0,2,2,2,2,2,0,0,2,4,4,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,2,4,0,0,0,4,0,4,2,0,0,0,2,0,2,0,0,0,0,2,0,2,2,0,0,2,2,0,4,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,2,4,2,0,0,4,4,2,2,2,0,0,2,2,2,2,2,0,0,4,2,4,4,0,0,0,6,2,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,0,4,0,0,0,2,2,0,4,0,0,0,2,2,0,4,0,0,0,4,0,2,4,0,0,0,4,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,6,2,4,4,0,0,0,5,2,2,4,0,0,2,4,2,4,4,0,0,4,4,4,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,2,4,0,0,0,6,0,2,4,0,0,0,4,0,2,4,0,0,2,4,0,4,4,0,0,0,4,0,6,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,6,0,0,0,4,4,4,5,0,0,0,4,4,2,4,0,0,0,4,4,4,4,0,0,0,6,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,0,4,4,0,4,2,0,0,4,2,0,6,0,0,0,4,0,2,4,0,0,0,4,0,4,6,0,0,0,6,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,6,4,4,4,0,0,0,6,4,4,4,0,0,4,4,4,4,4,0,0,0,4,4,4,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,4,4,0,0,0,6,0,4,4,0,0,0,6,0,2,4,0,0,0,4,0,4,4,0,0,4,4,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,6,0,0,0,4,4,4,4,0,0,0,4,4,4,6,0,0,0,4,4,4,4,0,0,0,6,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,0,4,4,0,0,4,2,4,4,0,0,0,4,4,0,4,0,0,0,4,4,0,4,0,0,0,6,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,4,4,4,4,0,0,0,6,4,4,4,0,0,4,4,4,6,0,0,0,4,4,4,6,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,0,6,0,0,0,6,0,4,4,0,0,0,4,0,4,4,0,0,4,4,0,4,4,0,0,4,4,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,6,0,0,0,4,4,4,6,0,0,0,4,4,4,4,0,0,0,4,4,4,6,0,0,0,4,2,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,0,0,4,4,4,6,0,0,0,4,4,4,6,0,0,0,4,4,4,4,0,0,0,6,4,4,4,0,0,0,4,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,2,0,4,0,0,0,4,0,4,4,0,0,0,4,4,4,4,0,0,4,4,0,4,4,0,0,4,4,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,6,0,0,0,6,4,4,4,0,0,0,4,4,6,4,0,0,0,6,4,4,4,0,0,0,6,4,6,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,0,4,4,0,0,4,4,4,4,0,0,0,4,0,0,4,0,0,0,4,0,4,6,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,6,0,0,0,4,4,4,6,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,6,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,0,4,0,0,0,4,0,4,4,0,0,0,4,4,4,4,0,0,4,4,0,4,4,0,0,4,4,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,2,0,0,0,6,2,4,0,0,0,4,4,4,4,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,0,4,4,0,4,4,0,0,4,4,0,4,0,0,0,4,2,4,4,0,0,0,4,4,0,4,0,0,0,6,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,6,0,0,0,4,4,2,4,0,0,0,4,2,2,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,0,4,0,0,2,4,0,2,4,0,0,0,4,2,2,4,0,0,2,2,2,4,4,0,0,4,4,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,5,4,4,2,0,0,0,4,2,2,2,0,0,0,4,2,4,0,0,0,0,4,4,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,0,4,0,0,0,4,2,2,4,0,0,0,2,2,2,4,0,0,0,2,2,2,4,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,4,0,5,0,0,0,2,2,0,2,0,0,0,2,2,0,2,0,0,0,4,2,0,4,0,0,0,4,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,2,4,2,4,2,0,0,2,2,2,2,2,0,0,2,2,2,2,2,0,0,2,2,2,4,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,4,4,0,0,0,4,0,2,2,0,0,0,2,2,1,0,0,0,0,2,0,2,0,0,0,2,4,2,4,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,4,2,2,0,0,2,2,2,0,2,0,2,2,3,2,2,2,0,0,2,2,2,4,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,4,0,4,0,0,0,2,2,0,0,2,0,0,3,2,0,0,0,2,0,2,2,2,2,0,0,0,4,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,2,4,0,0,2,2,2,2,2,0,0,3,3,3,0,2,0,1,3,3,3,0,2,0,0,2,2,2,4,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,2,2,0,0,0,0,2,3,0,0,0,1,1,2,3,0,0,0,0,0,0,2,0,2,0,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,2,2,0,3,2,3,3,0,3,0,3,3,3,0,0,3,0,3,2,3,2,2,0,0,2,4,2,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,4,0,2,0,0,0,1,2,0,0,1,1,1,1,1,0,0,0,1,1,2,1,2,2,0,0,0,4,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,2,4,0,0,2,2,2,2,2,0,1,3,3,1,0,0,3,1,3,3,1,0,3,2,0,2,2,2,2,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,4,2,0,0,0,2,2,0,0,0,0,1,3,1,0,0,1,1,1,3,0,0,0,0,0,0,2,0,2,2,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,2,2,0,2,3,3,1,0,1,1,1,1,1,0,0,1,1,3,2,3,3,2,0,0,2,2,2,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,2,0,2,0,0,0,1,2,0,0,0,3,1,1,1,0,0,1,1,0,3,2,0,2,0,0,0,4,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,2,4,0,0,2,2,2,2,0,3,1,3,3,1,0,0,1,1,1,3,1,0,1,0,0,2,2,2,2,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,0,4,2,0,0,0,2,0,2,0,0,0,0,3,0,0,0,1,1,1,3,0,2,0,0,0,2,2,0,2,0,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,4,2,2,2,2,0,2,2,3,3,0,3,1,1,3,1,1,0,3,0,3,3,2,1,2,2,0,0,4,2,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,2,2,2,0,0,0,2,2,0,0,0,2,1,1,1,1,0,0,0,0,2,2,0,2,0,0,0,4,2,0,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,4,2,0,0,2,2,2,2,1,2,1,3,3,3,1,0,3,2,3,3,3,0,2,1,0,2,2,2,2,4,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,2,4,0,0,0,2,0,2,0,0,0,0,3,0,0,0,0,0,0,3,0,2,0,0,0,2,2,0,2,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,2,2,0,0,2,2,2,0,3,2,2,3,3,2,0,3,0,2,2,2,2,2,2,0,0,4,2,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,0,5,0,0,0,2,2,0,2,2,0,0,2,2,0,2,0,0,0,2,0,0,2,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,4,4,0,0,2,2,2,2,2,0,0,2,2,2,2,3,0,0,2,2,2,0,2,0,0,2,2,4,4,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,2,4,0,0,0,4,0,2,2,0,0,0,2,0,2,0,0,0,0,2,0,2,2,0,0,2,4,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,2,4,4,0,0,4,2,2,2,2,0,0,2,2,2,2,2,0,0,4,2,2,4,0,0,0,4,2,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,0,4,4,0,4,0,0,0,2,0,0,4,0,0,0,2,2,0,2,0,0,0,2,2,0,4,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,6,4,4,4,0,0,0,4,2,2,2,0,0,2,5,2,4,2,0,0,4,4,4,4,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,0,4,0,0,0,6,0,2,4,0,0,0,4,0,4,2,0,0,0,4,0,4,2,0,0,2,4,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,4,0,0,0,4,4,4,5,0,0,0,4,4,2,4,0,0,0,4,4,4,4,0,0,0,6,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,0,4,4,0,4,4,0,0,4,2,0,4,0,0,0,2,0,0,5,0,0,0,4,0,4,6,0,0,0,4,0,0,6,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,4,4,4,4,0,0,0,6,4,4,4,0,0,2,4,4,4,2,0,0,0,4,4,6,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,4,4,0,0,0,6,0,4,4,0,0,0,6,0,4,4,0,0,4,4,0,4,4,0,0,4,4,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,6,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,6,0,0,0,6,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,0,4,4,0,0,4,4,0,6,0,0,0,4,4,0,4,0,0,0,4,4,0,4,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,4,4,4,4,0,0,0,6,4,4,4,0,0,4,4,4,6,0,0,0,4,6,4,6,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,4,4,0,0,0,6,0,4,4,0,0,4,4,0,4,4,0,0,0,4,0,4,4,0,0,4,4,0,4,4,0,0,4,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,6,0,0,0,4,4,4,4,0,0,0,4,4,4,6,0,0,0,4,4,4,6,0,0,0,6,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,0,0,4,4,4,6,0,0,0,4,4,4,6,0,0,0,4,4,4,4,0,0,0,6,4,4,4,0,0,0,6,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,2,0,4,0,0,0,6,0,4,4,0,0,0,6,0,4,4,0,0,0,4,0,4,4,0,0,4,4,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,6,0,0,0,6,4,4,4,0,0,0,6,4,6,4,0,0,4,6,4,4,4,0,0,0,6,4,6,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,0,4,4,0,0,4,4,4,4,0,0,0,4,0,0,4,0,0,0,4,0,4,6,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,6,0,0,0,4,4,4,6,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,6,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,0,4,0,0,0,4,0,2,4,0,0,0,4,0,4,4,0,0,4,4,0,4,4,0,0,4,4,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,0,0,0,0,4,2,4,0,0,0,0,6,4,4,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,0,4,4,0,4,4,0,0,4,2,4,4,0,0,0,4,2,4,5,0,0,0,4,4,2,4,0,0,0,6,4,0,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,4,0,0,0,4,2,2,4,0,0,0,4,2,2,2,0,0,0,4,2,2,4,0,0,0,4,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,0,4,0,0,2,4,0,2,4,0,0,2,2,2,2,2,0,0,2,2,2,4,4,0,0,4,2,4,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,4,4,4,0,0,0,0,2,0,2,0,0,0,0,5,2,2,0,0,0,0,4,0,4,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,0,4,2,0,0,2,2,2,2,2,0,0,2,2,2,2,0,0,0,2,2,4,4,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,4,0,5,0,0,0,2,2,0,2,0,0,0,2,2,0,2,0,0,0,2,2,0,4,0,0,0,4,4,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,2,2,2,2,2,0,0,2,2,2,2,2,0,0,2,3,2,0,2,0,0,2,2,2,4,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,2,4,2,0,0,0,2,0,2,0,0,0,0,2,0,0,2,0,0,0,2,0,2,0,0,0,0,2,2,4,0,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,2,2,2,0,0,2,2,2,2,3,0,3,3,3,3,0,2,0,2,2,2,2,2,0,0,2,4,2,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,4,0,2,0,0,0,2,2,0,0,0,0,1,3,3,0,0,0,1,0,2,2,2,2,0,0,0,5,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,2,4,0,0,2,2,2,2,2,0,1,3,3,3,0,2,2,1,3,3,3,0,2,0,0,2,2,2,2,2,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,4,2,0,0,0,2,0,0,0,0,1,1,3,0,0,0,1,1,0,3,0,0,0,0,0,0,2,0,2,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,4,2,2,2,2,0,2,3,3,2,0,3,1,1,1,1,0,0,3,1,3,3,3,3,2,2,0,0,2,2,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,2,0,0,0,3,3,0,0,0,1,1,1,1,0,0,1,1,0,3,1,0,2,0,0,0,2,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,2,2,0,0,2,2,2,1,0,3,1,1,1,1,0,0,1,1,1,1,1,0,2,3,0,2,2,2,2,2,0,0,4,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,2,0,0,0,2,1,0,1,1,0,0,1,1,1,1,0,0,1,0,1,2,2,0,2,0,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,2,2,0,3,3,3,1,0,1,1,1,1,1,0,0,1,1,3,3,3,0,0,2,0,2,2,2,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,2,0,2,0,0,0,3,3,0,0,0,1,1,1,1,0,0,1,1,0,3,2,0,0,0,0,0,2,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,4,2,0,0,2,2,2,2,0,3,1,1,1,1,0,0,1,1,1,1,1,0,1,1,0,2,2,2,2,2,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,0,4,2,0,0,0,2,0,0,0,1,3,0,3,0,0,0,1,1,0,1,1,0,0,0,3,0,2,0,2,2,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,2,2,2,2,0,2,3,3,1,0,1,1,1,1,1,0,0,1,1,3,3,3,2,0,2,0,0,5,2,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,2,2,2,0,0,0,3,3,0,0,0,1,1,1,1,0,0,0,3,0,3,3,0,2,0,0,0,2,2,0,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,2,2,0,0,2,2,2,2,0,3,1,3,3,3,0,0,1,1,3,3,1,0,3,0,0,2,2,2,2,2,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,4,4,0,0,0,2,0,2,0,0,0,0,3,0,0,0,0,2,1,3,0,2,0,0,0,2,2,0,2,0,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,4,4,2,0,2,0,0,3,2,2,0,3,3,3,3,3,1,0,3,0,2,2,2,2,2,2,0,0,4,2,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,2,0,4,0,0,0,2,2,0,2,1,0,0,2,3,0,2,0,0,0,2,0,0,2,0,0,0,4,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,2,4,4,0,0,2,2,2,2,2,0,0,2,2,2,0,1,2,0,3,2,2,0,2,0,0,2,2,2,4,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,4,4,0,0,0,2,0,2,2,0,0,0,2,0,2,0,0,0,0,2,0,2,2,0,0,2,2,0,4,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,4,4,4,2,0,0,2,2,2,2,2,0,2,2,2,2,2,2,0,0,2,2,2,2,0,0,0,4,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,0,4,2,0,0,2,0,0,2,0,0,0,2,2,0,4,0,0,0,2,2,0,4,0,0,0,4,2,0,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,4,2,4,2,0,0,0,2,2,2,2,0,0,2,2,2,2,2,0,0,2,4,4,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,0,4,0,0,0,4,0,2,4,0,0,0,4,0,2,2,0,0,0,2,0,2,2,0,0,2,4,0,4,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,6,0,0,0,2,4,4,4,2,0,0,4,4,2,4,0,0,0,4,4,4,4,0,0,0,6,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,0,4,4,0,6,0,0,0,2,2,0,4,0,0,0,2,0,0,5,0,0,0,4,0,4,6,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,6,4,4,4,0,0,0,4,4,4,4,0,0,2,4,4,4,2,0,0,0,4,4,6,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,4,4,0,0,0,6,0,4,4,0,0,0,4,0,2,4,0,0,0,4,0,4,4,0,0,4,4,0,4,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,6,0,0,0,4,4,4,6,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,6,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,0,6,0,0,0,4,4,0,6,0,0,0,4,4,0,6,0,0,0,4,0,4,4,0,0,0,6,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,6,4,6,4,0,0,0,6,4,4,4,0,0,2,6,4,6,2,0,0,4,4,4,6,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,4,4,0,0,0,6,0,4,4,0,0,0,4,0,4,4,0,0,0,4,0,4,4,0,0,4,4,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,6,0,0,0,4,4,4,6,0,0,0,4,4,4,6,0,0,0,4,4,4,6,0,0,0,4,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,0,0,4,6,4,4,0,0,0,4,4,4,6,0,0,0,4,4,4,4,0,0,0,6,4,4,4,0,0,0,4,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,0,4,0,0,0,6,0,4,6,0,0,0,6,0,4,4,0,0,4,4,0,4,4,0,0,4,4,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,6,0,0,0,6,4,6,4,0,0,0,6,4,4,4,0,0,0,6,4,4,4,0,0,0,6,4,6,4,0,0,4,6,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,0,4,4,0,0,4,0,4,4,0,0,0,4,2,0,4,0,0,0,4,0,4,6,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,6,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,6,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,4,4,0,0,0,4,0,2,4,0,0,0,4,4,2,4,0,0,2,4,2,4,4,0,0,4,4,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,4,4,4,2,0,0,0,4,0,4,2,0,0,0,4,0,5,0,0,0,4,4,4,4,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,0,4,4,0,0,4,4,2,4,0,0,0,2,2,4,4,0,0,0,4,2,2,4,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,4,2,5,0,0,0,2,4,2,2,0,0,0,2,2,2,2,0,0,0,4,2,2,4,0,0,0,4,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,0,4,0,0,2,4,0,2,4,0,0,2,2,2,2,2,0,0,2,2,2,2,4,0,0,2,2,4,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,4,4,0,0,0,4,4,2,0,0,0,0,2,0,2,0,0,0,0,2,2,2,0,0,0,2,4,0,4,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,2,4,2,0,0,2,2,2,2,2,0,2,2,2,2,2,0,0,0,2,2,2,4,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,4,0,2,0,0,0,2,2,0,2,0,0,0,2,2,0,0,0,0,0,2,2,0,2,0,0,0,4,4,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,2,2,2,2,2,0,0,3,3,2,2,2,0,1,3,2,3,2,2,0,0,2,2,2,2,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,4,2,0,0,0,2,0,0,2,0,0,0,2,0,0,0,0,1,2,2,0,0,0,0,0,2,2,2,2,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,0,2,2,2,2,2,0,2,3,2,3,0,2,1,3,3,3,2,0,3,0,3,2,3,0,2,0,0,2,4,2,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,2,0,0,0,2,2,0,0,0,3,1,3,3,0,0,0,1,0,2,3,0,0,0,0,0,2,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,4,0,0,2,2,3,2,0,3,1,1,3,3,0,0,3,1,3,3,1,0,3,0,2,2,2,2,2,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,2,0,0,0,0,2,0,0,0,0,3,0,3,0,0,0,1,1,1,3,0,0,0,2,1,0,2,0,2,0,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,2,2,2,2,2,3,3,3,1,0,3,1,1,1,1,0,0,3,3,3,3,3,0,2,2,0,2,2,2,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,2,0,0,0,0,0,3,3,0,0,1,1,1,1,1,0,0,0,1,0,3,3,0,0,0,0,0,2,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,2,3,3,2,0,3,1,1,1,1,0,0,1,1,1,1,1,0,0,3,2,3,3,2,2,2,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,3,0,0,0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,1,2,3,0,2,0,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,2,2,2,2,2,2,0,1,3,3,1,0,1,1,1,1,1,0,0,1,1,3,3,3,0,0,2,0,2,2,2,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,2,0,0,2,0,0,3,3,0,0,0,1,1,1,1,0,0,0,1,0,1,3,0,0,0,0,0,2,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,3,2,3,2,0,3,1,1,1,1,0,0,1,1,1,1,1,0,1,1,2,2,3,2,2,2,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,0,2,2,0,0,0,3,1,0,0,0,3,0,1,0,0,0,1,1,1,1,0,0,0,3,1,0,3,0,2,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,2,2,2,3,0,3,3,3,1,0,1,1,1,1,1,0,0,1,3,3,3,3,1,0,2,0,2,2,2,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,2,0,0,2,0,0,3,3,0,0,0,1,1,1,1,0,0,0,3,0,3,2,2,0,0,0,0,2,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,4,2,0,0,2,2,2,2,0,3,1,3,3,3,0,0,1,3,3,3,1,0,0,3,0,2,3,2,0,2,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,4,2,0,0,0,2,0,0,0,2,0,1,3,0,0,0,0,3,1,3,0,0,0,0,2,0,2,0,2,2,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,2,2,2,2,0,3,2,3,2,0,1,3,3,3,3,1,0,1,1,2,3,3,2,0,2,0,2,2,2,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,2,0,2,2,0,0,2,3,0,0,0,2,0,3,3,0,0,0,0,0,3,2,0,2,0,0,0,4,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,4,2,0,0,2,2,2,2,2,0,0,3,3,2,0,1,3,2,3,2,3,0,2,0,0,2,2,2,2,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,4,4,0,0,0,2,0,2,2,0,0,0,3,0,2,0,0,0,0,3,0,2,0,0,0,0,2,2,4,0,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,4,2,2,2,0,0,2,2,2,2,2,0,2,2,2,2,2,2,0,2,2,2,2,2,0,0,0,4,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,4,0,0,0,0,2,0,2,0,0,0,2,0,0,2,0,0,0,2,2,0,2,0,0,0,4,2,0,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,5,2,4,2,0,0,2,2,2,2,2,0,0,2,2,2,2,2,0,0,4,4,2,4,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,4,4,0,0,0,4,0,2,2,0,0,0,2,0,2,2,0,0,0,2,0,2,2,0,0,2,4,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,4,2,0,0,2,4,2,2,2,0,0,4,2,2,2,0,0,0,4,4,2,4,0,0,0,4,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,0,4,2,0,0,2,0,0,5,0,0,0,2,0,0,4,0,0,0,4,0,0,4,0,0,0,4,0,0,6,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,6,0,0,0,6,4,4,4,0,0,0,4,4,4,2,0,0,2,4,2,4,2,0,0,4,4,4,6,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,0,4,0,0,0,4,0,4,4,0,0,0,4,2,4,4,0,0,0,4,0,4,4,0,0,4,4,0,4,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,6,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,6,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,0,6,0,0,0,4,4,0,6,0,0,0,4,4,0,6,0,0,0,4,0,0,6,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,6,4,4,4,0,0,0,6,4,4,4,0,0,2,6,4,4,4,0,0,4,6,4,6,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,0,6,0,0,4,4,0,4,6,0,0,0,4,0,4,4,0,0,4,4,0,4,4,0,0,4,4,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,6,4,6,0,0,0,4,4,4,6,0,0,0,4,4,4,4,0,0,0,4,4,4,6,0,0,0,6,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,0,0,4,7,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,7,4,4,4,0,0,0,4,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,0,4,0,0,0,4,0,4,4,0,0,4,7,0,4,4,0,0,0,4,0,4,4,0,0,4,4,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	7,4,4,7,0,0,0,7,4,7,4,0,0,0,7,4,4,4,0,0,0,7,4,4,0,0,0,0,7,4,7,0,0,0,4,7,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,0,4,4,0,0,4,0,4,4,0,0,0,4,2,0,7,0,0,0,4,4,0,7,0,0,0,7,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,7,0,0,0,4,4,0,4,0,0,0,4,2,4,4,0,0,0,7,4,4,4,0,0,0,7,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,4,4,0,0,0,4,0,4,4,0,0,4,4,0,2,4,0,0,2,4,2,2,4,0,0,4,4,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	7,4,4,4,0,0,0,7,4,4,2,0,0,0,5,2,2,2,0,0,0,4,0,4,0,0,0,0,4,4,4,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,0,4,0,0,0,2,2,2,4,0,0,0,2,2,2,2,0,0,0,2,2,2,4,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,4,0,0,0,2,2,2,2,0,0,0,2,2,2,2,0,0,0,4,2,2,2,0,0,0,4,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,0,4,0,0,2,2,2,0,2,0,0,2,2,2,2,2,0,0,2,2,2,2,2,0,0,2,2,2,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	7,4,4,2,0,0,0,2,2,2,0,0,0,0,2,0,0,0,0,0,0,2,0,2,0,0,0,0,2,0,4,0,0,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,2,2,2,2,0,0,2,2,2,2,2,0,2,3,2,3,0,2,0,2,2,2,2,4,0,0,2,2,2,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,2,2,2,0,0,0,2,2,0,0,0,0,0,3,2,0,0,0,0,1,2,2,0,2,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,2,4,0,0,2,2,2,0,2,2,0,3,3,3,0,1,0,3,3,3,3,0,2,0,0,2,2,2,2,2,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,2,2,0,0,0,5,0,0,0,0,0,0,3,2,0,0,0,3,2,3,0,0,2,0,0,2,5,0,2,0,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,2,2,0,2,0,3,3,3,3,0,3,3,3,3,3,0,0,3,0,3,3,3,0,0,0,0,2,2,2,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,2,2,0,0,0,0,3,3,0,0,1,1,0,3,1,0,0,0,3,0,3,2,0,0,0,0,0,5,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,4,2,2,0,0,2,3,3,0,0,3,1,1,1,1,0,0,1,1,1,1,1,0,3,0,0,3,3,5,0,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,2,2,0,0,0,5,0,0,0,1,3,0,3,0,0,0,1,1,1,3,0,0,1,1,0,0,5,0,2,0,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,2,5,0,3,0,3,1,3,0,0,1,1,1,1,1,0,0,1,1,1,3,3,0,0,3,0,2,2,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,2,0,0,0,0,3,1,3,0,0,0,1,1,1,1,0,0,0,1,0,3,1,0,0,0,3,0,2,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,2,0,2,3,3,3,0,0,3,1,1,1,1,0,0,1,1,1,1,1,0,0,3,3,3,3,3,0,2,0,0,4,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,2,2,0,0,0,0,3,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,2,3,0,2,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,2,2,2,5,0,3,1,1,1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,3,0,2,2,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,2,0,0,0,3,3,0,3,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,0,0,2,0,2,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,2,0,3,3,3,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,1,3,3,3,3,0,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,0,0,2,0,0,0,3,0,0,0,1,1,1,1,1,0,0,1,1,0,1,0,0,0,1,1,0,3,0,2,0,0,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,2,2,0,3,1,3,1,3,0,0,1,1,1,1,1,0,0,1,1,3,1,3,0,0,3,0,2,5,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,2,0,2,0,0,0,1,3,0,0,0,1,1,1,1,0,0,0,3,0,3,1,0,0,0,1,0,5,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,2,2,2,2,0,2,3,3,0,0,3,1,1,3,1,0,0,1,3,1,1,1,0,0,3,2,3,5,3,0,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,0,2,2,0,0,0,3,2,0,0,1,3,0,3,0,0,0,1,1,1,1,0,0,0,0,3,0,3,0,2,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,2,2,0,2,0,3,3,3,0,0,1,1,1,1,3,0,0,1,1,3,3,3,0,0,2,0,0,5,2,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,2,0,2,0,0,0,3,3,0,0,0,3,0,1,1,0,0,0,1,0,3,1,0,2,0,0,0,2,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,4,2,0,0,2,2,2,2,0,3,2,3,3,3,0,0,3,3,3,3,3,0,2,2,0,2,2,2,2,2,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,2,4,0,0,0,2,0,2,0,0,0,0,3,0,0,0,0,2,0,3,0,2,0,0,0,0,2,0,4,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,0,2,4,2,2,2,0,0,2,2,2,0,3,0,3,3,3,2,0,3,0,2,2,2,2,2,0,0,0,2,2,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,2,0,2,0,0,0,2,2,0,0,0,0,0,3,2,0,2,0,0,0,2,2,0,2,0,0,0,4,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,4,4,0,0,0,6,2,2,2,0,0,2,5,2,2,2,0,0,2,5,2,0,2,0,0,2,4,2,4,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	7,0,4,4,0,0,0,4,0,2,2,0,0,0,2,0,2,2,0,0,0,2,0,2,2,0,0,0,2,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,4,4,4,2,0,0,2,2,2,2,2,0,0,2,2,2,2,0,0,0,2,4,2,5,0,0,0,4,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,0,4,4,0,4,0,0,0,2,2,0,4,0,0,0,2,0,0,2,0,0,0,2,0,0,4,0,0,0,4,0,0,7,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	7,4,4,4,0,0,0,7,2,4,2,0,0,0,4,4,2,2,0,0,2,4,2,4,2,0,0,4,4,4,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,4,4,0,0,0,4,0,4,4,0,0,0,4,0,2,4,0,0,0,4,0,4,4,0,0,0,4,0,4,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,4,4,0,0,4,4,4,4,0,0,0,4,4,2,4,0,0,0,4,4,4,7,0,0,0,7,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,0,4,4,0,0,4,4,0,7,0,0,0,4,0,0,6,0,0,0,4,0,0,4,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	7,4,4,4,0,0,0,4,4,4,4,0,0,0,7,4,4,4,0,0,2,4,4,4,4,0,0,4,7,4,7,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	7,0,4,4,0,0,0,7,0,4,4,0,0,0,4,0,4,4,0,0,4,4,0,4,4,0,0,4,4,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,7,0,0,0,4,4,4,7,0,0,0,4,4,4,4,0,0,0,4,4,4,7,0,0,0,7,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,0,0,4,4,4,4,0,0,0,4,4,4,8,0,0,0,4,4,4,4,0,0,0,8,4,4,4,0,0,0,4,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	7,4,0,4,0,0,0,8,0,4,4,0,0,0,4,0,4,4,0,0,0,4,0,4,4,0,0,4,4,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	8,4,4,8,0,0,0,4,4,4,4,0,0,0,8,4,7,2,0,0,0,4,2,4,0,0,0,0,8,4,4,4,0,0,4,8,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,4,4,0,0,4,0,4,4,0,0,0,4,0,2,4,4,0,0,4,0,4,8,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,4,0,0,0,4,4,0,4,0,0,0,2,4,2,4,0,0,0,4,4,2,4,0,0,0,4,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,4,4,0,0,0,4,2,0,4,0,0,2,2,2,2,4,0,0,2,2,2,2,4,0,0,4,4,2,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	8,4,4,4,0,0,0,4,0,4,2,0,0,0,2,2,2,0,0,0,0,4,0,2,0,0,0,0,4,0,4,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,2,0,4,4,0,0,2,2,2,2,0,0,0,2,2,2,2,2,0,0,2,2,2,4,0,0,0,7,0,4,8,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,4,2,2,0,0,0,2,2,2,0,0,0,0,2,2,0,2,0,0,0,2,2,2,2,0,0,0,4,2,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,0,4,0,0,2,2,2,2,2,0,0,2,2,2,2,2,0,0,2,2,2,2,2,0,0,2,2,2,2,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	8,4,4,2,0,0,0,2,0,0,0,0,0,0,6,1,0,0,0,0,0,6,1,0,0,0,0,0,2,0,2,0,0,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,2,2,0,2,2,3,2,0,2,0,3,3,3,2,0,2,0,2,3,2,2,2,0,0,2,2,2,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,2,0,0,0,2,3,0,0,0,1,0,3,3,0,0,0,1,0,2,2,0,0,0,0,0,2,0,4,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,4,2,0,0,2,2,2,2,0,2,3,3,3,3,0,0,3,1,3,3,3,0,2,0,2,3,2,2,2,2,0,0,4,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,0,2,0,0,0,2,0,0,0,0,1,0,3,0,0,0,1,1,0,3,0,0,0,0,0,0,2,0,2,0,0,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,2,2,0,3,0,3,3,3,3,0,3,3,1,1,3,1,0,3,3,3,3,3,3,0,2,0,2,2,2,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,2,0,0,0,0,2,1,3,0,0,0,1,1,1,1,0,0,0,1,0,3,3,0,0,0,0,0,6,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,2,2,0,3,3,3,0,0,3,1,1,1,1,0,0,1,1,1,1,1,0,0,3,3,3,3,3,0,2,0,0,4,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,0,0,0,0,0,3,1,0,0,3,1,0,5,0,0,0,1,1,0,1,0,0,0,1,1,0,3,2,0,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,2,2,2,2,2,3,0,1,1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,3,0,2,2,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,0,0,1,1,0,1,0,0,0,5,1,1,1,0,0,1,1,0,1,1,0,0,0,1,0,6,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,2,2,1,3,3,3,0,0,3,1,1,5,0,0,0,1,1,1,1,0,0,0,1,3,3,3,3,0,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,0,0,0,0,0,3,0,0,0,1,1,0,5,1,0,0,1,1,1,1,0,0,0,1,1,2,3,0,0,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,3,6,2,3,0,3,1,1,1,5,0,0,0,1,0,1,1,0,0,1,5,1,1,1,0,0,3,1,3,2,6,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,3,0,0,0,3,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,1,3,0,3,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,2,2,3,3,3,3,0,0,1,1,1,1,1,0,0,1,1,1,5,1,0,0,1,3,3,3,3,0,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,0,0,0,0,0,3,0,0,0,0,5,1,5,0,0,0,1,1,0,5,0,0,0,1,1,0,3,0,3,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,2,2,2,2,0,3,1,3,1,5,0,0,0,5,1,1,1,0,0,1,5,1,1,1,0,0,3,0,2,6,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,0,0,1,2,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,0,2,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,2,2,0,2,0,3,3,3,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,1,3,3,3,3,0,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,2,2,0,0,0,3,0,0,0,1,3,0,5,0,0,0,1,1,1,5,0,0,0,1,3,0,3,0,2,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,2,2,0,3,1,3,3,3,0,0,1,1,1,1,1,0,0,0,1,3,3,3,0,0,2,0,2,2,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,2,0,2,0,0,0,3,3,0,0,0,3,0,1,1,0,0,0,1,0,3,1,2,0,0,0,0,2,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,2,2,0,0,3,2,3,2,0,3,1,3,3,3,0,0,1,3,3,3,3,0,1,3,0,6,2,2,2,2,0,0,4,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	7,0,2,2,0,0,0,2,0,2,0,0,0,0,3,1,0,0,0,3,1,3,0,2,0,0,0,0,3,0,2,0,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,2,2,2,2,0,0,2,3,2,0,3,2,3,3,3,1,0,3,0,3,3,2,2,0,2,0,2,2,2,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,2,0,2,0,0,0,0,2,0,2,0,0,0,3,1,0,0,0,0,0,2,0,0,2,0,0,0,4,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	7,4,2,4,0,0,0,6,2,2,1,2,0,2,3,2,0,2,2,0,6,3,2,2,2,2,0,2,2,2,2,2,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,4,4,0,0,0,2,0,2,2,0,0,0,2,0,2,0,0,0,0,6,0,2,0,0,0,2,2,0,4,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,0,2,4,4,2,2,0,0,2,2,2,0,2,0,0,6,2,2,0,2,0,0,2,2,2,2,0,0,0,7,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,0,4,0,0,0,0,2,0,2,0,0,0,2,2,0,2,0,0,0,2,0,0,4,0,0,0,4,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	8,4,4,4,0,0,0,4,4,2,2,0,0,2,4,2,2,2,0,0,2,2,2,2,2,0,0,4,4,2,4,0,0,0,4,8,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,4,4,0,0,0,7,0,4,4,0,0,0,2,0,2,2,0,0,0,4,0,2,2,0,0,0,4,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,4,2,0,0,4,2,4,2,2,0,0,4,2,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,0,4,4,0,0,2,4,0,4,0,0,0,4,0,0,4,0,0,0,2,0,0,8,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	8,4,4,4,0,0,0,4,4,4,4,0,0,4,4,4,4,4,0,0,2,4,4,4,4,0,0,4,8,4,8,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	8,0,4,4,0,0,0,8,0,4,4,0,0,0,4,0,2,4,0,0,0,4,0,4,4,0,0,4,4,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,8,0,0,0,4,4,4,8,0,0,0,4,4,4,8,0,0,0,4,4,4,8,0,0,0,8,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,2,4,0,0,0,4,4,2,4,0,0,0,4,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,0,4,0,0,0,4,0,4,4,0,0,0,4,4,4,4,0,0,0,4,2,4,4,0,0,4,4,4,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	8,4,8,4,0,0,0,4,4,4,4,0,0,0,4,0,4,0,0,0,0,4,4,4,0,0,0,0,4,4,8,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,4,2,0,0,4,0,2,4,2,0,0,4,2,2,4,2,0,0,4,2,4,4,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,4,0,0,0,4,2,2,4,0,0,0,2,2,2,0,0,0,0,4,4,2,4,0,0,0,4,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,0,4,0,0,2,4,2,2,2,0,0,2,2,2,2,2,0,0,2,2,2,2,2,0,0,4,2,2,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	8,4,4,4,0,0,0,4,0,4,0,0,0,0,2,0,0,0,0,0,2,2,0,2,0,0,0,0,4,0,4,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,2,2,4,0,0,0,2,2,2,2,2,0,2,2,2,2,2,2,0,2,2,2,2,2,0,0,2,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,2,0,0,0,2,2,0,0,0,0,0,3,2,0,0,0,2,0,2,2,2,2,0,0,0,4,2,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,0,4,0,0,2,2,2,2,2,0,2,3,3,2,0,2,0,2,2,3,2,0,2,0,0,2,2,2,2,2,0,0,4,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,6,0,0,0,0,2,0,3,2,0,0,0,2,0,3,2,0,0,0,0,0,2,0,2,0,0,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,0,2,2,2,2,2,0,3,3,2,3,0,3,0,3,3,3,1,0,3,0,3,2,3,2,0,2,0,2,2,2,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,2,2,0,0,0,2,2,3,0,0,0,1,0,3,3,0,0,0,1,0,3,2,0,0,0,0,0,2,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,2,0,0,3,2,3,0,0,3,1,3,3,3,0,0,3,1,1,3,1,0,2,1,2,3,3,2,2,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,2,0,0,0,0,3,0,0,0,1,1,0,3,0,0,0,1,1,0,3,0,0,0,3,0,1,3,0,2,0,0,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,2,2,2,6,0,3,0,3,3,3,0,0,1,1,1,1,1,0,0,3,3,3,1,3,0,0,3,0,2,2,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,2,0,0,0,1,2,1,3,0,0,0,5,1,1,1,0,0,0,1,0,3,3,0,0,0,1,0,6,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,2,2,1,3,3,3,0,0,3,0,1,1,1,0,0,1,1,1,1,1,0,0,1,3,3,3,3,0,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,2,0,0,0,2,0,3,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,0,3,0,0,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,2,3,3,3,0,3,1,1,1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,3,2,3,3,3,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,3,2,0,0,0,3,1,1,1,0,0,0,5,0,1,1,0,0,0,1,1,1,1,0,0,0,3,0,3,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,0,3,0,1,3,1,0,0,1,1,1,5,0,0,0,1,1,1,1,0,0,0,1,1,3,3,1,0,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,2,0,0,0,2,0,3,0,0,0,1,1,1,5,1,0,0,1,1,1,5,0,0,0,1,1,0,3,0,0,0,0,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,2,3,3,3,0,1,1,1,1,1,0,0,0,1,1,1,1,0,0,0,5,1,1,1,0,0,1,3,3,3,3,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,3,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,1,1,0,3,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,0,2,1,3,3,3,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,3,1,3,1,0,2,0,0,6,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,0,0,2,0,0,3,0,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,0,3,0,0,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,2,3,3,3,0,1,1,1,1,1,0,0,0,5,1,1,1,0,0,1,5,1,1,1,0,0,3,2,3,6,3,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,3,0,0,0,3,1,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,3,0,3,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,0,3,2,3,3,3,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,1,3,3,3,1,0,3,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,2,2,0,0,0,3,0,0,0,0,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,0,3,0,0,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,0,2,2,2,0,3,3,3,1,3,0,0,1,1,1,1,1,0,0,0,5,3,1,3,0,0,3,2,2,3,6,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,2,2,0,0,1,2,1,3,0,0,0,3,0,1,1,0,0,0,1,0,3,1,2,0,0,2,0,2,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,0,2,0,3,6,3,0,0,3,1,3,3,1,0,0,1,1,3,3,1,0,0,3,0,3,3,3,0,2,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,2,2,2,0,0,0,3,0,2,0,0,3,0,3,0,0,0,1,3,1,3,0,2,0,0,3,0,6,0,2,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,2,2,0,2,0,2,3,3,0,0,1,3,3,3,3,0,0,1,1,2,3,3,0,0,3,0,2,2,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,2,0,2,0,0,0,0,3,0,0,0,2,0,3,3,0,0,0,3,0,3,0,0,2,0,0,0,2,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,4,2,0,0,2,2,2,2,1,2,0,3,3,2,0,1,3,0,6,3,3,0,2,2,0,2,2,2,2,2,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	7,0,2,2,0,0,0,2,0,2,0,0,0,2,3,0,2,0,0,0,0,3,0,2,2,0,0,0,2,0,2,0,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,4,4,2,2,2,0,0,2,6,2,0,2,0,2,6,2,2,0,2,0,0,2,2,2,2,2,0,0,4,2,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,4,0,4,0,0,0,0,2,0,2,0,0,0,2,2,0,2,0,0,0,2,0,0,2,0,0,0,4,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	8,4,4,4,0,0,0,4,2,4,2,0,0,2,2,2,2,0,0,0,2,2,2,2,2,0,0,2,2,4,4,2,0,0,4,8,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,0,4,0,0,0,4,0,2,2,0,0,0,2,0,2,2,0,0,0,2,0,2,2,0,0,0,4,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,4,2,0,0,4,4,2,2,2,0,0,2,4,2,2,0,0,0,4,2,4,4,0,0,0,4,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,0,4,2,0,0,2,2,0,4,0,0,0,2,0,0,7,0,0,0,4,0,0,4,0,0,0,8,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	8,4,4,8,0,0,0,4,4,4,4,0,0,2,4,4,4,4,0,0,2,4,4,4,2,0,0,4,4,4,8,4,0,0,4,8,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	8,0,0,8,0,0,0,8,0,4,4,0,0,0,4,0,4,4,0,0,0,4,0,2,4,0,0,4,4,0,4,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,4,4,0,0,4,4,4,4,0,0,0,4,4,4,7,0,0,0,4,4,4,8,0,0,0,8,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,0,0,4,4,4,4,0,0,0,4,4,0,4,0,0,0,4,2,4,2,0,0,0,4,4,0,4,0,0,0,4,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,0,4,0,0,0,4,0,4,4,0,0,2,2,4,2,4,0,0,4,2,2,2,4,0,0,4,4,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,4,4,4,4,0,0,0,4,0,2,2,0,0,0,4,0,4,0,0,0,0,4,4,4,0,0,0,4,6,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,0,4,4,0,4,2,0,0,2,2,2,4,2,0,2,2,0,2,4,0,0,2,2,2,4,4,0,0,2,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,4,4,4,0,0,0,2,2,0,2,0,0,0,2,2,0,0,0,0,0,4,2,2,2,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,4,4,0,0,2,2,2,2,2,0,0,2,2,2,2,2,0,0,2,2,2,2,2,0,0,2,2,2,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,2,0,0,0,4,0,2,2,0,0,0,2,0,0,0,0,0,0,5,0,2,0,0,0,0,2,0,4,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,0,2,2,2,2,2,0,0,2,2,2,0,2,0,3,2,3,2,2,2,0,2,2,2,2,2,0,0,2,2,2,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,2,0,0,0,2,2,0,0,0,0,1,2,3,0,0,0,0,1,2,2,0,2,0,0,0,2,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,2,2,0,0,2,2,2,0,2,2,1,3,3,3,0,0,2,1,3,3,3,0,2,0,0,2,2,2,2,2,0,0,4,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,5,0,0,0,0,1,0,3,2,0,0,0,1,0,3,0,0,0,0,2,0,2,0,2,0,0,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,0,2,2,2,0,2,0,3,3,3,2,0,3,3,3,1,3,0,0,3,2,3,3,3,1,0,2,0,2,2,2,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,2,0,0,0,0,1,3,3,0,0,0,1,0,1,3,0,0,0,1,0,3,3,0,0,0,2,0,2,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,2,2,1,3,3,3,0,0,3,1,1,3,1,0,0,3,1,1,3,1,0,3,3,3,3,3,3,0,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,0,0,0,0,2,0,3,2,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,3,0,0,3,0,0,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,0,3,2,2,3,0,3,0,1,1,3,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,3,2,3,2,2,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,3,0,0,0,3,0,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,3,0,3,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,0,2,1,3,3,1,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,1,3,1,3,1,0,2,0,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,2,0,0,0,0,0,3,0,0,0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,1,0,3,0,0,0,2,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,3,3,3,3,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,0,1,1,1,1,0,0,1,1,3,3,3,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,3,0,0,0,1,1,1,1,0,0,1,1,0,1,1,0,0,0,1,1,1,1,0,0,1,1,0,3,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,0,3,3,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,3,0,0,3,1,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,3,0,0,0,3,0,3,1,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,0,1,0,0,0,3,0,2,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,3,3,3,1,0,1,1,0,1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,1,3,3,3,3,1,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,3,3,0,0,0,3,1,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,1,1,0,3,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,5,2,0,3,0,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,1,0,0,1,1,1,3,0,0,1,3,0,5,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,0,0,3,1,1,0,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,0,3,0,0,0,0,3,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,3,3,3,3,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,1,1,3,3,3,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,3,0,0,0,1,1,0,1,0,0,1,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,3,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,2,2,0,3,1,1,3,3,0,0,1,1,1,1,0,0,0,1,1,1,1,1,0,0,1,1,3,3,1,0,3,1,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,2,0,0,0,0,2,3,0,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,0,3,0,0,0,0,2,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,2,3,5,3,0,1,1,1,1,3,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,1,1,3,5,3,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,3,0,0,0,3,1,1,3,0,0,0,3,1,1,1,0,0,0,1,0,1,1,0,0,0,3,0,2,2,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,2,2,0,3,3,3,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,1,3,3,3,3,0,3,0,0,5,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,2,2,0,0,0,0,3,0,0,0,0,3,0,1,0,0,0,1,3,0,1,0,0,0,0,3,0,3,0,2,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,5,2,0,3,0,3,3,3,1,0,0,3,3,1,3,0,0,1,3,3,3,3,0,0,3,0,2,5,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,2,0,2,0,0,0,1,3,0,0,0,3,0,1,3,0,0,0,3,0,3,0,2,0,0,0,0,2,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,2,2,5,2,0,3,3,3,3,3,0,0,3,1,3,3,3,0,3,3,0,2,2,2,0,2,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,2,2,0,0,0,5,0,0,0,0,0,0,3,0,0,0,0,0,0,3,0,2,0,0,0,0,2,0,2,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,2,2,2,2,0,2,5,2,2,0,3,0,2,3,2,3,0,3,0,2,3,2,2,2,2,0,0,4,2,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,2,0,2,0,0,0,2,2,0,2,0,0,0,3,2,0,0,0,0,0,2,0,0,2,0,0,0,2,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,4,2,0,0,2,4,2,2,0,0,0,2,2,2,2,2,2,0,2,2,2,2,2,0,0,2,2,2,4,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,4,4,0,0,0,2,0,2,2,0,0,0,2,0,2,0,0,0,0,2,0,2,2,0,0,0,4,0,4,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,0,4,4,4,4,2,0,0,2,4,2,2,2,0,0,2,2,2,2,2,0,0,4,2,2,4,0,0,0,4,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,2,0,4,0,0,0,2,2,0,2,0,0,0,2,0,0,2,0,0,0,2,0,0,4,0,0,0,4,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,4,4,4,0,0,0,6,4,4,2,0,0,2,4,4,2,2,0,0,2,4,4,2,2,0,0,4,4,4,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,4,4,0,0,0,4,0,2,4,0,0,0,4,0,4,2,0,0,0,4,0,4,4,0,0,4,4,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,0,4,4,4,6,4,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,6,0,0,0,6,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,0,0,4,4,4,4,0,0,0,4,2,0,4,0,0,0,2,2,0,4,0,0,0,4,0,4,4,0,0,0,4,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,0,4,0,0,0,4,0,2,4,0,0,2,2,2,2,4,0,0,2,2,2,2,4,0,0,4,0,4,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,4,4,0,0,0,4,4,4,0,0,0,0,4,0,2,0,0,0,0,4,0,2,0,0,0,0,7,2,7,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,0,4,2,2,4,4,0,0,2,2,2,2,2,0,0,2,2,2,2,2,0,2,2,2,2,4,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,4,2,2,0,0,0,2,2,0,2,0,0,0,2,2,2,0,0,0,0,2,2,2,2,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,0,4,0,0,2,2,2,2,2,0,0,2,2,2,0,2,0,0,2,2,2,2,2,0,0,2,2,2,2,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	7,4,2,2,0,0,0,2,0,0,0,0,2,0,3,0,0,2,0,0,0,6,0,0,0,0,0,0,2,0,2,0,0,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,0,2,2,2,0,2,0,2,2,3,2,0,2,0,3,3,3,3,0,3,0,3,2,3,2,2,0,0,2,2,2,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,6,0,0,0,0,0,3,2,0,0,0,2,0,3,3,0,0,0,2,0,3,2,0,0,0,0,0,2,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,2,0,0,6,2,6,0,0,2,1,3,3,3,0,0,2,1,3,3,1,0,2,0,2,3,2,2,0,2,0,0,4,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,0,2,0,0,0,3,0,0,0,0,1,0,3,1,0,0,3,1,0,3,0,0,0,2,3,0,3,2,0,2,0,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,3,6,2,2,0,2,1,3,3,3,0,0,3,1,3,1,1,0,0,3,3,3,3,3,0,0,2,0,3,2,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,2,0,0,0,2,1,1,3,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,0,2,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,0,2,1,3,3,3,0,0,3,1,1,1,1,0,0,1,1,1,1,1,0,1,3,3,3,3,3,0,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,2,0,0,0,2,0,3,0,0,0,1,1,0,3,0,0,0,1,1,0,5,0,0,0,1,0,1,3,0,0,0,0,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,2,3,3,3,0,3,1,1,1,5,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,3,2,3,3,3,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,3,3,0,0,0,1,1,0,1,0,0,0,5,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,3,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,0,0,3,2,1,1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,3,1,0,3,2,3,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,2,0,0,0,3,0,3,1,0,0,1,1,0,5,0,0,0,1,1,1,5,0,0,0,1,1,0,1,0,0,0,1,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,3,3,3,1,0,1,1,0,1,1,0,0,0,5,0,1,1,0,0,0,1,1,1,1,0,0,1,3,3,3,3,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,3,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,5,1,1,1,0,0,0,1,0,3,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,3,2,0,3,1,1,1,1,0,0,1,1,1,5,1,0,0,1,1,0,5,0,0,0,1,1,1,1,1,0,0,3,2,3,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,0,0,0,3,0,1,1,0,0,1,1,1,5,0,0,0,1,1,1,5,0,0,0,1,1,1,5,0,0,0,1,3,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,3,3,3,1,0,0,1,0,1,1,0,0,0,5,0,1,1,0,0,0,1,1,1,1,0,0,1,3,3,3,3,0,0,6,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,2,1,3,0,0,0,1,1,0,1,0,0,0,5,1,1,1,0,0,0,5,1,1,1,0,0,0,5,0,3,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,6,0,0,3,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,5,0,0,3,3,2,6,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,0,0,1,3,1,5,0,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,3,0,0,6,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,3,3,3,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,1,1,3,3,3,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,2,2,3,0,0,0,1,1,1,1,0,0,0,5,1,1,1,0,0,0,5,1,1,1,0,0,0,1,0,3,0,2,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,6,0,0,3,1,1,3,1,0,0,1,1,1,5,0,0,0,1,1,1,1,0,0,0,1,1,1,5,0,0,1,3,0,3,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,0,0,0,3,0,1,0,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,0,3,0,0,0,2,1,2,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,3,3,3,3,0,0,1,1,1,1,0,0,0,5,1,1,1,0,0,1,1,1,1,1,0,0,1,3,3,3,3,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,3,3,0,0,0,3,1,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,3,0,3,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,0,3,1,3,3,3,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,1,3,3,3,0,0,3,2,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,2,0,0,0,0,0,3,0,0,0,0,3,1,1,0,0,0,1,1,0,5,1,0,0,1,3,0,3,0,2,0,0,0,0,6,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,2,2,6,2,0,3,1,3,3,3,0,0,1,1,1,1,1,0,0,1,1,3,3,3,0,0,3,1,2,3,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,2,0,0,0,0,2,1,3,0,0,0,3,1,0,1,0,0,0,3,0,1,3,0,0,0,2,0,2,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,2,2,0,3,6,3,0,0,3,3,3,3,1,0,0,1,3,3,3,1,0,0,3,0,2,3,2,0,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,2,2,0,0,0,2,0,0,0,0,2,0,3,0,2,0,1,2,0,3,0,2,0,0,2,0,3,0,2,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,2,2,0,3,2,2,3,2,0,0,3,3,3,3,3,0,0,3,1,2,3,2,3,0,2,0,0,2,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,0,2,0,2,0,0,0,0,3,0,0,1,0,0,3,3,0,2,0,0,0,2,2,0,2,0,0,0,2,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,2,2,0,0,2,2,2,2,0,2,0,2,6,2,0,0,2,0,2,2,3,2,2,0,0,2,2,2,2,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,4,4,0,0,0,2,0,2,2,0,0,0,6,0,2,0,0,0,0,2,0,2,0,0,0,0,2,0,2,2,0,0,4,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,4,4,4,2,2,0,0,2,2,6,0,2,0,2,2,2,2,0,2,0,0,2,2,2,2,2,0,0,4,2,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,2,0,4,0,0,0,0,2,0,2,0,0,0,2,2,0,2,0,0,0,2,0,0,4,0,0,0,4,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	7,4,4,4,0,0,0,4,2,4,2,0,0,2,6,2,2,2,0,0,2,2,4,2,2,0,0,4,4,4,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	7,0,0,4,0,0,0,4,0,2,4,0,0,0,4,0,2,2,0,0,0,4,0,2,2,0,0,2,4,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,0,4,4,4,4,4,0,0,4,4,4,4,0,0,0,4,7,4,2,0,0,0,4,4,4,4,0,0,0,7,4,4,7,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,0,0,4,4,4,4,0,0,0,2,2,0,2,0,0,0,2,0,2,0,0,0,0,2,2,0,4,0,0,0,4,0,4,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,0,4,0,0,0,2,0,2,4,0,0,2,2,2,2,2,0,0,2,2,2,2,4,0,0,2,2,2,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,4,4,0,0,0,6,4,2,0,0,0,0,2,0,0,2,0,0,0,5,2,0,0,0,0,0,4,2,4,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,0,4,2,2,2,2,0,0,2,2,2,2,2,0,2,2,2,2,2,0,0,2,2,2,2,2,0,0,2,2,2,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,4,0,2,0,0,0,2,2,0,0,0,0,0,2,2,0,0,0,2,0,2,2,0,2,0,0,0,4,2,0,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,2,2,0,0,2,2,2,2,2,0,0,3,3,5,0,2,0,3,3,2,3,0,2,0,0,2,2,2,2,2,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,2,2,2,0,0,0,2,0,0,0,0,2,0,3,2,0,0,0,1,0,3,0,0,0,0,0,2,2,0,2,0,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,2,2,0,2,0,3,3,3,3,0,3,0,3,3,3,3,0,5,0,3,3,3,2,0,2,0,2,2,2,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,0,0,0,0,3,3,0,0,0,3,0,3,3,0,0,0,1,0,3,0,0,0,0,2,0,2,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,2,2,2,3,3,3,0,0,3,1,1,3,1,0,0,1,1,1,3,1,0,3,2,3,3,3,3,0,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,0,0,0,0,0,3,2,0,0,0,1,0,3,0,0,0,1,1,0,3,0,0,0,1,0,1,3,0,0,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,3,3,2,3,0,3,1,3,1,3,0,0,1,1,1,1,1,0,0,1,3,1,1,3,0,0,3,2,3,3,3,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,3,0,0,0,3,1,1,1,0,0,0,1,0,1,1,0,0,1,1,0,3,1,0,0,1,3,0,3,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,0,3,0,3,1,3,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,1,3,1,1,1,0,2,0,2,5,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,0,0,0,0,3,1,3,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,0,1,3,0,0,0,3,0,2,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,1,3,3,1,0,0,1,1,1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,3,1,3,3,3,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,3,3,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,0,1,0,3,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,3,1,1,1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,1,1,0,0,1,3,3,5,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,0,0,0,1,1,0,1,0,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,0,1,0,0,0,3,0,2,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,1,3,3,0,0,1,1,0,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,1,1,1,3,1,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,3,0,3,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,1,1,1,1,1,0,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,3,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,1,1,0,1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,3,1,2,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,1,1,3,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,0,0,1,1,1,1,0,0,1,1,3,1,1,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,3,0,3,0,0,0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,3,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,0,0,1,3,1,1,0,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,3,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,1,1,1,3,3,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,2,1,2,1,0,0,0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,3,1,1,1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,1,1,2,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,0,0,0,3,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,0,1,0,0,0,2,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,3,3,3,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,1,1,3,3,3,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,3,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,1,3,0,3,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,2,2,0,3,1,1,1,3,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,1,1,1,3,0,0,0,3,0,3,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,1,0,0,0,3,0,3,0,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,0,2,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,2,3,2,3,0,2,1,1,1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,3,0,0,1,3,3,3,3,0,2,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,3,0,0,0,3,2,1,1,0,0,0,3,0,1,1,0,0,0,1,0,1,1,0,0,0,3,0,3,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,0,3,0,3,3,3,0,0,3,1,3,1,1,0,0,1,1,3,1,1,0,0,3,2,3,3,3,0,2,0,0,2,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,0,0,0,0,0,0,3,0,0,0,0,3,0,3,0,0,0,0,3,0,3,0,0,0,2,1,0,3,0,2,0,0,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,0,0,5,2,2,0,3,2,3,3,3,0,0,1,3,3,3,3,0,0,1,3,3,3,3,0,0,3,0,2,2,2,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,0,2,0,2,0,0,0,2,3,0,0,0,2,1,3,3,0,0,0,2,0,3,3,0,2,0,0,0,2,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,4,0,2,0,2,2,2,2,0,3,0,3,3,3,0,0,3,2,3,3,3,0,0,2,0,2,2,2,2,2,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,2,2,0,0,0,2,0,2,0,0,0,0,5,0,0,0,0,0,0,3,0,2,0,0,0,0,2,0,2,0,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,4,2,2,2,2,0,0,5,2,2,0,3,0,2,2,3,2,0,2,0,0,5,2,2,2,2,0,0,6,4,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,4,0,2,0,0,0,0,2,0,2,0,0,0,2,2,0,2,0,0,0,2,0,0,2,0,0,0,4,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,4,4,0,0,2,4,2,4,2,0,0,2,5,2,2,2,0,0,2,2,2,2,2,0,0,2,2,4,2,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,0,4,0,0,0,4,0,2,2,0,0,0,2,0,2,0,0,0,0,2,0,2,2,0,0,2,4,0,4,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,4,2,0,0,4,2,4,2,2,0,0,4,4,2,2,2,0,0,4,4,2,4,0,0,0,4,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,0,0,4,4,0,4,0,0,0,2,2,0,2,0,0,0,2,0,2,0,0,0,0,2,0,2,2,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,0,4,0,0,2,2,0,2,2,0,0,2,2,2,2,2,0,0,2,2,2,2,2,0,0,2,2,2,4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,4,2,0,0,0,4,2,0,0,0,0,0,2,0,0,0,0,0,0,6,2,0,0,0,0,0,2,0,2,0,0,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,0,2,2,2,2,2,0,2,2,2,2,0,2,0,3,2,3,2,0,2,0,2,2,2,2,4,2,0,2,2,2,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,2,0,0,0,2,2,0,0,0,2,0,3,2,0,0,0,0,0,2,0,0,0,0,0,0,6,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,2,0,0,2,3,3,2,0,2,2,3,3,3,0,0,2,3,3,3,3,0,2,0,2,3,2,2,0,2,0,0,4,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,0,0,0,0,0,6,0,0,0,0,3,0,3,0,0,0,2,3,0,3,0,0,0,2,1,2,3,0,2,0,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,2,2,2,2,0,2,0,3,3,3,0,0,3,3,3,1,3,0,0,3,3,3,3,3,0,0,2,0,2,2,2,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,3,0,0,0,0,3,3,3,0,0,0,1,0,1,3,0,0,0,1,0,3,2,0,0,0,3,0,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,0,2,0,3,3,3,0,0,3,0,1,3,1,0,0,3,1,1,1,0,0,0,1,3,3,3,3,0,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,0,0,0,2,0,3,0,0,0,1,3,0,1,0,0,0,1,1,0,3,0,0,0,1,0,1,3,0,0,0,0,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,3,3,3,3,0,3,3,1,1,1,0,0,1,1,0,1,1,0,0,1,1,1,3,1,0,0,3,3,3,3,3,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,2,2,3,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,3,1,0,3,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,3,0,0,3,0,1,1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,5,1,1,5,0,0,2,3,2,3,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,0,0,3,3,1,5,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,3,0,2,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,3,1,3,0,0,0,1,1,1,1,0,0,0,5,1,1,1,0,0,0,1,0,1,1,0,0,1,3,1,1,1,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,3,0,3,0,0,0,5,1,1,1,0,0,0,5,1,1,1,0,0,0,5,1,1,1,0,0,0,5,0,3,0,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,3,1,1,1,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,3,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,0,1,5,0,1,1,0,0,1,1,1,1,1,0,0,1,1,1,5,0,0,0,1,1,0,5,0,0,0,1,1,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,1,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,1,5,1,1,1,0,2,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,1,0,3,0,0,0,5,1,1,1,0,0,0,1,0,1,1,0,0,0,5,1,1,1,0,0,0,1,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,1,1,1,1,0,0,0,1,1,1,5,0,0,0,1,1,0,1,0,0,0,1,1,0,5,0,0,0,1,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,0,1,1,0,1,1,0,0,1,1,0,5,1,0,0,1,1,1,5,0,0,0,1,1,0,5,0,0,0,3,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,1,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,3,0,3,0,0,0,1,0,1,1,0,0,0,5,1,1,1,0,0,0,1,1,1,1,0,0,0,5,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,0,5,0,0,0,1,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,0,0,1,1,0,1,0,0,0,1,1,1,5,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,1,1,5,0,0,0,1,1,1,1,0,0,0,5,0,1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,3,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,1,0,3,0,0,0,5,1,0,1,0,0,0,5,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,5,0,0,0,1,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,0,0,0,3,1,1,1,0,0,1,1,0,1,1,0,0,1,1,0,5,0,0,0,1,1,0,1,0,0,0,3,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,3,3,3,1,0,0,1,1,1,1,0,0,0,5,1,1,1,0,0,0,5,1,1,1,0,0,1,1,1,3,3,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,2,2,1,3,0,0,0,1,1,1,1,0,0,0,5,0,1,1,0,0,0,5,0,1,1,0,0,0,5,0,3,1,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,3,0,0,3,1,1,5,1,0,0,1,1,1,5,0,0,0,1,1,1,5,0,0,0,1,1,1,5,0,0,0,1,2,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,0,0,0,3,0,1,0,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,1,0,3,0,0,0,2,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,3,3,3,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,1,1,3,3,3,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,3,0,0,0,3,1,0,1,0,0,0,3,0,1,1,0,0,0,5,0,1,1,0,0,0,3,0,3,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,0,3,3,3,3,3,0,0,1,1,1,1,1,0,0,1,1,1,3,1,0,0,1,3,3,3,3,0,3,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,0,0,0,0,0,3,0,0,0,0,3,0,5,0,0,0,0,3,0,1,0,0,0,0,3,0,3,0,0,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,2,2,2,2,0,3,3,3,3,3,2,0,1,1,1,1,3,0,0,1,1,3,3,3,0,0,3,0,2,6,3,2,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,2,0,0,0,2,0,3,3,0,0,0,3,3,0,3,0,0,0,3,0,3,1,0,0,0,0,0,2,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,2,2,0,2,0,2,6,3,0,0,3,0,3,3,3,0,0,3,3,3,3,3,0,0,3,2,2,6,3,0,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,2,2,0,0,0,3,0,0,0,0,0,0,3,0,0,0,0,0,0,3,0,0,0,0,2,0,3,0,2,0,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,0,2,2,2,2,2,0,2,6,2,2,0,3,2,3,2,3,2,0,3,0,2,2,2,2,0,2,0,2,2,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,2,0,0,0,0,2,0,2,0,0,0,3,2,0,2,0,0,0,2,0,0,2,0,0,0,4,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,4,2,0,0,2,6,2,2,2,0,0,2,6,2,0,0,2,0,2,2,2,2,2,0,0,2,2,2,2,2,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,0,4,0,0,0,2,0,2,2,0,0,0,6,0,2,0,0,0,0,2,0,2,2,0,0,0,2,0,4,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,0,4,4,4,4,2,0,0,2,4,6,0,2,0,0,6,2,2,2,2,0,0,6,6,2,4,0,0,0,4,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,0,0,0,2,0,2,0,0,0,2,2,0,0,0,0,0,2,2,0,0,0,0,0,2,2,0,2,0,0,0,7,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,7,0,0,2,2,2,0,2,2,0,2,2,2,2,2,0,0,2,2,2,0,2,0,0,2,2,2,2,2,0,0,7,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	7,0,2,0,0,0,0,6,0,0,0,0,2,0,6,0,0,0,0,0,0,6,0,0,0,0,0,2,2,0,2,0,0,0,0,7,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	7,0,0,7,2,2,2,2,0,2,2,3,3,0,3,0,3,3,3,1,0,2,2,3,2,3,2,0,2,0,2,2,2,2,7,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,2,0,0,0,0,0,2,3,0,0,0,0,0,3,3,0,0,0,0,0,3,2,0,0,0,0,0,6,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,2,0,2,3,3,3,2,0,3,0,3,3,3,0,0,3,2,1,3,3,0,3,2,2,3,2,3,0,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,0,0,0,0,2,3,0,0,0,0,3,0,5,0,0,0,2,1,1,3,0,0,0,0,1,2,3,0,0,0,0,0,0,7,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,2,3,2,3,0,2,0,3,1,3,0,0,1,3,3,1,1,0,0,3,3,1,1,3,0,0,3,2,3,2,3,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,3,0,0,0,3,1,1,3,0,0,0,1,0,1,1,0,0,0,1,0,3,1,0,0,0,1,0,3,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,0,2,1,3,1,3,0,0,3,1,1,1,1,0,0,3,1,1,1,0,0,0,3,1,3,3,0,0,3,0,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,2,0,0,0,3,0,3,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,0,1,5,0,0,0,3,0,2,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,3,1,3,3,0,1,1,1,0,1,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,1,3,3,3,3,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,2,3,0,3,0,0,0,4,0,1,1,0,0,0,1,0,1,1,0,0,0,4,0,1,1,0,0,1,1,0,3,1,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,3,1,0,1,1,0,0,1,1,1,4,0,0,0,1,1,1,1,1,0,0,1,1,0,1,0,0,2,3,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,0,0,1,3,1,1,0,0,0,1,1,1,1,1,0,0,1,1,0,4,0,0,0,1,1,1,1,0,0,0,3,0,0,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,1,1,1,1,1,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,1,0,3,0,0,0,4,1,1,1,0,0,0,4,1,1,1,0,0,0,4,1,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,1,1,0,1,0,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,0,4,0,0,0,1,3,3,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,0,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,0,4,0,0,0,1,0,2,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,3,1,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,1,0,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,4,1,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,0,1,1,1,1,0,0,0,1,1,1,1,1,0,0,1,1,0,4,0,0,0,1,1,0,1,0,0,0,1,3,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,0,1,4,0,1,1,0,0,1,1,1,4,0,0,0,1,1,1,1,0,0,0,1,1,0,1,0,0,0,1,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,1,4,1,1,1,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,1,1,1,1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,1,0,4,0,0,0,1,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,0,1,1,0,1,1,0,0,1,1,1,4,0,0,0,1,1,1,1,0,0,0,1,1,1,4,0,0,0,1,0,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,4,0,1,1,0,0,0,4,0,1,1,0,0,0,1,1,1,1,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,1,0,1,0,0,0,1,1,0,1,0,0,0,4,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,0,0,0,4,1,1,1,0,0,1,1,0,1,1,0,0,1,1,0,4,0,0,0,1,1,0,4,0,0,0,3,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,3,1,1,5,0,0,0,1,1,1,1,0,0,0,4,0,1,1,0,0,0,4,1,1,1,0,0,1,1,1,1,1,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,1,0,1,0,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,4,0,1,1,0,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,1,1,1,1,1,0,0,1,1,1,4,1,0,0,1,1,1,4,0,0,0,1,1,1,1,0,0,0,3,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,0,0,0,3,0,1,0,0,0,1,1,0,4,0,0,0,1,1,0,4,0,0,0,1,0,1,1,0,0,0,1,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,3,3,3,3,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,1,4,5,3,3,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,3,3,0,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,3,0,3,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,3,0,0,3,3,1,3,3,0,0,1,1,1,1,1,0,0,1,1,1,4,0,0,0,1,3,1,3,1,0,0,3,2,6,6,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,0,0,0,2,0,3,1,0,0,0,3,0,1,0,0,0,1,1,0,4,0,0,0,1,1,0,5,0,0,0,0,2,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,2,3,3,3,0,0,1,3,1,3,0,0,1,1,1,1,1,0,0,0,1,3,1,3,0,0,3,0,2,3,3,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,0,0,2,3,0,1,0,0,0,1,0,3,3,0,0,0,1,0,3,1,0,0,0,2,0,3,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,2,2,0,3,0,3,3,3,0,0,3,1,3,3,3,0,0,1,3,3,3,3,0,0,3,2,3,3,3,0,2,2,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,2,0,0,0,0,6,0,0,0,0,2,0,5,0,0,0,0,3,0,3,0,0,0,0,2,0,3,0,2,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,0,2,6,2,0,3,0,2,3,3,2,0,1,3,3,3,3,0,0,3,0,3,3,3,0,0,2,0,2,2,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,2,0,2,0,0,0,2,3,0,2,0,0,0,3,2,2,0,0,2,0,3,0,0,2,0,0,0,2,0,2,7,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	7,0,7,2,2,0,2,2,2,2,0,2,0,2,3,2,0,0,3,0,2,3,2,0,2,2,0,2,2,2,2,2,0,0,0,7,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	7,0,0,7,0,0,0,2,0,2,2,0,0,0,2,0,2,0,0,0,0,2,0,2,0,0,0,0,2,0,2,0,0,0,0,7,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	7,0,0,2,7,2,2,2,0,0,2,2,6,0,2,0,2,2,2,2,2,2,0,0,6,6,2,0,2,0,0,7,2,7,7,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,0,0,0,6,0,2,0,0,0,2,0,0,0,0,0,0,2,2,0,0,0,0,0,2,2,0,2,0,0,0,2,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,2,0,0,2,2,2,2,2,2,2,3,3,2,0,2,0,2,3,2,3,0,2,0,0,2,2,2,2,2,0,0,6,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,2,2,0,0,0,0,6,0,0,0,0,2,0,7,0,0,0,0,3,0,3,0,0,0,0,2,0,2,0,2,0,0,0,0,6,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,2,2,2,2,0,2,0,3,3,3,1,0,3,2,3,3,3,0,0,3,2,3,3,3,2,0,2,0,2,2,2,2,6,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,0,0,0,2,3,3,0,0,0,1,0,3,3,0,0,2,3,0,3,3,0,0,0,2,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,0,0,2,3,3,3,0,0,3,0,3,1,3,0,0,3,1,1,1,1,0,2,2,3,3,3,3,0,2,0,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,0,0,0,2,0,3,2,0,0,1,1,0,3,0,0,0,3,1,0,3,0,0,0,3,1,0,3,0,0,0,0,0,2,6,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,3,2,3,3,0,3,1,1,1,3,0,0,3,1,0,1,1,0,0,1,1,1,1,1,0,0,3,3,3,3,3,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,3,0,0,0,3,0,1,1,0,0,0,4,0,1,1,0,0,0,1,1,3,1,0,0,2,1,0,3,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,3,0,3,1,1,0,0,3,1,0,1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,1,0,2,3,3,3,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,0,0,3,1,1,1,0,0,0,1,1,0,1,0,0,0,1,1,0,4,0,0,0,1,0,1,4,0,0,0,3,0,2,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,3,1,3,0,0,0,1,1,0,1,0,0,1,1,0,1,1,0,0,0,1,1,1,1,0,0,3,1,1,1,1,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,2,1,3,0,0,0,4,0,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,1,1,0,3,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,3,1,0,1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,0,4,0,0,0,3,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,0,0,0,1,1,1,1,0,0,0,1,1,1,4,1,0,0,1,1,1,1,0,0,0,1,1,1,4,0,0,0,1,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,4,1,1,1,0,0,0,1,1,1,1,0,0,0,4,1,1,1,0,0,0,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,3,0,0,1,1,0,1,0,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,0,4,0,0,0,4,3,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,0,4,0,0,0,1,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,1,0,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,4,1,1,1,0,0,0,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,0,1,1,1,1,0,0,0,1,1,1,4,0,0,0,1,1,0,1,0,0,0,1,1,0,4,0,0,0,4,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,4,1,0,0,1,1,1,1,0,0,0,1,1,1,4,0,0,0,1,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,1,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,1,1,1,0,0,0,1,0,1,1,0,0,0,4,1,1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,0,4,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,4,0,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,3,0,0,1,1,1,1,0,0,0,0,1,0,1,0,0,0,1,1,1,1,0,0,0,1,1,1,4,0,0,0,1,3,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,0,0,4,1,1,1,0,0,1,1,1,1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,4,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,1,0,1,0,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,1,1,1,1,1,0,0,1,1,1,4,0,0,0,1,1,1,4,0,0,0,1,1,1,4,0,0,0,1,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,0,0,3,0,1,0,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,1,0,4,0,0,0,3,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,3,1,4,0,0,0,1,1,1,1,0,0,0,4,0,1,1,0,0,0,1,1,1,1,0,0,1,4,3,4,1,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,2,2,1,3,0,0,0,1,0,1,1,0,0,0,4,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,3,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,3,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,4,0,0,0,1,1,1,3,0,0,0,1,2,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,0,0,0,3,0,3,1,0,0,0,1,0,1,0,0,0,1,1,0,4,0,0,0,1,1,0,1,0,0,0,2,1,2,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,3,3,7,1,0,0,1,1,3,1,0,0,1,1,1,1,1,0,0,0,1,1,1,3,0,0,1,3,3,3,3,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,3,0,0,0,1,2,1,3,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,3,0,3,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,2,2,0,3,0,3,3,3,0,0,1,3,1,3,3,0,0,1,1,3,3,0,0,0,3,3,3,3,2,0,3,3,0,2,6,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,0,0,0,0,0,7,1,0,0,0,3,0,3,0,0,0,0,3,0,3,0,0,0,1,2,0,3,0,2,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,2,2,2,2,0,3,2,3,3,3,0,0,1,1,3,3,3,0,0,1,3,3,7,3,0,0,3,0,2,2,6,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,2,0,2,0,0,2,2,3,0,0,0,2,0,3,3,0,0,0,2,0,3,1,2,0,0,0,0,2,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,6,6,2,2,0,2,2,2,0,0,3,2,3,3,3,0,0,1,2,3,3,3,0,2,2,0,2,6,2,0,6,0,0,6,6,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,2,2,0,0,0,2,0,2,0,0,0,0,3,0,2,0,0,2,0,3,0,2,0,0,0,2,2,0,6,0,0,0,2,6,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,0,2,2,2,2,2,0,2,6,6,2,0,3,0,2,2,2,2,0,2,0,2,2,2,2,0,2,0,0,6,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,0,0,0,2,0,0,0,0,0,2,2,0,0,0,0,2,2,2,0,0,0,2,0,2,2,0,0,0,0,2,2,2,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,2,2,0,2,2,2,2,0,2,2,3,3,3,0,0,0,3,3,3,3,0,2,0,2,2,3,2,0,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,2,0,0,0,0,2,3,2,0,0,0,0,2,3,2,0,0,0,3,0,3,0,0,0,0,1,2,2,0,0,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,2,2,2,2,0,2,0,3,3,3,1,0,3,1,3,1,3,0,0,3,2,3,3,3,0,0,3,2,2,2,6,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,0,0,3,0,3,3,0,0,2,1,0,3,1,0,0,1,1,0,3,3,0,0,0,2,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,6,2,0,2,1,3,3,3,0,0,3,0,1,3,1,0,0,3,1,0,3,0,0,0,3,3,1,3,1,0,2,0,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,2,0,0,0,3,0,5,0,0,0,1,3,0,1,0,0,0,1,1,1,3,0,0,0,1,1,2,3,0,0,0,2,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,3,3,3,3,0,0,3,1,1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,1,0,0,3,1,3,3,3,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,2,1,2,3,0,0,0,1,0,1,1,0,0,0,4,0,1,1,0,0,0,1,1,1,1,0,0,1,1,0,3,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,3,1,1,1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,2,3,3,2,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,0,0,2,1,0,1,0,0,0,1,1,1,1,0,0,0,1,1,0,4,0,0,0,1,1,0,3,0,0,0,3,0,2,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,3,1,1,4,0,0,1,1,1,0,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,2,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,3,0,1,0,0,0,4,0,1,1,0,0,0,4,0,1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,1,0,1,0,0,0,3,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,0,0,0,0,4,1,1,0,0,0,1,1,1,4,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,1,4,0,1,1,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,1,0,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,4,1,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,0,4,0,0,0,1,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,1,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,4,0,0,0,1,1,0,1,0,0,0,1,1,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,4,0,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,4,0,1,1,0,0,1,1,1,1,1,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,4,1,1,1,0,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,1,4,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,1,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,4,1,1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,0,4,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,4,1,1,0,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,4,0,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,4,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,1,0,4,0,0,0,1,1,0,4,0,0,0,1,1,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,1,1,1,0,0,0,1,1,1,1,0,0,0,4,0,1,1,0,0,0,4,1,1,1,0,0,1,1,1,1,1,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,1,0,1,0,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,0,0,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,0,1,1,1,1,0,0,0,1,1,1,4,0,0,0,1,1,0,4,0,0,0,1,1,1,4,0,0,0,1,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,2,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,1,0,4,0,0,0,1,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,3,1,4,0,0,0,1,1,1,1,0,0,0,4,1,1,1,0,0,0,1,1,1,1,0,0,1,4,1,1,1,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,3,0,3,0,0,0,1,0,1,1,0,0,0,4,0,1,1,0,0,0,1,1,1,1,0,0,0,4,0,1,1,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,3,0,0,0,3,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,0,0,1,3,2,1,1,0,0,0,1,0,1,1,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,2,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,3,3,3,0,0,0,1,1,1,1,0,0,0,4,1,1,1,0,0,0,1,1,1,1,0,0,1,3,3,3,3,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,3,0,0,0,3,0,1,1,0,0,0,1,0,1,1,0,0,0,4,0,1,1,0,0,0,3,0,3,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,0,3,1,3,3,3,0,0,1,3,1,4,1,0,0,1,1,1,3,1,0,0,1,3,3,3,0,0,1,3,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,2,0,0,0,2,0,3,1,0,0,0,3,0,1,0,0,0,0,3,0,4,0,0,0,1,3,0,3,0,0,0,2,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,2,2,3,2,0,1,1,3,3,3,0,0,0,3,3,1,3,0,0,0,1,3,3,3,0,0,3,1,2,6,3,2,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,2,0,2,0,2,0,2,3,2,0,0,2,2,0,1,0,0,0,3,2,3,1,0,0,0,2,0,2,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,2,2,2,2,0,3,2,3,0,0,3,1,3,3,3,0,0,3,3,3,3,3,0,0,3,2,2,3,2,0,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,2,0,0,0,0,2,0,2,0,0,2,0,3,0,0,0,0,2,2,3,0,0,0,2,2,0,2,0,2,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,0,6,6,6,0,2,0,2,6,2,2,0,3,3,2,3,3,2,0,3,0,2,2,2,2,0,2,0,2,6,6,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,0,0,2,2,0,0,0,0,2,3,2,0,0,0,2,0,2,3,0,0,0,2,0,2,2,0,0,0,2,0,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,0,2,2,3,2,3,0,0,2,3,1,1,3,0,2,3,1,3,3,3,0,2,1,2,3,2,3,0,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,2,0,0,0,0,2,3,2,0,0,1,1,0,3,0,0,0,2,1,0,3,0,0,0,3,1,2,6,0,0,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,3,2,3,3,0,3,1,3,0,3,0,0,3,3,1,1,1,0,0,3,1,1,1,1,0,0,3,2,3,3,3,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,2,2,3,0,0,0,3,0,1,3,0,0,0,3,0,1,1,0,0,0,1,0,3,1,0,0,2,1,0,3,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,0,0,3,1,3,1,1,0,0,3,1,0,1,1,0,0,3,1,1,1,1,0,0,3,1,3,3,0,0,2,2,2,6,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,0,0,2,3,1,3,0,0,0,1,1,0,4,0,0,0,1,1,0,3,0,0,0,1,0,0,4,0,0,0,1,0,2,6,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,1,3,1,0,0,0,3,1,1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,1,0,0,1,3,1,3,3,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,2,1,2,3,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,1,4,0,3,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,3,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,0,0,1,1,1,1,0,0,0,1,1,1,1,1,0,0,1,1,0,4,0,0,0,1,1,0,1,0,0,0,1,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,3,1,1,1,0,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,4,1,1,1,0,0,1,1,1,1,1,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,4,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,1,0,4,0,0,0,3,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,0,1,1,1,4,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,4,0,0,0,1,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,4,0,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,4,1,1,1,0,0,0,4,1,1,1,0,0,0,1,0,1,0,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,0,4,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,0,4,0,0,0,4,1,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,1,1,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,4,0,1,1,0,0,1,1,1,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,4,0,1,1,0,0,0,1,1,1,1,0,0,1,4,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,4,1,1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,1,1,0,1,0,0,0,1,1,1,4,0,0,0,1,1,0,4,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,4,0,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,4,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,1,1,0,1,1,0,0,1,1,0,4,0,0,0,1,1,0,4,0,0,0,1,1,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,4,0,1,1,0,0,0,4,1,1,1,0,0,1,1,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,4,0,0,1,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,0,0,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,0,1,1,1,1,1,0,0,1,1,1,4,0,0,0,1,1,0,4,0,0,0,1,1,1,4,0,0,0,1,1,3,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,4,0,1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,1,1,1,0,0,0,1,1,1,1,0,0,0,4,1,1,1,0,0,0,1,1,1,1,0,0,1,4,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,1,0,1,0,0,0,1,0,1,1,0,0,0,4,0,1,1,0,0,0,1,1,1,1,0,0,1,1,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,0,0,0,4,1,1,0,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,0,0,1,0,0,0,3,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,1,3,3,0,0,0,1,1,1,1,0,0,0,4,1,1,1,0,0,0,1,1,1,1,0,0,1,3,1,3,1,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,2,2,0,3,0,0,0,1,2,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,0,3,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,3,1,1,3,1,0,0,1,1,1,4,0,0,0,1,1,1,1,1,0,0,1,1,3,3,0,0,0,1,2,3,6,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,0,0,0,3,0,3,1,0,0,0,1,0,1,1,0,0,1,1,0,4,0,0,0,1,1,0,4,0,0,0,3,2,2,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,3,3,3,2,0,1,3,1,3,3,0,0,0,3,1,1,3,0,0,0,1,3,3,3,0,0,3,1,6,6,3,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,0,3,0,0,0,3,2,1,3,0,0,0,3,2,0,1,0,0,0,3,0,1,3,0,0,0,3,0,3,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,0,3,0,6,6,6,0,0,1,1,3,3,1,0,0,1,3,3,3,1,0,0,3,2,3,3,2,0,2,2,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,0,0,2,0,2,0,6,0,0,0,0,2,0,3,0,0,0,1,3,0,3,0,0,0,0,2,0,3,0,2,0,0,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,0,2,5,2,2,0,2,2,3,6,3,2,0,3,3,3,3,6,0,0,3,2,6,6,6,0,0,3,2,2,2,2,2,0,2,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,0,0,0,2,0,0,0,0,0,2,3,0,0,0,3,0,2,3,0,0,0,2,0,3,2,0,0,0,1,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,2,2,0,3,3,3,0,0,3,1,0,1,3,0,0,3,1,1,3,1,0,0,3,1,2,3,2,0,2,0,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,0,0,0,3,1,3,2,0,0,3,1,0,3,0,0,0,1,3,0,5,0,0,0,3,0,3,3,0,0,0,2,0,2,6,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,1,2,3,2,0,2,3,1,0,1,0,0,3,1,0,1,1,0,0,2,1,1,1,1,0,0,3,3,3,2,3,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,2,2,3,3,0,0,0,3,0,3,1,0,0,0,3,0,1,1,0,0,0,1,0,3,0,0,0,0,1,0,3,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,3,0,0,3,0,3,1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,1,0,0,1,3,1,3,0,0,2,3,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,0,0,3,3,1,1,0,0,0,1,1,1,1,0,0,0,1,1,0,4,0,0,0,1,1,0,5,0,0,0,1,0,2,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,1,0,1,0,0,0,1,1,1,1,0,0,0,4,1,1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,3,0,0,6,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,1,2,1,0,0,0,4,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,4,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,0,1,1,0,1,0,0,0,1,1,0,1,1,0,0,1,0,0,1,0,0,0,1,0,1,4,0,0,0,3,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,0,1,1,1,1,1,0,0,1,1,0,1,0,0,0,1,1,1,4,0,0,0,1,1,0,4,0,0,0,4,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,1,1,1,0,0,0,1,1,0,1,0,0,1,1,0,1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,1,1,1,0,0,0,4,0,1,1,0,0,0,4,1,1,1,0,0,0,1,1,1,1,0,0,0,4,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,0,1,1,0,0,0,1,1,0,4,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,4,0,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,4,1,1,1,0,0,0,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,0,4,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,0,4,0,0,0,4,1,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,4,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,4,1,1,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,1,4,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,1,1,0,4,1,0,0,1,1,1,1,0,0,0,1,1,0,4,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,1,4,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,4,0,1,1,0,0,0,4,1,1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,0,4,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,4,0,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,4,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,0,1,0,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,1,1,1,0,0,1,1,0,4,1,0,0,1,1,0,1,1,0,0,1,1,0,4,0,0,0,1,1,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,4,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,0,1,0,0,0,1,0,1,1,0,0,0,4,0,1,1,0,0,0,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,1,1,1,4,0,0,0,1,1,1,4,0,0,0,1,1,1,4,0,0,0,1,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,1,1,4,0,0,0,1,1,1,1,0,0,0,4,1,1,1,0,0,0,4,1,1,1,0,0,1,4,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,4,0,1,1,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,3,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,0,4,0,0,0,1,1,3,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,0,1,3,0,1,1,0,0,0,1,0,1,1,0,0,1,1,1,1,0,0,0,1,1,0,4,0,0,0,3,0,0,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,1,3,1,0,0,0,1,1,1,1,0,0,0,4,1,1,1,0,0,0,1,1,1,1,0,0,0,3,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,2,0,1,0,0,0,3,1,1,1,0,0,0,4,0,1,1,0,0,0,1,0,1,1,0,0,0,1,0,3,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,1,3,1,1,0,0,0,0,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,3,0,0,0,3,3,6,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,0,0,1,3,0,3,1,0,0,0,1,0,1,0,0,0,1,1,0,1,1,0,0,1,1,0,3,0,0,0,1,2,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,3,3,3,0,0,0,1,3,1,3,0,0,0,4,1,1,1,0,0,0,1,1,3,1,0,0,1,1,3,3,3,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,3,0,0,0,3,0,1,1,0,0,0,3,0,1,1,0,0,0,3,0,3,1,0,0,0,3,0,3,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,0,3,2,3,3,3,0,0,1,1,3,5,0,0,0,1,1,3,5,1,0,0,1,3,3,3,0,0,2,2,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,0,0,0,0,0,3,2,0,0,2,3,0,3,1,0,0,2,3,0,1,0,0,0,2,3,0,3,2,0,0,0,2,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,2,6,6,2,0,3,3,3,3,3,0,0,0,3,3,3,3,0,0,3,3,3,5,6,0,0,3,0,2,6,6,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,0,2,2,3,0,0,0,3,0,2,3,0,0,0,3,0,2,1,0,0,0,3,0,3,1,0,0,0,3,0,2,2,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,0,3,0,2,2,3,0,0,3,0,1,1,1,0,0,3,1,2,1,0,0,0,3,1,2,3,1,0,2,2,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,0,0,1,2,0,3,0,0,0,2,3,0,3,0,0,0,1,1,1,4,0,0,0,1,1,2,3,0,0,0,2,0,2,6,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,1,2,3,2,0,2,1,1,1,1,0,0,1,1,2,1,1,0,0,0,3,1,1,1,0,0,3,1,2,3,3,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,2,2,1,3,0,0,0,3,1,1,1,0,0,0,4,0,1,1,0,0,0,4,0,2,1,0,0,0,3,0,3,0,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,3,0,0,2,1,1,1,1,0,0,1,1,0,1,1,0,0,1,1,1,4,0,0,0,1,1,0,1,0,0,0,3,3,2,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,1,0,0,1,3,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,4,0,0,0,1,1,2,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,3,0,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,4,0,1,1,0,0,1,1,2,1,1,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,1,1,1,0,0,0,4,1,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,0,4,0,0,0,1,1,0,1,0,0,0,1,0,1,4,0,0,0,1,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,0,0,1,1,1,1,1,0,0,1,1,1,4,0,0,0,1,1,1,4,0,0,0,1,1,0,4,0,0,0,1,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,0,1,0,0,0,4,0,1,1,0,0,0,1,1,1,1,0,0,1,1,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,4,0,1,1,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,4,0,0,0,1,1,1,4,0,0,0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,4,1,1,0,0,0,0,1,1,4,0,0,0,1,1,0,4,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,4,0,1,1,0,0,0,4,0,1,1,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,4,1,1,1,0,0,0,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,0,1,4,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,1,1,0,4,0,0,0,1,1,1,4,0,0,0,1,1,0,4,0,0,0,4,1,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,1,0,1,0,0,0,4,0,1,1,0,0,0,4,0,1,1,0,0,0,4,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,4,1,1,1,0,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,1,4,1,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,1,1,1,0,0,1,1,0,4,0,0,0,1,1,1,4,0,0,0,1,1,0,1,0,0,0,1,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,4,0,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,4,0,1,1,0,0,1,4,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,4,1,1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,4,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,0,4,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,1,0,4,0,0,0,1,0,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,4,0,1,1,0,0,0,4,0,1,1,0,0,0,4,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,0,1,0,4,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,4,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,0,0,4,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,4,0,1,1,0,0,0,4,1,1,1,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,1,1,0,1,0,0,1,1,0,1,1,0,0,0,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,0,1,1,4,0,0,0,1,1,0,4,0,0,0,1,1,1,4,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,4,0,0,0,4,0,1,1,0,0,0,4,0,1,1,0,0,0,4,1,1,1,0,0,1,4,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,4,1,0,1,0,0,0,1,0,1,1,0,0,0,4,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,3,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,4,0,0,0,1,1,0,4,0,0,0,1,3,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,0,1,1,1,1,0,0,0,1,1,0,4,0,0,0,1,1,0,4,0,0,0,1,1,0,4,0,0,0,1,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,1,1,1,0,0,0,1,1,1,1,0,0,0,4,0,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,1,0,3,0,0,0,1,0,1,1,0,0,0,4,1,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,1,1,1,1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,1,1,3,0,0,0,3,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,0,2,3,0,1,0,0,0,1,1,0,4,0,0,0,1,1,0,4,0,0,0,1,1,0,4,0,0,0,1,2,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,2,3,3,0,0,0,3,1,1,1,0,0,0,4,1,1,1,0,0,0,4,1,1,1,0,0,1,3,3,3,2,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,2,2,0,3,0,0,0,1,1,0,3,0,0,0,1,2,1,1,0,0,0,3,1,1,1,0,0,0,3,0,2,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,2,0,0,1,3,3,3,2,0,0,1,1,1,3,2,0,0,1,1,1,4,0,0,0,1,3,2,3,0,0,2,2,2,2,6,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,0,0,2,0,3,1,0,0,2,3,0,1,1,0,0,1,2,0,1,0,0,0,2,3,0,5,0,0,0,2,2,2,6,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,3,6,3,2,0,0,3,3,3,5,0,0,0,1,3,3,3,0,0,1,3,3,3,3,0,0,1,2,6,6,3,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,0,2,0,2,0,0,0,2,0,1,2,0,0,0,2,0,1,2,0,0,0,2,0,1,1,0,0,0,1,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,0,0,2,0,1,1,2,0,0,1,0,1,1,1,0,0,1,1,0,1,0,0,0,2,0,1,2,0,0,2,2,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,0,0,1,2,1,2,0,0,0,2,2,0,1,0,0,0,1,1,2,3,0,0,0,1,2,1,2,0,0,0,2,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,0,2,2,0,0,0,1,1,0,1,0,0,1,1,0,1,1,0,0,0,1,1,1,1,0,0,2,1,1,2,1,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,2,2,0,2,0,0,0,1,1,1,1,0,0,0,3,0,1,1,0,0,0,1,1,1,1,0,0,0,2,0,4,0,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,1,0,0,1,1,1,1,1,0,0,1,1,0,1,1,0,0,1,1,1,3,0,0,0,1,1,0,1,0,0,0,2,2,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,0,1,2,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,3,0,0,0,3,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,2,0,1,1,0,0,0,3,1,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,3,0,0,0,1,1,0,1,0,0,0,1,1,0,3,0,0,0,3,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,3,1,1,0,0,0,1,1,1,3,0,0,0,1,1,1,3,0,0,0,1,1,0,3,0,0,0,1,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,0,1,0,0,0,3,0,1,1,0,0,0,1,1,1,1,0,0,1,1,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,3,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,3,0,0,0,1,1,1,1,0,0,0,1,1,0,3,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,3,1,3,0,0,0,0,1,1,3,0,0,0,1,1,1,1,0,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,3,0,1,1,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,3,1,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,0,1,3,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,3,0,0,0,1,1,0,3,0,0,0,1,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,3,0,1,1,0,0,0,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,3,1,1,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,1,3,1,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,1,1,1,0,0,1,1,0,3,0,0,0,1,1,1,3,0,0,0,1,1,1,3,0,0,0,1,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,3,0,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,3,0,1,1,0,0,0,3,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,3,0,1,1,0,0,0,3,1,1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,0,3,0,0,0,1,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,0,1,0,3,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,3,0,0,0,3,1,0,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,3,1,1,1,0,0,0,3,0,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,0,1,0,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,3,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,1,0,3,0,0,0,1,0,0,3,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,3,0,1,1,0,0,0,3,1,1,1,0,0,0,3,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,1,1,0,1,0,0,1,1,0,0,1,0,0,0,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,0,1,1,1,1,1,0,0,0,1,1,3,1,0,0,1,1,0,3,0,0,0,1,1,1,3,0,0,0,1,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,0,1,3,0,0,0,1,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,1,1,1,0,0,0,3,0,1,1,0,0,0,3,0,1,1,0,0,0,3,1,1,1,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,3,0,1,1,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,3,0,0,0,1,1,0,3,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,0,0,3,0,1,0,0,0,0,1,0,1,1,0,0,1,1,0,3,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,3,0,0,0,3,1,1,3,0,0,0,3,0,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,3,0,1,1,0,0,0,3,0,1,1,0,0,0,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,0,0,1,1,1,1,1,0,0,1,1,1,3,0,0,0,1,1,0,3,0,0,0,1,1,1,1,0,0,0,1,2,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,2,0,1,0,0,0,1,1,0,1,0,0,0,1,1,0,3,0,0,0,1,1,0,3,0,0,0,2,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,2,1,2,4,0,0,0,1,1,1,3,0,0,0,3,1,1,1,0,0,0,3,1,1,1,0,0,1,2,1,2,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,2,2,0,2,0,0,0,2,1,0,1,0,0,0,4,1,0,1,0,0,0,3,1,1,1,0,0,0,2,0,2,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,0,0,1,1,1,2,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,2,1,2,0,0,0,2,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,0,0,0,2,0,2,1,0,0,1,2,0,1,1,0,0,1,2,0,2,0,0,0,1,2,0,1,0,2,0,2,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,2,2,2,2,2,0,0,2,1,2,2,0,0,0,1,2,1,1,0,0,1,1,2,2,1,0,0,1,2,2,2,2,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	1,1,3,1,3,1,1,1,3,1,2,2,1,1,1,3,1,2,2,1,1,1,2,1,3,2,1,1,2,2,1,3,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,1,1,3,1,1,3,2,1,1,3,1,2,2,2,1,1,3,1,2,2,1,1,1,2,2,1,3,1,1,1,3,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,1,1,2,2,2,3,1,1,1,2,2,2,2,1,1,1,2,2,2,2,1,1,1,2,3,2,3,1,1,1,3,1,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,3,1,3,1,1,1,2,2,1,2,1,1,1,2,1,2,2,1,1,1,2,2,2,2,1,1,2,2,1,2,2,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,3,2,1,3,1,1,1,4,1,2,2,1,1,1,2,1,2,2,1,1,1,2,2,2,1,1,1,1,2,1,3,1,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,1,1,2,2,1,2,2,1,1,2,2,1,2,1,1,1,2,2,1,2,1,1,1,2,2,1,4,1,1,1,3,3,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,1,1,2,2,2,2,1,1,1,2,2,2,4,2,1,1,2,2,2,4,1,1,1,2,2,1,4,1,1,1,2,2,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,2,1,2,2,1,1,1,4,1,1,2,1,1,2,2,1,2,2,1,1,2,4,1,2,2,1,1,2,2,1,2,2,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,4,2,2,2,1,1,1,2,2,4,2,1,1,1,4,0,2,2,1,1,1,2,2,4,2,1,1,1,2,2,2,2,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,1,1,1,2,2,1,2,2,1,0,2,2,1,2,2,0,0,2,2,1,4,1,1,0,2,2,1,2,1,1,1,2,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,1,1,1,4,2,4,1,1,0,2,2,2,4,2,0,0,2,2,2,4,1,1,0,2,2,2,4,1,1,1,2,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,2,1,2,2,1,1,1,2,1,0,2,1,0,2,2,0,2,2,1,0,2,2,2,2,2,1,1,2,2,2,2,1,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,2,2,2,2,1,1,1,4,2,2,4,1,0,1,4,0,2,2,1,0,2,4,2,2,2,1,1,2,2,1,2,2,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,1,1,2,2,1,2,2,0,0,2,2,0,4,2,0,0,2,2,2,4,1,0,0,2,1,0,4,1,1,1,2,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,1,1,1,2,4,2,4,2,0,0,2,4,2,4,2,0,0,2,4,2,4,2,0,0,4,2,0,4,1,1,1,2,1,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,2,2,1,2,0,0,1,4,0,2,4,0,0,1,2,0,2,4,0,0,2,4,0,4,2,0,0,2,2,1,2,2,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,2,2,2,2,0,0,1,2,2,2,4,0,0,1,4,2,2,4,0,0,1,4,2,4,4,0,0,2,2,2,2,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,1,0,2,2,0,4,2,0,0,2,2,0,4,1,0,0,2,2,0,4,2,0,0,2,0,2,4,1,1,0,2,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,1,0,2,2,2,4,2,0,0,2,2,2,4,2,0,0,4,2,2,4,1,0,0,4,2,0,4,1,1,0,4,2,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,2,1,2,2,0,0,1,4,2,0,4,0,0,1,4,0,2,2,0,0,2,4,0,2,2,0,0,2,2,1,2,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,4,2,0,4,0,0,1,2,2,2,2,0,0,1,4,1,2,2,0,0,1,4,2,2,2,0,0,2,4,2,2,2,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,1,1,0,2,4,0,4,2,0,0,2,4,2,4,1,1,1,2,4,0,4,1,0,0,2,2,0,4,1,0,0,2,2,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,1,0,2,2,2,2,2,0,0,2,2,2,4,2,1,1,2,2,2,4,2,0,0,2,1,2,2,1,0,0,2,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,2,2,2,2,1,1,1,4,2,0,2,1,1,1,4,1,2,2,1,1,1,4,0,2,2,1,1,2,2,0,2,2,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,4,2,0,4,1,1,1,4,0,2,2,1,1,1,2,2,4,2,1,1,1,4,2,2,2,1,1,1,4,2,2,2,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,0,0,2,2,1,2,2,0,0,2,2,2,4,1,1,0,2,2,2,4,1,0,0,2,2,1,4,1,0,0,2,2,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,0,0,2,4,0,4,2,0,0,2,4,0,4,1,1,0,2,4,2,4,1,0,0,4,2,2,4,1,0,0,2,1,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,2,2,0,4,0,0,1,4,2,2,2,0,0,2,2,2,0,2,0,0,2,4,2,2,2,0,0,2,4,2,2,2,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,2,2,2,2,0,0,1,4,2,2,4,0,0,2,4,0,2,2,0,0,2,4,0,2,2,0,0,2,2,0,2,2,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,1,0,2,2,2,4,2,0,0,2,2,0,4,1,0,0,2,2,2,4,2,0,0,2,2,2,4,1,0,0,2,2,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,1,0,2,2,0,4,2,0,0,2,2,0,4,2,0,0,2,2,0,2,1,0,0,4,0,0,4,1,0,0,2,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,2,2,0,2,0,0,1,2,2,2,2,0,0,1,4,0,2,2,0,0,2,4,2,4,2,0,0,2,2,2,2,2,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,2,2,1,4,0,0,1,2,2,2,2,0,0,2,4,2,0,4,0,0,2,2,2,4,2,0,0,2,2,1,2,2,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,1,1,2,4,2,4,1,1,0,2,4,2,4,1,0,0,2,4,0,4,1,1,0,2,2,2,4,1,1,1,2,2,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,1,1,2,2,0,4,2,1,0,2,2,2,4,2,0,0,2,2,2,4,1,1,0,4,2,2,2,1,1,1,2,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,2,2,2,4,1,0,1,2,1,2,2,1,1,1,4,0,2,2,1,1,1,4,2,2,2,1,0,2,2,2,4,2,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,2,2,1,2,1,0,1,2,0,2,2,1,1,1,2,0,2,2,1,1,2,2,0,2,2,1,0,2,2,1,2,1,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,1,1,2,2,2,4,2,0,0,2,2,2,4,2,0,0,2,2,2,4,1,0,0,2,2,0,4,1,1,1,2,2,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,1,1,2,2,1,2,2,0,0,2,2,0,2,2,0,0,2,2,0,4,2,0,0,2,2,1,4,1,1,1,4,2,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,2,2,2,4,1,1,1,4,2,2,2,1,0,1,4,0,2,2,1,0,1,4,2,4,2,1,1,1,2,2,2,2,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,2,1,2,2,1,1,1,2,2,1,2,1,0,2,4,1,2,2,1,0,2,2,1,2,2,1,1,1,2,1,2,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,1,1,2,2,2,2,1,1,1,2,2,2,4,1,1,1,2,4,0,4,1,1,1,2,2,2,4,1,1,1,2,3,2,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,1,1,1,1,3,1,2,2,1,1,2,2,1,2,1,1,1,2,1,1,4,1,1,1,2,2,1,2,1,1,1,3,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,3,2,2,2,1,1,1,2,2,2,2,1,1,1,4,2,2,2,1,1,1,2,2,2,2,1,1,1,4,2,3,2,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,3,3,1,5,1,1,1,3,1,2,2,1,1,1,2,1,1,2,1,1,1,4,1,2,2,1,1,1,3,1,3,2,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,1,1,2,2,2,2,1,1,1,2,2,2,4,1,1,1,2,2,2,2,1,1,1,2,2,2,2,1,1,1,2,3,3,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,1,1,1,3,1,3,2,1,1,2,2,1,2,2,1,1,2,2,1,2,1,1,1,2,2,1,3,1,1,1,3,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,3,3,3,5,1,1,1,2,3,2,3,1,1,1,3,2,2,3,1,1,1,4,3,3,2,1,1,2,5,3,3,3,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,2,0,0,2,0,0,0,2,0,1,1,0,0,0,2,0,1,1,0,0,0,3,1,1,1,0,0,0,1,0,2,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,2,0,0,2,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,2,0,2,0,0,0,2,2,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,0,0,3,1,1,0,0,0,1,3,1,3,0,0,0,1,1,1,3,0,0,0,1,1,0,1,0,0,0,1,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,2,2,0,2,0,0,0,2,0,1,1,0,0,0,1,0,1,1,0,0,0,2,0,1,1,0,0,1,2,0,1,0,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,2,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,0,0,3,0,0,0,1,1,0,1,0,0,0,4,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,0,0,1,1,1,0,0,0,0,1,1,3,1,0,0,1,1,1,3,0,0,0,1,1,1,3,0,0,0,3,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,2,0,1,2,0,0,0,3,0,1,1,0,0,0,1,0,1,1,0,0,0,1,0,0,1,0,0,1,1,0,1,1,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,3,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,0,0,1,0,0,0,1,0,0,1,0,0,0,2,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,0,0,3,1,1,1,0,0,1,1,1,3,1,0,0,1,1,1,3,0,0,0,1,1,1,3,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,0,1,3,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,1,1,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,3,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,3,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,0,1,0,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,1,1,0,3,0,0,0,1,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,0,1,1,3,1,0,0,1,1,0,3,0,0,0,1,1,1,1,0,0,0,1,1,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,3,0,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,3,1,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,0,1,3,0,0,0,1,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,1,1,0,3,0,0,0,1,1,1,3,0,0,0,1,1,1,3,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,3,0,1,1,0,0,0,3,0,1,1,0,0,0,3,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,3,1,1,1,0,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,1,0,3,0,0,0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,1,1,1,0,0,1,1,1,3,1,0,0,1,1,1,3,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,3,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,3,0,1,1,0,0,1,1,1,1,0,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,3,0,1,1,0,0,0,3,1,1,1,0,0,0,1,1,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,0,3,0,0,0,1,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,3,0,1,1,0,0,0,3,0,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,3,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,0,1,0,3,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,1,0,3,0,0,0,1,1,0,3,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,3,0,1,1,0,0,0,3,1,1,1,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,1,3,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,0,1,1,3,0,0,0,1,1,0,3,0,0,0,1,1,1,3,0,0,0,1,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,1,0,3,0,0,0,1,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,3,0,0,0,1,1,1,1,0,0,0,3,0,1,1,0,0,0,3,1,1,1,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,3,0,0,0,1,1,0,1,0,0,0,3,1,1,1,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,3,0,0,0,1,1,1,1,0,0,0,1,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,0,1,1,1,1,0,0,0,1,1,0,1,1,0,0,1,0,0,3,0,0,0,1,0,0,3,0,0,0,1,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,2,0,0,0,1,1,0,1,0,0,0,3,0,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,1,0,0,0,1,1,1,0,0,0,1,1,1,3,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,0,1,1,0,0,0,1,1,0,1,0,0,0,2,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,2,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,2,1,0,1,0,0,0,3,1,0,1,0,0,0,3,1,0,1,0,0,0,1,0,1,1,0,0,0,2,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,0,0,0,3,1,1,0,0,0,1,1,1,3,0,0,0,1,1,1,1,0,0,0,1,1,1,2,0,0,0,1,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,0,0,2,0,2,0,0,0,1,1,0,1,0,0,0,1,1,1,3,0,0,0,1,0,0,1,0,0,0,2,1,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,2,2,2,2,0,0,0,2,1,1,2,0,0,0,2,1,1,1,0,0,0,3,1,2,1,0,0,1,4,2,2,0,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,1,1,0,2,0,0,0,2,1,1,2,0,0,0,2,0,1,1,0,0,0,1,1,1,1,0,0,1,1,0,2,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,2,1,0,0,1,1,0,2,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,1,0,0,0,2,1,2,0,0,0,1,2,1,2,0,0,0,1,1,1,2,0,0,0,1,1,1,1,0,0,0,2,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,2,0,0,0,2,0,0,2,0,0,0,2,0,1,1,0,0,0,1,1,1,1,0,0,1,1,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,2,1,1,2,0,0,0,2,1,1,1,0,0,0,2,1,1,1,0,0,0,1,1,1,1,0,0,0,2,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,0,2,0,0,0,1,0,1,2,0,0,0,1,0,1,1,0,0,0,2,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,2,0,2,1,0,0,1,1,1,2,0,0,0,1,1,1,1,0,0,0,1,1,0,2,0,0,0,2,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,2,0,0,0,2,0,0,2,0,0,0,2,0,1,1,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,2,0,0,0,2,1,1,1,0,0,0,2,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,2,0,0,0,1,0,1,1,0,0,0,1,0,1,2,0,0,0,1,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,1,1,0,0,0,1,1,1,2,0,0,0,1,1,1,1,0,0,0,1,1,0,2,0,0,0,2,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,2,0,1,1,0,0,0,2,0,1,1,0,0,0,1,1,1,1,0,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,2,1,1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,0,2,0,0,0,1,0,1,1,0,0,0,1,1,0,1,0,0,0,1,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,2,1,0,0,1,1,1,2,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,2,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,2,0,1,1,0,0,0,2,0,1,1,0,0,0,1,0,1,1,0,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,2,1,1,1,0,0,0,2,1,1,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,0,2,0,0,0,1,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,0,2,0,0,0,2,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,2,0,1,1,0,0,0,2,1,1,1,0,0,0,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,2,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,1,1,1,2,0,0,0,1,1,0,2,0,0,0,1,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,2,0,1,1,0,0,0,1,1,1,1,0,0,1,2,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,2,1,1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,1,0,2,0,0,0,1,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,2,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,2,0,1,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,2,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,0,1,0,1,0,0,0,1,1,1,2,0,0,0,1,1,1,2,0,0,0,1,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,2,1,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,2,0,1,1,0,0,0,2,1,1,1,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,2,0,1,1,0,0,0,2,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,0,1,1,1,1,0,0,1,1,1,2,0,0,0,1,1,1,2,0,0,0,1,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,2,0,0,0,1,1,0,2,0,0,0,2,1,0,2,0,0,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,2,1,1,1,0,0,0,2,1,1,1,0,0,0,2,0,2,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,2,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,2,0,1,1,0,0,0,2,0,1,0,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,1,1,1,0,0,1,1,1,2,0,0,0,1,1,1,2,0,0,0,1,1,1,2,0,0,0,1,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,1,1,0,1,1,0,0,1,1,0,2,0,0,0,1,0,1,2,0,0,0,1,1,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,2,1,1,1,0,0,0,2,1,1,1,0,0,0,2,1,2,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,2,0,1,1,0,0,0,1,0,1,1,0,0,0,2,1,1,1,0,0,0,2,0,2,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,0,2,0,0,0,1,1,1,2,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,2,1,0,2,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,2,1,1,1,0,0,0,1,1,2,1,0,0,0,2,1,2,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,2,0,1,1,0,0,0,2,0,1,1,0,0,0,1,1,1,1,0,0,0,2,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,1,0,0,0,2,1,1,0,0,0,1,1,1,2,0,0,0,1,1,1,1,0,0,0,2,2,1,2,0,0,0,2,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,0,1,2,0,1,0,0,0,1,1,0,1,0,0,0,1,1,1,2,0,0,0,1,1,0,2,0,0,0,1,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,2,2,1,1,0,0,0,2,1,1,2,0,0,0,2,1,1,1,0,0,0,1,1,2,1,0,0,0,2,2,2,1,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,1,1,1,1,0,0,0,2,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,0,0,1,0,0,0,1,1,0,1,0,0,0,2,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,2,0,0,0,1,1,1,1,0,0,0,1,1,1,2,0,0,0,1,1,1,1,0,0,0,2,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,2,0,1,1,0,0,0,1,1,1,1,0,0,1,1,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,2,1,1,1,0,0,0,1,1,1,1,0,0,0,2,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,0,2,0,0,0,1,0,0,1,0,0,0,1,1,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,2,1,1,0,0,0,1,1,1,2,0,0,0,1,1,1,2,0,0,0,1,1,1,2,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,2,0,1,1,0,0,0,2,0,1,1,0,0,0,2,0,1,1,0,0,1,1,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,2,1,1,1,0,0,0,1,1,1,1,0,0,0,2,1,1,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,1,0,0,1,0,0,1,0,0,0,1,1,0,2,0,0,0,1,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,2,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,2,0,0,0,1,1,1,2,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,1,0,2,0,0,0,2,0,1,1,0,0,0,2,0,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,2,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,1,0,2,0,0,0,1,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,2,0,0,0,0,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,2,0,0,0,2,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,2,0,1,1,0,0,0,2,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,2,1,1,1,0,0,0,2,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,0,2,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,2,0,0,0,1,1,1,1,0,0,0,1,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,2,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,2,0,1,1,0,0,1,1,0,2,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,2,0,0,0,1,1,1,1,0,0,0,2,1,1,1,0,0,1,1,1,1,1,0,0,0,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,1,0,1,0,0,0,1,1,0,2,0,0,0,1,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,2,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,2,0,0,0,1,0,1,1,0,0,0,2,0,1,1,0,0,0,1,1,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,2,0,1,1,0,0,0,2,1,1,1,0,0,0,2,1,1,1,0,0,0,2,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,1,1,2,0,0,0,2,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,0,1,2,0,0,0,1,1,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,2,1,0,1,0,0,0,2,0,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,2,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,0,1,0,2,0,0,0,1,1,1,1,0,0,0,1,1,1,2,0,0,0,1,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,2,0,0,0,1,1,1,1,0,0,0,1,1,0,2,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,2,1,1,1,0,0,0,2,1,1,1,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,2,0,0,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,0,1,1,1,1,1,0,0,1,1,1,2,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,0,1,0,0,0,1,1,0,1,1,0,0,1,1,0,2,0,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,2,1,1,2,0,0,0,1,1,1,1,0,0,0,2,1,1,1,0,0,0,2,1,1,1,0,0,0,2,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,2,0,1,1,0,0,0,1,0,1,1,0,0,1,1,0,1,0,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,2,0,0,0,1,1,1,2,0,0,0,1,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,1,0,2,0,0,0,1,0,0,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,2,1,1,1,0,0,0,2,1,1,1,0,0,0,1,1,2,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,2,0,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,2,1,1,0,0,0,1,1,1,2,0,0,0,1,1,1,1,0,0,0,1,1,1,2,0,0,0,1,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,0,0,2,0,0,0,1,1,0,2,0,0,0,1,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,2,1,1,1,0,0,0,2,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,1,0,1,0,0,0,2,0,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,2,0,0,0,1,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,1,0,2,0,0,0,1,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,2,1,1,1,0,0,1,2,1,2,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,3,1,1,4,0,0,0,4,1,1,1,0,0,0,4,1,1,1,0,0,0,4,1,1,1,0,0,1,4,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,0,0,1,0,0,0,1,1,0,1,0,0,0,4,0,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,0,0,1,4,1,4,0,0,0,1,1,1,4,0,0,0,1,1,1,4,0,0,0,1,1,1,4,0,0,0,4,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,1,0,1,0,0,0,1,0,1,1,0,0,0,2,0,1,1,0,0,0,1,1,1,1,0,0,1,1,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,4,1,1,4,0,0,0,1,1,1,1,0,0,0,2,1,1,1,0,0,0,1,1,1,1,0,0,0,2,1,4,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,0,2,0,0,0,1,0,0,1,0,0,0,1,1,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,0,0,0,2,1,1,0,0,0,1,1,1,2,0,0,0,1,1,1,2,0,0,0,1,1,1,2,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,2,0,1,1,0,0,0,2,0,1,1,0,0,0,2,0,1,1,0,0,1,1,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,2,1,1,1,0,0,0,1,1,1,1,0,0,0,2,1,1,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,1,0,0,1,0,0,1,0,0,0,1,1,0,2,0,0,0,1,0,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,2,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,2,0,0,0,1,1,1,2,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,1,0,2,0,0,0,2,0,1,1,0,0,0,2,0,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,2,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,1,0,2,0,0,0,1,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,2,0,0,0,0,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,2,0,0,0,2,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,2,0,1,1,0,0,0,2,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,4,1,1,1,0,0,0,2,1,1,1,0,0,0,2,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,1,0,0,1,1,0,4,0,0,0,1,1,0,2,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,1,1,1,0,0,1,1,1,4,0,0,0,1,1,1,4,0,0,0,1,1,1,1,0,0,0,1,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,2,0,0,0,1,0,1,1,0,0,0,4,0,1,1,0,0,0,4,0,1,1,0,0,1,1,0,2,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,2,0,0,0,1,1,1,1,0,0,0,3,1,1,1,0,0,1,4,1,1,1,0,0,0,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,1,4,0,0,0,3,1,0,4,0,0,0,1,1,0,2,0,0,0,1,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,1,1,1,0,0,1,1,1,4,1,0,0,5,1,1,6,0,0,0,1,1,1,2,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,2,0,0,0,1,0,1,1,0,0,0,4,0,1,1,0,0,0,4,1,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,2,0,1,1,0,0,0,5,6,1,6,0,0,0,4,1,1,1,0,0,0,2,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,4,0,0,0,1,5,1,4,0,0,0,1,1,1,2,0,0,0,2,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,1,1,1,0,0,1,1,1,4,0,0,0,1,0,1,2,0,0,0,1,1,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,2,1,0,1,0,0,0,4,0,1,1,0,0,0,4,1,1,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,4,1,1,1,0,0,0,4,1,1,1,0,0,0,1,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,0,1,0,4,0,0,0,1,1,1,4,0,0,0,1,1,1,2,0,0,0,1,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,2,0,0,0,1,1,1,1,0,0,0,1,1,0,2,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,4,1,1,1,0,0,0,2,1,1,1,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,2,0,0,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,0,1,1,1,1,1,0,0,1,1,1,2,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,0,1,0,0,0,1,1,0,1,1,0,0,1,1,0,2,0,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,2,1,1,2,0,0,0,1,1,1,1,0,0,0,2,1,1,1,0,0,0,2,1,1,1,0,0,0,2,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,2,0,1,1,0,0,0,1,0,1,1,0,0,1,1,0,1,0,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,2,0,0,0,1,1,1,2,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,1,0,2,0,0,0,1,0,0,1,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,2,1,1,1,0,0,0,2,1,1,1,0,0,0,1,1,2,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,2,0,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,0,0,0,2,1,1,0,0,0,1,1,1,2,0,0,0,1,1,1,1,0,0,0,1,1,1,2,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,0,0,2,0,0,0,1,1,0,2,0,0,0,1,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,4,1,1,4,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,2,1,1,1,0,0,0,2,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,4,1,0,4,0,0,0,1,1,1,1,0,0,0,1,1,0,1,0,0,0,2,0,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,0,0,1,4,1,4,0,0,0,1,1,1,1,0,0,0,1,1,1,4,0,0,0,1,1,1,4,0,0,0,4,4,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,1,0,2,0,0,0,4,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,4,1,1,4,0,0,0,4,1,1,1,0,0,0,4,1,1,1,0,0,0,4,1,1,1,0,0,1,4,1,4,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,3,1,1,1,0,0,0,3,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,3,1,3,0,0,0,1,1,1,3,1,0,0,1,1,1,3,0,0,0,1,1,1,1,0,0,0,3,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,0,0,1,0,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,1,0,0,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,1,0,3,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,0,3,0,0,0,1,1,1,1,0,0,0,1,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,1,1,1,3,1,0,0,1,1,1,3,0,0,0,1,1,0,3,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,0,0,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,3,1,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,0,1,1,0,1,1,0,0,1,1,0,3,0,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,1,1,1,3,0,0,0,1,1,1,3,0,0,0,1,1,0,3,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,1,0,1,0,0,0,3,0,1,1,0,0,0,1,1,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,3,0,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,1,0,3,0,0,0,1,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,3,1,1,0,0,0,0,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,0,3,0,0,0,3,1,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,3,0,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,3,1,1,1,0,0,0,3,1,1,1,0,0,0,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,0,1,3,0,0,0,1,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,3,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,3,0,0,0,1,0,1,1,0,0,0,1,0,2,2,0,0,0,2,1,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,3,0,0,0,1,1,1,1,0,0,0,2,2,1,2,0,0,1,1,1,1,1,0,0,0,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,1,3,0,0,0,1,1,0,2,0,0,0,1,1,0,1,0,0,0,1,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,1,2,1,3,2,0,0,2,1,2,2,0,0,0,1,1,0,3,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,3,0,2,2,0,0,0,3,0,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,3,0,1,1,0,0,0,2,2,2,2,0,0,0,1,1,1,2,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,2,0,0,0,2,2,1,2,0,0,0,1,1,0,3,0,0,0,1,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,1,2,1,0,0,2,1,2,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,2,0,1,1,0,0,0,3,0,1,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,3,2,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,0,1,0,1,1,0,0,1,2,1,1,0,0,0,1,1,1,3,0,0,0,1,1,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,1,0,3,0,0,0,1,0,0,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,3,2,1,1,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,1,1,0,1,0,0,1,1,0,1,1,0,0,0,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,0,1,1,3,1,0,0,1,1,0,3,0,0,0,1,1,1,3,0,0,0,1,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,3,0,0,0,1,1,1,1,0,0,0,1,0,1,3,0,0,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,3,0,1,1,0,0,0,3,1,1,1,0,0,0,3,1,1,1,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,3,0,0,0,1,1,0,3,0,0,0,1,1,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,0,0,3,0,0,0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,3,0,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,3,0,0,0,3,1,0,1,0,0,0,1,1,1,1,0,0,0,3,1,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,1,1,0,3,0,0,0,1,1,0,3,0,0,0,1,1,0,3,0,0,0,1,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,0,3,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,3,0,1,1,0,0,0,1,1,1,1,0,0,0,3,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,1,0,0,1,0,0,0,3,1,1,1,0,0,0,1,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,3,1,3,0,0,0,1,1,1,3,0,0,0,1,1,1,1,0,0,0,1,1,1,3,0,0,0,1,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,3,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,3,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,3,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,0,0,1,0,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,3,0,0,0,1,1,1,1,0,0,0,3,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,3,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,0,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,0,3,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,3,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,0,1,1,0,0,0,1,0,0,3,0,0,0,3,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,1,0,1,0,0,0,3,0,1,1,0,0,0,1,1,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,3,0,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,0,1,1,0,0,0,1,1,0,1,0,0,0,1,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,3,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,3,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,3,0,1,1,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,3,1,1,1,0,0,1,1,1,1,1,0,0,0,1,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,0,2,0,0,0,1,1,0,3,0,0,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,2,1,2,3,0,0,0,1,1,1,1,0,0,0,1,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,2,1,0,0,0,2,0,2,1,0,0,0,3,0,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,1,1,1,0,0,1,2,2,1,2,0,0,1,1,1,1,1,0,0,0,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,2,0,3,0,0,0,1,1,0,2,0,0,0,1,2,0,1,0,0,0,1,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,1,1,2,2,1,0,0,2,2,1,2,0,0,0,1,1,0,3,0,0,0,1,1,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,0,2,2,0,0,0,1,2,1,1,0,0,1,3,0,1,0,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,3,1,1,1,0,0,0,2,2,2,2,2,0,2,1,0,1,2,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,0,1,0,2,1,0,0,0,2,1,1,0,0,0,1,1,1,3,0,0,0,1,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,2,2,1,0,0,2,2,1,2,0,0,0,1,0,1,1,0,0,0,1,1,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,0,2,1,0,0,0,2,0,2,1,0,0,1,2,0,1,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,3,1,2,2,0,0,0,2,1,1,1,0,0,0,1,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,0,1,0,1,0,0,0,1,2,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,0,3,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,2,0,1,1,0,0,0,3,1,1,1,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,3,0,0,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,1,1,1,3,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,1,0,0,1,1,0,3,0,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,3,1,1,1,0,0,0,3,1,1,1,0,0,0,3,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,3,0,0,0,1,0,1,1,0,0,0,3,0,1,1,0,0,0,1,0,1,1,0,0,0,3,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,3,0,0,0,1,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,0,0,3,0,0,0,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,3,0,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,3,1,1,0,0,0,1,1,1,3,0,0,0,1,1,0,3,0,0,0,1,1,0,1,0,0,0,1,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,1,0,1,0,0,0,1,1,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,3,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,3,0,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,1,1,1,3,0,0,0,1,1,1,1,0,0,0,1,1,1,3,0,0,0,1,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,1,3,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,4,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,0,0,1,0,0,0,1,1,0,1,0,0,0,1,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,0,0,1,1,1,4,0,0,0,1,1,1,1,0,0,0,1,1,1,4,0,0,0,1,1,1,1,0,0,0,4,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,0,1,0,0,1,1,0,1,1,0,0,0,1,1,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,4,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,0,1,1,0,0,1,1,0,1,0,0,0,1,0,0,1,1,0,0,1,0,0,1,0,0,0,1,0,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,0,1,1,4,1,0,0,1,1,1,1,0,0,0,1,1,1,4,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,4,0,1,1,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,4,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,1,0,0,1,0,1,1,0,0,0,1,0,0,4,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,4,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,1,0,1,0,0,0,4,0,1,1,0,0,0,1,1,1,1,0,0,1,1,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,4,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,1,0,0,1,1,1,4,0,0,0,1,1,0,4,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,4,1,4,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,4,0,2,1,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,4,1,1,1,0,0,0,4,3,1,1,0,0,1,3,1,1,1,0,0,0,4,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,0,4,0,0,0,2,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,1,1,2,1,2,0,0,3,1,1,1,0,0,0,1,1,0,4,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,4,0,2,1,0,0,0,4,0,2,3,0,0,2,4,0,1,1,0,0,0,4,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,4,1,2,1,0,0,1,3,1,3,3,0,0,2,1,1,1,1,0,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,0,3,0,0,0,2,1,2,3,0,0,0,1,1,2,1,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,1,3,3,3,2,0,2,2,2,3,3,2,0,0,1,1,0,1,0,0,0,1,1,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,4,0,2,1,0,0,0,1,0,2,2,0,0,0,3,0,2,1,0,0,1,4,1,1,0,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,4,0,0,0,4,1,2,1,0,0,2,2,2,2,2,2,0,2,1,2,1,1,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,0,1,1,0,0,1,1,0,4,2,0,0,2,2,1,3,0,0,0,1,1,0,4,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,1,3,2,3,1,0,0,3,2,2,3,2,0,0,1,1,1,1,0,0,0,1,1,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,4,1,2,1,0,0,0,3,2,1,2,0,0,0,1,1,1,2,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,1,1,3,0,0,0,3,2,1,3,0,0,1,1,2,1,1,0,0,0,1,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,0,1,0,3,0,0,0,0,3,0,3,0,0,0,3,1,1,1,0,0,0,1,0,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,2,1,1,0,0,1,1,1,3,0,0,0,1,1,0,4,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,4,0,1,3,0,0,0,4,1,1,1,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,1,1,2,1,0,0,1,1,0,1,1,0,0,0,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,1,1,1,4,0,0,0,1,1,0,4,0,0,0,1,1,1,4,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,4,0,1,1,0,0,0,1,1,1,1,0,0,1,4,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,4,0,0,0,1,1,0,1,0,0,0,4,1,1,1,0,0,0,1,1,1,1,0,0,1,1,0,1,0,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,4,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,1,1,0,1,1,0,0,1,0,1,1,0,0,0,1,0,0,4,0,0,0,1,1,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,4,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,4,1,1,0,0,0,1,1,1,4,0,0,0,1,1,0,4,0,0,0,1,1,0,1,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,1,0,1,0,0,0,1,1,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,4,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,4,1,0,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,0,0,1,1,1,1,0,0,0,1,1,1,4,0,0,0,1,1,1,1,0,0,0,1,1,1,4,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,1,0,1,0,0,0,1,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,1,4,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,4,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,0,0,1,1,0,0,1,1,0,1,0,0,0,1,0,0,1,0,0,0,1,0,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,1,1,0,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,1,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,0,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,4,1,1,0,0,0,0,1,1,4,0,0,0,1,1,1,4,0,0,0,1,1,0,4,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,4,0,1,1,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,0,4,0,0,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,1,4,0,0,0,1,1,1,1,0,0,0,1,1,0,4,0,0,0,1,0,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,1,0,1,0,0,0,4,1,0,1,0,0,0,1,1,1,1,0,0,1,1,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,1,1,1,0,0,1,1,1,4,1,0,0,1,1,1,3,0,0,0,1,1,0,1,0,0,0,4,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,1,0,0,0,1,0,0,3,0,0,0,1,0,1,3,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,1,3,1,1,1,0,0,0,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,3,1,0,3,0,0,0,3,1,0,3,0,0,0,1,1,0,1,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,1,1,1,0,0,1,1,2,3,3,0,0,3,3,3,3,0,0,0,3,0,1,4,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,1,3,0,0,0,1,0,2,3,0,0,0,3,0,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,4,0,0,0,1,1,3,1,0,0,3,3,3,3,3,0,0,3,3,1,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,0,1,1,0,1,0,0,0,1,1,0,3,2,0,0,2,3,0,3,0,0,0,1,3,0,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,1,1,1,0,0,1,3,3,3,3,0,2,2,2,3,3,2,0,0,3,3,1,4,0,0,0,1,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,2,0,3,0,0,0,3,0,2,2,0,0,0,3,1,3,0,0,0,0,4,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,3,1,3,0,0,2,0,2,2,2,2,0,3,1,2,1,1,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,0,1,0,3,2,0,0,2,2,2,3,0,0,0,3,1,0,4,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,1,1,0,0,0,1,3,3,3,3,0,0,3,2,3,3,2,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,1,3,0,0,0,3,0,3,3,0,0,0,3,3,1,3,0,0,0,4,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,4,3,3,1,0,0,1,3,3,3,3,3,0,0,1,0,1,3,0,0,0,1,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,0,1,0,0,0,1,3,0,3,0,0,0,0,3,2,4,0,0,0,1,1,1,3,0,0,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,1,1,0,3,3,0,0,1,2,1,3,0,0,0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,1,0,1,0,0,0,1,0,3,1,0,0,0,4,3,1,1,0,0,0,4,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,1,0,3,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,0,1,1,1,1,1,0,0,0,1,1,4,0,0,0,1,3,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,3,0,1,1,0,0,1,1,0,1,0,0,0,1,1,0,4,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,4,0,1,1,0,0,0,4,0,1,1,0,0,0,4,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,1,1,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,1,1,4,0,0,0,1,1,0,1,0,0,0,1,0,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,4,0,1,1,0,0,0,4,0,1,1,0,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,1,0,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,0,4,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,0,1,0,0,0,1,1,0,1,0,0,0,1,0,0,1,0,0,0,1,0,0,1,0,0,0,1,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,4,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,4,0,0,0,1,1,0,1,0,0,0,4,0,0,1,0,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,1,1,1,4,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,0,1,1,0,0,1,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,4,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,0,0,1,1,0,0,1,0,0,1,0,0,0,1,0,0,1,0,0,0,1,0,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,1,1,0,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,1,0,0,0,1,1,0,1,0,0,0,1,0,0,1,0,0,0,1,1,0,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,4,1,1,0,0,0,0,1,1,4,0,0,0,1,1,1,4,0,0,0,1,1,0,4,0,0,0,4,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,4,0,1,1,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,0,4,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,3,1,1,1,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,0,1,0,1,0,0,0,1,1,0,1,0,0,0,1,0,0,1,0,0,0,1,0,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,3,1,1,4,1,0,0,1,3,1,4,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,1,0,0,0,1,0,1,1,0,0,0,3,0,1,3,0,0,0,4,0,1,0,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,3,1,0,0,1,3,1,3,1,0,0,3,1,1,1,1,0,0,0,1,0,1,0,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,0,3,0,0,0,3,0,0,3,0,0,0,1,1,0,4,0,0,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,1,1,1,0,0,3,3,2,3,1,0,0,2,3,3,3,2,0,0,3,1,0,4,0,0,0,4,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,4,0,0,1,0,0,0,3,0,3,3,0,0,0,3,0,1,2,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,4,0,0,0,1,1,3,3,0,0,3,2,3,3,3,1,0,3,3,1,1,3,0,0,0,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,0,1,1,0,1,0,0,0,1,3,0,3,0,0,2,0,2,0,3,0,0,0,3,1,0,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,3,0,0,3,3,3,3,3,0,2,0,2,3,3,2,0,0,3,1,0,4,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,4,0,0,3,0,0,0,2,2,2,2,2,0,0,3,2,1,3,0,0,3,4,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,4,3,1,3,0,0,3,2,2,2,2,2,0,3,2,3,3,3,0,0,3,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,3,0,0,0,3,0,3,0,0,0,0,2,2,3,0,0,0,0,1,0,4,0,0,0,1,0,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,1,1,1,0,0,1,2,3,3,3,0,2,2,3,3,3,3,0,0,3,1,1,4,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,1,3,0,0,0,3,0,3,2,0,0,0,3,0,1,2,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,3,1,1,3,0,0,1,3,3,3,3,3,0,1,1,3,1,3,0,0,0,4,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,0,1,0,0,0,1,3,0,3,0,0,0,0,2,0,3,0,0,0,1,1,0,1,0,0,0,1,1,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,1,1,3,3,0,0,0,3,3,3,3,0,0,0,3,1,0,4,0,0,0,1,1,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,1,0,3,0,0,0,3,2,1,1,0,0,0,3,1,1,1,0,0,0,4,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,2,1,4,0,0,0,3,1,2,3,0,0,1,1,0,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,0,1,1,1,1,1,0,0,0,1,1,4,0,0,0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,1,0,0,1,1,1,3,1,0,0,1,1,0,4,0,0,0,1,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,0,0,1,0,0,0,4,0,1,1,0,0,0,1,1,1,0,0,0,0,4,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,1,1,4,0,0,0,1,1,0,1,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,4,0,1,1,0,0,0,1,1,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,1,0,0,0,1,0,1,1,0,0,0,4,0,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,1,0,4,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,0,1,0,1,1,0,0,0,1,0,0,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,4,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,1,0,0,0,1,1,0,1,0,0,0,1,0,0,1,0,0,1,1,0,0,1,0,0,1,1,0,0,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,1,1,1,0,0,1,1,0,1,1,0,0,1,0,1,1,0,0,0,1,1,0,1,0,0,0,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,4,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,1,1,1,1,0,0,0,4,1,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,4,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,0,0,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,1,1,0,0,0,1,1,1,4,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,1,0,0,0,1,0,0,1,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,1,0,1,0,0,0,1,0,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,0,1,1,4,0,0,0,1,1,1,1,0,0,0,1,1,0,4,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,4,0,1,1,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,4,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,4,1,1,1,0,0,0,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,0,1,0,0,0,1,1,1,4,0,0,0,1,1,1,1,0,0,0,1,1,0,4,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,4,0,0,0,1,1,0,1,0,0,0,4,0,1,1,0,0,0,4,0,1,1,0,0,1,1,0,1,0,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,3,1,1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,3,0,0,3,0,0,0,1,1,0,4,0,0,0,1,0,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,4,1,1,1,0,0,3,1,3,4,1,0,0,3,3,3,1,0,0,0,1,1,0,4,0,0,0,4,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,1,0,0,0,1,0,0,1,0,0,0,3,0,2,1,0,0,0,4,0,3,0,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,3,1,3,0,0,3,3,3,3,3,0,0,3,3,1,1,1,0,0,2,1,0,1,0,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,0,3,0,0,0,0,2,0,3,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,3,2,3,3,3,0,2,2,1,3,3,2,0,0,3,1,0,4,0,0,0,4,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,3,3,0,0,0,2,0,2,2,0,0,2,3,0,3,2,0,0,0,4,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,3,3,3,3,0,0,2,0,2,2,2,2,0,2,2,3,3,3,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,0,1,1,0,3,0,0,0,0,2,2,2,2,0,2,0,0,0,2,0,0,0,3,1,0,3,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,3,0,3,2,2,2,2,0,2,2,2,2,0,0,3,1,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,2,2,3,0,0,0,2,0,2,2,0,0,2,0,2,3,2,0,0,2,4,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,4,0,0,0,1,3,3,3,2,0,2,0,2,2,2,2,0,2,2,3,3,3,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,3,1,0,0,2,2,0,3,0,2,0,0,0,2,3,0,0,0,2,3,0,3,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,3,1,1,0,0,3,2,2,3,2,2,0,2,2,2,2,2,0,0,3,1,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,3,0,1,3,0,0,0,0,0,2,2,0,0,0,2,0,3,2,0,0,2,4,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,3,3,3,0,0,3,2,2,2,2,2,0,3,2,3,1,3,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,0,3,0,3,0,0,0,0,2,1,3,0,0,0,1,3,1,1,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,1,1,1,0,0,1,3,3,3,3,0,0,3,2,3,3,2,0,0,3,1,0,4,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,4,0,0,0,1,1,0,3,0,0,0,3,2,3,1,0,0,0,3,1,1,0,0,0,0,4,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,3,1,0,0,0,1,3,3,3,0,0,1,1,3,1,3,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,0,1,1,0,4,1,0,0,0,3,1,3,0,0,0,1,3,0,3,0,0,0,1,1,1,4,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,3,0,0,3,0,1,1,0,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,4,0,1,1,0,0,0,4,0,1,0,0,0,0,4,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,4,0,1,1,0,0,0,1,1,0,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,4,0,0,0,1,1,0,1,0,0,0,1,0,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,0,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,4,0,1,1,0,0,0,1,1,1,1,0,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,1,0,0,0,1,0,1,1,0,0,0,4,0,1,1,0,0,1,1,0,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,1,0,4,0,0,0,1,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,4,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,4,0,0,0,1,1,0,1,0,0,1,1,0,0,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,0,4,0,0,0,1,1,0,1,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,0,0,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,1,4,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,1,1,1,4,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,4,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,0,0,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,1,1,0,0,0,1,1,1,4,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,1,0,0,0,1,0,0,1,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,0,1,0,1,0,0,0,1,1,1,1,0,0,0,1,1,0,1,0,0,0,1,0,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,4,1,1,0,0,0,1,1,1,4,0,0,0,1,1,1,1,0,0,0,1,1,0,4,0,0,0,4,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,4,0,1,1,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,4,1,1,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,1,4,0,0,0,1,1,1,1,0,0,0,1,1,0,4,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,1,0,1,0,0,0,4,0,1,1,0,0,0,4,0,1,1,0,0,1,1,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,3,1,1,3,0,0,3,3,0,1,1,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,0,3,0,0,0,3,0,0,4,0,0,0,1,0,0,1,0,0,0,1,0,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,3,3,1,4,3,0,0,3,3,1,3,1,0,0,3,1,1,1,0,0,0,4,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,1,0,0,0,1,0,0,1,0,0,0,3,0,1,3,0,0,0,3,0,1,0,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,3,3,1,3,0,0,3,2,3,3,3,0,0,3,3,3,1,3,0,0,1,1,0,1,0,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,0,3,0,0,2,0,3,0,3,0,0,0,3,1,0,3,0,0,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,1,3,1,0,0,3,2,3,3,3,0,2,0,2,3,3,3,0,0,3,1,0,1,0,0,0,4,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,4,0,0,0,1,0,3,3,0,0,2,0,0,2,2,0,0,0,2,0,3,2,0,0,0,4,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,3,3,3,3,2,0,2,0,2,2,2,2,2,2,0,3,3,3,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,3,0,0,0,0,3,0,2,2,0,2,0,0,0,2,2,0,0,2,3,1,3,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,3,3,0,2,3,0,2,2,2,2,2,0,0,2,2,2,0,2,1,1,3,3,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,0,3,2,0,0,0,0,0,2,2,2,0,2,0,0,3,2,0,0,0,4,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,3,3,3,3,2,0,2,0,0,2,2,2,0,2,0,2,3,3,2,0,1,3,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,3,1,0,0,2,2,0,2,0,2,2,0,0,2,2,0,0,0,2,3,1,3,0,0,0,1,0,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,1,3,1,0,0,3,0,2,2,2,0,2,0,2,2,2,2,0,0,1,1,2,3,1,0,0,4,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,3,0,3,3,2,0,0,0,0,2,2,0,0,2,0,0,3,2,0,0,0,4,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,3,3,3,3,0,3,2,2,2,2,2,0,3,2,3,3,3,0,0,3,1,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,0,3,0,0,0,0,3,0,3,0,2,0,0,0,2,3,0,0,0,3,3,0,1,0,0,0,1,1,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,4,1,1,1,0,0,1,2,3,3,3,0,0,3,2,3,3,3,0,0,3,1,0,3,1,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,3,1,0,3,0,0,0,2,0,3,3,0,0,0,2,3,1,1,0,0,0,4,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,3,0,0,1,1,3,3,3,0,0,1,2,1,1,3,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,0,1,1,1,1,0,0,0,0,3,0,3,0,0,0,0,3,0,3,0,0,0,1,1,1,1,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,0,1,1,0,0,1,1,3,1,3,0,0,1,3,1,3,3,0,0,1,1,0,1,1,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,4,0,1,1,0,0,0,3,0,1,1,0,0,0,4,0,1,0,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,4,1,2,1,0,0,0,1,1,1,1,0,0,1,1,0,1,0,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,1,1,0,4,0,0,0,1,1,1,4,0,0,0,1,1,0,1,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,0,1,1,0,1,0,0,0,0,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,4,1,1,1,0,0,0,4,0,1,1,0,0,0,1,1,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,1,0,0,0,1,0,1,1,0,0,0,4,0,1,1,0,0,1,1,0,1,1,0,0,0,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,0,4,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,0,0,1,0,0,0,1,0,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,4,0,0,0,1,1,0,1,0,0,0,1,0,0,1,0,0,0,1,1,0,1,0,0,1,1,0,0,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,1,0,0,1,1,0,4,0,0,0,1,1,1,1,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,4,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,4,0,1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,0,0,1,0,0,0,1,1,0,1,0,0,0,1,0,0,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,4,1,1,0,0,0,1,1,1,4,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,1,0,0,0,1,1,0,1,0,0,0,4,0,1,1,0,0,0,1,1,0,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,0,0,1,0,0,0,1,0,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,1,1,0,0,0,1,1,1,4,1,0,0,1,1,1,4,0,0,0,1,1,1,4,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,4,0,0,0,1,0,0,1,0,0,0,1,0,1,1,0,0,0,4,0,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,4,1,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,4,1,1,1,0,0,1,1,1,4,1,0,0,3,1,1,1,1,0,0,1,1,0,4,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,0,0,4,0,0,0,3,0,1,1,0,0,0,3,0,1,1,0,0,1,1,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,4,0,0,0,1,1,3,1,0,0,2,1,1,3,1,0,0,3,1,1,1,1,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,0,1,0,0,0,1,1,0,3,0,0,0,3,1,0,3,0,0,0,3,1,0,1,0,0,0,1,0,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,3,1,0,0,3,1,3,3,3,0,2,2,3,3,3,3,0,0,1,1,0,4,0,0,0,4,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,1,0,0,0,1,0,1,3,0,0,0,3,0,2,1,0,0,0,3,0,3,2,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,3,3,1,3,0,0,3,2,3,2,3,2,0,2,2,3,3,3,0,0,1,3,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,3,0,0,0,3,3,0,3,2,0,0,0,2,0,3,0,0,0,3,1,0,3,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,3,1,0,2,3,0,2,3,2,0,2,0,2,3,2,3,0,0,2,1,3,1,1,0,0,4,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,3,0,2,3,0,0,2,0,2,2,2,0,0,2,0,0,3,2,0,0,0,3,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,4,1,0,1,0,0,2,3,2,3,3,2,2,2,0,2,2,2,2,2,2,2,3,3,3,2,0,1,3,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,0,1,1,0,3,0,0,0,0,0,0,2,2,2,0,0,0,0,2,0,0,0,0,2,1,3,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,3,3,3,0,0,2,0,2,2,2,2,2,0,0,2,2,2,2,2,1,3,1,3,3,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,3,0,0,0,3,1,2,2,0,2,0,0,0,2,2,2,2,0,0,0,2,2,0,0,0,3,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,1,3,3,2,3,2,0,2,0,0,2,2,2,2,2,0,2,2,3,2,0,3,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,0,3,0,2,0,0,0,2,2,2,2,2,0,0,0,2,0,0,2,0,0,2,3,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,3,3,3,3,0,2,3,0,2,2,2,2,2,0,0,2,2,2,2,2,1,3,3,3,3,0,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,2,3,0,0,2,0,0,2,2,2,2,0,0,0,3,2,0,0,0,3,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,3,3,3,3,2,0,3,2,2,2,2,2,2,2,2,2,3,3,0,0,1,1,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,0,1,1,0,3,0,0,0,0,2,2,3,0,2,0,0,0,2,3,0,0,0,2,2,3,3,0,0,0,1,1,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,3,1,1,3,0,0,1,0,3,3,2,0,2,3,0,2,2,3,0,0,3,1,0,3,1,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,4,0,1,1,0,0,0,1,0,3,3,0,0,0,2,0,2,3,0,0,0,2,1,3,1,0,0,0,4,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,3,3,3,0,0,3,3,3,3,3,0,0,3,1,3,1,3,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,0,1,1,1,1,1,0,0,0,3,1,3,0,0,0,0,2,0,3,0,0,0,3,3,0,4,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,3,1,3,1,0,0,3,3,3,3,1,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,0,0,1,0,0,0,3,0,3,1,0,0,0,3,2,1,0,0,0,0,4,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,3,3,0,3,0,0,0,1,1,3,1,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,0,0,0,1,1,1,4,0,0,0,1,1,1,4,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,4,0,1,1,0,0,0,4,1,1,0,0,0,0,4,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,1,0,0,0,1,1,1,1,0,0,0,4,1,1,1,0,0,1,1,0,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,0,1,1,1,0,0,0,1,1,0,1,0,0,0,1,1,0,4,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,0,0,1,0,0,0,1,1,0,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,1,0,0,0,1,0,1,1,0,0,0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,1,1,1,4,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,0,1,0,1,1,0,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,4,0,1,0,0,0,1,4,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,5,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,0,0,1,0,0,0,1,1,0,1,0,0,0,1,0,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,5,0,0,0,1,1,1,1,0,0,0,1,1,1,5,0,0,0,1,1,1,1,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,5,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,0,1,1,0,0,1,1,0,5,0,0,0,1,1,1,5,0,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,1,5,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,5,0,0,0,5,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,0,1,1,0,1,1,0,0,1,1,0,5,0,0,0,1,1,0,3,0,0,0,1,0,0,5,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,3,1,1,3,1,0,0,3,3,1,5,3,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,3,0,0,3,0,0,0,1,0,3,1,0,0,1,5,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,3,1,1,3,0,0,3,2,3,3,3,0,0,3,3,1,1,1,0,0,1,3,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,3,0,0,0,1,3,0,3,0,0,0,1,1,0,3,0,0,0,3,1,0,1,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,3,3,3,3,3,0,2,0,3,3,3,3,0,0,1,3,1,5,3,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,5,0,0,1,0,0,0,3,0,2,3,0,0,0,3,0,2,2,0,0,2,3,2,3,2,0,0,0,1,0,3,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,3,3,3,3,3,0,2,2,2,3,2,2,0,2,0,3,3,3,2,0,3,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,0,3,0,0,0,2,3,0,2,0,2,0,0,2,0,2,2,0,0,0,3,0,3,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,3,3,3,1,0,2,3,0,2,2,2,0,2,0,0,2,2,2,0,2,3,3,3,3,1,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,5,0,0,0,3,0,2,2,0,2,0,0,0,2,2,2,0,2,0,0,2,0,0,0,0,3,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,3,0,0,3,2,2,3,2,2,0,2,0,2,4,2,2,2,2,0,2,2,3,2,0,3,0,3,1,3,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,0,1,1,0,3,0,0,0,0,0,2,2,0,2,0,0,0,2,2,0,0,0,0,2,0,3,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,3,3,3,3,3,0,2,2,0,2,4,2,2,4,0,0,2,2,2,2,2,0,3,3,3,3,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,3,0,0,0,3,0,2,2,0,2,0,0,0,4,4,4,2,0,0,0,2,2,0,0,2,3,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,3,0,0,3,3,2,2,2,2,2,2,0,0,4,4,0,2,2,0,2,2,2,2,0,3,3,1,3,3,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,0,3,0,0,2,0,0,0,2,0,4,2,0,0,0,4,0,2,0,0,0,2,3,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,3,3,3,3,0,0,2,0,2,2,2,0,2,0,0,2,2,2,2,2,0,3,3,3,3,0,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,3,0,0,0,3,0,2,3,0,2,2,0,0,4,2,2,2,0,0,0,3,2,0,0,0,3,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,3,0,0,1,3,2,2,3,2,0,2,0,0,4,2,2,0,2,0,2,2,2,2,0,3,1,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,0,3,0,0,0,0,0,2,2,2,2,2,0,0,2,2,0,2,0,3,0,0,3,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,3,3,3,3,0,0,3,0,2,2,2,0,2,2,0,2,2,2,0,0,3,2,3,3,3,0,0,1,1,0,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,3,0,3,3,2,0,0,0,0,2,2,0,0,0,2,0,3,3,0,0,0,5,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,5,0,0,0,3,3,3,3,0,0,3,3,2,2,2,2,0,3,2,3,3,3,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,3,0,0,0,0,3,2,3,0,0,0,1,0,0,3,0,0,0,1,3,2,3,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,3,3,3,3,3,0,0,3,3,3,3,3,0,0,3,1,1,1,0,0,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,3,1,1,1,0,0,0,3,3,3,3,0,0,0,3,2,3,1,0,0,0,5,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,3,0,0,0,3,3,1,3,0,0,1,1,1,1,3,0,0,1,1,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,0,1,2,5,0,0,0,0,3,1,1,0,0,0,1,1,0,1,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,1,0,0,1,3,1,3,0,0,0,1,1,1,5,0,0,0,1,0,0,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,5,0,1,1,0,0,0,5,1,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,5,1,1,0,0,0,0,1,1,1,0,0,0,1,1,0,5,0,0,0,1,1,1,1,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,1,0,1,0,0,0,1,0,0,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,5,1,1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,5,1,0,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,0,0,0,1,1,1,1,0,0,0,1,1,1,5,0,0,0,1,1,1,1,0,0,0,1,1,1,5,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,1,0,1,0,0,0,1,0,0,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,1,5,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,1,1,1,5,0,0,0,1,1,1,1,0,0,0,5,0,1,1,0,0,0,5,1,1,1,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,0,0,1,1,0,0,1,1,0,1,0,0,0,1,0,0,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,1,0,0,0,1,1,0,1,0,0,0,5,0,1,1,0,0,0,5,0,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,1,0,1,0,0,0,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,1,1,1,5,1,0,0,1,1,1,1,0,0,0,1,1,1,5,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,0,0,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,3,0,0,0,3,0,0,3,0,0,0,1,0,0,1,0,0,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,3,3,1,3,1,0,0,3,1,3,3,1,0,0,3,1,1,5,0,0,0,1,0,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,0,1,3,0,0,0,3,0,3,3,0,0,0,1,0,3,1,0,0,1,5,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,5,1,1,1,0,0,0,1,3,1,3,0,0,2,3,3,3,3,0,0,3,2,3,1,3,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,0,1,1,0,1,1,0,0,2,1,0,3,0,0,0,2,3,0,3,0,0,0,3,1,0,3,0,0,0,5,0,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,3,1,3,1,0,0,3,2,3,3,3,0,2,0,2,3,3,3,0,3,2,3,1,3,1,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,1,0,0,0,3,0,2,3,0,0,0,2,0,2,2,0,0,2,0,0,3,0,0,0,0,3,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,3,3,3,3,3,2,0,2,0,2,2,2,2,0,2,0,3,3,3,2,0,3,1,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,3,0,3,2,0,0,0,2,0,2,2,2,0,0,0,2,2,0,0,2,0,2,0,3,0,0,0,1,1,0,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,3,3,3,3,0,2,2,0,2,2,2,2,2,0,0,2,2,2,2,2,0,3,3,3,1,0,0,3,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,3,0,0,0,2,1,0,2,0,2,0,0,0,2,4,2,2,0,0,0,2,2,0,0,2,3,0,3,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,3,3,0,0,2,2,0,2,2,2,2,2,0,0,4,2,2,2,2,0,2,2,2,2,0,3,0,1,3,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,0,1,1,0,3,0,2,2,0,0,0,4,0,4,0,0,0,2,4,2,0,0,0,2,0,3,0,0,0,3,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,1,0,0,1,2,3,3,3,0,2,2,0,2,2,4,4,4,0,0,2,4,2,2,2,0,2,3,3,2,0,0,3,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,3,0,0,2,0,0,2,2,0,2,0,0,0,4,4,2,4,0,0,0,2,2,0,0,2,3,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,3,3,3,0,0,3,0,0,2,2,2,2,4,0,0,4,4,2,2,2,0,2,2,2,2,0,3,2,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,3,0,3,2,2,2,0,0,0,4,2,4,4,0,0,2,2,0,2,0,0,0,2,3,0,0,0,3,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,3,1,3,3,3,0,2,0,0,2,4,2,2,4,0,0,2,4,2,0,2,0,2,3,3,3,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,3,0,0,0,2,0,2,2,0,2,0,0,0,2,4,0,4,0,0,0,2,2,0,0,0,3,0,3,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,3,0,0,3,3,2,2,2,2,2,2,0,0,4,2,2,2,2,0,2,2,2,2,0,3,3,3,1,3,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,3,0,3,0,0,0,0,0,2,2,2,2,2,0,0,0,2,0,2,0,2,0,0,3,0,0,0,1,1,0,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,3,3,3,3,0,0,2,0,2,2,2,2,2,0,0,2,2,2,0,3,0,3,3,3,3,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,3,0,3,3,0,2,0,0,0,2,2,0,2,0,0,2,3,2,0,0,0,3,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,1,3,2,3,3,2,0,3,0,2,2,2,2,0,3,2,3,3,3,2,0,1,0,1,1,3,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,0,0,0,1,3,0,1,0,0,0,0,1,2,3,0,2,0,0,0,2,3,0,0,0,1,2,1,3,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,3,3,0,0,3,2,3,3,3,0,0,3,2,3,2,3,0,0,3,3,0,3,1,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,3,1,1,3,0,0,0,2,3,3,3,0,0,0,1,2,3,0,0,0,0,5,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,3,3,0,0,1,3,3,3,3,0,0,0,3,1,1,3,0,0,1,1,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,0,3,0,3,0,0,0,0,3,3,5,0,0,0,1,1,0,5,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,3,0,0,1,3,0,3,1,0,0,1,1,1,1,0,0,0,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,3,1,1,0,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,1,0,0,0,1,1,1,1,0,0,1,1,0,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,0,1,1,1,0,0,0,1,1,0,5,0,0,0,1,1,1,1,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,1,1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,1,0,1,0,0,0,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,0,0,0,1,1,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,1,0,0,0,1,1,0,1,0,0,1,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,1,1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,0,1,5,0,0,0,1,0,0,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,5,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,1,1,1,1,0,0,0,5,1,1,1,0,0,0,5,0,1,1,0,0,0,5,1,1,1,0,0,0,5,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,0,0,1,1,0,0,1,1,0,1,0,0,0,1,0,0,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,5,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,5,0,0,0,5,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,1,0,0,0,5,1,0,1,0,0,0,5,0,1,1,0,0,0,5,0,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,1,1,1,1,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,0,5,0,0,0,1,1,0,1,0,0,0,1,1,0,5,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,0,5,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,3,0,0,0,3,0,1,1,0,0,0,5,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,5,1,1,1,0,0,0,1,1,1,3,0,0,0,3,3,3,1,0,0,3,1,1,1,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,0,1,1,0,3,0,0,0,1,1,0,3,0,0,0,3,0,0,3,0,0,0,3,0,0,1,0,0,0,1,0,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,3,1,3,3,3,0,0,3,3,3,3,1,0,0,3,1,1,5,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,1,0,0,0,3,0,1,3,0,0,0,3,0,1,2,0,0,0,3,0,3,1,0,0,3,5,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,3,0,0,1,3,3,3,3,0,0,2,0,2,3,3,0,2,2,0,3,3,3,0,0,3,1,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,3,2,0,0,0,3,0,2,0,0,0,2,2,0,2,0,0,0,2,3,0,3,0,0,0,1,0,0,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,3,1,3,3,3,0,2,1,0,2,3,2,0,2,0,2,3,3,2,0,2,2,3,3,3,3,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,1,0,0,0,3,0,2,2,0,2,0,2,0,2,2,0,2,0,0,0,3,0,0,0,0,3,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,3,3,0,0,3,0,2,2,2,2,2,2,0,0,2,2,2,2,2,0,2,2,2,2,0,3,2,1,3,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,0,3,0,2,0,0,0,0,2,2,2,2,0,0,0,2,0,0,2,0,0,1,3,0,0,0,3,1,0,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,3,2,3,2,3,0,2,0,0,2,2,2,2,4,0,0,2,2,2,2,2,0,2,3,3,3,0,2,3,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,3,0,0,2,2,0,2,2,0,2,0,0,0,4,2,0,2,0,0,0,2,2,0,0,0,2,0,3,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,3,3,3,0,0,2,0,0,2,2,2,4,4,0,0,4,2,4,4,2,0,0,2,2,2,0,2,0,3,3,3,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,0,1,3,0,3,0,2,2,0,0,0,4,0,4,0,0,0,0,4,4,2,0,0,0,2,3,0,0,0,3,1,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,0,3,0,2,3,2,0,2,0,0,2,4,4,4,4,0,0,2,4,4,0,2,0,2,3,2,2,0,1,3,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,2,3,0,2,0,0,0,2,2,0,4,0,0,0,4,4,4,4,0,0,0,2,0,2,0,0,2,0,3,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,3,3,3,3,0,2,0,0,2,2,2,4,2,0,0,4,4,4,4,2,0,0,2,2,2,0,2,2,3,3,3,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,3,0,2,0,2,2,0,0,0,4,0,4,4,0,0,0,4,0,4,2,0,0,2,3,0,0,0,3,3,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,3,0,0,3,0,2,2,2,2,2,0,0,2,4,4,4,4,0,0,2,4,4,0,2,0,0,2,3,2,0,0,1,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,3,2,0,0,0,0,2,2,0,4,0,0,0,4,0,4,4,0,0,0,2,2,2,0,2,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,5,3,3,3,0,0,3,0,0,2,2,2,2,2,0,0,4,4,2,2,0,0,2,2,2,2,0,3,0,3,3,3,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,3,0,3,0,2,0,0,0,0,2,0,2,4,0,0,0,4,0,2,0,0,0,2,3,0,0,0,3,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,3,3,2,3,2,0,2,0,2,2,2,0,2,0,0,2,2,2,2,2,0,3,3,2,3,0,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,3,0,0,0,2,0,2,3,0,2,0,0,0,2,2,0,2,0,0,0,2,2,0,0,2,3,0,3,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,5,3,0,3,0,0,3,1,2,2,2,2,0,2,0,2,2,2,2,2,2,0,2,2,3,2,0,3,0,3,1,3,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,0,0,1,0,3,0,2,0,0,0,2,3,0,2,0,0,0,0,3,0,2,0,2,0,0,3,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,3,3,1,3,0,0,3,2,3,2,2,0,0,3,0,2,2,2,0,0,3,3,1,3,1,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,3,1,3,3,0,0,0,0,0,2,3,2,0,0,0,0,3,3,0,0,0,3,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,5,0,0,0,3,3,3,3,0,0,3,3,3,3,2,3,0,1,3,3,3,3,0,0,1,1,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,1,0,0,0,1,1,3,0,0,0,0,3,0,3,0,0,0,0,2,2,3,0,0,0,0,3,1,1,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,3,3,3,0,0,3,3,3,1,3,0,0,1,1,1,1,1,0,0,1,0,0,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,3,1,3,1,0,0,0,3,1,1,0,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,5,0,0,0,1,1,1,1,0,0,1,1,1,2,3,0,0,1,1,1,1,1,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,0,0,0,0,5,1,1,0,0,0,0,1,1,1,0,0,0,1,1,0,5,0,0,0,1,1,1,1,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,1,1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,1,0,1,1,0,0,1,0,0,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,5,0,1,0,0,0,0,5,0,5,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,5,0,0,0,5,1,0,1,0,0,0,5,0,1,1,0,0,0,5,1,1,1,0,0,1,1,0,0,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,5,1,1,0,0,0,1,1,1,5,0,0,0,1,1,0,5,0,0,0,1,1,1,1,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,0,0,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,5,0,1,1,0,0,0,5,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,5,0,1,1,0,0,0,5,1,1,1,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,0,0,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,5,1,5,0,0,0,1,1,1,5,0,0,0,1,1,1,5,0,0,0,1,1,1,5,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,1,0,0,0,5,0,0,1,0,0,0,5,0,1,1,0,0,0,5,0,1,0,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,5,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,0,1,0,0,0,1,1,0,5,0,0,0,1,0,0,3,0,0,0,1,1,0,1,0,0,0,1,0,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,1,3,1,5,3,0,0,3,1,1,5,0,0,0,3,1,0,5,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,0,0,3,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,3,3,3,0,0,3,0,3,3,3,0,0,3,1,3,1,3,0,0,0,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,0,1,0,3,0,0,0,1,3,0,3,0,0,0,3,0,0,3,0,0,0,5,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,3,3,1,0,0,3,3,3,3,3,0,0,0,3,3,3,3,0,1,2,1,1,5,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,0,3,3,0,0,0,3,0,2,2,0,0,0,3,0,3,3,0,0,1,3,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,5,0,0,3,2,3,3,3,2,0,2,0,2,2,3,2,0,2,0,3,3,3,2,0,3,1,3,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,0,3,0,0,2,0,3,0,2,0,0,0,0,2,2,2,0,0,0,0,3,0,3,0,0,0,1,0,0,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,3,3,3,3,3,0,2,0,0,2,2,2,2,2,0,0,2,2,2,2,2,0,0,3,3,3,0,0,3,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,3,0,0,0,3,0,2,2,0,2,0,0,0,2,2,0,2,0,0,0,2,2,0,0,0,3,0,3,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,3,3,3,0,0,3,0,2,2,2,2,2,2,0,0,2,2,2,2,0,0,2,2,2,2,0,2,0,3,3,3,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,0,0,3,0,2,0,2,0,0,0,0,4,0,2,2,0,0,0,4,0,2,0,0,0,2,3,0,0,0,3,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,3,0,2,3,2,0,2,0,0,2,2,2,4,4,0,0,2,4,2,2,2,0,2,2,2,2,0,3,0,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,3,2,0,0,0,0,2,2,0,4,0,0,0,4,2,4,4,0,0,0,2,2,0,0,0,2,0,3,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,3,3,3,1,0,2,0,0,2,2,2,4,0,0,0,4,2,4,4,0,0,0,2,2,2,2,2,0,3,3,3,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,0,0,2,3,0,2,0,2,2,0,0,4,4,0,4,4,0,0,0,4,2,4,0,0,0,0,2,0,0,0,1,3,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,3,0,0,3,0,2,2,2,2,2,0,0,0,4,4,4,4,0,0,4,4,4,2,2,0,0,2,2,2,2,2,3,1,3,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,2,3,0,0,2,0,0,4,4,0,4,0,0,0,4,4,4,4,0,0,0,2,2,2,2,0,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,3,3,3,3,0,2,0,0,2,2,4,4,0,0,0,4,4,4,4,2,0,0,4,2,2,0,2,0,3,3,3,2,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,0,0,0,0,2,2,2,2,0,0,0,4,4,4,4,0,0,0,4,4,4,0,0,0,0,2,2,0,0,0,3,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,0,3,2,2,2,2,2,2,0,0,2,4,4,4,4,0,0,4,4,0,4,2,0,0,2,2,2,0,3,3,1,3,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,2,3,0,0,2,0,0,2,2,0,4,0,0,0,4,4,0,4,0,0,0,2,0,2,2,0,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,3,3,3,2,0,2,0,0,2,2,2,2,2,0,0,4,4,4,4,0,0,2,2,2,2,0,2,0,3,3,3,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,0,0,3,0,3,0,0,0,0,0,0,4,0,2,4,0,0,0,4,0,2,2,0,0,2,3,0,0,0,3,3,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,3,0,3,2,2,2,2,2,0,2,2,2,2,2,0,0,2,2,4,0,2,0,0,2,2,3,0,0,1,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,3,0,0,0,2,0,0,2,0,4,0,0,0,2,2,0,2,0,0,0,2,2,0,0,2,0,2,3,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,3,3,0,0,3,0,2,2,2,2,2,2,0,0,2,2,2,2,2,0,2,2,2,2,0,3,0,3,3,3,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,0,0,0,1,3,0,3,2,0,0,2,0,0,2,0,2,2,0,0,0,2,0,0,0,0,0,0,3,0,0,0,1,3,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,3,3,3,3,0,0,3,0,2,2,2,2,0,0,0,2,2,2,2,2,3,3,3,3,3,0,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,2,1,2,3,0,0,0,0,0,2,2,2,0,0,0,0,3,2,0,0,0,3,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,5,0,0,0,1,3,3,3,3,0,3,2,2,2,3,2,0,3,0,3,3,3,0,0,1,1,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,5,1,3,1,0,0,0,2,0,3,0,0,0,0,0,2,3,0,0,0,0,3,3,3,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,3,1,1,0,0,3,1,3,3,3,0,0,3,3,3,3,3,0,0,3,1,1,1,1,0,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,2,1,1,0,0,0,3,1,3,3,0,0,0,3,1,1,0,0,0,0,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,3,0,0,1,1,3,0,3,0,0,1,1,3,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,5,1,5,0,0,0,0,5,0,3,0,0,0,0,3,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,0,1,0,0,0,5,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,0,0,0,0,5,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,1,0,0,0,1,1,0,1,0,0,0,5,0,1,1,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,1,1,1,5,0,0,0,1,1,0,5,0,0,0,1,1,1,1,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,1,0,1,0,0,0,1,0,0,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,1,5,1,5,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,1,1,1,1,0,0,0,5,1,1,1,0,0,0,1,1,1,1,0,0,0,5,1,1,1,0,0,1,5,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,0,5,0,0,0,1,0,0,1,0,0,0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,5,1,0,0,1,1,1,5,0,0,0,1,1,1,5,1,0,0,1,1,1,5,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,1,0,0,0,1,0,1,1,0,0,0,5,0,1,1,0,0,0,1,0,1,0,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,5,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,0,3,0,0,0,3,1,0,3,0,0,0,1,0,0,1,0,0,0,1,1,0,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,3,3,1,5,3,0,0,3,1,1,3,1,0,0,3,1,1,5,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,1,0,0,0,1,0,1,3,0,0,0,3,0,3,3,0,0,0,1,0,1,3,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,1,3,1,3,3,0,0,3,0,3,3,3,0,0,3,0,3,3,3,0,0,3,1,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,3,0,0,0,0,3,0,3,0,0,0,2,3,0,3,0,0,0,0,1,0,3,0,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,3,3,3,3,0,0,3,2,3,3,2,0,2,0,0,3,3,2,0,2,0,3,3,3,1,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,3,0,0,0,1,0,3,2,0,0,0,2,0,2,2,2,2,0,2,0,3,3,0,0,0,1,0,3,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,3,1,3,1,0,2,0,2,3,2,2,2,2,0,0,2,2,2,2,2,0,2,2,3,2,0,2,1,3,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,0,3,0,2,0,0,0,0,2,0,2,0,0,0,0,2,0,0,0,0,2,0,3,0,0,0,3,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,1,0,0,3,2,3,3,3,0,2,0,0,2,2,2,2,2,0,0,2,2,2,2,2,0,2,3,3,2,0,3,3,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,3,0,2,0,0,2,2,2,0,2,0,0,0,4,2,0,2,0,0,0,2,2,0,0,0,2,0,3,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,3,3,3,0,0,2,0,0,2,2,2,2,2,0,0,4,4,2,4,0,0,2,2,2,2,2,2,0,3,3,3,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,0,3,3,0,2,0,0,2,0,0,0,4,0,4,0,0,0,0,4,0,2,0,0,0,0,2,0,0,0,0,3,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,3,0,2,2,2,2,4,0,0,2,4,2,4,4,0,0,2,4,4,4,4,0,0,2,2,2,2,2,3,3,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,2,0,2,2,0,0,2,2,0,6,0,0,0,4,2,0,4,0,0,0,2,2,2,0,0,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,2,3,3,3,0,2,0,0,4,2,4,6,0,0,0,4,4,4,4,0,0,0,4,4,2,2,2,0,2,3,3,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,0,0,2,0,2,0,0,2,0,0,0,6,0,4,4,0,0,0,4,4,4,0,0,0,0,2,2,0,0,0,2,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,2,0,2,2,2,2,4,0,0,0,4,4,4,4,0,0,0,4,4,4,2,0,0,2,2,2,0,2,0,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,0,2,3,0,2,0,0,0,2,4,4,6,0,0,0,4,4,4,4,0,0,0,4,2,2,2,0,0,2,3,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,2,3,3,2,0,2,0,0,4,2,4,4,0,0,0,4,4,4,6,0,0,0,4,4,4,0,2,0,2,3,3,2,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,0,0,0,0,2,2,2,2,0,0,4,4,4,4,4,0,0,0,4,4,4,0,0,0,0,2,0,0,0,2,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,2,0,2,2,2,2,4,0,0,0,4,4,4,4,0,0,4,4,0,4,2,0,0,2,2,2,2,2,1,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,1,0,3,0,2,2,0,0,2,2,0,4,0,0,0,4,4,0,4,0,0,0,4,2,2,2,0,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,3,2,3,2,0,2,0,0,4,2,2,4,2,0,0,4,4,0,4,0,0,0,2,2,2,2,2,0,3,2,3,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,0,0,1,0,0,2,0,0,2,0,0,0,4,0,4,4,0,0,2,4,2,4,0,0,0,0,2,0,0,0,2,2,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,3,0,2,2,2,2,2,0,0,2,4,4,4,2,0,0,4,4,2,0,2,0,0,2,2,2,2,3,3,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,3,2,2,0,0,0,2,2,0,2,0,0,0,2,4,0,4,0,0,0,2,2,2,0,0,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,3,3,3,3,0,2,0,0,2,2,2,2,2,0,0,4,2,2,2,2,0,2,2,2,2,0,3,0,3,3,3,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,3,0,3,2,0,2,0,0,0,2,0,2,2,0,0,0,2,0,2,0,0,0,2,3,0,0,0,1,3,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,3,0,3,2,3,0,0,2,0,2,2,2,0,2,0,0,2,2,2,0,2,0,2,3,3,2,0,0,3,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,3,3,0,0,0,0,2,3,2,0,2,0,0,0,2,2,0,2,0,0,0,3,2,0,0,0,3,2,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,3,1,1,1,0,1,3,2,3,3,2,0,3,0,2,2,2,2,0,3,0,2,3,2,3,0,3,1,3,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,3,0,3,0,0,0,0,0,0,3,2,0,0,0,0,2,3,2,0,0,0,2,0,3,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,3,1,3,0,0,3,2,3,3,3,0,0,3,2,3,2,3,0,0,3,1,3,3,1,0,0,1,1,0,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,3,0,1,3,0,0,0,0,0,3,3,0,0,0,0,1,3,0,0,0,0,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,5,0,0,0,1,3,1,3,1,0,1,3,3,3,3,0,0,3,1,3,1,3,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,5,1,5,0,0,0,0,3,0,3,0,0,0,0,3,0,3,0,0,0,1,3,0,1,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,3,0,0,1,1,1,3,1,0,0,1,1,0,1,1,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,5,0,0,0,1,1,1,1,0,0,0,1,1,1,3,0,0,0,1,1,1,1,0,0,0,5,0,5,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,1,0,0,1,1,1,1,0,0,0,0,5,1,5,0,0,0,1,5,0,1,0,0,0,1,1,1,5,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,1,1,0,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,0,0,0,0,5,1,5,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,1,1,1,1,0,0,0,5,1,1,1,0,0,0,5,1,1,1,0,0,0,5,1,5,1,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,0,5,0,0,0,1,0,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,5,0,0,0,1,1,1,5,1,0,0,3,1,1,1,0,0,0,1,1,1,1,0,0,0,5,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,5,0,1,1,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,3,1,0,0,1,1,1,3,1,0,0,3,1,1,1,1,0,0,1,1,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,3,0,0,0,1,1,0,3,0,0,0,1,1,0,1,0,0,0,1,1,0,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,3,1,3,3,3,0,0,3,1,3,3,1,0,0,3,1,1,1,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,0,2,3,0,0,0,3,0,3,2,0,0,0,3,1,3,3,0,0,1,3,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,3,0,0,3,3,3,3,3,3,0,2,0,3,3,2,1,0,2,0,3,3,3,0,0,3,1,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,3,0,0,0,0,3,0,2,0,0,0,2,2,0,3,0,0,0,0,3,0,3,0,0,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,3,1,3,6,3,0,2,0,0,2,3,2,0,2,0,0,2,2,2,2,2,2,3,3,3,3,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,3,0,0,0,1,0,2,2,2,0,0,2,0,2,2,0,2,0,0,0,2,0,0,0,0,3,1,3,0,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,3,3,3,3,0,2,0,0,2,2,2,2,2,0,0,2,2,2,2,2,0,2,3,2,2,2,2,2,3,3,3,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,1,0,0,0,3,0,2,0,2,0,0,0,0,2,0,2,0,0,0,0,2,0,0,0,0,0,0,3,0,0,0,3,1,1,6,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,3,0,0,2,0,2,3,2,2,2,0,0,2,2,2,2,4,0,0,2,2,2,2,2,0,2,2,2,2,0,2,2,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,3,0,2,0,0,0,2,2,0,2,0,0,0,4,4,2,2,0,0,0,2,2,2,0,0,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,3,3,3,3,0,2,0,0,2,2,2,4,0,0,0,4,4,2,4,0,0,0,2,2,2,2,2,0,3,3,3,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,0,0,2,0,2,0,2,2,0,0,0,4,0,4,4,0,0,0,4,2,4,0,0,0,0,2,0,2,0,2,0,3,6,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,2,0,2,2,2,2,4,0,0,4,4,4,4,4,0,0,2,4,4,4,4,0,0,2,2,2,0,2,0,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,0,2,2,0,2,0,0,0,2,2,0,4,0,0,0,4,4,0,4,0,0,0,4,0,2,2,0,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,2,3,2,3,2,2,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,2,2,2,0,2,3,3,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,2,0,0,0,0,2,0,2,4,0,0,0,4,4,4,4,0,0,4,4,4,4,0,0,0,0,2,0,2,0,0,2,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,2,0,2,2,4,2,4,0,0,4,4,4,4,4,0,0,0,4,4,4,4,0,0,2,2,2,2,2,0,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,2,0,2,0,2,0,0,0,4,4,0,4,0,0,0,4,4,4,4,0,0,0,4,4,2,2,0,0,0,2,0,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,3,0,2,2,2,2,2,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,0,4,2,0,2,2,2,2,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,2,0,0,0,0,2,0,2,4,0,0,4,4,4,4,4,0,0,0,4,4,4,4,0,0,0,2,0,0,0,0,0,3,6,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,2,0,2,2,2,2,4,0,0,0,4,4,4,4,0,0,4,4,4,4,4,0,0,2,2,2,2,2,0,3,3,6,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,1,2,2,0,2,0,0,0,4,2,0,4,0,0,0,4,4,4,4,0,0,0,4,4,2,2,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,2,2,2,3,0,2,0,0,4,2,2,4,4,0,0,4,4,4,4,0,0,0,4,0,2,2,0,0,2,3,2,2,0,6,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,0,0,0,0,2,2,0,0,4,0,0,0,4,0,4,4,0,0,0,4,0,4,2,0,0,2,2,0,0,0,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,3,0,2,2,2,2,2,0,0,4,4,2,4,4,0,0,4,4,2,4,2,0,0,2,2,2,2,2,3,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,3,3,2,0,0,0,0,2,2,0,4,0,0,0,4,2,0,4,0,0,0,2,2,0,0,0,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,2,3,3,2,0,2,0,0,2,2,2,2,2,0,0,4,4,2,4,2,0,0,2,2,2,2,2,0,3,3,3,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,0,0,3,0,3,0,2,2,0,0,0,2,0,2,2,0,0,0,2,0,2,0,0,0,0,3,0,0,0,0,3,1,6,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,3,0,0,3,0,2,2,2,2,2,0,0,2,2,2,0,2,0,0,2,2,2,2,2,0,2,3,2,2,0,0,3,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,3,3,0,0,0,0,0,0,2,0,2,2,0,0,2,2,0,2,0,0,0,2,2,0,0,0,2,0,3,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,3,3,3,3,0,3,0,2,2,2,2,2,2,0,0,2,2,2,0,2,0,2,2,2,2,0,3,1,3,3,3,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,0,3,1,2,0,0,0,0,3,0,2,0,0,0,2,3,0,0,0,0,0,1,3,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,3,3,3,3,0,0,3,0,3,2,2,0,2,2,0,3,2,2,0,0,3,3,3,3,3,0,0,3,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,3,1,3,3,0,0,0,0,0,3,3,0,0,0,2,0,3,3,0,0,0,3,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,3,3,3,3,0,3,3,3,2,3,3,0,3,3,3,3,3,0,0,1,1,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,5,0,0,0,0,3,0,3,0,0,0,0,0,0,6,0,0,0,1,3,1,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,1,1,1,3,3,0,0,3,3,3,1,3,0,0,1,0,1,1,1,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,3,1,1,1,0,0,0,5,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,0,1,1,1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,1,1,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,5,0,0,0,0,1,1,5,0,0,0,1,1,0,5,0,0,0,1,1,1,1,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,1,1,0,1,0,0,0,1,1,0,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,1,0,0,0,5,0,1,1,0,0,0,1,1,1,1,0,0,1,5,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,1,1,1,1,0,0,0,5,5,1,1,0,0,0,5,1,1,1,0,0,1,5,1,1,1,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,5,1,0,5,0,0,0,5,0,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,0,0,0,1,1,1,6,1,0,0,3,1,1,6,0,0,0,1,1,1,1,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,5,0,0,1,0,0,0,5,0,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,5,1,1,1,0,0,1,3,1,1,3,0,0,3,0,3,3,3,0,0,3,1,1,3,1,0,0,1,1,1,5,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,2,1,0,3,0,0,0,1,1,0,3,0,0,0,3,1,0,3,0,0,0,1,1,0,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,3,3,1,0,0,3,3,3,3,3,0,1,2,1,3,3,3,0,0,1,3,1,3,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,0,0,3,0,0,0,3,0,2,2,2,0,0,2,0,3,2,0,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,3,0,0,2,0,3,3,3,2,0,2,0,2,3,2,2,0,2,0,3,3,3,0,0,3,1,1,3,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,3,0,3,0,0,0,0,2,0,2,0,2,0,0,0,2,2,0,0,0,0,3,0,3,0,0,0,1,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,0,3,0,3,3,3,0,2,0,0,2,2,2,0,2,0,0,2,2,2,0,2,0,2,3,2,3,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,2,3,0,0,0,2,0,2,2,0,2,0,0,0,2,2,0,2,0,0,0,2,2,0,0,0,2,2,3,0,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,3,3,3,3,3,0,2,0,0,2,2,2,2,2,0,0,2,2,2,2,0,0,0,2,2,2,2,2,0,3,3,3,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,0,0,1,0,2,0,2,0,0,0,0,4,0,2,0,0,0,2,4,0,2,0,0,0,0,2,0,0,0,0,3,1,6,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,2,0,2,2,2,2,2,0,0,2,2,2,4,4,0,0,2,4,2,2,2,0,0,2,2,2,2,2,0,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,0,0,2,0,2,0,0,0,4,2,0,4,0,0,0,4,2,2,4,0,0,0,4,0,2,2,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,2,3,2,2,2,2,0,0,4,2,4,4,0,0,0,4,4,4,4,0,0,0,4,4,2,2,0,0,2,3,3,2,2,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,0,0,0,0,0,2,0,2,2,0,0,0,4,0,4,4,0,0,0,4,4,4,0,0,0,0,2,0,0,0,0,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,1,2,2,0,2,2,2,2,4,0,0,4,4,4,4,4,0,0,2,4,4,4,2,0,0,2,2,2,2,2,0,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,2,2,0,2,0,2,0,0,0,4,2,0,4,0,0,0,4,4,0,4,0,0,0,4,4,2,2,0,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,2,2,2,2,2,2,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,2,2,2,2,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,0,0,0,0,0,2,0,2,4,0,0,4,4,4,4,4,0,0,4,4,4,4,0,0,0,0,2,0,2,0,0,0,2,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,2,0,0,2,4,2,4,4,0,0,0,7,4,4,4,0,0,4,4,4,4,2,0,0,4,4,2,2,2,0,2,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,2,0,0,0,4,4,4,7,0,0,0,4,4,4,4,0,0,0,4,4,2,2,0,0,0,2,0,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,0,2,2,2,2,2,0,0,4,4,4,4,0,0,0,4,4,4,7,0,0,0,4,4,4,2,0,0,2,2,2,2,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,0,2,0,0,0,2,0,4,4,0,0,0,7,4,4,4,0,0,0,4,4,4,4,0,0,0,4,0,2,0,0,0,2,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,2,2,0,2,7,2,4,4,0,0,4,4,4,4,0,0,0,4,4,4,4,4,0,0,4,2,2,2,2,0,2,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,2,0,0,0,2,4,0,4,0,0,0,4,4,4,4,0,0,0,4,0,4,2,0,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,0,2,2,2,2,2,0,0,4,2,2,4,4,0,0,4,4,4,4,0,0,0,4,4,4,2,0,0,2,2,2,2,2,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,2,0,0,0,0,2,0,0,4,0,0,0,4,0,4,4,0,0,0,4,0,4,0,0,0,0,2,0,2,0,0,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,2,0,2,2,2,2,4,0,0,4,4,4,4,4,0,0,4,4,4,4,4,0,0,2,2,2,0,2,0,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,1,2,2,0,2,0,0,0,2,4,0,4,0,0,0,4,4,0,4,0,0,0,2,2,2,2,0,0,0,2,2,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,2,3,2,2,2,0,0,4,2,2,4,2,0,0,4,2,4,4,0,0,0,4,2,2,2,2,0,2,3,2,2,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,2,0,0,2,0,2,2,0,0,0,4,2,4,2,0,0,0,4,2,2,0,0,0,2,2,0,0,0,0,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,3,0,2,2,2,2,2,0,0,2,2,2,2,2,0,0,4,2,2,0,2,0,0,2,2,2,0,2,1,1,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,3,3,0,0,0,0,0,0,2,0,2,0,0,0,2,2,2,2,0,0,0,2,2,2,0,0,0,0,3,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,3,3,3,3,0,3,0,2,2,2,2,2,2,0,0,2,4,2,2,2,0,2,2,2,2,0,3,2,3,3,3,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,2,0,3,0,0,0,0,0,0,2,0,2,0,0,0,2,2,0,2,0,0,0,0,3,0,0,0,3,1,1,6,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,3,1,3,2,3,0,0,3,0,2,2,2,0,2,0,0,2,2,2,0,2,0,3,2,3,3,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,3,0,2,3,0,0,0,0,0,2,2,0,0,0,0,0,3,3,0,0,0,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,1,0,0,1,2,3,3,2,0,3,2,3,2,2,2,0,3,2,3,3,3,2,0,1,1,1,1,3,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,3,1,3,1,0,0,0,1,0,3,0,0,0,1,0,1,3,0,0,0,0,0,1,3,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,3,0,0,1,3,3,3,3,0,0,3,0,3,3,3,0,0,1,1,1,3,1,0,0,1,1,0,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,3,0,0,0,0,3,1,3,0,0,0,3,1,3,1,0,0,0,6,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,1,0,0,1,1,1,1,1,0,0,1,1,3,1,3,0,0,1,1,1,1,1,0,0,1,1,0,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,5,1,1,0,0,0,0,1,1,1,0,0,0,1,1,0,6,0,0,0,1,1,1,1,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,5,0,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,1,1,1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,5,0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,0,3,0,0,0,1,1,0,5,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,3,1,1,3,1,0,0,3,1,1,6,1,0,0,1,1,1,1,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,5,0,0,1,0,0,0,1,0,1,3,0,0,0,3,0,1,3,0,0,0,1,0,3,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,5,1,1,1,0,0,3,3,3,3,3,0,0,3,0,3,3,6,0,0,3,0,3,3,3,0,0,3,1,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,6,1,0,0,0,3,0,3,0,0,0,2,3,0,3,0,0,0,1,1,0,3,0,0,0,1,1,0,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,3,3,3,0,2,1,0,3,3,2,0,2,0,0,2,3,3,0,2,0,3,6,3,1,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,3,0,0,0,1,0,2,2,0,0,0,2,0,2,2,2,0,0,2,0,2,2,0,0,0,3,0,3,0,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,3,3,6,2,0,2,0,2,2,3,2,2,2,0,0,2,2,2,0,2,0,2,2,3,2,0,2,1,3,3,3,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,1,0,0,1,3,0,2,0,0,0,0,0,0,2,0,2,0,0,0,0,2,0,0,0,0,0,0,3,0,0,0,1,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,0,2,0,2,3,3,2,2,0,0,2,2,2,2,2,0,0,2,2,2,2,2,0,2,3,2,2,0,2,0,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,0,0,3,0,2,0,0,0,2,2,0,2,0,0,0,4,2,0,2,0,0,0,2,2,0,0,0,2,0,3,0,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,2,3,3,2,0,2,0,0,2,2,2,4,0,0,0,4,2,2,4,0,0,0,2,2,2,2,2,0,2,3,3,2,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,0,0,0,0,2,0,2,0,0,0,0,7,0,2,0,0,0,0,4,0,2,2,0,0,0,2,0,0,0,0,2,3,6,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,0,0,2,2,2,2,2,0,0,2,4,2,4,4,0,0,4,4,2,4,4,0,0,2,2,2,0,2,0,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,0,2,2,0,2,0,0,0,4,4,0,4,0,0,0,4,4,2,4,0,0,0,4,0,2,2,0,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,2,2,2,2,0,0,4,4,2,4,0,0,0,7,4,4,7,0,0,0,4,4,2,4,0,0,2,2,2,2,2,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,2,0,0,0,0,2,0,0,4,0,0,0,7,0,4,4,0,0,0,7,4,7,0,0,0,0,4,0,2,0,0,0,2,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,2,2,0,0,2,4,2,4,4,0,0,0,7,4,4,4,0,0,4,4,4,4,4,0,0,2,2,2,2,2,0,0,3,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,4,0,0,0,4,4,4,4,0,0,0,7,4,0,4,0,0,0,4,4,2,4,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,2,2,2,2,0,0,4,4,4,7,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,2,2,2,2,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,0,2,0,0,0,4,0,4,4,0,0,0,7,4,4,4,0,0,4,4,4,7,0,0,0,0,4,0,2,0,0,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,0,2,0,0,0,4,4,4,4,0,0,4,7,4,4,4,0,0,4,7,0,4,4,0,0,4,4,2,2,2,0,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,2,0,4,2,0,0,4,4,0,4,0,0,0,4,4,4,4,0,0,0,4,4,2,4,0,0,0,2,0,1,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,0,2,2,2,2,2,0,0,4,4,4,4,0,0,0,4,4,4,7,0,0,0,7,4,4,4,0,0,0,2,2,2,2,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,0,2,0,0,0,4,0,4,4,0,0,4,7,4,4,4,0,0,0,4,4,4,4,0,0,0,4,0,2,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,2,2,2,0,0,4,0,4,4,0,0,0,7,4,4,4,0,0,4,4,4,4,4,0,0,4,4,2,2,2,0,2,2,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,2,0,4,2,0,0,4,4,4,7,0,0,0,4,4,4,4,0,0,0,4,0,4,4,0,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,0,2,2,2,2,2,0,0,4,4,0,7,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,2,2,2,2,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,0,2,0,0,0,4,0,4,4,0,0,0,7,0,4,4,0,0,4,4,4,4,0,0,0,0,4,0,2,0,0,0,2,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,2,0,2,0,0,2,2,2,4,0,0,0,7,4,4,4,0,0,0,4,4,4,4,0,0,2,2,2,0,2,0,2,3,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,2,0,4,0,0,0,4,2,4,4,0,0,0,4,4,0,7,0,0,0,4,2,4,2,0,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,2,2,2,2,2,2,0,0,4,2,4,4,0,0,0,4,0,4,4,4,0,0,4,2,2,2,0,0,2,2,2,2,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,0,0,0,2,0,0,2,0,0,0,4,2,4,4,0,0,0,4,0,4,2,0,0,0,2,2,2,0,0,0,3,6,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,3,0,0,2,2,2,2,0,0,2,4,2,4,2,0,0,2,4,2,0,2,0,0,2,2,2,0,2,0,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,1,2,2,0,2,2,0,0,2,2,0,4,0,0,0,2,2,0,4,0,0,0,2,0,0,2,0,0,0,3,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,2,3,3,2,0,2,0,0,2,2,2,0,2,0,0,4,2,2,2,2,0,2,2,2,2,0,3,2,3,2,3,2,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,1,0,0,0,1,0,3,0,0,2,0,0,0,2,0,0,4,0,0,0,2,0,2,2,0,0,0,2,0,0,0,0,1,1,6,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,3,0,0,3,2,2,3,2,1,0,2,0,2,2,2,0,2,0,0,2,2,2,2,3,0,2,2,3,2,0,1,3,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,3,0,0,0,0,0,2,2,0,2,0,0,0,2,2,0,0,0,0,0,2,0,0,0,0,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,3,3,3,0,1,3,2,2,3,2,0,2,2,2,2,2,2,0,3,2,2,2,3,2,0,3,3,3,1,3,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,1,0,3,0,0,0,0,0,0,3,0,0,0,0,0,0,3,0,0,0,0,0,1,3,0,0,0,1,3,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,3,3,3,0,0,1,1,3,2,3,0,2,3,0,3,2,3,0,0,3,3,1,3,3,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,3,3,0,0,0,0,0,3,3,0,0,0,1,2,3,1,0,0,0,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,1,1,1,3,3,0,0,1,3,3,3,3,0,0,1,1,3,1,3,0,0,1,1,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,0,0,0,0,5,1,1,1,0,0,0,3,1,3,0,0,0,1,3,1,3,0,0,0,1,1,1,1,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,0,0,0,5,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,5,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,1,1,1,1,0,0,1,1,1,1,1,0,0,1,1,6,1,6,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,1,0,0,0,1,1,0,3,0,0,0,1,1,0,3,0,0,0,1,1,0,1,0,0,0,1,1,0,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,3,1,3,6,3,0,0,3,3,3,6,3,0,2,1,1,1,3,1,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,5,0,0,0,1,0,1,3,0,0,0,3,0,2,1,0,0,0,3,0,3,1,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,5,1,1,1,0,0,3,1,3,3,3,0,0,2,0,3,3,7,0,0,2,0,3,3,3,0,0,3,1,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,3,0,0,2,0,3,0,2,0,0,0,0,2,0,3,0,0,0,0,2,0,3,0,0,0,1,1,0,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,3,2,3,3,3,0,0,0,0,2,3,7,0,2,0,0,2,7,2,2,2,0,1,3,3,2,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,3,0,0,0,0,2,2,2,0,2,0,0,0,2,2,0,2,0,0,0,2,2,0,0,0,3,0,3,0,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,3,3,3,2,0,2,0,0,2,2,2,2,2,0,0,2,2,2,2,0,0,0,2,2,2,0,2,0,3,3,3,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,0,3,0,2,0,2,0,0,0,0,2,0,2,0,0,0,2,2,0,0,0,0,0,2,2,2,0,0,2,1,1,6,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,3,0,0,2,0,2,2,2,2,2,0,0,2,2,2,2,4,0,0,2,2,4,2,2,0,0,2,2,2,0,3,0,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,3,1,0,2,0,2,0,0,0,2,2,0,4,0,0,0,4,4,0,2,0,0,0,2,2,2,0,0,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,0,2,2,2,2,2,0,0,2,2,2,4,0,0,0,4,4,2,4,0,0,0,4,2,2,4,0,0,2,2,3,2,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,0,2,0,0,0,2,0,2,2,0,0,0,4,0,4,0,0,0,4,4,0,2,0,0,0,0,4,0,2,0,0,0,2,7,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,2,0,0,0,2,4,2,4,0,0,4,4,4,4,4,0,0,0,4,4,4,2,0,0,2,2,2,2,2,0,1,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,2,0,4,0,0,0,4,4,0,4,0,0,0,4,4,4,4,0,0,0,4,2,4,2,0,0,0,2,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,2,2,2,2,0,0,4,4,2,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,7,2,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	7,0,0,2,0,0,0,4,0,4,4,0,0,0,4,4,4,4,0,0,4,4,4,4,0,0,0,0,4,2,2,0,0,0,0,7,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,2,2,0,0,0,4,2,4,4,0,0,0,4,4,4,4,0,0,4,4,4,4,4,0,0,4,4,2,4,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,0,4,4,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,4,2,2,4,2,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,2,2,2,2,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	7,0,0,2,0,0,0,4,0,4,4,0,0,4,4,4,4,4,0,0,4,4,4,4,4,0,0,0,4,0,4,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,2,0,0,0,4,4,4,4,0,0,4,4,4,4,4,0,0,4,4,4,4,4,0,0,2,4,4,4,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,0,4,4,0,0,0,7,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,2,2,4,2,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,2,2,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	7,2,0,2,0,0,0,4,0,4,4,0,0,4,4,4,4,4,0,0,4,4,4,4,4,0,0,0,4,0,4,0,0,0,2,7,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,2,0,0,2,4,4,4,4,0,0,0,4,4,4,4,0,0,4,4,4,4,4,0,0,4,4,4,2,4,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,4,0,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,7,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,2,2,7,4,0,0,4,4,0,4,0,0,0,4,4,0,4,0,0,0,4,4,4,4,0,0,2,2,2,2,2,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,0,2,0,0,0,4,0,2,4,0,0,4,4,4,4,4,0,0,4,4,4,4,0,0,0,0,4,0,2,0,0,0,0,7,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,2,0,0,0,4,4,4,4,0,0,4,4,4,4,4,0,0,4,4,4,4,4,0,0,4,4,2,0,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,4,0,0,0,4,2,0,4,0,0,0,4,4,4,4,0,0,0,4,4,2,4,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,0,2,2,2,2,2,0,0,4,4,4,4,0,0,0,4,4,0,4,0,0,0,4,2,2,4,0,0,2,2,2,2,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,2,0,0,0,0,2,0,2,2,0,0,0,4,4,4,4,0,0,4,4,0,4,4,0,0,0,2,0,2,0,0,0,2,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,3,0,2,0,2,2,2,2,4,0,0,0,4,0,4,4,0,0,4,4,2,4,2,0,0,2,2,2,2,2,0,2,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,2,0,0,2,0,2,2,0,0,2,4,0,4,0,0,0,2,4,0,4,0,0,0,4,0,2,2,0,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,2,2,3,0,2,0,0,4,2,2,2,2,0,0,4,4,0,4,2,0,0,2,2,2,0,2,0,2,2,2,2,0,6,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,2,0,0,0,0,7,0,0,2,0,0,0,4,0,2,2,0,0,0,2,0,2,2,0,0,0,7,0,0,0,0,0,3,6,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,3,0,2,2,2,0,2,0,0,2,2,2,2,2,0,0,2,2,2,2,2,0,0,2,2,2,0,3,3,3,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,3,0,2,0,0,0,2,2,0,2,0,0,0,2,2,0,2,0,0,0,2,2,0,0,0,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,3,3,3,0,1,2,0,2,2,2,0,7,0,0,2,0,2,0,7,0,2,2,2,2,0,3,0,3,3,3,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,2,0,3,0,0,0,1,0,0,7,0,2,0,0,0,0,7,0,0,0,0,0,1,3,0,0,0,1,3,1,6,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,2,3,3,3,0,0,3,0,7,2,3,0,2,2,0,2,2,2,2,0,3,2,3,3,3,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,6,0,0,0,1,0,3,3,0,0,0,0,0,3,3,0,0,1,0,0,3,1,0,0,0,3,0,6,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,5,1,1,1,0,0,0,1,3,3,3,3,0,3,1,2,3,3,3,0,3,3,3,1,3,2,0,1,1,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,0,1,1,1,5,0,0,0,0,0,1,3,0,0,0,0,2,0,6,0,0,0,0,1,1,1,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,1,1,0,0,1,3,3,1,3,0,0,1,1,3,1,3,0,0,1,1,1,1,1,0,0,5,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,5,1,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,1,5,1,1,0,0,1,1,3,3,6,0,0,3,1,3,6,6,0,0,3,1,1,3,3,0,0,3,1,1,1,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,6,1,0,0,0,1,0,3,0,0,0,1,1,0,3,0,0,0,1,1,0,3,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,3,1,3,3,1,0,0,3,1,3,3,3,0,2,2,1,3,8,3,0,3,0,1,3,6,1,0,1,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,3,0,0,0,1,0,1,2,0,0,0,2,1,0,2,0,0,0,2,0,2,1,0,0,0,1,0,3,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,1,3,6,1,0,3,0,3,2,3,2,0,2,0,2,3,2,2,0,2,0,3,3,3,0,0,3,1,3,3,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,0,3,0,7,0,0,0,0,2,0,2,0,2,0,0,0,2,2,0,0,0,0,2,0,2,0,0,0,1,1,1,6,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,0,3,0,3,3,3,0,2,0,0,2,2,2,0,2,0,0,2,2,2,0,2,0,0,3,3,3,0,3,0,3,1,6,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,2,0,0,0,0,2,2,2,0,2,0,0,0,2,2,0,2,0,0,0,2,2,2,0,0,0,0,7,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,2,3,3,3,0,2,0,0,2,2,2,2,2,0,0,2,2,2,4,0,0,0,2,2,2,2,0,0,2,3,3,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,1,0,0,2,0,2,0,2,0,0,0,0,4,0,2,0,0,0,2,4,0,2,0,0,0,0,2,0,2,0,0,2,1,8,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	7,3,0,2,0,0,2,2,2,2,2,0,0,2,2,4,2,4,0,0,2,2,4,2,2,0,0,2,7,2,0,2,0,3,3,8,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,2,2,0,2,0,0,0,4,2,0,4,0,0,0,4,4,0,4,0,0,0,4,0,2,2,0,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,2,2,2,2,0,0,4,2,2,4,0,0,0,4,4,4,4,0,0,0,9,2,4,2,0,0,2,2,2,2,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	7,2,0,2,0,0,0,2,0,2,2,0,0,0,4,4,4,0,0,0,4,4,0,4,2,0,0,0,2,0,2,0,0,0,2,7,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,3,2,2,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,2,2,4,4,2,0,0,2,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,2,0,0,0,4,4,4,4,0,0,0,4,4,4,9,0,0,0,4,0,4,4,0,0,0,7,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,2,2,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,2,2,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	7,0,2,2,0,0,0,4,0,4,4,0,0,0,4,4,4,4,0,0,0,9,4,4,4,0,0,0,4,0,4,0,0,0,0,7,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,2,0,0,2,4,4,4,4,0,0,0,9,4,4,4,0,0,4,4,4,4,4,0,0,4,4,4,2,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,4,2,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,0,4,4,0,0,0,4,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,4,2,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,0,4,0,0,0,4,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	7,0,2,4,0,0,0,4,0,4,4,0,0,4,4,4,4,4,0,0,4,4,4,4,4,0,0,4,4,2,9,0,0,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,0,2,0,0,4,4,4,4,4,0,0,0,9,4,4,4,0,0,4,4,4,4,4,0,0,4,4,2,4,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,2,4,0,0,0,4,4,4,9,0,0,0,4,4,4,4,0,0,0,9,0,4,4,0,0,0,9,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,4,2,4,4,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,2,4,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	7,2,0,4,0,0,0,4,0,4,4,0,0,0,9,4,4,4,0,0,4,4,4,4,4,0,0,0,4,0,4,0,0,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,2,0,0,2,4,0,4,4,0,0,4,4,4,4,4,0,0,4,4,4,4,4,0,0,4,4,4,2,4,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,4,0,4,0,0,0,4,4,4,9,0,0,0,4,4,4,9,0,0,0,4,4,4,4,0,0,0,2,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,4,2,4,4,0,0,4,4,0,9,0,0,0,4,4,0,9,0,0,0,4,4,4,4,0,0,0,4,2,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	7,0,2,2,0,0,0,9,0,4,4,0,0,0,4,4,4,4,0,0,4,9,4,4,0,0,0,0,4,0,4,2,0,0,0,7,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,2,0,0,0,4,4,4,4,0,0,0,9,4,4,4,0,0,4,4,4,4,4,0,0,4,4,4,0,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,0,2,0,4,0,0,0,4,4,4,4,0,0,0,4,4,0,4,0,0,0,4,4,4,4,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,2,2,4,2,0,0,4,2,4,9,0,0,0,4,4,0,4,0,0,0,4,4,2,4,0,0,2,2,2,2,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	8,0,0,2,0,0,0,2,0,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,0,0,0,0,4,2,2,0,0,0,2,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,7,0,2,0,0,2,4,2,4,4,0,0,0,4,2,4,4,0,0,4,4,0,4,4,0,0,4,2,2,2,2,0,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,2,0,0,0,4,4,0,9,0,0,0,4,4,4,4,0,0,0,4,2,2,2,0,0,0,2,0,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,0,2,2,2,2,2,0,0,4,2,4,4,0,0,0,4,0,4,2,0,0,0,4,0,2,2,2,0,2,2,2,2,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	8,1,2,0,0,0,0,2,0,0,2,0,0,0,4,0,2,4,0,0,0,4,2,4,2,0,0,0,7,0,0,0,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,8,0,0,2,0,2,2,2,2,2,0,0,2,2,2,2,2,0,0,2,4,2,2,2,0,0,2,2,2,0,3,0,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,3,0,0,0,0,0,2,2,0,2,0,0,0,2,2,0,2,0,0,0,2,0,2,0,0,0,0,7,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,2,3,1,3,0,2,0,0,7,2,2,2,2,0,0,2,2,2,0,2,0,0,7,2,2,0,3,0,3,2,3,2,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,0,0,0,0,0,8,0,2,0,0,0,0,7,0,2,2,0,0,0,7,0,2,0,0,0,0,8,0,0,0,0,1,1,6,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,3,0,3,2,3,0,0,2,0,2,2,2,0,2,0,0,2,2,2,0,2,0,0,3,2,2,0,1,1,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,6,0,0,0,0,0,3,3,0,0,0,0,0,2,3,0,0,0,0,0,3,2,0,0,0,1,1,3,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,3,1,0,1,1,3,2,3,3,0,3,0,3,2,3,2,0,3,0,8,1,2,2,0,1,1,1,1,3,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,0,0,0,0,3,1,3,0,0,0,0,0,0,8,0,0,0,0,0,2,3,0,0,0,1,1,1,6,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,5,0,0,1,1,1,3,3,0,0,1,2,3,3,3,0,0,3,2,3,3,3,0,0,1,1,1,3,3,0,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,1,0,0,0,1,1,1,3,0,0,0,1,0,1,1,0,0,0,3,0,3,1,0,0,0,1,0,5,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,1,1,1,3,0,0,1,1,3,3,3,1,0,2,0,3,3,3,0,0,3,1,3,3,3,0,0,3,1,1,1,1,0,0,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,0,3,0,0,0,1,3,0,3,0,0,0,1,3,0,3,0,0,0,1,1,1,3,0,0,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,3,1,3,3,3,0,2,0,0,3,3,3,0,2,0,2,2,3,2,0,2,2,3,3,3,3,0,3,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,3,0,0,0,1,0,2,2,0,2,0,0,0,2,2,0,2,0,0,0,2,0,0,0,0,1,0,3,0,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,3,3,3,1,0,2,0,0,2,2,2,2,2,0,0,2,2,2,0,2,0,2,3,2,0,0,2,1,3,3,3,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,0,0,3,0,7,0,2,0,0,0,0,2,0,2,0,0,0,0,2,0,0,0,0,2,0,2,0,0,0,0,3,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,2,2,0,2,2,3,2,2,0,0,2,2,2,2,2,0,0,2,2,2,2,2,0,0,6,2,3,0,2,0,3,3,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,0,3,0,0,0,0,0,2,2,0,2,0,0,0,4,0,2,2,0,0,0,2,2,0,0,0,0,0,6,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,2,3,2,2,2,2,0,0,2,2,2,4,2,0,0,2,4,2,4,0,0,0,2,2,2,2,0,0,2,2,7,2,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	7,0,0,0,0,0,0,6,0,2,0,0,0,0,4,0,4,2,0,0,0,4,0,2,0,0,0,0,2,0,2,0,0,0,2,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	7,2,0,2,0,0,0,2,2,2,4,0,0,0,4,4,4,4,0,0,2,4,4,4,4,0,0,2,2,2,2,2,0,2,3,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,4,0,0,0,4,2,0,4,0,0,0,4,0,0,4,0,0,0,4,0,2,2,0,0,0,6,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,0,2,2,2,2,2,0,0,4,4,4,4,0,0,0,4,4,4,8,0,0,0,4,2,4,4,0,0,0,2,2,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,2,2,0,0,0,4,0,4,0,0,0,0,4,4,4,4,0,0,4,4,0,4,4,0,0,0,4,0,2,0,0,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,2,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,8,4,4,4,0,0,2,4,2,4,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,4,0,0,0,4,4,4,4,0,0,0,4,4,4,8,0,0,0,4,0,4,4,0,0,0,6,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,4,2,4,0,0,0,4,4,4,4,0,0,0,8,4,4,4,0,0,0,4,4,4,4,0,0,0,4,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,2,2,0,0,0,4,0,4,4,0,0,0,4,4,4,4,0,0,0,8,4,4,4,0,0,0,4,0,8,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,4,0,0,4,4,4,4,4,0,0,0,8,4,4,4,0,0,0,8,4,4,4,0,0,4,8,4,4,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,4,0,4,0,0,0,4,4,4,4,0,0,0,4,4,4,8,0,0,0,8,0,4,4,0,0,0,4,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,0,2,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,8,0,0,0,4,4,0,4,0,0,0,4,4,0,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,0,4,0,0,0,4,0,4,4,0,0,4,8,0,4,4,0,0,4,4,4,4,4,0,0,4,4,2,8,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,4,0,0,0,8,4,4,4,0,0,0,8,4,4,4,0,0,4,4,4,4,4,0,0,4,4,4,4,4,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,0,4,4,0,0,4,4,4,8,0,0,0,4,4,4,4,0,0,0,8,0,4,4,0,0,0,8,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,8,4,0,8,0,0,0,4,4,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,2,0,4,0,0,0,4,4,4,4,0,0,4,8,4,4,4,0,0,4,8,4,4,4,0,0,4,4,4,4,0,0,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,4,0,0,0,4,0,4,4,0,0,0,4,4,4,4,0,0,0,8,4,4,4,0,0,4,4,0,4,4,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,4,0,8,0,0,0,4,4,4,8,0,0,0,4,4,4,8,0,0,0,4,4,4,4,0,0,0,8,0,4,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,4,2,4,8,4,0,0,4,4,0,8,0,0,0,4,4,0,4,0,0,0,4,4,4,4,0,0,0,4,2,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,2,4,0,0,0,8,0,4,4,0,0,0,4,4,4,4,0,0,4,8,4,4,0,0,0,0,4,0,4,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,2,0,0,0,8,4,4,4,0,0,0,8,4,4,4,0,0,0,4,4,4,4,0,0,4,4,4,4,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,0,2,0,4,0,0,0,4,4,4,4,0,0,0,4,4,4,8,0,0,0,8,4,4,4,0,0,0,2,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,2,2,4,2,0,0,4,4,4,8,0,0,0,4,4,0,4,0,0,0,8,0,4,4,0,0,0,2,2,4,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,0,2,0,0,0,8,0,4,4,0,0,0,8,4,4,4,0,0,4,4,4,8,4,0,0,0,4,2,4,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,2,0,0,0,4,4,2,4,0,0,0,4,0,4,4,0,0,0,4,0,4,4,0,0,2,4,2,2,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,4,0,0,0,2,4,4,8,0,0,0,4,4,4,8,0,0,0,4,2,2,4,0,0,0,2,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,0,2,2,2,2,2,0,0,4,4,2,4,0,0,0,4,0,4,4,0,0,0,4,4,0,4,2,0,0,2,2,2,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	7,2,0,2,0,0,0,2,0,2,2,0,0,0,4,4,4,4,0,0,0,4,2,4,0,0,0,0,2,0,2,0,0,0,2,7,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,2,0,2,0,2,2,2,2,2,0,0,0,4,2,4,2,0,0,4,2,2,2,2,0,0,2,2,2,2,3,0,0,3,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,2,2,0,0,0,0,0,2,2,0,4,0,0,0,4,2,0,4,0,0,0,2,0,2,2,0,0,0,7,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,3,2,2,0,3,0,0,2,2,2,0,2,0,0,2,2,2,2,2,0,0,6,2,2,0,2,0,2,2,3,2,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,0,0,0,0,6,0,2,2,0,0,0,6,0,2,2,0,0,0,2,0,2,0,0,0,0,7,0,0,0,0,0,3,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,7,0,2,2,3,2,0,2,0,2,2,2,0,2,0,0,2,2,2,0,2,0,0,2,2,3,2,1,1,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,2,3,0,0,0,0,0,2,2,0,0,0,0,0,2,2,0,2,0,0,0,2,2,0,0,0,0,0,3,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,3,1,3,3,0,1,1,2,2,3,2,0,3,0,2,2,2,2,0,2,0,3,2,2,3,0,3,0,3,1,3,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,1,7,0,0,0,0,0,0,7,0,0,0,0,0,0,3,0,0,0,0,0,1,3,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,3,2,3,0,0,3,0,3,3,3,0,1,3,0,2,3,3,2,0,3,1,3,3,3,0,1,1,1,0,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,1,0,0,0,1,0,3,3,0,0,0,0,0,2,1,0,0,0,0,0,3,1,0,0,0,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	0,1,3,3,3,1,0,1,0,3,3,6,1,0,2,0,3,6,5,2,0,2,0,3,6,6,0,0,3,0,3,3,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,1,1,3,0,3,0,0,0,0,1,0,5,0,0,0,0,1,0,2,0,1,0,0,3,0,3,0,0,0,1,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,2,0,3,6,3,0,2,0,0,2,2,3,0,2,0,0,3,2,2,0,2,0,1,3,6,2,0,2,0,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,1,0,3,0,0,0,2,0,2,2,0,2,0,0,0,2,2,0,2,0,0,0,2,0,2,0,0,1,0,3,1,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,3,3,5,3,0,2,0,0,2,2,2,2,2,0,0,2,2,2,2,0,0,0,5,2,2,2,2,0,3,6,3,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,0,0,0,0,0,5,0,2,0,0,0,0,2,0,2,0,0,0,2,2,0,2,0,0,0,0,2,0,0,0,0,1,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,6,0,0,2,0,0,2,2,2,4,0,0,2,2,2,2,4,0,0,2,2,2,2,2,0,0,2,2,2,0,2,0,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,1,2,2,0,2,0,0,0,2,2,0,2,0,0,0,2,2,0,4,0,0,0,2,2,2,0,0,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,2,2,2,2,0,0,2,2,4,4,0,0,0,4,2,4,4,0,0,0,4,2,2,4,0,0,2,2,2,2,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,2,2,0,0,0,7,0,2,2,0,0,0,4,0,4,4,0,0,0,4,0,2,0,0,0,0,2,0,2,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,3,0,2,0,0,0,4,2,4,4,0,0,0,4,4,4,4,0,0,2,4,4,4,4,0,0,2,4,2,2,2,0,0,3,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,4,0,0,0,2,4,2,4,0,0,0,4,0,0,4,0,0,0,4,0,2,2,0,0,0,5,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,2,2,4,2,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,0,2,2,0,0,0,4,0,4,4,0,0,0,4,4,4,4,0,0,4,4,0,4,4,0,0,0,4,0,2,0,0,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,4,0,0,0,4,4,4,4,0,0,4,4,4,4,4,0,0,4,4,4,4,2,0,0,0,4,4,4,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,4,0,4,0,0,0,4,4,0,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,4,2,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	7,0,2,2,0,0,0,4,4,0,4,0,0,0,4,4,4,4,0,0,0,4,4,4,0,0,0,4,4,0,4,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,4,0,0,4,4,4,4,4,0,0,0,4,4,4,4,0,0,4,4,0,4,4,0,0,4,4,4,4,4,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,4,4,2,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	7,0,0,4,0,0,0,4,0,4,4,0,0,4,4,4,4,4,0,0,4,4,4,4,4,0,0,0,4,4,4,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,4,4,0,0,4,4,4,4,4,0,0,0,4,4,4,4,0,0,4,4,4,4,4,0,0,4,4,4,4,4,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,0,4,4,0,0,0,4,0,4,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,4,4,0,4,4,0,0,4,4,4,4,0,0,0,4,4,0,4,0,0,0,4,4,4,4,0,0,0,4,4,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,0,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,4,4,4,4,4,0,0,4,4,0,4,4,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,4,0,0,0,4,0,4,4,0,0,0,4,4,4,4,0,0,4,4,0,4,4,0,0,4,4,4,4,4,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,4,4,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,0,4,4,0,0,0,4,0,4,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,4,2,2,4,4,0,0,4,4,0,4,4,0,0,4,4,0,4,0,0,0,4,4,4,4,0,0,0,4,0,4,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	7,0,2,4,0,0,0,4,0,4,4,0,0,4,4,0,4,4,0,0,4,4,4,4,4,0,0,0,4,0,4,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,4,0,0,0,4,4,4,4,0,0,4,4,4,4,4,0,0,4,4,4,4,4,0,0,4,4,4,4,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,4,0,4,0,0,0,4,4,0,4,0,0,0,4,4,0,4,0,0,0,4,4,4,4,0,0,0,4,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,4,4,4,4,2,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,0,4,4,0,0,0,4,4,4,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,0,0,2,0,0,0,7,0,4,4,0,0,4,4,0,4,4,0,0,4,4,4,4,4,0,0,0,4,4,4,2,0,0,2,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,2,0,0,0,4,2,4,4,0,0,0,4,4,4,4,0,0,0,4,0,4,4,0,0,4,4,2,2,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,2,4,0,0,0,2,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,0,0,2,2,2,2,2,0,0,4,4,4,4,0,0,0,4,0,4,4,0,0,0,4,0,4,4,0,0,0,2,2,2,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,0,2,2,0,0,0,4,0,2,4,0,0,0,4,4,4,4,0,0,0,4,4,4,2,0,0,0,4,0,2,2,0,0,2,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,0,2,0,0,4,2,2,2,0,0,0,4,0,2,4,0,0,4,4,0,2,2,0,0,2,2,2,2,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,2,0,0,0,2,2,2,4,0,0,0,2,4,0,4,0,0,0,4,2,2,2,0,0,0,5,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,5,2,2,2,2,0,0,2,2,2,2,2,0,0,4,2,0,4,2,0,0,2,2,2,2,0,0,2,2,2,2,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,0,0,0,0,0,5,0,0,2,0,0,0,4,0,4,2,0,0,0,2,0,2,2,0,0,0,2,0,0,0,0,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,3,0,2,2,2,2,2,0,0,2,2,2,0,2,0,0,2,2,2,2,2,0,2,2,2,2,2,3,0,1,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,3,3,0,0,0,0,0,2,2,0,2,0,0,0,2,2,0,2,0,0,0,2,2,0,0,0,0,0,3,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,1,2,3,0,3,0,2,2,2,2,0,2,0,2,2,2,2,0,2,0,2,2,2,2,0,3,0,3,1,3,2,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,1,0,0,0,1,0,3,0,2,0,1,0,0,5,0,0,0,0,0,0,2,0,0,0,0,0,0,3,0,0,0,1,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,0,0,1,1,3,2,3,0,0,3,0,2,2,3,2,0,2,0,2,3,2,2,1,2,2,1,3,3,0,1,3,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,3,0,0,0,0,0,3,3,0,0,0,0,0,3,1,0,0,0,0,0,3,1,0,0,0,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	1,1,3,3,3,1,0,2,0,2,3,6,1,0,2,0,2,1,6,1,2,2,0,3,6,3,2,0,1,1,5,3,3,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,0,0,3,0,3,0,1,0,0,2,0,6,0,2,0,0,0,0,2,0,0,0,0,2,1,2,0,0,0,1,1,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,1,1,0,1,2,2,2,2,0,0,2,2,2,2,2,0,0,2,2,2,2,2,0,0,2,3,2,0,1,2,3,3,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,1,0,2,0,2,0,0,1,2,0,0,2,0,0,0,2,0,2,2,0,0,0,2,2,1,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,3,6,1,2,2,0,0,2,2,2,2,2,0,0,4,2,2,4,0,0,0,2,2,2,2,0,0,1,2,3,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,2,0,0,2,0,6,0,2,2,0,0,0,4,0,2,0,0,0,2,4,0,2,0,0,0,2,2,0,2,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,3,2,2,0,0,0,2,2,2,2,0,0,2,4,2,4,4,0,0,2,4,4,2,2,0,0,2,2,2,2,2,0,1,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,2,0,0,0,4,2,0,4,0,0,0,4,0,2,2,0,0,0,4,2,0,2,0,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,2,2,4,2,0,0,4,4,2,4,0,0,0,4,4,4,4,0,0,0,4,2,4,4,0,0,2,2,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,0,2,0,0,0,7,0,2,2,0,0,0,4,4,4,4,0,0,0,4,0,4,2,0,0,0,4,0,2,0,0,0,2,6,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,2,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,4,4,4,4,4,0,0,2,4,2,4,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,4,0,0,0,4,2,4,4,0,0,0,4,4,0,4,0,0,0,4,0,2,4,0,0,0,7,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,2,4,4,2,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,2,0,4,0,0,0,4,0,4,4,0,0,0,4,4,4,4,0,0,4,4,4,4,4,0,0,4,4,0,4,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,4,0,0,0,4,4,4,4,0,0,4,4,4,4,4,0,0,0,4,4,4,0,0,0,2,4,4,4,4,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,7,0,0,0,4,0,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,7,0,4,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,4,4,2,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	7,0,2,4,0,0,0,7,0,4,4,0,0,0,4,4,4,4,0,0,4,4,4,4,4,0,0,0,4,4,4,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,4,4,0,0,0,7,4,4,4,0,0,0,4,4,4,4,0,0,4,4,4,4,4,0,0,4,4,4,4,4,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,4,4,4,4,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,7,0,0,0,4,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,0,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,0,4,0,0,4,4,4,4,4,0,0,4,4,4,4,4,0,0,4,4,4,4,4,0,0,0,4,4,4,0,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,4,4,4,4,4,0,0,4,4,4,4,4,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,4,4,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,4,4,4,4,4,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,0,4,0,0,0,4,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,0,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,4,4,4,4,4,0,0,4,4,4,4,4,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,4,4,0,0,0,4,4,4,4,0,0,4,4,4,4,4,0,0,4,4,4,4,4,0,0,4,4,4,4,4,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,4,4,0,7,4,0,0,4,4,0,4,0,0,0,4,4,0,4,0,0,0,4,4,4,4,0,0,0,7,4,2,4,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	7,0,4,4,0,0,0,4,0,4,4,0,0,4,4,4,4,4,0,0,4,4,4,4,4,0,0,4,4,4,4,0,0,0,2,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,4,4,4,4,0,0,0,4,4,4,4,2,0,0,4,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,4,0,4,4,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,4,4,4,4,0,0,4,4,4,4,0,0,0,4,0,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,0,4,0,0,0,7,4,4,4,0,0,4,4,0,4,4,0,0,4,4,4,4,4,0,0,0,4,4,7,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,4,0,0,0,7,0,4,4,0,0,0,4,4,4,4,0,0,4,4,0,4,4,0,0,2,4,4,2,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,4,0,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,4,4,4,0,0,0,4,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,2,2,4,2,0,0,4,0,4,4,0,0,0,4,4,4,4,0,0,0,4,0,4,4,0,0,0,4,2,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,2,2,2,0,0,0,4,4,4,4,0,0,0,7,4,4,4,0,0,4,4,4,4,4,0,0,0,4,0,4,2,0,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,2,2,0,0,4,2,2,4,0,0,0,4,0,4,4,0,0,4,4,0,2,2,0,0,2,2,2,2,2,0,0,6,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,2,0,4,0,0,0,2,4,4,7,0,0,0,4,4,0,4,0,0,0,4,4,2,4,0,0,0,6,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,2,0,2,2,2,2,2,0,0,4,2,2,4,2,0,0,4,2,4,4,0,0,0,2,2,4,2,0,0,0,2,2,2,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,2,0,0,0,0,2,0,2,2,0,0,0,4,0,4,2,0,0,0,4,0,4,2,0,0,0,2,0,2,2,0,0,1,6,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,1,1,2,0,2,2,0,2,2,0,0,2,4,2,2,2,0,0,2,2,2,2,2,0,0,2,2,2,0,1,0,1,3,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,2,1,0,2,0,0,0,2,2,0,2,0,0,0,2,2,0,2,0,0,0,2,2,2,2,2,0,0,2,2,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,2,1,2,2,0,1,0,0,2,2,2,2,2,0,0,2,2,2,2,2,0,0,2,2,2,0,1,0,1,1,2,1,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,1,0,0,1,0,1,6,2,0,0,2,0,0,2,0,2,0,0,0,0,2,0,2,2,0,0,0,2,2,0,0,1,0,1,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,0,0,3,1,2,1,1,2,1,1,0,2,2,2,2,2,2,0,2,2,2,0,1,0,1,2,1,6,0,1,1,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,1,0,1,3,0,0,0,0,0,2,2,0,0,0,0,0,1,2,0,0,0,0,0,2,1,0,0,1,0,0,3,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	2,2,2,2,2,2,0,1,0,0,2,1,1,1,1,0,0,4,1,1,1,1,0,1,2,1,1,1,1,0,2,2,2,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,0,0,2,0,1,0,1,0,0,1,0,1,0,1,0,0,0,0,1,0,1,0,0,0,0,1,0,2,0,0,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,0,0,1,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,2,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,1,0,1,0,0,0,1,0,1,1,0,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,1,4,1,1,1,0,0,1,1,1,3,1,0,0,1,3,1,3,0,0,0,4,1,1,1,0,0,1,1,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,1,0,0,0,1,0,1,1,0,0,0,3,0,3,0,0,0,1,3,0,1,1,0,0,0,1,0,1,0,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,1,1,1,0,0,0,5,1,1,3,0,0,1,3,1,3,3,0,0,0,3,3,3,1,0,0,1,3,1,1,1,0,0,2,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,1,0,4,0,0,0,3,1,0,3,0,0,0,3,1,1,3,0,0,0,3,0,1,3,0,0,0,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,1,1,1,3,3,0,0,3,3,3,3,0,0,0,3,3,3,3,0,0,0,3,3,3,3,0,0,0,4,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,0,1,0,0,0,3,0,1,1,0,0,0,5,0,3,1,0,0,0,3,1,3,0,0,0,1,3,1,5,0,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,1,3,0,0,0,5,3,3,3,0,0,3,5,3,3,3,0,0,3,3,3,3,3,0,0,1,3,1,3,3,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,3,0,3,0,0,0,3,3,0,3,0,0,0,3,3,0,3,0,0,0,3,0,1,3,0,0,0,3,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,1,3,1,3,1,0,0,3,3,3,5,0,0,0,3,3,3,3,0,0,0,5,3,3,3,0,0,0,3,1,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,1,3,0,0,0,3,0,3,3,0,0,0,3,3,3,3,0,0,3,3,3,3,3,0,0,3,3,0,3,0,0,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,3,3,0,0,0,5,3,3,3,0,0,0,3,3,3,3,0,0,0,3,3,3,0,0,0,0,3,3,3,3,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,3,3,3,0,0,0,3,3,3,3,0,0,0,3,3,3,3,0,0,0,5,3,3,3,0,0,0,5,0,3,1,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,3,3,1,3,0,0,0,3,3,1,3,0,0,0,3,3,0,5,0,0,0,3,3,3,5,0,0,0,3,1,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,0,1,3,0,0,0,5,0,3,3,0,0,0,3,3,3,3,0,0,3,3,3,3,3,0,0,0,3,3,3,0,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,3,3,0,0,0,5,3,3,3,0,0,0,5,3,3,3,0,0,3,3,0,3,3,0,0,3,3,3,3,3,0,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,3,3,3,3,3,0,0,3,3,3,3,0,0,0,3,3,3,3,0,0,0,3,0,3,3,0,0,0,3,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,0,3,3,3,3,0,0,0,3,3,3,3,0,0,0,3,3,1,3,0,0,0,5,3,3,3,0,0,0,3,3,1,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,1,3,0,0,0,3,0,3,3,0,0,3,5,0,3,3,0,0,3,3,3,3,0,0,0,3,3,3,5,0,0,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,3,3,0,0,0,5,3,3,3,0,0,0,5,3,3,3,0,0,3,3,3,3,3,0,0,3,3,3,3,3,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,3,3,3,3,3,0,0,3,3,3,5,0,0,0,3,3,3,3,0,0,0,3,3,3,3,0,0,0,3,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,3,3,3,3,3,0,0,3,3,3,3,0,0,0,3,3,3,3,0,0,0,5,3,3,3,0,0,0,3,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,3,0,3,0,0,0,3,3,3,3,0,0,0,3,3,3,3,0,0,3,3,0,3,3,0,0,3,3,3,3,3,0,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,3,3,0,0,0,3,0,3,3,0,0,3,3,3,3,3,0,0,3,3,3,3,3,0,0,0,3,3,3,3,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,3,3,3,5,0,0,0,3,3,3,3,0,0,0,3,3,0,3,0,0,0,3,3,3,5,0,0,0,5,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,3,3,0,5,3,0,0,3,3,0,5,0,0,0,3,1,0,5,0,0,0,3,3,0,5,0,0,0,3,3,1,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,0,3,3,0,0,0,5,3,3,3,0,0,0,3,3,3,3,0,0,3,5,3,3,3,0,0,3,3,3,5,0,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,3,3,0,0,0,5,0,3,3,0,0,0,5,3,3,3,0,0,3,3,3,3,0,0,0,3,3,3,3,1,0,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,3,0,5,0,0,0,3,3,3,3,0,0,0,3,3,3,3,0,0,0,3,3,3,3,0,0,0,3,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,3,3,3,3,3,0,0,3,3,3,5,0,0,0,3,0,3,3,0,0,0,3,3,3,5,0,0,0,3,3,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,3,0,0,0,5,0,3,3,0,0,0,3,3,3,3,0,0,3,3,3,3,3,0,0,0,3,3,5,0,0,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,1,3,0,0,0,5,3,3,3,0,0,0,3,3,3,3,0,0,0,3,3,3,0,0,0,3,3,1,3,1,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,3,3,0,5,0,0,0,3,3,3,5,0,0,0,3,3,3,5,0,0,0,3,3,3,3,0,0,0,3,1,3,1,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,1,1,1,3,1,0,0,3,3,3,3,0,0,0,3,3,0,3,0,0,0,3,1,0,3,0,0,0,3,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,1,3,0,0,0,3,0,3,3,0,0,0,5,3,3,3,0,0,1,3,3,3,3,0,0,3,3,0,3,1,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,1,1,0,0,1,3,0,1,3,0,0,0,3,0,3,3,0,0,3,3,0,3,1,0,0,3,3,1,1,1,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,3,0,3,0,0,0,3,1,3,5,0,0,0,3,3,3,3,0,0,0,3,3,1,3,0,0,0,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,1,1,1,1,1,0,0,3,0,3,3,3,0,0,3,1,0,3,0,0,0,3,1,1,3,0,0,1,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,0,1,0,0,0,4,0,1,3,0,0,0,3,0,3,1,0,0,0,5,3,3,1,0,0,0,4,0,1,1,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,1,0,1,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,1,3,1,1,1,0,0,1,1,1,0,1,0,1,2,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,1,0,1,0,0,0,1,1,0,3,0,0,0,3,1,0,3,0,0,0,1,0,1,1,0,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,1,1,1,0,1,0,0,4,1,1,1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,1,1,2,1,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,0,0,0,0,0,4,0,0,1,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,1,0,0,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,0,2,0,2,1,1,1,0,1,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,2,1,1,0,2,2,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,0,0,0,0,0,1,1,0,0,0,0,0,1,1,0,0,0,0,0,1,1,0,0,0,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	2,0,0,5,5,2,0,1,0,0,4,1,1,4,1,0,0,1,4,1,1,0,0,0,4,4,1,1,1,0,2,5,5,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,2,0,0,0,0,1,0,1,0,0,0,0,1,0,1,1,0,0,1,1,0,1,0,0,0,1,1,0,0,0,0,1,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,0,1,0,0,1,1,1,1,1,0,0,1,4,1,1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,1,0,1,0,1,0,0,0,1,1,0,1,0,0,0,3,0,0,1,0,0,0,1,1,0,1,0,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,1,1,1,3,1,0,0,1,1,3,3,0,0,0,3,1,3,3,0,0,0,3,1,1,3,0,0,0,4,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,1,0,0,0,4,0,3,1,0,0,0,3,0,3,1,0,0,1,3,0,3,0,0,0,0,1,0,1,0,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,1,1,0,0,0,6,1,3,3,0,0,0,6,3,3,3,0,0,0,6,3,3,3,0,0,1,3,1,1,1,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,1,0,4,0,0,0,3,3,1,3,0,0,0,3,1,3,3,0,0,0,3,1,1,3,0,0,0,3,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,1,3,3,6,0,0,0,3,3,1,3,0,0,0,3,3,1,3,0,0,0,3,3,3,3,0,0,0,3,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,1,1,0,0,0,6,0,1,3,0,0,0,3,3,3,3,0,0,3,3,0,3,1,0,0,3,3,1,3,0,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,3,3,0,0,0,6,3,3,3,0,0,0,3,3,3,3,0,0,0,6,3,3,3,0,0,0,3,1,3,3,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,3,0,6,0,0,0,3,3,3,3,0,0,0,3,3,0,6,0,0,0,3,0,1,3,0,0,0,3,0,3,1,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,1,3,1,3,0,0,0,3,3,3,3,0,0,0,3,3,3,6,0,0,0,6,3,3,3,0,0,0,3,3,1,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,3,0,0,0,6,0,3,3,0,0,0,3,3,3,3,0,0,3,6,0,3,3,0,0,3,3,0,3,3,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,3,3,0,0,0,3,3,3,3,0,0,0,3,3,3,3,0,0,0,6,3,3,0,0,0,0,3,3,3,3,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,3,3,3,6,0,0,0,3,3,3,6,0,0,0,3,3,3,3,0,0,0,6,3,3,3,0,0,0,3,0,3,1,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,1,3,3,3,0,0,0,3,3,0,6,0,0,0,6,3,0,6,0,0,0,3,3,3,6,0,0,0,6,3,1,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,3,3,0,0,0,6,3,3,3,0,0,0,6,0,3,3,0,0,3,3,3,3,3,0,0,0,3,3,3,0,0,0,3,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,3,3,3,0,0,0,6,0,3,3,0,0,0,6,3,3,3,0,0,3,3,0,3,3,0,0,3,3,3,3,3,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,3,3,0,3,3,0,0,3,3,3,3,0,0,0,3,3,3,3,0,0,0,6,0,3,3,0,0,0,3,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,3,3,3,3,0,0,0,3,3,3,3,0,0,0,3,3,3,6,0,0,0,3,3,0,3,0,0,0,6,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,3,3,0,0,0,6,3,3,3,0,0,3,6,0,3,3,0,0,3,3,3,3,3,0,0,3,3,3,6,0,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,3,3,3,0,0,0,6,0,3,3,0,0,0,6,3,3,3,0,0,3,3,0,6,3,0,0,3,3,3,3,3,0,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,3,3,3,3,3,0,0,3,3,3,6,0,0,0,3,3,3,3,0,0,0,6,3,0,6,0,0,0,3,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,3,3,3,3,0,0,0,3,3,3,3,0,0,0,3,3,0,6,0,0,0,3,3,0,6,0,0,0,3,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,3,3,3,0,0,0,6,3,3,3,0,0,0,6,3,3,3,0,0,0,3,3,3,3,0,0,3,6,0,6,3,0,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,1,3,0,0,0,3,0,3,3,0,0,0,3,3,3,3,0,0,3,3,3,3,0,0,0,3,3,3,3,3,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,3,3,3,6,3,0,0,3,3,3,6,0,0,0,3,3,1,3,0,0,0,6,3,3,3,0,0,0,6,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,0,3,3,0,6,0,0,0,3,3,0,6,0,0,0,3,3,0,6,0,0,0,3,3,3,3,0,0,0,6,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,3,3,0,0,0,6,3,3,3,0,0,0,3,3,3,3,0,0,3,6,3,3,3,0,0,0,3,3,6,0,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,3,3,0,0,0,6,0,3,3,0,0,0,6,3,3,3,0,0,0,3,3,3,3,0,0,3,3,0,3,3,0,0,3,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,3,3,3,0,0,0,3,3,3,3,0,0,0,3,3,0,6,0,0,0,3,3,3,3,0,0,0,6,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,3,3,3,6,0,0,0,3,3,3,6,0,0,0,3,3,0,3,0,0,0,3,1,3,3,0,0,0,6,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,1,3,0,0,0,6,0,3,3,0,0,0,6,3,3,3,0,0,3,3,3,3,3,0,0,0,3,3,6,0,0,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,3,3,0,0,0,6,3,3,3,0,0,0,3,3,3,3,0,0,0,6,0,3,3,0,0,3,3,3,3,1,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,3,3,0,6,0,0,0,3,3,3,6,0,0,0,3,3,3,6,0,0,0,3,3,3,3,0,0,0,3,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,1,1,0,3,3,0,0,3,3,0,6,0,0,0,3,3,0,3,0,0,0,3,0,3,3,0,0,0,3,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,1,3,0,0,0,6,0,3,3,0,0,0,6,3,3,3,0,0,3,3,3,3,3,0,0,0,3,3,3,1,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,1,3,0,0,0,3,0,1,3,0,0,0,3,3,0,3,0,0,3,3,0,3,3,0,0,3,3,0,3,1,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,3,1,6,0,0,0,3,3,3,6,0,0,0,3,3,3,3,0,0,0,3,1,3,3,0,0,0,4,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,1,1,1,3,0,0,0,3,1,0,3,0,0,0,3,1,0,3,0,0,0,3,0,3,3,0,0,0,3,0,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,1,1,0,0,0,6,1,3,3,0,0,0,3,3,3,3,0,0,0,6,3,6,1,0,0,0,3,1,1,1,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,1,1,0,0,1,1,0,1,3,0,0,1,3,0,3,1,0,0,3,1,0,3,1,0,0,1,1,0,1,1,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,4,0,1,0,0,0,1,1,0,6,0,0,0,3,3,0,3,0,0,0,3,1,1,1,0,0,0,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,3,0,1,1,1,0,0,1,1,1,1,1,0,1,1,1,1,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,0,1,0,0,0,0,1,0,1,1,0,0,0,1,0,1,1,0,0,0,3,0,1,1,0,0,0,1,0,0,0,0,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,0,1,0,1,1,0,1,1,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,1,1,1,0,2,0,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,2,0,1,0,0,0,1,1,0,1,0,0,0,1,0,0,1,0,0,0,1,0,1,0,0,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	1,0,0,3,3,1,1,1,0,0,1,3,1,1,1,0,0,1,1,1,3,1,0,0,3,1,1,1,0,0,1,1,3,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,0,1,0,0,0,1,0,1,0,0,0,1,1,0,1,1,0,0,0,2,0,1,1,0,0,1,1,1,1,0,0,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,3,1,1,0,0,1,1,1,1,1,0,0,0,4,1,2,2,0,0,1,2,1,1,1,0,0,1,1,1,1,1,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,1,0,1,0,0,0,2,1,0,2,0,0,0,2,0,0,2,0,0,0,2,0,1,1,0,0,0,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,1,1,1,3,1,0,0,2,1,2,4,0,0,0,2,2,1,2,0,0,0,2,1,1,2,0,0,0,3,3,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,1,1,0,0,0,2,0,1,2,0,0,0,2,1,1,2,0,0,2,2,0,2,1,0,0,2,2,0,1,0,0,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,1,1,0,0,0,4,1,2,2,0,0,0,2,2,2,2,0,0,0,2,1,2,1,0,0,1,2,1,2,1,0,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,1,0,2,0,0,0,2,2,1,2,0,0,0,2,1,2,4,0,0,0,2,2,0,2,0,0,0,2,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,1,2,2,4,0,0,0,2,2,1,4,0,0,0,2,2,2,2,0,0,0,2,2,2,2,0,0,0,2,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,1,2,0,0,0,2,0,1,2,0,0,0,2,2,2,2,0,0,2,2,2,2,2,0,0,0,2,1,2,0,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,1,2,2,0,0,0,4,2,2,2,0,0,0,2,2,2,2,0,0,0,4,2,2,1,0,0,2,2,2,4,2,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,2,2,0,0,2,2,2,2,0,0,0,2,1,0,2,0,0,0,4,0,1,2,0,0,0,4,0,2,1,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,0,0,0,2,2,2,4,0,0,0,2,2,2,4,0,0,0,4,2,2,2,0,0,0,4,2,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,0,2,0,0,0,4,0,2,2,0,0,0,4,0,2,2,0,0,2,4,0,2,2,0,0,2,2,2,2,0,0,0,2,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,1,2,2,0,0,0,4,2,2,2,0,0,0,4,2,2,2,0,0,0,4,2,2,2,0,0,1,2,2,2,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,4,0,0,0,2,2,2,4,0,0,0,2,2,2,2,0,0,0,2,0,2,2,0,0,0,4,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,0,0,0,2,2,2,2,0,0,0,2,2,2,2,0,0,0,2,2,2,4,0,0,0,4,2,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,2,2,0,0,0,4,0,2,2,0,0,0,2,2,2,2,0,0,0,4,2,2,2,0,0,0,2,2,2,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,4,1,2,2,0,0,0,4,2,2,2,0,0,2,2,2,2,2,0,0,2,2,1,2,2,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,2,2,0,0,2,2,1,2,0,0,0,2,2,0,2,0,0,0,4,0,2,4,0,0,0,2,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,2,0,0,0,2,2,2,4,0,0,0,2,2,2,4,0,0,0,2,2,2,4,0,0,0,4,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,2,2,0,0,0,4,0,2,2,0,0,0,4,0,2,1,0,0,0,4,2,2,2,0,0,0,2,2,4,0,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,4,2,2,2,0,0,0,4,2,2,2,0,0,2,2,0,4,0,0,0,2,2,2,2,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,4,0,0,0,2,2,2,4,0,0,0,2,2,2,4,0,0,0,2,2,2,2,0,0,0,2,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,2,2,2,0,0,0,2,2,2,2,0,0,0,2,2,0,2,0,0,0,2,2,1,2,0,0,0,2,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,2,0,0,0,4,2,2,2,0,0,2,2,2,2,2,0,0,2,2,2,2,2,0,0,2,2,2,2,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,2,2,0,0,0,2,0,2,2,0,0,0,2,2,2,2,0,0,2,2,1,2,0,0,0,1,2,2,2,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,4,0,0,0,2,2,0,4,0,0,0,2,2,1,2,0,0,0,4,2,2,2,0,0,0,4,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,2,2,0,4,2,0,0,2,2,0,4,0,0,0,2,1,2,2,0,0,0,4,2,2,2,0,0,0,4,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,2,0,0,0,4,2,2,2,0,0,0,2,2,2,2,0,0,2,2,2,2,2,0,0,0,2,2,4,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,4,0,2,2,0,0,0,4,2,2,2,0,0,0,2,2,2,0,0,0,2,2,0,2,2,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,2,2,0,0,0,2,2,2,2,0,0,0,2,2,1,4,0,0,0,4,2,2,2,0,0,0,4,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,2,2,2,2,2,0,0,2,2,2,4,0,0,0,2,2,1,2,0,0,0,2,1,2,4,0,0,0,2,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,1,2,0,0,0,4,2,2,2,0,0,0,2,2,2,2,0,0,2,2,2,2,2,0,0,0,2,2,4,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,2,0,0,0,4,0,2,2,0,0,0,2,2,2,2,0,0,0,2,2,2,2,0,0,2,2,2,2,2,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,0,0,0,2,2,2,4,0,0,0,2,2,2,4,0,0,0,2,2,2,2,0,0,0,4,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,2,1,0,4,2,0,0,2,2,2,2,0,0,0,2,2,0,4,0,0,0,2,0,2,2,0,0,0,2,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,1,1,2,0,0,0,4,1,2,2,0,0,0,4,2,2,2,0,0,0,2,2,2,2,0,0,1,2,2,2,1,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,1,1,2,0,0,0,4,0,1,2,0,0,0,2,2,2,2,0,0,2,2,0,2,1,0,0,2,1,1,2,1,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,2,4,0,0,0,2,2,2,4,0,0,0,2,2,2,4,0,0,0,2,2,2,2,0,0,0,4,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,1,1,1,2,1,0,0,2,1,0,4,0,0,0,2,1,0,4,0,0,0,2,1,0,2,0,0,0,4,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,1,1,0,0,0,2,1,2,2,0,0,0,4,0,2,2,0,0,0,4,2,4,1,0,0,1,2,1,4,0,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,1,1,0,0,0,2,0,1,2,0,0,0,2,2,1,2,0,0,1,2,0,2,2,0,0,2,2,0,1,1,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,0,1,0,4,0,0,0,1,2,1,4,0,0,0,2,1,1,4,0,0,0,2,1,1,2,0,0,0,3,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,0,1,1,1,1,1,0,0,1,1,1,2,1,0,0,2,1,0,2,0,0,0,1,1,1,1,0,0,0,3,1,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,1,0,0,0,3,0,1,1,0,0,0,2,0,1,2,0,0,0,2,1,2,1,0,0,0,3,0,3,0,0,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,1,1,1,0,1,1,1,1,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,1,1,1,0,3,0,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,1,0,1,0,0,0,1,1,0,2,0,0,0,1,1,0,1,0,0,0,3,1,0,1,0,0,0,3,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	1,0,0,1,1,1,1,1,0,0,1,1,1,4,0,0,0,2,1,1,4,0,0,0,3,1,1,1,0,0,1,3,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,1,1,0,0,0,3,0,1,1,0,0,0,3,0,1,1,0,0,1,2,0,1,1,0,0,1,1,0,1,0,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,1,1,0,0,0,4,1,1,2,0,0,0,4,2,2,2,0,0,0,2,1,2,1,0,0,1,1,1,1,1,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,1,0,3,0,0,0,2,1,0,2,0,0,0,2,0,0,4,0,0,0,2,0,1,1,0,0,0,2,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,1,1,1,2,0,0,0,2,2,2,4,0,0,0,2,2,1,2,0,0,0,2,2,2,2,0,0,0,3,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,1,1,0,0,1,2,0,2,1,0,0,0,2,1,2,2,0,0,2,2,0,2,1,0,0,1,2,0,2,0,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,1,2,0,0,0,4,2,2,2,0,0,0,2,2,2,2,0,0,1,2,2,2,1,0,0,2,2,1,2,1,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,1,0,2,0,0,0,2,2,1,2,0,0,0,2,2,0,4,0,0,0,2,2,0,2,0,0,0,2,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,2,4,0,0,0,2,2,1,4,0,0,0,2,2,2,2,0,0,0,2,2,2,2,0,0,0,2,2,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,0,2,0,0,2,4,0,1,2,0,0,0,4,0,2,2,0,0,1,2,0,2,1,0,0,2,2,0,4,0,0,0,2,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,2,2,0,0,0,4,2,2,2,0,0,0,4,2,2,2,0,0,0,4,2,4,0,0,0,1,4,2,4,2,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,4,0,0,0,2,2,0,4,0,0,0,2,2,0,4,0,0,0,2,2,2,2,0,0,0,2,0,2,1,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,0,0,0,2,2,2,4,0,0,0,2,2,1,4,0,0,0,4,2,2,2,0,0,0,2,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,0,2,0,0,0,4,0,2,2,0,0,0,2,2,2,2,0,0,2,2,0,2,2,0,0,0,2,0,2,2,0,0,2,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,2,2,0,0,0,2,2,2,2,0,0,0,4,2,2,2,0,0,0,4,2,2,2,0,0,2,4,2,4,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,2,0,0,0,2,2,2,4,0,0,0,2,2,0,4,0,0,0,2,2,0,2,0,0,0,4,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,2,2,0,0,0,2,2,1,4,0,0,0,2,2,2,2,0,0,0,2,2,2,4,0,0,0,4,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,4,0,2,2,0,0,0,4,0,2,2,0,0,0,4,0,2,2,0,0,0,2,1,2,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,4,1,2,2,0,0,0,4,2,2,2,0,0,2,2,2,4,2,0,0,2,2,2,2,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,4,0,0,0,2,1,2,2,0,0,0,2,2,0,2,0,0,0,4,0,2,4,0,0,0,2,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,4,0,0,0,2,2,2,4,0,0,0,2,2,1,4,0,0,0,4,0,2,2,0,0,0,4,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,2,2,0,0,0,4,2,2,2,0,0,0,4,0,2,2,0,0,0,4,2,2,2,0,0,2,2,2,4,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,4,0,2,2,0,0,0,2,2,2,2,0,0,0,4,0,4,0,0,0,2,2,2,4,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,4,0,0,0,2,2,2,4,0,0,0,2,2,2,4,0,0,0,2,2,1,2,0,0,0,4,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,0,0,0,2,2,2,4,0,0,0,2,1,1,4,0,0,0,4,0,2,4,0,0,0,4,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,4,2,2,2,0,0,0,4,2,2,2,0,0,0,4,2,2,2,0,0,2,4,0,4,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,1,2,2,0,0,0,4,0,2,2,0,0,0,4,0,2,2,0,0,0,4,0,2,0,0,0,1,2,2,4,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,2,2,0,0,2,2,2,4,0,0,0,2,2,1,4,0,0,0,4,2,2,2,0,0,0,4,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,4,0,0,0,2,2,0,4,0,0,0,2,1,0,4,0,0,0,4,2,2,2,0,0,0,4,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,4,1,2,2,0,0,0,2,2,2,2,0,0,0,4,2,2,2,0,0,0,2,2,4,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,4,0,2,2,0,0,0,4,2,2,2,0,0,2,2,2,2,0,0,0,2,2,0,2,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,0,0,0,2,2,2,2,0,0,0,2,2,1,4,0,0,0,4,2,2,2,0,0,0,4,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,4,0,0,0,2,2,2,4,0,0,0,2,2,0,4,0,0,0,2,2,0,2,0,0,0,4,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,2,2,0,0,0,4,1,2,2,0,0,0,4,0,2,2,0,0,0,2,2,4,2,0,0,2,2,2,4,0,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,1,2,0,0,0,4,0,2,2,0,0,0,2,2,2,2,0,0,2,2,0,2,0,0,0,1,2,2,2,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,2,0,0,0,2,2,2,4,0,0,0,2,2,2,4,0,0,0,2,2,2,2,0,0,0,4,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,2,1,0,4,2,0,0,2,1,2,2,0,0,0,2,2,0,2,0,0,0,4,0,2,2,0,0,0,2,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,1,2,0,0,0,4,2,2,2,0,0,0,4,2,2,2,0,0,1,2,2,2,2,0,0,2,2,2,2,1,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,1,2,0,0,0,4,0,1,2,0,0,0,4,0,2,2,0,0,2,2,0,2,2,0,0,1,2,0,2,1,0,0,2,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,2,4,0,0,0,2,2,2,4,0,0,0,2,1,2,2,0,0,0,2,2,2,2,0,0,0,4,1,2,1,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,1,2,0,2,1,0,0,2,1,0,2,0,0,0,2,0,1,2,0,0,0,2,2,0,2,0,0,0,2,0,0,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,1,2,0,0,0,2,1,2,2,0,0,0,4,2,2,2,0,0,0,4,2,4,1,0,0,1,2,2,2,1,0,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,1,1,0,0,0,2,0,2,2,0,0,1,2,0,2,2,0,0,2,2,0,2,1,0,0,1,2,0,1,1,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,1,1,2,1,0,0,1,2,2,2,0,0,0,2,1,2,2,0,0,0,2,2,1,4,0,0,0,2,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,1,1,1,1,1,0,0,2,1,1,2,0,0,0,2,2,0,2,1,0,0,2,1,0,2,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,0,1,0,0,0,1,0,1,1,0,0,0,4,1,2,1,0,0,0,2,1,2,1,0,0,0,1,1,1,1,0,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,1,1,0,0,1,1,1,1,1,0,0,0,2,0,1,1,0,0,1,1,0,1,1,0,0,1,1,1,1,1,0,0,3,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,1,0,1,0,0,0,1,1,0,2,0,0,0,1,1,0,2,0,0,0,1,1,0,1,0,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	1,0,0,1,1,1,3,1,0,0,1,2,2,4,0,0,0,1,2,1,2,0,0,0,2,1,1,4,0,0,0,3,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,1,1,0,0,0,2,0,1,1,0,0,0,4,0,2,1,0,0,1,2,0,2,1,0,0,1,1,0,3,0,0,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,1,1,0,0,0,2,1,2,1,0,0,1,4,1,2,2,0,0,1,2,2,2,1,0,0,1,1,2,2,1,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,1,1,2,0,0,0,2,1,0,2,0,0,0,2,1,0,2,0,0,0,2,1,1,1,0,0,0,2,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,1,2,1,5,1,0,0,2,2,2,2,0,0,0,2,2,1,5,0,0,0,2,2,2,2,0,0,0,4,1,1,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,1,2,0,0,0,2,0,1,2,0,0,0,2,1,2,2,0,0,1,2,0,2,1,0,0,1,2,0,2,0,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,1,2,2,0,0,0,2,2,2,2,0,0,0,5,2,2,2,0,0,0,5,1,5,1,0,0,2,2,2,2,1,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,1,0,2,1,0,0,2,2,1,2,0,0,0,2,1,1,5,0,0,0,2,2,0,2,0,0,0,2,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,5,0,0,0,2,2,2,2,0,0,0,2,2,1,2,0,0,0,2,2,2,2,0,0,0,5,2,2,1,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,0,1,2,0,0,0,2,0,1,2,0,0,0,2,1,2,2,0,0,1,2,1,2,2,0,0,2,2,0,5,0,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,2,2,2,0,0,0,5,2,2,2,0,0,0,5,2,2,2,0,0,0,5,2,2,1,0,0,1,5,2,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,5,1,0,0,2,1,1,2,0,0,0,2,1,1,5,0,0,0,5,0,1,2,0,0,0,5,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,5,0,0,0,2,2,2,5,0,0,0,2,2,1,5,0,0,0,2,2,1,2,0,0,0,5,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,1,1,2,0,0,0,2,0,2,2,0,0,0,2,1,2,2,0,0,1,2,0,2,2,0,0,2,2,0,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,1,2,2,0,0,0,2,2,2,2,0,0,0,5,2,2,2,0,0,1,5,2,2,2,0,0,1,5,2,5,0,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,5,0,0,0,2,2,1,2,0,0,0,2,1,2,2,0,0,0,2,0,2,2,0,0,0,2,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,5,0,0,0,2,2,2,2,0,0,0,2,2,1,5,0,0,0,2,2,2,2,0,0,0,5,2,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,1,2,2,0,0,0,2,0,1,2,0,0,0,5,0,2,2,0,0,0,5,0,2,1,0,0,1,2,1,2,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,2,2,2,0,0,0,5,1,2,2,0,0,0,5,2,2,2,0,0,1,2,2,2,2,0,0,1,2,1,5,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,0,5,1,0,0,2,2,1,5,0,0,0,2,1,1,5,0,0,0,5,0,2,5,0,0,0,2,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,5,0,0,0,2,2,2,5,0,0,0,2,2,1,5,0,0,0,2,2,2,2,0,0,0,5,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,0,2,2,0,0,0,5,0,2,2,0,0,0,5,1,2,2,0,0,0,5,1,2,1,0,0,1,2,1,2,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,2,1,2,0,0,0,5,1,2,2,0,0,0,2,1,2,1,0,0,1,2,1,2,1,0,0,2,2,2,5,0,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,5,0,0,0,2,2,1,2,0,0,0,2,1,2,5,0,0,0,2,2,1,2,0,0,0,2,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,2,0,0,0,2,2,2,2,0,0,0,2,1,0,5,0,0,0,5,1,1,2,0,0,0,5,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,2,2,2,0,0,0,5,1,2,2,0,0,0,5,2,2,2,0,0,0,5,1,2,2,0,0,2,5,0,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,1,1,2,0,0,0,5,1,1,2,0,0,0,2,2,2,2,0,0,0,5,0,2,1,0,0,1,2,2,5,0,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,5,0,0,0,2,2,2,5,0,0,0,2,2,1,5,0,0,0,2,2,2,2,0,0,0,5,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,2,1,0,0,2,2,0,5,0,0,0,2,1,0,5,0,0,0,5,1,2,2,0,0,0,5,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,2,2,2,0,0,0,5,1,2,2,0,0,0,2,1,2,2,0,0,0,5,1,2,2,0,0,0,2,1,5,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,1,2,2,0,0,0,5,0,2,2,0,0,0,5,1,2,2,0,0,2,2,2,2,1,0,0,2,2,1,2,1,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,2,2,0,0,0,2,2,1,5,0,0,0,2,1,2,2,0,0,0,2,2,2,2,0,0,0,5,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,5,0,0,0,2,2,2,5,0,0,0,2,2,0,5,0,0,0,2,1,2,2,0,0,0,5,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,1,2,2,0,0,0,2,1,2,2,0,0,0,2,2,2,2,0,0,0,2,1,2,1,0,0,1,2,2,5,0,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,1,1,2,0,0,0,5,0,2,2,0,0,0,2,1,2,2,0,0,2,2,1,2,2,0,0,2,2,0,2,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,1,5,1,0,0,2,2,2,2,0,0,0,2,2,2,5,0,0,0,2,2,2,2,0,0,0,5,1,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,2,1,1,2,0,0,0,2,1,2,2,0,0,0,2,1,0,5,0,0,0,2,0,2,2,0,0,0,5,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,2,1,2,0,0,0,5,1,2,2,0,0,0,5,2,2,2,0,0,0,5,2,2,2,0,0,2,2,1,5,0,0,0,1,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,1,2,0,0,0,5,0,1,2,0,0,0,2,1,2,2,0,0,1,2,1,2,1,0,0,1,2,1,2,1,0,0,2,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,5,0,0,0,2,2,2,5,0,0,0,2,2,1,5,0,0,0,2,2,2,2,0,0,0,4,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,1,2,0,2,1,0,0,2,1,1,2,0,0,0,2,1,0,5,0,0,0,2,1,0,2,0,0,0,2,1,1,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	4,1,1,2,0,0,0,2,1,2,2,0,0,0,2,2,2,2,0,0,0,5,2,5,1,0,0,2,2,1,2,1,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,1,2,0,0,1,2,0,1,2,0,0,0,2,1,1,2,0,0,1,2,0,2,2,0,0,2,2,0,2,1,0,0,2,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,2,1,5,0,0,0,2,2,2,5,0,0,0,2,2,1,2,0,0,0,2,2,1,2,0,0,0,2,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,0,0,1,1,0,2,1,0,0,2,1,2,2,0,0,0,2,1,0,2,0,0,0,2,1,0,2,0,0,1,1,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,1,1,1,0,0,0,2,1,1,2,0,0,0,4,1,2,2,0,0,0,5,2,2,1,0,0,1,2,1,1,0,0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	1,1,1,1,0,0,1,1,0,1,1,0,0,0,2,0,1,2,0,0,1,1,1,1,1,0,0,1,1,1,1,1,0,0,3,1,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,1,1,0,2,0,0,0,2,1,1,2,0,0,0,1,1,1,2,0,0,0,1,1,1,1,0,0,0,3,0,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0


	dc.b	2,0,0,2,2,2,5,2,0,0,3,3,2,6,0,0,0,3,3,2,3,0,0,0,3,3,3,3,0,0,0,5,2,5,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,0,2,2,0,0,0,6,0,2,2,0,0,0,3,2,3,3,0,0,2,3,0,3,2,0,0,2,3,0,2,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,2,2,2,0,0,0,8,2,3,3,0,0,2,8,2,3,3,0,0,2,8,3,3,2,0,0,2,3,3,3,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,2,3,0,0,0,3,2,0,3,0,0,0,3,2,2,3,0,0,0,3,0,2,3,0,0,0,3,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,3,3,6,0,0,0,3,8,3,3,0,0,0,3,4,3,6,0,0,0,6,3,3,3,0,0,0,6,2,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,0,2,3,0,0,2,3,0,3,6,0,0,0,3,2,3,8,0,0,2,3,2,3,3,0,0,2,3,0,6,0,0,0,2,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,2,3,3,0,0,0,8,3,3,3,0,0,0,7,4,8,4,0,0,0,7,1,8,2,0,0,3,8,3,6,2,0,0,2,5,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,3,3,0,0,3,4,2,3,0,0,0,4,1,3,6,0,0,0,3,3,0,6,0,0,0,3,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,3,8,3,3,2,0,0,3,4,4,4,0,0,0,4,4,0,3,0,0,0,3,4,4,6,0,0,0,8,3,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	8,0,2,3,0,0,0,8,0,2,3,0,0,0,4,1,4,3,0,0,2,4,1,4,4,0,0,3,4,2,3,3,0,0,2,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	8,3,3,3,0,0,0,7,4,4,4,0,0,0,7,4,4,3,0,0,0,7,4,4,1,0,0,2,7,4,8,3,0,0,2,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,3,0,3,1,0,0,4,1,1,4,0,0,0,3,3,3,3,0,0,0,7,0,1,3,0,0,0,3,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,4,8,3,0,0,0,4,4,4,7,0,0,0,3,4,1,6,0,0,0,4,4,1,4,0,0,0,8,4,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	8,2,3,3,0,0,0,4,0,4,4,0,0,2,8,1,8,3,0,0,2,4,0,4,4,0,0,4,4,0,4,3,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	8,3,3,3,0,0,0,4,4,4,4,0,0,0,8,3,3,4,0,0,0,8,3,3,3,0,0,1,7,4,7,3,0,0,2,8,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,0,4,1,3,0,0,0,3,4,1,8,0,0,0,4,1,4,8,0,0,0,6,0,4,4,0,0,0,3,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,4,1,7,0,0,0,3,4,4,6,0,0,0,4,4,1,3,0,0,0,3,4,4,4,0,0,0,8,4,1,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	8,2,3,3,0,0,0,4,0,1,3,0,0,0,7,0,2,4,0,0,0,7,0,2,3,0,0,1,4,1,4,4,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	8,3,2,4,0,0,0,3,2,3,3,0,0,0,7,4,4,4,0,0,1,4,4,4,2,0,0,1,3,2,3,1,0,0,3,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,0,1,4,0,7,0,0,0,4,4,1,3,0,0,0,3,1,1,7,0,0,0,7,0,4,7,0,0,0,4,0,1,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,1,7,2,0,0,4,4,4,8,0,0,0,3,2,2,6,0,0,0,4,4,4,4,0,0,0,7,4,4,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	8,2,2,4,0,0,0,3,2,2,4,0,0,3,8,1,8,3,0,0,2,7,1,8,1,0,0,3,3,2,3,4,0,0,3,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	8,3,3,4,0,0,2,3,2,2,4,0,0,0,6,2,3,3,0,0,0,3,2,3,1,0,0,2,3,2,2,0,0,0,3,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,8,0,0,0,4,4,1,8,0,0,0,3,3,3,6,0,0,0,4,4,1,3,0,0,0,4,1,4,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,4,4,1,8,2,0,0,3,4,4,8,0,0,0,3,2,2,6,0,0,0,7,1,1,3,0,0,0,7,1,4,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	8,3,2,4,0,0,0,3,2,3,3,0,0,0,8,3,3,3,0,0,2,3,3,3,4,0,0,2,3,2,2,1,0,0,3,4,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,3,4,0,0,0,6,2,3,4,0,0,2,8,2,3,3,0,0,2,7,2,2,1,0,0,2,3,2,3,0,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,4,4,4,7,0,0,0,4,4,4,3,0,0,0,3,2,2,3,0,0,0,4,4,4,3,0,0,0,7,1,4,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,4,4,0,4,0,0,0,4,4,0,8,0,0,0,3,1,0,3,0,0,0,7,1,4,4,0,0,0,7,1,1,8,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	8,2,3,3,0,0,0,7,2,2,4,0,0,0,4,1,3,6,0,0,2,7,0,2,4,0,0,0,2,2,3,0,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	8,2,2,3,0,0,0,7,0,4,4,0,0,0,7,1,4,4,0,0,2,4,4,3,3,0,0,4,4,1,4,1,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,0,4,4,4,0,0,0,3,4,1,7,0,0,0,4,1,4,4,0,0,0,6,4,4,4,0,0,0,8,1,4,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,3,4,0,3,0,0,0,3,4,4,8,0,0,0,4,4,0,8,0,0,0,3,1,4,4,0,0,0,8,0,2,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	8,3,2,3,0,0,0,4,1,4,3,0,0,3,8,4,4,4,0,0,2,8,1,8,3,0,0,1,4,4,7,0,0,0,3,8,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	8,2,2,6,0,0,0,7,0,4,3,0,0,2,8,1,4,4,0,0,2,8,1,4,4,0,0,4,4,0,6,3,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,4,2,8,1,0,0,4,4,4,6,0,0,0,3,4,4,8,0,0,0,4,4,4,4,0,0,0,8,2,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,3,0,3,0,0,0,4,1,4,4,0,0,0,3,1,3,3,0,0,0,4,0,4,8,0,0,0,3,0,2,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	8,3,3,3,0,0,0,8,1,4,4,0,0,0,7,4,4,3,0,0,0,7,4,4,4,0,0,3,4,1,8,3,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	6,0,2,6,0,0,0,6,0,2,3,0,0,0,4,1,4,4,0,0,2,4,1,4,3,0,0,2,2,0,3,3,0,0,3,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,3,3,2,8,0,0,0,3,4,4,7,0,0,0,4,4,3,6,0,0,0,6,4,4,8,0,0,0,8,2,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,3,3,0,3,3,0,0,3,0,2,3,0,0,0,4,1,0,3,0,0,0,3,0,2,3,0,0,0,6,2,0,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,2,3,3,0,0,0,8,2,3,3,0,0,0,4,4,8,3,0,0,2,7,4,8,2,0,0,3,6,3,6,2,0,0,2,3,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	3,0,3,3,0,0,0,8,0,3,3,0,0,0,3,0,3,8,0,0,0,3,2,3,3,0,0,3,3,0,3,3,0,0,3,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,3,2,8,0,0,0,3,3,2,6,0,0,0,3,6,3,8,0,0,0,3,3,2,8,0,0,0,3,2,3,3,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,0,0,2,2,0,3,2,0,0,3,2,2,3,0,0,0,3,2,0,3,2,0,0,3,2,2,3,0,0,0,2,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	5,2,2,5,0,0,0,6,2,3,3,0,0,0,8,3,3,3,0,0,0,8,3,3,2,0,0,0,6,2,5,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	2,2,2,2,0,0,2,3,0,2,3,0,0,0,3,0,3,3,0,0,0,3,0,3,2,0,0,2,2,2,2,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
	dc.b	0,0,0,2,2,0,3,0,0,0,3,3,2,3,0,0,0,3,3,2,6,0,0,0,3,2,2,3,0,0,0,5,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0,0


