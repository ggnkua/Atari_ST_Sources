	dc.w	%1111111111111111,%1111111111100000,%0000000000000000,%0000000001111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000011111111111,%1111111111111111,%1110000000000000,%0000000000000000,%0111111111111111,%1111111111111110,%0000000000000000,%0000000000000111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000001111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000011111111111,%1111111111111111,%1110000000000000,%0000000000000000,%0111111111111111,%1111111111111110,%0000000000000000,%0000000000000111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000001111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000011111111111,%1111111111111111,%1110000000000000

	dc.w	%1111111111111100,%0000000000000000,%0000000000000111,%1111111111111111,%1111111111110000,%0000000000000000,%0000000000011111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000001111111,%1111111111111111,%1111111100000000,%0000000000000000,%0000000111111111,%1111111111111111,%1111110000000000,%0000000000000000,%0000011111111111,%1111111111111111,%1111000000000000,%0000000000000000,%0001111111111111,%1111111111111111,%1100000000000000,%0000000000000000,%0111111111111111,%1111111111111111,%0000000000000000,%0000000000000001,%1111111111111111,%1111111111111100,%0000000000000000,%0000000000000111,%1111111111111111,%1111111111110000,%0000000000000000,%0000000000011111,%1111111111111111,%1111111111000000

	dc.w	%0000000000000000,%0000000000000000,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%1111111111111111,%1111111111111111

	dc.w	%0000000000000000,%0000111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000001111111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000000011111111,%1111111111111111,%1111111110000000,%0000000000000000,%0000000000111111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000000001111,%1111111111111111,%1111111111111000,%0000000000000000,%0000000000000011,%1111111111111111,%1111111111111110,%0000000000000000,%0000000000000000,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0011111111111111,%1111111111111111,%1110000000000000,%0000000000000000,%0000111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000001111111111,%1111111111111111

	dc.w	%0000000111111111,%1111111111111111,%1111111110000000,%0000000000000000,%0000000000011111,%1111111111111111,%1111111111111000,%0000000000000000,%0000000000000001,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0001111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000000111111111,%1111111111111111,%1111111110000000,%0000000000000000,%0000000000011111,%1111111111111111,%1111111111111000,%0000000000000000,%0000000000000001,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0001111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000000111111111,%1111111111111111,%1111111110000000,%0000000000000000,%0000000000011111,%1111111111111111

	dc.w	%1111111111111111,%1111111111111100,%0000000000000000,%0000000000000000,%0111111111111111,%1111111111111111,%1111000000000000,%0000000000000000,%0000000111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000111,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%0001111111111111,%1111111111111111,%1111110000000000,%0000000000000000,%0000000001111111,%1111111111111111,%1111111111110000,%0000000000000000,%0000000000000001,%1111111111111111,%1111111111111111,%1100000000000000,%0000000000000000,%0000011111111111,%1111111111111111,%1111111100000000,%0000000000000000,%0000000000011111,%1111111111111111,%1111111111111100,%0000000000000000,%0000000000000000,%0111111111111111

	dc.w	%1111111111111111,%1100000000000000,%0000000000000000,%0000001111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000011,%1111111111111111,%1111111111111111,%1100000000000000,%0000000000000000,%0000001111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000011,%1111111111111111,%1111111111111111,%1100000000000000,%0000000000000000,%0000001111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000011,%1111111111111111,%1111111111111111,%1100000000000000,%0000000000000000,%0000001111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000011,%1111111111111111,%1111111111111111,%1100000000000000,%0000000000000000,%0000001111111111

	dc.w	%1111111000000000,%0000000000000000,%0000000000001111,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0000001111111111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000000000000,%1111111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000000000111111,%1111111111111111,%1111111111111110,%0000000000000000,%0000000000000000,%0000111111111111,%1111111111111111,%1111111110000000,%0000000000000000,%0000000000000011,%1111111111111111,%1111111111111111,%1110000000000000,%0000000000000000,%0000000011111111,%1111111111111111,%1111111111111000,%0000000000000000,%0000000000000000,%0011111111111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000000000001111

	dc.w	%0000000000000000,%0000000000000000,%0111111111111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000000000000111,%1111111111111111,%1111111111111111,%1110000000000000,%0000000000000000,%0000000001111111,%1111111111111111,%1111111111111110,%0000000000000000,%0000000000000000,%0000011111111111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000000000000,%0111111111111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000000000000111,%1111111111111111,%1111111111111111,%1110000000000000,%0000000000000000,%0000000001111111,%1111111111111111,%1111111111111110,%0000000000000000,%0000000000000000,%0000011111111111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000111111111,%1111111111111111,%1111111111111100,%0000000000000000,%0000000000000000,%0000011111111111,%1111111111111111,%1111111111110000,%0000000000000000,%0000000000000000,%0001111111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000000,%0111111111111111,%1111111111111111,%1111111100000000,%0000000000000000,%0000000000000001,%1111111111111111,%1111111111111111,%1111110000000000,%0000000000000000,%0000000000000111,%1111111111111111,%1111111111111111,%1111000000000000,%0000000000000000,%0000000000011111,%1111111111111111,%1111111111111111,%1100000000000000,%0000000000000000,%0000000001111111,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000

	dc.w	%0000000000001111,%1111111111111111,%1111111111111111,%1111000000000000,%0000000000000000,%0000000000001111,%1111111111111111,%1111111111111111,%1111000000000000,%0000000000000000,%0000000000001111,%1111111111111111,%1111111111111111,%1111000000000000,%0000000000000000,%0000000000001111,%1111111111111111,%1111111111111111,%1111000000000000,%0000000000000000,%0000000000001111,%1111111111111111,%1111111111111111,%1111000000000000,%0000000000000000,%0000000000001111,%1111111111111111,%1111111111111111,%1111000000000000,%0000000000000000,%0000000000001111,%1111111111111111,%1111111111111111,%1111000000000000,%0000000000000000,%0000000000001111,%1111111111111111,%1111111111111111,%1111000000000000,%0000000000000000

	dc.w	%0011111111111111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000000000000,%0000111111111111,%1111111111111111,%1111111111111000,%0000000000000000,%0000000000000000,%0000001111111111,%1111111111111111,%1111111111111110,%0000000000000000,%0000000000000000,%0000000011111111,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0000000000111111,%1111111111111111,%1111111111111111,%1110000000000000,%0000000000000000,%0000000000001111,%1111111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000000000000011,%1111111111111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000000000000000,%1111111111111111,%1111111111111111,%1111111110000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0000000000011111,%1111111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000000000000001,%1111111111111111,%1111111111111111,%1111111110000000,%0000000000000000,%0000000000000000,%0001111111111111,%1111111111111111,%1111111111111000,%0000000000000000,%0000000000000000,%0000000111111111,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0000000000011111,%1111111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000000000000001,%1111111111111111,%1111111111111111,%1111111110000000,%0000000000000000,%0000000000000000,%0001111111111111,%1111111111111111,%1111111111111000,%0000000000000000

	dc.w	%1111111111111111,%1111111100000000,%0000000000000000,%0000000000000000,%0001111111111111,%1111111111111111,%1111111111111100,%0000000000000000,%0000000000000000,%0000000001111111,%1111111111111111,%1111111111111111,%1111000000000000,%0000000000000000,%0000000000000001,%1111111111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000000,%0000011111111111,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%0000000000011111,%1111111111111111,%1111111111111111,%1111110000000000,%0000000000000000,%0000000000000000,%0111111111111111,%1111111111111111,%1111111111110000,%0000000000000000,%0000000000000000,%0000000111111111,%1111111111111111,%1111111111111111,%1100000000000000

	dc.w	%1111111111111100,%0000000000000000,%0000000000000000,%0000000000111111,%1111111111111111,%1111111111111111,%1111110000000000,%0000000000000000,%0000000000000000,%0011111111111111,%1111111111111111,%1111111111111100,%0000000000000000,%0000000000000000,%0000000000111111,%1111111111111111,%1111111111111111,%1111110000000000,%0000000000000000,%0000000000000000,%0011111111111111,%1111111111111111,%1111111111111100,%0000000000000000,%0000000000000000,%0000000000111111,%1111111111111111,%1111111111111111,%1111110000000000,%0000000000000000,%0000000000000000,%0011111111111111,%1111111111111111,%1111111111111100,%0000000000000000,%0000000000000000,%0000000000111111,%1111111111111111,%1111111111111111,%1111110000000000

	dc.w	%1111100000000000,%0000000000000000,%0000000000000000,%0011111111111111,%1111111111111111,%1111111111111110,%0000000000000000,%0000000000000000,%0000000000001111,%1111111111111111,%1111111111111111,%1111111110000000,%0000000000000000,%0000000000000000,%0000001111111111,%1111111111111111,%1111111111111111,%1110000000000000,%0000000000000000,%0000000000000000,%1111111111111111,%1111111111111111,%1111111111111000,%0000000000000000,%0000000000000000,%0000000000111111,%1111111111111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000000000000000,%0000111111111111,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0000000000000011,%1111111111111111,%1111111111111111,%1111111111100000

	dc.w	%0000000000000000,%0000000000000000,%0000000001111111,%1111111111111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000000000000000,%0000011111111111,%1111111111111111,%1111111111111111,%1110000000000000,%0000000000000000,%0000000000000000,%0111111111111111,%1111111111111111,%1111111111111110,%0000000000000000,%0000000000000000,%0000000000000111,%1111111111111111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000000000000,%0000000001111111,%1111111111111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000000000000000,%0000011111111111,%1111111111111111,%1111111111111111,%1110000000000000,%0000000000000000,%0000000000000000,%0111111111111111,%1111111111111111,%1111111111111110

	dc.w	%0000000000000000,%0000000000000000,%0111111111111111,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%0000000000000001,%1111111111111111,%1111111111111111,%1111111111111100,%0000000000000000,%0000000000000000,%0000000000000111,%1111111111111111,%1111111111111111,%1111111111110000,%0000000000000000,%0000000000000000,%0000000000011111,%1111111111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000000,%0000000001111111,%1111111111111111,%1111111111111111,%1111111100000000,%0000000000000000,%0000000000000000,%0000000111111111,%1111111111111111,%1111111111111111,%1111110000000000,%0000000000000000,%0000000000000000,%0000011111111111,%1111111111111111,%1111111111111111

	dc.w	%0000000000000000,%0000000011111111,%1111111111111111,%1111111111111111,%1111111100000000,%0000000000000000,%0000000000000000,%0000000011111111,%1111111111111111,%1111111111111111,%1111111100000000,%0000000000000000,%0000000000000000,%0000000011111111,%1111111111111111,%1111111111111111,%1111111100000000,%0000000000000000,%0000000000000000,%0000000011111111,%1111111111111111,%1111111111111111,%1111111100000000,%0000000000000000,%0000000000000000,%0000000011111111,%1111111111111111,%1111111111111111,%1111111100000000,%0000000000000000,%0000000000000000,%0000000011111111,%1111111111111111,%1111111111111111,%1111111100000000,%0000000000000000,%0000000000000000,%0000000011111111,%1111111111111111,%1111111111111111

	dc.w	%0000000000000000,%1111111111111111,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0000000000000000,%0011111111111111,%1111111111111111,%1111111111111111,%1110000000000000,%0000000000000000,%0000000000000000,%0000111111111111,%1111111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000000000000000,%0000001111111111,%1111111111111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000000000000000,%0000000011111111,%1111111111111111,%1111111111111111,%1111111110000000,%0000000000000000,%0000000000000000,%0000000000111111,%1111111111111111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000000000000,%0000000000001111,%1111111111111111,%1111111111111111

	dc.w	%0000000111111111,%1111111111111111,%1111111111111111,%1111111110000000,%0000000000000000,%0000000000000000,%0000000000011111,%1111111111111111,%1111111111111111,%1111111111111000,%0000000000000000,%0000000000000000,%0000000000000001,%1111111111111111,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0000000000000000,%0001111111111111,%1111111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000000000000000,%0000000111111111,%1111111111111111,%1111111111111111,%1111111110000000,%0000000000000000,%0000000000000000,%0000000000011111,%1111111111111111,%1111111111111111,%1111111111111000,%0000000000000000,%0000000000000000,%0000000000000001,%1111111111111111,%1111111111111111

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1100000000000000,%0000000000000000,%0000000000000000,%0000011111111111,%1111111111111111,%1111111111111111,%1111111100000000,%0000000000000000,%0000000000000000,%0000000000011111,%1111111111111111,%1111111111111111,%1111111111111100,%0000000000000000,%0000000000000000,%0000000000000000,%0111111111111111,%1111111111111111,%1111111111111111,%1111000000000000,%0000000000000000,%0000000000000000,%0000000111111111,%1111111111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000000,%0000000000000111,%1111111111111111,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%0000000000000000,%0001111111111111,%1111111111111111

	dc.w	%1111111111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000000,%0000000000000011,%1111111111111111,%1111111111111111,%1111111111111111,%1100000000000000,%0000000000000000,%0000000000000000,%0000001111111111,%1111111111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000000,%0000000000000011,%1111111111111111,%1111111111111111,%1111111111111111,%1100000000000000,%0000000000000000,%0000000000000000,%0000001111111111,%1111111111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000000,%0000000000000011,%1111111111111111,%1111111111111111,%1111111111111111,%1100000000000000,%0000000000000000,%0000000000000000,%0000001111111111,%1111111111111111

	dc.w	%1111111111111111,%1111111111111111,%1110000000000000,%0000000000000000,%0000000000000000,%0000000011111111,%1111111111111111,%1111111111111111,%1111111111111000,%0000000000000000,%0000000000000000,%0000000000000000,%0011111111111111,%1111111111111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000000000000000,%0000000000001111,%1111111111111111,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0000000000000000,%0000001111111111,%1111111111111111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000000000000,%0000000000000000,%1111111111111111,%1111111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000000000000000,%0000000000111111,%1111111111111111

	dc.w	%1111111111111111,%1111111111100000,%0000000000000000,%0000000000000000,%0000000000000000,%0111111111111111,%1111111111111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000000000000000,%0000000000000111,%1111111111111111,%1111111111111111,%1111111111111111,%1110000000000000,%0000000000000000,%0000000000000000,%0000000001111111,%1111111111111111,%1111111111111111,%1111111111111110,%0000000000000000,%0000000000000000,%0000000000000000,%0000011111111111,%1111111111111111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000000000000,%0000000000000000,%0111111111111111,%1111111111111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000000000000000,%0000000000000111,%1111111111111111

	dc.w	%1111111111111111,%1111000000000000,%0000000000000000,%0000000000000000,%0000000000011111,%1111111111111111,%1111111111111111,%1111111111111111,%1100000000000000,%0000000000000000,%0000000000000000,%0000000001111111,%1111111111111111,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%0000000000000000,%0000000111111111,%1111111111111111,%1111111111111111,%1111111111111100,%0000000000000000,%0000000000000000,%0000000000000000,%0000011111111111,%1111111111111111,%1111111111111111,%1111111111110000,%0000000000000000,%0000000000000000,%0000000000000000,%0001111111111111,%1111111111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000000,%0000000000000000,%0111111111111111

	dc.w	%1111111111110000,%0000000000000000,%0000000000000000,%0000000000000000,%0000111111111111,%1111111111111111,%1111111111111111,%1111111111110000,%0000000000000000,%0000000000000000,%0000000000000000,%0000111111111111,%1111111111111111,%1111111111111111,%1111111111110000,%0000000000000000,%0000000000000000,%0000000000000000,%0000111111111111,%1111111111111111,%1111111111111111,%1111111111110000,%0000000000000000,%0000000000000000,%0000000000000000,%0000111111111111,%1111111111111111,%1111111111111111,%1111111111110000,%0000000000000000,%0000000000000000,%0000000000000000,%0000111111111111,%1111111111111111,%1111111111111111,%1111111111110000,%0000000000000000,%0000000000000000,%0000000000000000,%0000111111111111

	dc.w	%1111100000000000,%0000000000000000,%0000000000000000,%0000000000000011,%1111111111111111,%1111111111111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000000000000000,%0000000000000000,%1111111111111111,%1111111111111111,%1111111111111111,%1111111110000000,%0000000000000000,%0000000000000000,%0000000000000000,%0011111111111111,%1111111111111111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000000000000,%0000000000000000,%0000111111111111,%1111111111111111,%1111111111111111,%1111111111111000,%0000000000000000,%0000000000000000,%0000000000000000,%0000001111111111,%1111111111111111,%1111111111111111,%1111111111111110,%0000000000000000,%0000000000000000,%0000000000000000,%0000000011111111

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0000000000000000,%0000000000011111,%1111111111111111,%1111111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000000000000000,%0000000000000001,%1111111111111111,%1111111111111111,%1111111111111111,%1111111110000000,%0000000000000000,%0000000000000000,%0000000000000000,%0001111111111111,%1111111111111111,%1111111111111111,%1111111111111000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0000000000000000,%0000000000011111

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0111111111111111,%1111111111111111,%1111111111111111,%1111111111110000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1100000000000000,%0000000000000000,%0000000000000000,%0000000000000111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111100000000,%0000000000000000,%0000000000000000,%0000000000000000,%0001111111111111,%1111111111111111,%1111111111111111,%1111111111111100,%0000000000000000,%0000000000000000,%0000000000000000,%0000000001111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111000000000000,%0000000000000000,%0000000000000000,%0000000000000001

	dc.w	%0000000000000000,%0000000000000000,%0000000000111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111110000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0011111111111111,%1111111111111111,%1111111111111111,%1111111111111100,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111110000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0011111111111111,%1111111111111111,%1111111111111111,%1111111111111100,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111110000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000000000000,%0000111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0000000000000000,%0000000000000011,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000011111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0011111111111111,%1111111111111111,%1111111111111111,%1111111111111110,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000001111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111110000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000000000111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000001111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000011111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1110000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0111111111111111,%1111111111111111,%1111111111111111,%1111111111111110,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111110000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000011111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0001111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1100000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000001,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111100,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000001111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000011,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111110,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0011111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1110000000000000,%0000000000000000,%0000000000000000

	dc.w	%0001111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111110000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000011111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000001,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0001111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0001111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111110000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000001111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111110000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000001,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1100000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000011111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111100000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000011,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1100000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000001111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000011,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1100000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000001111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111110,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111110000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000011,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1110000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000011111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111110,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000011111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1110000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000001111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111110,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111100000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000001,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111110000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000011111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1100000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000001111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000001111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000001111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000001111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111110,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000011111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1110000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000001111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000011,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111110000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0001111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000011111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000001,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111110000000,%0000000000000000

	dc.w	%1111111111111111,%1111000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000001,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000011111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000011111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111110000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111110000,%0000000000000000

	dc.w	%1111111111111100,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111110000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0011111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111100,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111110000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0011111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111100,%0000000000000000

	dc.w	%1111111110000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000001111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1110000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1000000000000000

	dc.w	%1110000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111110,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000001111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000011111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1110000000000000

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111110000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000011111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000001111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111100000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111110000000000

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000011111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111100000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000011111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111100000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000011111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111100000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000011111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111100000000

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000001111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000011111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111110000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111100000

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000001,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0001111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111110000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000011111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111000

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000011111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111100,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000001111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000011,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1100000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000001111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000011,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0011111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000001111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000001111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111

	dc.w	%0000000000000000,%0000000000000000,%0000000000000111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1110000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000001111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111110,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000011111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111

	dc.w	%0000000000000000,%0000000000000000,%0000000001111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111100,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000011111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111110000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0001111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111

	dc.w	%0000000000000000,%0000000000000000,%0000111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111110000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111110000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111110000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111

	dc.w	%0000000000000000,%0000000000000000,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111110000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0011111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000001111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111

	dc.w	%0000000000000000,%0000000000011111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000001,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111110000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0001111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111

	dc.w	%0000000000000000,%0000000111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1100000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111100000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0001111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111100,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000001111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111

	dc.w	%0000000000000000,%0011111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111100,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111110000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0011111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111100,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111

	dc.w	%0000000000000011,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000011111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0011111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111110,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000001111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111

	dc.w	%0000000001111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000011111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1110000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111110,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111

	dc.w	%0000011111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0001111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1100000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000001,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000011,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111110,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0011111111111111,%1111111111111111,%1111111111111111,%1111111111111111

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111110000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000011111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000001,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0001111111111111,%1111111111111111,%1111111111111111,%1111111111111111

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111110000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000001111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111110000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000001,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1100000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000011111111111,%1111111111111111,%1111111111111111,%1111111111111111

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1100000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000001111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000011,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1100000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000001111111111,%1111111111111111,%1111111111111111,%1111111111111111

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111110,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111110000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000011,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1110000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000011111111,%1111111111111111,%1111111111111111,%1111111111111111

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1110000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000001111111,%1111111111111111,%1111111111111111,%1111111111111111

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111100000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000001,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111110000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000011111,%1111111111111111,%1111111111111111,%1111111111111111

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000001111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000001111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000001111,%1111111111111111,%1111111111111111,%1111111111111111

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1110000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000001111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000011,%1111111111111111,%1111111111111111,%1111111111111111

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000011111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000001,%1111111111111111,%1111111111111111,%1111111111111111

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000011111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000011111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111110000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0111111111111111,%1111111111111111,%1111111111111111

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111110000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0011111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111100,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111110000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0011111111111111,%1111111111111111,%1111111111111111

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1110000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000111111111111,%1111111111111111,%1111111111111111

	dc.w	%1111111111111111,%1111111111111111,%1111111111111110,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000001111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000011111111111,%1111111111111111,%1111111111111111

	dc.w	%1111111111111111,%1111111111111111,%1111111111110000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000011111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000001111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111100000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000111111111,%1111111111111111,%1111111111111111

	dc.w	%1111111111111111,%1111111111111111,%1111111100000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000011111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111100000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000011111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111100000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000011111111,%1111111111111111,%1111111111111111

	dc.w	%1111111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000001111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000011111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111110000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000111111,%1111111111111111,%1111111111111111

	dc.w	%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0001111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111110000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000011111,%1111111111111111,%1111111111111111

	dc.w	%1111111111111111,%1111111111111100,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000111,%1111111111111111,%1111111111111111

	dc.w	%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000011,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1100000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000001111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000011,%1111111111111111,%1111111111111111

	dc.w	%1111111111111111,%1111111000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000001111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000001111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%1111111111111111,%1111111111111111

	dc.w	%1111111111111111,%1110000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000001111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111110,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000011111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0111111111111111,%1111111111111111

	dc.w	%1111111111111111,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111100,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000011111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111110000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0001111111111111,%1111111111111111

	dc.w	%1111111111110000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111110000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111110000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000111111111111,%1111111111111111

	dc.w	%1111111110000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0011111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000001111111111,%1111111111111111

	dc.w	%1111100000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000001,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111110000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0001111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000111111111,%1111111111111111

	dc.w	%1100000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111100000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0001111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111100,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000001111111,%1111111111111111

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111110000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0011111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111100,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000111111,%1111111111111111

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000011111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0011111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111110,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000001111,%1111111111111111

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0001111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1100000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000001,%1111111111111111

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%1111111111111111

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000011,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111110,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0011111111111111

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000011111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000001,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0001111111111111

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000001111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000011,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1100000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000001111111111

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111110000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000011,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1110000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000011111111

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1110000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000001111111

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000001,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111110000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000011111

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1110000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000001111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000011

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000011111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000001

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000011111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000011111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111110000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0011111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111100,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111110000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000001111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000011111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000001111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111100000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000011111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111100000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000011111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111100000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000001111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000011111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111110000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000011,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1100000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000001111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000001111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000001111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000001111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111110,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000011111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111110000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111110000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0011111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000000000000,%0000000000000001,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111110000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0001111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000000000000,%0000000000000111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111100000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0001111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111100,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000000000000,%0000000011111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0011111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111110,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000000000000,%0000011111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1110000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111110,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000000000000,%0001111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1100000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000000000000,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000000011111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000001,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000001111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111110000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000001,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1100000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000001111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000011,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1100000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111110000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000011,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1110000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000001,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111110000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000001111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000001111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1110000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000001111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000011111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0011111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111100,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111110000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000001111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111100000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000011111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111100000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000011111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111110000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1100000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000001111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111110,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000011111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111100,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000011111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111110000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111100000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0001111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111100,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111110000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0011111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111100,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1110000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111110,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1100000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111110,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000001,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000011,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1100000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1110000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111110000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1110000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000001111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000011111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111100,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111110000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000001111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000001111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111100000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000011111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111110000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111110000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1100000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000001111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000001111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111100,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000011111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111110000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111110000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0001111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111110000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0011111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111100,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0011111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111110,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1100000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000001,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000011,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1100000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111110000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000011,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1110000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111110000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000001111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000011111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000011111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111110000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111100000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000011111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111100000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111110000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000001111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111100,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000011111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111110000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111111110000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0001111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1111110000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0011111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111100,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111111,%1100000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111111110,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000011,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1100000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1110000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%1110000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000001111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000011111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111110000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111111100000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000001111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111111100000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000011111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111100000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1111000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111111111,%1000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000001111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111111110000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111110000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111111110000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0001111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1111100000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0011111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111110,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%1100000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000001,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000011,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1100000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111000000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000001111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111110000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000001111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111000000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000011111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111110000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111000000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000011111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111100000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111110000,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0001111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111100,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0011111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111110,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%0000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000001,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1000000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000011,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1110000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111000000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000011111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111100000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111110000000000,%0000000000000000,%0000000000000000

	dc.w	%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000000000000,%0000000001111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111111111111,%1111111100000000,%0000000000000000,%0000000000000000

