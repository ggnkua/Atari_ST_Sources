	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	16
	dc.w	16
	dc.w	16
	dc.w	16
	dc.w	16
	dc.w	16
	dc.w	24
	dc.w	24
	dc.w	24
	dc.w	24
	dc.w	24
	dc.w	24
	dc.w	24
	dc.w	32
	dc.w	32
	dc.w	32
	dc.w	32
	dc.w	32
	dc.w	32
	dc.w	32
	dc.w	40
	dc.w	40
	dc.w	40
	dc.w	40
	dc.w	40
	dc.w	40
	dc.w	40
	dc.w	40
	dc.w	48
	dc.w	48
	dc.w	48
	dc.w	48
	dc.w	48
	dc.w	48
	dc.w	48
	dc.w	48
	dc.w	48
	dc.w	48
	dc.w	48
	dc.w	48
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	48
	dc.w	48
	dc.w	48
	dc.w	48
	dc.w	48
	dc.w	48
	dc.w	48
	dc.w	48
	dc.w	48
	dc.w	48
	dc.w	48
	dc.w	48
	dc.w	40
	dc.w	40
	dc.w	40
	dc.w	40
	dc.w	40
	dc.w	40
	dc.w	40
	dc.w	40
	dc.w	32
	dc.w	32
	dc.w	32
	dc.w	32
	dc.w	32
	dc.w	32
	dc.w	32
	dc.w	24
	dc.w	24
	dc.w	24
	dc.w	24
	dc.w	24
	dc.w	24
	dc.w	24
	dc.w	16
	dc.w	16
	dc.w	16
	dc.w	16
	dc.w	16
	dc.w	16
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	-0
	dc.w	-0
	dc.w	-8
	dc.w	-8
	dc.w	-8
	dc.w	-8
	dc.w	-8
	dc.w	-8
	dc.w	-16
	dc.w	-16
	dc.w	-16
	dc.w	-16
	dc.w	-16
	dc.w	-16
	dc.w	-24
	dc.w	-24
	dc.w	-24
	dc.w	-24
	dc.w	-24
	dc.w	-24
	dc.w	-24
	dc.w	-32
	dc.w	-32
	dc.w	-32
	dc.w	-32
	dc.w	-32
	dc.w	-32
	dc.w	-32
	dc.w	-40
	dc.w	-40
	dc.w	-40
	dc.w	-40
	dc.w	-40
	dc.w	-40
	dc.w	-40
	dc.w	-40
	dc.w	-48
	dc.w	-48
	dc.w	-48
	dc.w	-48
	dc.w	-48
	dc.w	-48
	dc.w	-48
	dc.w	-48
	dc.w	-48
	dc.w	-48
	dc.w	-48
	dc.w	-48
	dc.w	-56
	dc.w	-56
	dc.w	-56
	dc.w	-56
	dc.w	-56
	dc.w	-56
	dc.w	-56
	dc.w	-56
	dc.w	-56
	dc.w	-56
	dc.w	-56
	dc.w	-56
	dc.w	-56
	dc.w	-56
	dc.w	-56
	dc.w	-56
	dc.w	-56
	dc.w	-56
	dc.w	-56
	dc.w	-56
	dc.w	-56
	dc.w	-56
	dc.w	-56
	dc.w	-56
	dc.w	-56
	dc.w	-56
	dc.w	-56
	dc.w	-56
	dc.w	-56
	dc.w	-56
	dc.w	-56
	dc.w	-48
	dc.w	-48
	dc.w	-48
	dc.w	-48
	dc.w	-48
	dc.w	-48
	dc.w	-48
	dc.w	-48
	dc.w	-48
	dc.w	-48
	dc.w	-48
	dc.w	-48
	dc.w	-40
	dc.w	-40
	dc.w	-40
	dc.w	-40
	dc.w	-40
	dc.w	-40
	dc.w	-40
	dc.w	-40
	dc.w	-32
	dc.w	-32
	dc.w	-32
	dc.w	-32
	dc.w	-32
	dc.w	-32
	dc.w	-32
	dc.w	-24
	dc.w	-24
	dc.w	-24
	dc.w	-24
	dc.w	-24
	dc.w	-24
	dc.w	-24
	dc.w	-16
	dc.w	-16
	dc.w	-16
	dc.w	-16
	dc.w	-16
	dc.w	-16
	dc.w	-8
	dc.w	-8
	dc.w	-8
	dc.w	-8
	dc.w	-8
	dc.w	-8
	dc.w	-0
	dc.w	-0
	dc.w	-0
	dc.w	0
	dc.w	0
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	16
	dc.w	16
	dc.w	16
	dc.w	16
	dc.w	16
	dc.w	16
	dc.w	24
	dc.w	24
	dc.w	24
	dc.w	24
	dc.w	24
	dc.w	24
	dc.w	24
	dc.w	32
	dc.w	32
	dc.w	32
	dc.w	32
	dc.w	32
	dc.w	32
	dc.w	32
	dc.w	40
	dc.w	40
	dc.w	40
	dc.w	40
	dc.w	40
	dc.w	40
	dc.w	40
	dc.w	40
	dc.w	48
	dc.w	48
	dc.w	48
	dc.w	48
	dc.w	48
	dc.w	48
	dc.w	48
	dc.w	48
	dc.w	48
	dc.w	48
	dc.w	48
	dc.w	48
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
