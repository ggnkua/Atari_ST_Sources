	dc.l	34080	;335
	dc.l	34080	;335
	dc.l	-1	;334
	dc.l	-1	;334
	dc.l	-1	;333
	dc.l	-1	;333
	dc.l	33920	;332
	dc.l	33920	;332
	dc.l	-1	;331
	dc.l	-1	;331
	dc.l	33760	;330
	dc.l	33760	;330
	dc.l	-1	;329
	dc.l	-1	;329
	dc.l	-1	;328
	dc.l	-1	;328
	dc.l	33600	;327
	dc.l	33600	;327
	dc.l	-1	;326
	dc.l	-1	;326
	dc.l	33440	;325
	dc.l	33440	;325
	dc.l	-1	;324
	dc.l	-1	;324
	dc.l	-1	;323
	dc.l	-1	;323
	dc.l	33280	;322
	dc.l	33280	;322
	dc.l	-1	;321
	dc.l	-1	;321
	dc.l	33120	;320
	dc.l	33120	;320
	dc.l	-1	;319
	dc.l	-1	;319
	dc.l	-1	;318
	dc.l	-1	;318
	dc.l	32960	;317
	dc.l	32960	;317
	dc.l	-1	;316
	dc.l	-1	;316
	dc.l	32800	;315
	dc.l	32800	;315
	dc.l	-1	;314
	dc.l	-1	;314
	dc.l	-1	;313
	dc.l	-1	;313
	dc.l	32640	;312
	dc.l	32640	;312
	dc.l	-1	;311
	dc.l	-1	;311
	dc.l	32480	;310
	dc.l	32480	;310
	dc.l	-1	;309
	dc.l	-1	;309
	dc.l	-1	;308
	dc.l	-1	;308
	dc.l	32320	;307
	dc.l	32320	;307
	dc.l	-1	;306
	dc.l	-1	;306
	dc.l	32160	;305
	dc.l	32160	;305
	dc.l	-1	;304
	dc.l	-1	;304
	dc.l	-1	;303
	dc.l	-1	;303
	dc.l	32000	;302
	dc.l	32000	;302
	dc.l	-1	;301
	dc.l	-1	;301
	dc.l	31840	;300
	dc.l	31840	;300
	dc.l	-1	;299
	dc.l	-1	;299
	dc.l	-1	;298
	dc.l	-1	;298
	dc.l	31680	;297
	dc.l	31680	;297
	dc.l	-1	;296
	dc.l	-1	;296
	dc.l	31520	;295
	dc.l	31520	;295
	dc.l	-1	;294
	dc.l	-1	;294
	dc.l	-1	;293
	dc.l	-1	;293
	dc.l	31360	;292
	dc.l	31360	;292
	dc.l	-1	;291
	dc.l	-1	;291
	dc.l	31200	;290
	dc.l	31200	;290
	dc.l	-1	;289
	dc.l	-1	;289
	dc.l	-1	;288
	dc.l	-1	;288
	dc.l	31040	;287
	dc.l	31040	;287
	dc.l	-1	;286
	dc.l	-1	;286
	dc.l	30880	;285
	dc.l	30880	;285
	dc.l	-1	;284
	dc.l	-1	;284
	dc.l	-1	;283
	dc.l	-1	;283
	dc.l	30720	;282
	dc.l	30720	;282
	dc.l	-1	;281
	dc.l	-1	;281
	dc.l	30560	;280
	dc.l	30560	;280
	dc.l	-1	;279
	dc.l	-1	;279
	dc.l	-1	;278
	dc.l	-1	;278
	dc.l	30400	;277
	dc.l	30400	;277
	dc.l	-1	;276
	dc.l	-1	;276
	dc.l	30240	;275
	dc.l	30240	;275
	dc.l	-1	;274
	dc.l	-1	;274
	dc.l	-1	;273
	dc.l	-1	;273
	dc.l	30080	;272
	dc.l	30080	;272
	dc.l	-1	;271
	dc.l	-1	;271
	dc.l	29920	;270
	dc.l	29920	;270
	dc.l	-1	;269
	dc.l	-1	;269
	dc.l	-1	;268
	dc.l	-1	;268
	dc.l	29760	;267
	dc.l	29760	;267
	dc.l	-1	;266
	dc.l	-1	;266
	dc.l	29600	;265
	dc.l	29600	;265
	dc.l	-1	;264
	dc.l	-1	;264
	dc.l	-1	;263
	dc.l	-1	;263
	dc.l	29440	;262
	dc.l	29440	;262
	dc.l	-1	;261
	dc.l	-1	;261
	dc.l	29280	;260
	dc.l	29280	;260
	dc.l	-1	;259
	dc.l	-1	;259
	dc.l	-1	;258
	dc.l	-1	;258
	dc.l	29120	;257
	dc.l	29120	;257
	dc.l	-1	;256
	dc.l	-1	;256
	dc.l	28960	;255
	dc.l	28960	;255
	dc.l	-1	;254
	dc.l	-1	;254
	dc.l	-1	;253
	dc.l	-1	;253
	dc.l	28800	;252
	dc.l	28800	;252
	dc.l	-1	;251
	dc.l	-1	;251
	dc.l	28640	;250
	dc.l	28640	;250
	dc.l	-1	;249
	dc.l	-1	;249
	dc.l	-1	;248
	dc.l	-1	;248
	dc.l	28480	;247
	dc.l	28480	;247
	dc.l	-1	;246
	dc.l	-1	;246
	dc.l	28320	;245
	dc.l	28320	;245
	dc.l	-1	;244
	dc.l	-1	;244
	dc.l	-1	;243
	dc.l	-1	;243
	dc.l	28160	;242
	dc.l	28160	;242
	dc.l	-1	;241
	dc.l	-1	;241
	dc.l	28000	;240
	dc.l	28000	;240
	dc.l	-1	;239
	dc.l	-1	;239
	dc.l	-1	;238
	dc.l	-1	;238
	dc.l	27840	;237
	dc.l	27840	;237
	dc.l	-1	;236
	dc.l	-1	;236
	dc.l	27680	;235
	dc.l	27680	;235
	dc.l	27520	;234
	dc.l	27520	;234
	dc.l	-1	;233
	dc.l	-1	;233
	dc.l	27360	;232
	dc.l	27360	;232
	dc.l	27200	;231
	dc.l	27200	;231
	dc.l	-1	;230
	dc.l	-1	;230
	dc.l	27040	;229
	dc.l	27040	;229
	dc.l	26880	;228
	dc.l	26880	;228
	dc.l	-1	;227
	dc.l	-1	;227
	dc.l	26720	;226
	dc.l	26720	;226
	dc.l	-1	;225
	dc.l	-1	;225
	dc.l	26560	;224
	dc.l	26560	;224
	dc.l	26400	;223
	dc.l	26400	;223
	dc.l	-1	;222
	dc.l	-1	;222
	dc.l	26240	;221
	dc.l	26240	;221
	dc.l	26080	;220
	dc.l	26080	;220
	dc.l	-1	;219
	dc.l	-1	;219
	dc.l	25920	;218
	dc.l	25920	;218
	dc.l	25760	;217
	dc.l	25760	;217
	dc.l	-1	;216
	dc.l	-1	;216
	dc.l	25600	;215
	dc.l	25600	;215
	dc.l	-1	;214
	dc.l	-1	;214
	dc.l	25440	;213
	dc.l	25440	;213
	dc.l	25280	;212
	dc.l	25280	;212
	dc.l	-1	;211
	dc.l	-1	;211
	dc.l	25120	;210
	dc.l	25120	;210
	dc.l	24960	;209
	dc.l	24960	;209
	dc.l	-1	;208
	dc.l	-1	;208
	dc.l	24800	;207
	dc.l	24800	;207
	dc.l	24640	;206
	dc.l	24640	;206
	dc.l	-1	;205
	dc.l	-1	;205
	dc.l	24480	;204
	dc.l	24480	;204
	dc.l	-1	;203
	dc.l	-1	;203
	dc.l	24320	;202
	dc.l	24320	;202
	dc.l	24160	;201
	dc.l	24160	;201
	dc.l	-1	;200
	dc.l	-1	;200
	dc.l	24000	;199
	dc.l	24000	;199
	dc.l	23840	;198
	dc.l	23840	;198
	dc.l	-1	;197
	dc.l	-1	;197
	dc.l	23680	;196
	dc.l	23680	;196
	dc.l	-1	;195
	dc.l	-1	;195
	dc.l	23520	;194
	dc.l	23520	;194
	dc.l	23360	;193
	dc.l	23360	;193
	dc.l	-1	;192
	dc.l	-1	;192
	dc.l	23200	;191
	dc.l	23200	;191
	dc.l	23040	;190
	dc.l	23040	;190
	dc.l	-1	;189
	dc.l	-1	;189
	dc.l	22880	;188
	dc.l	22880	;188
	dc.l	22720	;187
	dc.l	22720	;187
	dc.l	-1	;186
	dc.l	-1	;186
	dc.l	22560	;185
	dc.l	22560	;185
	dc.l	-1	;184
	dc.l	-1	;184
	dc.l	22400	;183
	dc.l	22400	;183
	dc.l	22240	;182
	dc.l	22240	;182
	dc.l	-1	;181
	dc.l	-1	;181
	dc.l	22080	;180
	dc.l	22080	;180
	dc.l	21920	;179
	dc.l	21920	;179
	dc.l	-1	;178
	dc.l	-1	;178
	dc.l	21760	;177
	dc.l	21760	;177
	dc.l	21600	;176
	dc.l	21600	;176
	dc.l	-1	;175
	dc.l	-1	;175
	dc.l	21440	;174
	dc.l	21440	;174
	dc.l	21280	;173
	dc.l	21280	;173
	dc.l	21120	;172
	dc.l	21120	;172
	dc.l	-1	;171
	dc.l	-1	;171
	dc.l	20960	;170
	dc.l	20960	;170
	dc.l	20800	;169
	dc.l	20800	;169
	dc.l	20640	;168
	dc.l	20640	;168
	dc.l	20480	;167
	dc.l	20480	;167
	dc.l	-1	;166
	dc.l	-1	;166
	dc.l	20320	;165
	dc.l	20320	;165
	dc.l	20160	;164
	dc.l	20160	;164
	dc.l	20000	;163
	dc.l	20000	;163
	dc.l	19840	;162
	dc.l	19840	;162
	dc.l	-1	;161
	dc.l	-1	;161
	dc.l	19680	;160
	dc.l	19680	;160
	dc.l	19520	;159
	dc.l	19520	;159
	dc.l	19360	;158
	dc.l	19360	;158
	dc.l	19200	;157
	dc.l	19200	;157
	dc.l	-1	;156
	dc.l	-1	;156
	dc.l	19040	;155
	dc.l	19040	;155
	dc.l	18880	;154
	dc.l	18880	;154
	dc.l	18720	;153
	dc.l	18720	;153
	dc.l	18560	;152
	dc.l	18560	;152
	dc.l	-1	;151
	dc.l	-1	;151
	dc.l	18400	;150
	dc.l	18400	;150
	dc.l	18240	;149
	dc.l	18240	;149
	dc.l	18080	;148
	dc.l	18080	;148
	dc.l	17920	;147
	dc.l	17920	;147
	dc.l	-1	;146
	dc.l	-1	;146
	dc.l	17760	;145
	dc.l	17760	;145
	dc.l	17600	;144
	dc.l	17600	;144
	dc.l	17440	;143
	dc.l	17440	;143
	dc.l	17280	;142
	dc.l	17280	;142
	dc.l	-1	;141
	dc.l	-1	;141
	dc.l	17120	;140
	dc.l	17120	;140
	dc.l	16960	;139
	dc.l	16960	;139
	dc.l	16800	;138
	dc.l	16800	;138
	dc.l	16640	;137
	dc.l	16640	;137
	dc.l	-1	;136
	dc.l	-1	;136
	dc.l	16480	;135
	dc.l	16480	;135
	dc.l	16320	;134
	dc.l	16320	;134
	dc.l	16160	;133
	dc.l	16160	;133
	dc.l	16000	;132
	dc.l	16000	;132
	dc.l	-1	;131
	dc.l	-1	;131
	dc.l	15840	;130
	dc.l	15840	;130
	dc.l	15680	;129
	dc.l	15680	;129
	dc.l	15520	;128
	dc.l	15520	;128
	dc.l	15360	;127
	dc.l	15360	;127
	dc.l	-1	;126
	dc.l	-1	;126
	dc.l	15200	;125
	dc.l	15200	;125
	dc.l	15040	;124
	dc.l	15040	;124
	dc.l	14880	;123
	dc.l	14880	;123
	dc.l	14720	;122
	dc.l	14720	;122
	dc.l	14560	;121
	dc.l	14560	;121
	dc.l	14400	;120
	dc.l	14400	;120
	dc.l	14240	;119
	dc.l	14240	;119
	dc.l	14080	;118
	dc.l	14080	;118
	dc.l	13920	;117
	dc.l	13920	;117
	dc.l	13760	;116
	dc.l	13760	;116
	dc.l	13600	;115
	dc.l	13600	;115
	dc.l	13440	;114
	dc.l	13440	;114
	dc.l	13280	;113
	dc.l	13280	;113
	dc.l	13120	;112
	dc.l	13120	;112
	dc.l	12960	;111
	dc.l	12960	;111
	dc.l	12800	;110
	dc.l	12800	;110
	dc.l	12640	;109
	dc.l	12640	;109
	dc.l	12480	;108
	dc.l	12480	;108
	dc.l	12320	;107
	dc.l	12320	;107
	dc.l	12160	;106
	dc.l	12160	;106
	dc.l	12000	;105
	dc.l	12000	;105
	dc.l	11840	;104
	dc.l	11840	;104
	dc.l	11680	;103
	dc.l	11680	;103
	dc.l	11520	;102
	dc.l	11520	;102
	dc.l	11360	;101
	dc.l	11360	;101
	dc.l	11200	;100
	dc.l	11200	;100
	dc.l	11040	;99
	dc.l	11040	;99
	dc.l	10880	;98
	dc.l	10880	;98
	dc.l	10720	;97
	dc.l	10720	;97
	dc.l	10560	;96
	dc.l	10560	;96
	dc.l	10400	;95
	dc.l	10400	;95
	dc.l	10240	;94
	dc.l	10240	;94
	dc.l	10080	;93
	dc.l	10080	;93
	dc.l	9920	;92
	dc.l	9920	;92
	dc.l	9760	;91
	dc.l	9760	;91
	dc.l	9600	;90
	dc.l	9600	;90
	dc.l	9440	;89
	dc.l	9440	;89
	dc.l	9280	;88
	dc.l	9280	;88
	dc.l	9120	;87
	dc.l	9120	;87
	dc.l	8960	;86
	dc.l	8960	;86
	dc.l	8800	;85
	dc.l	8800	;85
	dc.l	8640	;84
	dc.l	8640	;84
	dc.l	8480	;83
	dc.l	8480	;83
	dc.l	8320	;82
	dc.l	8320	;82
	dc.l	8160	;81
	dc.l	8160	;81
	dc.l	8000	;80
	dc.l	8000	;80
	dc.l	7840	;79
	dc.l	7840	;79
	dc.l	7680	;78
	dc.l	7680	;78
	dc.l	7520	;77
	dc.l	7520	;77
	dc.l	7360	;76
	dc.l	7360	;76
	dc.l	7200	;75
	dc.l	7200	;75
	dc.l	7040	;74
	dc.l	7040	;74
	dc.l	6880	;73
	dc.l	6880	;73
	dc.l	6720	;72
	dc.l	6720	;72
	dc.l	6560	;71
	dc.l	6560	;71
	dc.l	6400	;70
	dc.l	6400	;70
	dc.l	6240	;69
	dc.l	6240	;69
	dc.l	6080	;68
	dc.l	6080	;68
	dc.l	5920	;67
	dc.l	5920	;67
	dc.l	5760	;66
	dc.l	5760	;66
	dc.l	5600	;65
	dc.l	5600	;65
	dc.l	5440	;64
	dc.l	5440	;64
	dc.l	5280	;63
	dc.l	5280	;63
	dc.l	5120	;62
	dc.l	5120	;62
	dc.l	4960	;61
	dc.l	4960	;61
	dc.l	4800	;60
	dc.l	4800	;60
	dc.l	4640	;59
	dc.l	4640	;59
	dc.l	4480	;58
	dc.l	4480	;58
	dc.l	4320	;57
	dc.l	4320	;57
	dc.l	4160	;56
	dc.l	4160	;56
	dc.l	4000	;55
	dc.l	4000	;55
	dc.l	3840	;54
	dc.l	3840	;54
	dc.l	3680	;53
	dc.l	3680	;53
	dc.l	3520	;52
	dc.l	3520	;52
	dc.l	3360	;51
	dc.l	3360	;51
	dc.l	3200	;50
	dc.l	3200	;50
	dc.l	3040	;49
	dc.l	3040	;49
	dc.l	2880	;48
	dc.l	2880	;48
	dc.l	2720	;47
	dc.l	2720	;47
	dc.l	2560	;46
	dc.l	2560	;46
	dc.l	2400	;45
	dc.l	2400	;45
	dc.l	2240	;44
	dc.l	2240	;44
	dc.l	2080	;43
	dc.l	2080	;43
	dc.l	1920	;42
	dc.l	1920	;42
	dc.l	1760	;41
	dc.l	1760	;41
	dc.l	1600	;40
	dc.l	1600	;40
	dc.l	1440	;39
	dc.l	1440	;39
	dc.l	1280	;38
	dc.l	1280	;38
	dc.l	1120	;37
	dc.l	1120	;37
	dc.l	960	;36
	dc.l	960	;36
	dc.l	800	;35
	dc.l	800	;35
	dc.l	640	;34
	dc.l	640	;34
	dc.l	480	;33
	dc.l	480	;33
	dc.l	320	;32
	dc.l	320	;32
	dc.l	160	;31
	dc.l	160	;31
	dc.l	0	;30
	dc.l	0	;30
	dc.l	-1	;29
	dc.l	-1	;29
	dc.l	-1	;28
	dc.l	-1	;28
	dc.l	-1	;27
	dc.l	-1	;27
	dc.l	-1	;26
	dc.l	-1	;26
	dc.l	-1	;25
	dc.l	-1	;25
	dc.l	-1	;24
	dc.l	-1	;24
	dc.l	-1	;23
	dc.l	-1	;23
	dc.l	-1	;22
	dc.l	-1	;22
	dc.l	-1	;21
	dc.l	-1	;21
	dc.l	-1	;20
	dc.l	-1	;20
	dc.l	-1	;19
	dc.l	-1	;19
	dc.l	-1	;18
	dc.l	-1	;18
	dc.l	-1	;17
	dc.l	-1	;17
	dc.l	-1	;16
	dc.l	-1	;16
	dc.l	-1	;15
	dc.l	-1	;15
	dc.l	-1	;14
	dc.l	-1	;14
	dc.l	-1	;13
	dc.l	-1	;13
	dc.l	-1	;12
	dc.l	-1	;12
	dc.l	-1	;11
	dc.l	-1	;11
	dc.l	-1	;10
	dc.l	-1	;10
	dc.l	-1	;9
	dc.l	-1	;9
	dc.l	-1	;8
	dc.l	-1	;8
	dc.l	-1	;7
	dc.l	-1	;7
	dc.l	-1	;6
	dc.l	-1	;6
	dc.l	-1	;5
	dc.l	-1	;5
	dc.l	-1	;4
	dc.l	-1	;4
	dc.l	-1	;3
	dc.l	-1	;3
	dc.l	-1	;2
	dc.l	-1	;2
	dc.l	-1	;1
	dc.l	-1	;1

