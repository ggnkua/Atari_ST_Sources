	dc.w	432
	dc.w	452
	dc.w	468
	dc.w	488
	dc.w	504
	dc.w	524
	dc.w	540
	dc.w	560
	dc.w	576
	dc.w	592
	dc.w	608
	dc.w	624
	dc.w	640
	dc.w	656
	dc.w	672
	dc.w	688
	dc.w	700
	dc.w	712
	dc.w	728
	dc.w	740
	dc.w	752
	dc.w	760
	dc.w	772
	dc.w	780
	dc.w	788
	dc.w	796
	dc.w	804
	dc.w	812
	dc.w	816
	dc.w	820
	dc.w	824
	dc.w	828
	dc.w	832
	dc.w	832
	dc.w	832
	dc.w	832
	dc.w	832
	dc.w	828
	dc.w	824
	dc.w	824
	dc.w	816
	dc.w	812
	dc.w	808
	dc.w	800
	dc.w	792
	dc.w	784
	dc.w	772
	dc.w	764
	dc.w	752
	dc.w	740
	dc.w	732
	dc.w	716
	dc.w	704
	dc.w	692
	dc.w	676
	dc.w	660
	dc.w	644
	dc.w	632
	dc.w	616
	dc.w	596
	dc.w	580
	dc.w	564
	dc.w	544
	dc.w	528
	dc.w	512
	dc.w	492
	dc.w	472
	dc.w	456
	dc.w	436
	dc.w	420
	dc.w	400
	dc.w	380
	dc.w	364
	dc.w	344
	dc.w	328
	dc.w	312
	dc.w	292
	dc.w	276
	dc.w	260
	dc.w	244
	dc.w	228
	dc.w	212
	dc.w	196
	dc.w	180
	dc.w	168
	dc.w	152
	dc.w	140
	dc.w	128
	dc.w	116
	dc.w	104
	dc.w	96
	dc.w	84
	dc.w	76
	dc.w	68
	dc.w	60
	dc.w	56
	dc.w	48
	dc.w	44
	dc.w	40
	dc.w	36
	dc.w	36
	dc.w	32
	dc.w	32
	dc.w	32
	dc.w	32
	dc.w	36
	dc.w	36
	dc.w	40
	dc.w	44
	dc.w	52
	dc.w	56
	dc.w	64
	dc.w	72
	dc.w	80
	dc.w	88
	dc.w	96
	dc.w	108
	dc.w	120
	dc.w	132
	dc.w	144
	dc.w	156
	dc.w	168
	dc.w	184
	dc.w	200
	dc.w	212
	dc.w	228
	dc.w	244
	dc.w	264
	dc.w	280
	dc.w	296
	dc.w	312
	dc.w	332
	dc.w	348
	dc.w	368
	dc.w	384
	dc.w	404
	dc.w	424
	dc.w	440
	dc.w	460
	dc.w	476
	dc.w	496
	dc.w	512
	dc.w	532
	dc.w	548
	dc.w	568
	dc.w	584
	dc.w	600
	dc.w	616
	dc.w	632
	dc.w	648
	dc.w	664
	dc.w	680
	dc.w	692
	dc.w	708
	dc.w	720
	dc.w	732
	dc.w	744
	dc.w	756
	dc.w	764
	dc.w	776
	dc.w	784
	dc.w	792
	dc.w	800
	dc.w	808
	dc.w	812
	dc.w	820
	dc.w	824
	dc.w	828
	dc.w	828
	dc.w	832
	dc.w	832
	dc.w	832
	dc.w	832
	dc.w	828
	dc.w	828
	dc.w	824
	dc.w	820
	dc.w	816
	dc.w	808
	dc.w	804
	dc.w	796
	dc.w	788
	dc.w	780
	dc.w	768
	dc.w	760
	dc.w	748
	dc.w	736
	dc.w	724
	dc.w	712
	dc.w	696
	dc.w	684
	dc.w	668
	dc.w	656
	dc.w	640
	dc.w	624
	dc.w	608
	dc.w	588
	dc.w	572
	dc.w	556
	dc.w	536
	dc.w	520
	dc.w	500
	dc.w	484
	dc.w	464
	dc.w	448
	dc.w	428
	dc.w	408
	dc.w	392
	dc.w	372
	dc.w	356
	dc.w	336
	dc.w	320
	dc.w	300
	dc.w	284
	dc.w	268
	dc.w	252
	dc.w	236
	dc.w	220
	dc.w	204
	dc.w	188
	dc.w	176
	dc.w	160
	dc.w	148
	dc.w	136
	dc.w	124
	dc.w	112
	dc.w	100
	dc.w	92
	dc.w	80
	dc.w	72
	dc.w	64
	dc.w	60
	dc.w	52
	dc.w	48
	dc.w	44
	dc.w	40
	dc.w	36
	dc.w	32
	dc.w	32
	dc.w	32
	dc.w	32
	dc.w	32
	dc.w	36
	dc.w	40
	dc.w	44
	dc.w	48
	dc.w	52
	dc.w	60
	dc.w	68
	dc.w	76
	dc.w	84
	dc.w	92
	dc.w	104
	dc.w	112
	dc.w	124
	dc.w	136
	dc.w	148
	dc.w	164
	dc.w	176
	dc.w	192
	dc.w	204
	dc.w	220
	dc.w	236
	dc.w	252
	dc.w	268
	dc.w	288
	dc.w	304
	dc.w	320
	dc.w	340
	dc.w	356
	dc.w	376
	dc.w	396
	dc.w	412		; 273 8 times