;	dc.w 0,18560
;	dc.w 4,18560
;	dc.w 8,18560
;	dc.w 12,18560
;	dc.w 16,18560
;	dc.w 20,18560
;	dc.w 24,18560
;	dc.w 28,18560
;	dc.w 32,18560
;	dc.w 36,18560
;	dc.w 40,18560		
;	dc.w 44,18560
;	dc.w 48,18560			; 13 times normal 18560
	dc.w 52,18400			; 516 - 14 = 502 * 4 = 2008 bytes
	dc.w 52,18240
	dc.w 52,18080
	dc.w 52,17920
	dc.w 56,17760		;generateStuff
	dc.w 56,17600		;	moveq	#0,d0
	dc.w 56,17440		;	move.w	#18560,d1
	dc.w 60,17280		;	move.w	#13-1,d7
	dc.w 60,17120		;	lea		buffer,a0
	dc.w 60,16960		;.l
	dc.w 64,16800		;		move.w	d0,(a0)+
	dc.w 64,16640		;		move.w	d1,(a0)+
	dc.w 68,16480		;		addq.w	#4,d0
	dc.w 68,16320		;	dbra	d7,.l
	dc.w 72,16160		; 	lea		oud,a1
	dc.w 76,16000		;	move.w	#502-1,d7
	dc.w 80,16000		;.l2
	dc.w 84,16160		;		move.l	(a1)+,(a0)+
	dc.w 88,16320		;		dbra	d7,.l2
	dc.w 88,16480		;	
	dc.w 92,16640		;	move.w	#416,d0
	dc.w 92,16800		;	move.w	#103-1,d7
	dc.w 92,16960		;.l3
	dc.w 96,17120		;		move.w	d0,(a0)+
	dc.w 96,17280		;		move.w	d1,(a0)+		addq.w	#4,d0
	dc.w 96,17440		;	dbra	d7,.l3
	dc.w 100,17600		;	lea		oud,a1
	dc.w 100,17760		;	move.w	#502-1,d7
	dc.w 100,17920		;.l4
	dc.w 104,18080		;		move.l	(a1)+,(a0)+
	dc.w 104,18240		;	dbra	d7,.l4
	dc.w 108,18400		;	move.w	#21-1,d7
	dc.w 112,18560		;	move.w	#1196,d0
	dc.w 116,18400		;.l5
	dc.w 120,18240		;		move.w	d0,(a0)+
	dc.w 120,18080		;		move.w	d1,(a0)+
	dc.w 124,17920		;		addq.w	#4,d0
	dc.w 124,17760		;	dbra	d7,.l5
	dc.w 124,17600		;	move.w	#-1,(a0)+
	dc.w 128,17440		;	move.w	#-1,(a0)+
	dc.w 128,17280
	dc.w 128,17120
	dc.w 128,16960
	dc.w 128,16800
	dc.w 132,16640
	dc.w 132,16480
	dc.w 132,16320
	dc.w 132,16160
	dc.w 132,16000
	dc.w 132,15840
	dc.w 136,15680
	dc.w 136,15520
	dc.w 136,15360
	dc.w 136,15200
	dc.w 136,15040
	dc.w 136,14880
	dc.w 136,14720
	dc.w 140,14560
	dc.w 140,14400
	dc.w 140,14240
	dc.w 140,14080
	dc.w 140,13920
	dc.w 140,13760
	dc.w 140,13600
	dc.w 140,13440
	dc.w 140,13280
	dc.w 144,13120
	dc.w 144,12960
	dc.w 144,12800
	dc.w 144,12640
	dc.w 144,12480
	dc.w 144,12320
	dc.w 144,12160
	dc.w 144,12000
	dc.w 144,11840
	dc.w 144,11680
	dc.w 144,11520
	dc.w 148,11360
	dc.w 148,11200
	dc.w 148,11040
	dc.w 148,10880
	dc.w 148,10720
	dc.w 148,10560
	dc.w 148,10400
	dc.w 148,10240
	dc.w 148,10080
	dc.w 148,9920
	dc.w 148,9760
	dc.w 148,9600
	dc.w 148,9440
	dc.w 152,9280
	dc.w 152,9120
	dc.w 152,8960
	dc.w 152,8800
	dc.w 152,8640
	dc.w 152,8480
	dc.w 152,8320
	dc.w 152,8160
	dc.w 152,8000
	dc.w 152,7840
	dc.w 152,7680
	dc.w 152,7520
	dc.w 152,7360
	dc.w 152,7200
	dc.w 156,7040
	dc.w 156,6880
	dc.w 156,6720
	dc.w 156,6560
	dc.w 156,6400
	dc.w 156,6240
	dc.w 156,6080
	dc.w 156,5920
	dc.w 156,5760
	dc.w 156,5600
	dc.w 156,5440
	dc.w 156,5280
	dc.w 156,5120
	dc.w 156,4960
	dc.w 156,4800
	dc.w 160,4640
	dc.w 160,4480
	dc.w 160,4320
	dc.w 160,4160
	dc.w 160,4000
	dc.w 160,3840
	dc.w 160,3680
	dc.w 160,3520
	dc.w 160,3360
	dc.w 160,3200
	dc.w 160,3040
	dc.w 160,2880
	dc.w 160,2720
	dc.w 160,2560
	dc.w 164,2400
	dc.w 164,2240
	dc.w 164,2080
	dc.w 164,1920
	dc.w 164,1760
	dc.w 164,1600
	dc.w 164,1440
	dc.w 164,1280
	dc.w 164,1120
	dc.w 164,960
	dc.w 164,800
	dc.w 168,640
	dc.w 168,480
	dc.w 168,320
	dc.w 168,160
	dc.w 172,0
	dc.w 176,160
	dc.w 176,320
	dc.w 176,480
	dc.w 176,640
	dc.w 180,800
	dc.w 180,960
	dc.w 180,1120
	dc.w 180,1280
	dc.w 180,1440
	dc.w 180,1600
	dc.w 180,1760
	dc.w 180,1920
	dc.w 180,2080
	dc.w 180,2240
	dc.w 180,2400
	dc.w 180,2560
	dc.w 180,2720
	dc.w 180,2880
	dc.w 184,3040
	dc.w 184,3200
	dc.w 184,3360
	dc.w 184,3520
	dc.w 184,3680
	dc.w 184,3840
	dc.w 184,4000
	dc.w 184,4160
	dc.w 184,4320
	dc.w 184,4480
	dc.w 184,4640
	dc.w 184,4800
	dc.w 184,4960
	dc.w 184,5120
	dc.w 184,5280
	dc.w 184,5440
	dc.w 184,5600
	dc.w 184,5760
	dc.w 184,5920
	dc.w 184,6080
	dc.w 188,6240
	dc.w 188,6400
	dc.w 188,6560
	dc.w 188,6720
	dc.w 188,6880
	dc.w 188,7040
	dc.w 188,7200
	dc.w 188,7360
	dc.w 188,7520
	dc.w 188,7680
	dc.w 188,7840
	dc.w 188,8000
	dc.w 188,8160
	dc.w 188,8320
	dc.w 188,8480
	dc.w 188,8640
	dc.w 188,8800
	dc.w 188,8960
	dc.w 188,9120
	dc.w 188,9280
	dc.w 188,9440
	dc.w 188,9600
	dc.w 188,9760
	dc.w 188,9920
	dc.w 188,10080
	dc.w 188,10240
	dc.w 192,10400
	dc.w 192,10560
	dc.w 192,10720
	dc.w 192,10880
	dc.w 192,11040
	dc.w 192,11200
	dc.w 192,11360
	dc.w 192,11520
	dc.w 192,11680
	dc.w 192,11840
	dc.w 192,12000
	dc.w 192,12160
	dc.w 192,12320
	dc.w 192,12480
	dc.w 192,12640
	dc.w 192,12800
	dc.w 192,12960
	dc.w 192,13120
	dc.w 192,13280
	dc.w 192,13440
	dc.w 192,13600
	dc.w 192,13760
	dc.w 192,13920
	dc.w 192,14080
	dc.w 192,14240
	dc.w 192,14400
	dc.w 192,14560
	dc.w 192,14720
	dc.w 192,14880
	dc.w 192,15040
	dc.w 196,15200
	dc.w 196,15360
	dc.w 196,15520
	dc.w 196,15680
	dc.w 196,15840
	dc.w 196,16000
	dc.w 196,16160
	dc.w 196,16320
	dc.w 196,16480
	dc.w 196,16640
	dc.w 196,16800
	dc.w 196,16960
	dc.w 196,17120
	dc.w 196,17280
	dc.w 196,17440
	dc.w 196,17600
	dc.w 196,17760
	dc.w 196,17920
	dc.w 196,18080
	dc.w 196,18240
	dc.w 196,18400
	dc.w 196,18560
	dc.w 196,18720
	dc.w 196,18880
	dc.w 196,19040
	dc.w 196,19200
	dc.w 196,19360
	dc.w 196,19520
	dc.w 200,19680
	dc.w 200,19840
	dc.w 200,20000
	dc.w 200,20160
	dc.w 200,20320
	dc.w 200,20480
	dc.w 200,20640
	dc.w 200,20800
	dc.w 200,20960
	dc.w 200,21120
	dc.w 200,21280
	dc.w 200,21440
	dc.w 200,21600
	dc.w 200,21760
	dc.w 200,21920
	dc.w 200,22080
	dc.w 200,22240
	dc.w 204,22400
	dc.w 204,22560
	dc.w 204,22720
	dc.w 204,22880
	dc.w 204,23040
	dc.w 204,23200
	dc.w 204,23360
	dc.w 204,23520
	dc.w 204,23680
	dc.w 204,23840
	dc.w 204,24000
	dc.w 204,24160
	dc.w 204,24320
	dc.w 208,24480
	dc.w 208,24640
	dc.w 208,24800
	dc.w 208,24960
	dc.w 208,25120
	dc.w 208,25280
	dc.w 208,25440
	dc.w 208,25600
	dc.w 212,25760
	dc.w 212,25920
	dc.w 212,26080
	dc.w 212,26240
	dc.w 212,26400
	dc.w 212,26560
	dc.w 212,26720
	dc.w 212,26880
	dc.w 216,27040
	dc.w 220,27040
	dc.w 224,26880
	dc.w 224,26720
	dc.w 224,26560
	dc.w 224,26400
	dc.w 224,26240
	dc.w 224,26080
	dc.w 224,25920
	dc.w 224,25760
	dc.w 224,25600
	dc.w 224,25440
	dc.w 228,25280
	dc.w 228,25120
	dc.w 228,24960
	dc.w 228,24800
	dc.w 228,24640
	dc.w 228,24480
	dc.w 228,24320
	dc.w 232,24160
	dc.w 232,24000
	dc.w 232,23840
	dc.w 232,23680
	dc.w 232,23520
	dc.w 232,23360
	dc.w 232,23200
	dc.w 232,23040
	dc.w 232,22880
	dc.w 236,22720
	dc.w 236,22560
	dc.w 236,22400
	dc.w 236,22240
	dc.w 236,22080
	dc.w 236,21920
	dc.w 236,21760
	dc.w 236,21600
	dc.w 236,21440
	dc.w 236,21280
	dc.w 236,21120
	dc.w 240,20960
	dc.w 240,20800
	dc.w 240,20640
	dc.w 240,20480
	dc.w 240,20320
	dc.w 240,20160
	dc.w 240,20000
	dc.w 240,19840
	dc.w 240,19680
	dc.w 240,19520
	dc.w 240,19360
	dc.w 240,19200
	dc.w 244,19040
	dc.w 244,18880
	dc.w 244,18720
	dc.w 244,18560
	dc.w 244,18400
	dc.w 244,18240
	dc.w 244,18080
	dc.w 244,17920
	dc.w 248,17760
	dc.w 248,17600
	dc.w 248,17440
	dc.w 248,17280
	dc.w 252,17120
	dc.w 256,16960
	dc.w 260,16960
	dc.w 264,17120
	dc.w 268,17280
	dc.w 268,17440
	dc.w 268,17600
	dc.w 268,17760
	dc.w 268,17920
	dc.w 268,18080
	dc.w 272,18240
	dc.w 272,18400
	dc.w 276,18560
	dc.w 280,18400
	dc.w 280,18240
	dc.w 280,18080
	dc.w 280,17920
	dc.w 280,17760
	dc.w 280,17600
	dc.w 280,17440
	dc.w 280,17280
	dc.w 280,17120
	dc.w 280,16960
	dc.w 280,16800
	dc.w 280,16640
	dc.w 280,16480
	dc.w 280,16320
	dc.w 280,16160
	dc.w 280,16000
	dc.w 280,15840
	dc.w 280,15680
	dc.w 284,15520
	dc.w 284,15360
	dc.w 284,15200
	dc.w 284,15040
	dc.w 284,14880
	dc.w 284,14720
	dc.w 284,14560
	dc.w 288,14400
	dc.w 288,14240
	dc.w 288,14080
	dc.w 288,13920
	dc.w 288,13760
	dc.w 288,13600
	dc.w 292,13440
	dc.w 292,13280
	dc.w 292,13120
	dc.w 292,12960
	dc.w 292,12800
	dc.w 296,12640
	dc.w 296,12480
	dc.w 296,12320
	dc.w 296,12160
	dc.w 300,12000
	dc.w 300,11840
	dc.w 300,11680
	dc.w 304,11520
	dc.w 308,11360
	dc.w 312,11360
	dc.w 316,11520
	dc.w 320,11680
	dc.w 320,11840
	dc.w 320,12000
	dc.w 324,12160
	dc.w 324,12320
	dc.w 324,12480
	dc.w 328,12640
	dc.w 328,12800
	dc.w 328,12960
	dc.w 332,13120
	dc.w 332,13280
	dc.w 332,13440
	dc.w 332,13600
	dc.w 336,13760
	dc.w 336,13920
	dc.w 336,14080
	dc.w 336,14240
	dc.w 336,14400
	dc.w 340,14560
	dc.w 340,14720
	dc.w 340,14880
	dc.w 340,15040
	dc.w 340,15200
	dc.w 344,15360
	dc.w 344,15520
	dc.w 344,15680
	dc.w 344,15840
	dc.w 348,16000
	dc.w 348,16160
	dc.w 348,16320
	dc.w 348,16480
	dc.w 348,16640
	dc.w 352,16800
	dc.w 352,16960
	dc.w 352,17120
	dc.w 352,17280
	dc.w 352,17440
	dc.w 352,17600
	dc.w 356,17760
	dc.w 356,17920
	dc.w 356,18080
	dc.w 356,18240
	dc.w 356,18400
	dc.w 360,18560
	dc.w 364,18400
	dc.w 364,18240
	dc.w 368,18080
	dc.w 372,17920
	dc.w 372,17760
	dc.w 372,17600
	dc.w 376,17440
	dc.w 380,17280
	dc.w 384,17280
	dc.w 388,17280
	dc.w 392,17280
	dc.w 396,17440
	dc.w 396,17600
	dc.w 400,17760
	dc.w 404,17920
	dc.w 408,18080
	dc.w 412,18240
	dc.w 412,18400


	dc.w	0,0
	REPT 15
		dc.w	0
	ENDR

;	dc.w 416,18560			; 516 normal (18560) again
;	dc.w 420,18560
;	dc.w 424,18560
;	dc.w 428,18560
;	dc.w 432,18560
;	dc.w 436,18560
;	dc.w 440,18560
;	dc.w 444,18560
;	dc.w 448,18560
;	dc.w 452,18560
;	dc.w 456,18560
;	dc.w 460,18560
;	dc.w 464,18560
;	dc.w 468,18560
;	dc.w 472,18560
;	dc.w 476,18560
;	dc.w 480,18560
;	dc.w 484,18560
;	dc.w 488,18560
;	dc.w 492,18560
;	dc.w 496,18560
;	dc.w 500,18560
;	dc.w 504,18560
;	dc.w 508,18560
;	dc.w 512,18560
;	dc.w 516,18560
;	dc.w 520,18560
;	dc.w 524,18560
;	dc.w 528,18560
;	dc.w 532,18560
;	dc.w 536,18560
;	dc.w 540,18560
;	dc.w 544,18560
;	dc.w 548,18560
;	dc.w 552,18560
;	dc.w 556,18560
;	dc.w 560,18560
;	dc.w 564,18560
;	dc.w 568,18560
;	dc.w 572,18560
;	dc.w 576,18560
;	dc.w 580,18560
;	dc.w 584,18560
;	dc.w 588,18560
;	dc.w 592,18560
;	dc.w 596,18560
;	dc.w 600,18560
;	dc.w 604,18560
;	dc.w 608,18560
;	dc.w 612,18560
;	dc.w 616,18560
;	dc.w 620,18560
;	dc.w 624,18560
;	dc.w 628,18560
;	dc.w 632,18560
;	dc.w 636,18560
;	dc.w 640,18560
;	dc.w 644,18560
;	dc.w 648,18560
;	dc.w 652,18560
;	dc.w 656,18560
;	dc.w 660,18560
;	dc.w 664,18560
;	dc.w 668,18560
;	dc.w 672,18560
;	dc.w 676,18560
;	dc.w 680,18560
;	dc.w 684,18560
;	dc.w 688,18560
;	dc.w 692,18560
;	dc.w 696,18560
;	dc.w 700,18560
;	dc.w 704,18560
;	dc.w 708,18560
;	dc.w 712,18560
;	dc.w 716,18560
;	dc.w 720,18560
;	dc.w 724,18560
;	dc.w 728,18560
;	dc.w 732,18560
;	dc.w 736,18560
;	dc.w 740,18560
;	dc.w 744,18560
;	dc.w 748,18560
;	dc.w 752,18560
;	dc.w 756,18560
;	dc.w 760,18560
;	dc.w 764,18560
;	dc.w 768,18560
;	dc.w 772,18560
;	dc.w 776,18560
;	dc.w 780,18560
;	dc.w 784,18560
;	dc.w 788,18560
;	dc.w 792,18560
;	dc.w 796,18560
;	dc.w 800,18560
;	dc.w 804,18560
;	dc.w 808,18560
;	dc.w 812,18560
;	dc.w 816,18560
;	dc.w 820,18560
;	dc.w 824,18560
;	dc.w 828,18560		623-520 = 103+111 = 	515+13+	214		
;x set 832
;	REPT 111
;		dc.w	x,18560
;x set x+4
;	ENDR
;	dc.w	-1,-1
