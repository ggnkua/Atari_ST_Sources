    dc.w    1       ;0
    dc.w    3       ;1
    dc.w    3       ;2
    dc.w    3       ;3
    dc.w    3       ;4
    dc.w    3       ;5
    dc.w    3       ;6
    dc.w    3       ;7
    dc.w    3       ;8
    dc.w    3       ;9
    dc.w    3       ;10
    dc.w    3       ;11
    dc.w    4-1      ;12     one zer0
    dc.w    3       ;13
    dc.w    3       ;14
    dc.w    3       ;15
    dc.w    3       ;16
    dc.w    3       ;17
    dc.w    5       ;18
    dc.w    5       ;19
    dc.w    4       ;20
    dc.w    4       ;21
    dc.w    3       ;22
    dc.w    3       ;23
    dc.w    3       ;24
    dc.w    3       ;25
    dc.w    3       ;26
    dc.w    3       ;27
    dc.w    3       ;28
    dc.w    3       ;29
    dc.w    3-1       ;30 one zero
    dc.w    2       ;31
    dc.w    2       ;32
    dc.w    2       ;33
    dc.w    2       ;34
    dc.w    3       ;35
    dc.w    3       ;36
    dc.w    3-1       ;37 one zero
    dc.w    2       ;38
    dc.w    2       ;39
    dc.w    3       ;40
    dc.w    3       ;41
    dc.w    2       ;42
    dc.w    2       ;43
    dc.w    2       ;44
    dc.w    2       ;45
    dc.w    2       ;46
    dc.w    1       ;47
    dc.w    -1,-1