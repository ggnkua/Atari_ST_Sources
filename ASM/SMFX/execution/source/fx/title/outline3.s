	dc.w 9024,$4000
	dc.w 9024,$2000
	dc.w 9024,$1000
	dc.w 9024,$800
	dc.w 9024,$400
	dc.w 9024,$200
	dc.w 9024,$100
	dc.w 9024,$80
	dc.w 9024,$40
	dc.w 9024,$20
	dc.w 9024,$10
	dc.w 9024,$8
	dc.w 9024,$4
	dc.w 9024,$2
	dc.w 9024,$1
	dc.w 9032,$8000
	dc.w 9032,$4000
	dc.w 9032,$2000
	dc.w 9032,$1000
	dc.w 9032,$800
	dc.w 9032,$400
	dc.w 9032,$200
	dc.w 9032,$100
	dc.w 9032,$80
	dc.w 9032,$40
	dc.w 9032,$20
	dc.w 9032,$10
	dc.w 9032,$8
	dc.w 9032,$4
	dc.w 9192,$4
	dc.w 9352,$4
	dc.w 9512,$4
	dc.w 9672,$4
	dc.w 9832,$4
	dc.w 9992,$4
	dc.w 10152,$4
	dc.w 10152,$8
	dc.w 10152,$10
	dc.w 10152,$20
	dc.w 10152,$40
	dc.w 10152,$80
	dc.w 10152,$100
	dc.w 10152,$200
	dc.w 10152,$400
	dc.w 10152,$800
	dc.w 10152,$1000
	dc.w 10312,$1000
	dc.w 10472,$1000
	dc.w 10632,$1000
	dc.w 10792,$1000
	dc.w 10792,$800
	dc.w 10792,$400
	dc.w 10792,$200
	dc.w 10792,$100
	dc.w 10792,$80
	dc.w 10792,$40
	dc.w 10792,$20
	dc.w 10792,$10
	dc.w 10792,$8
	dc.w 10792,$4
	dc.w 10792,$2
	dc.w 10792,$1
	dc.w 10800,$8000
	dc.w 10800,$4000
	dc.w 10800,$2000
	dc.w 10800,$1000
	dc.w 10800,$800
	dc.w 10800,$400
	dc.w 10800,$200
	dc.w 10800,$100
	dc.w 10800,$80
	dc.w 10800,$40
	dc.w 10800,$20
	dc.w 10800,$10
	dc.w 10800,$8
	dc.w 10800,$4
	dc.w 10800,$2
	dc.w 10800,$1
	dc.w 10808,$8000
	dc.w 10808,$4000
	dc.w 10808,$2000
	dc.w 10808,$1000
	dc.w 10808,$800
	dc.w 10808,$400
	dc.w 10808,$200
	dc.w 10808,$100
	dc.w 10808,$80
	dc.w 10808,$40
	dc.w 10808,$20
	dc.w 10808,$10
	dc.w 10808,$8
	dc.w 10808,$4
	dc.w 10808,$2
	dc.w 10808,$1
	dc.w 10816,$8000
	dc.w 10816,$4000
	dc.w 10816,$2000
	dc.w 10816,$1000
	dc.w 10816,$800
	dc.w 10816,$400
	dc.w 10816,$200
	dc.w 10816,$100
	dc.w 10816,$80
	dc.w 10816,$40
	dc.w 10816,$20
	dc.w 10816,$10
	dc.w 10816,$8
	dc.w 10816,$4
	dc.w 10816,$2
	dc.w 10816,$1
	dc.w 10824,$8000
	dc.w 10824,$4000
	dc.w 10824,$2000
	dc.w 10824,$1000
	dc.w 10824,$800
	dc.w 10824,$400
	dc.w 10824,$200
	dc.w 10824,$100
	dc.w 10824,$80
	dc.w 10824,$40
	dc.w 10824,$20
	dc.w 10824,$10
	dc.w 10824,$8
	dc.w 10824,$4
	dc.w 10824,$2
	dc.w 10824,$1
	dc.w 10832,$8000
	dc.w 10832,$4000
	dc.w 10832,$2000
	dc.w 10832,$1000
	dc.w 10832,$800
	dc.w 10832,$400
	dc.w 10832,$200
	dc.w 10832,$100
	dc.w 10832,$80
	dc.w 10832,$40
	dc.w 10832,$20
	dc.w 10832,$10
	dc.w 10832,$8
	dc.w 10832,$4
	dc.w 10832,$2
	dc.w 10832,$1
	dc.w 10840,$8000
	dc.w 10840,$4000
	dc.w 10840,$2000
	dc.w 10840,$1000
	dc.w 10840,$800
	dc.w 10840,$400
	dc.w 10840,$200
	dc.w 10840,$80
	dc.w 10840,$100
	dc.w 10840,$40
	dc.w 10840,$20
	dc.w 10680,$20
	dc.w 10520,$20
	dc.w 10360,$20
	dc.w 10200,$20
	dc.w 10040,$20
	dc.w 9880,$20
	dc.w 9720,$20
	dc.w 9720,$10
	dc.w 9720,$8
	dc.w 9720,$4
	dc.w 9720,$2
	dc.w 9720,$1
	dc.w 9728,$8000
	dc.w 9728,$4000
	dc.w 9728,$2000
	dc.w 9728,$1000
	dc.w 9728,$800
	dc.w 9728,$400
	dc.w 9728,$200
	dc.w 9728,$100
	dc.w 9728,$80
	dc.w 9728,$40
	dc.w 9728,$20
	dc.w 9728,$10
	dc.w 9728,$8
	dc.w 9728,$4
	dc.w 9728,$2
	dc.w 9728,$1
	dc.w 9736,$8000
	dc.w 9736,$4000
	dc.w 9736,$2000
	dc.w 9736,$1000
	dc.w 9736,$800
	dc.w 9736,$400
	dc.w 9736,$200
	dc.w 9736,$100
	dc.w 9736,$80
	dc.w 9576,$80
	dc.w 9416,$80
	dc.w 9256,$80
	dc.w 9096,$80
	dc.w 9096,$40
	dc.w 9096,$20
	dc.w 9096,$10
	dc.w 9096,$8
	dc.w 9096,$4
	dc.w 9096,$2
	dc.w 9096,$1
	dc.w 9104,$8000
	dc.w 9104,$4000
	dc.w 9104,$2000
	dc.w 9104,$1000
	dc.w 9104,$800
	dc.w 9104,$400
	dc.w 9104,$200
	dc.w 9104,$100
	dc.w 9104,$80
	dc.w 9104,$40
	dc.w 9104,$20
	dc.w 9104,$10
	dc.w 9104,$8
	dc.w 9104,$4
	dc.w 9104,$2
	dc.w 9104,$1
	dc.w 9112,$8000
	dc.w 9112,$4000
	dc.w 9112,$2000
	dc.w 9112,$1000
	dc.w 9112,$800
	dc.w 9112,$400
	dc.w 9112,$200
	dc.w 9112,$100
	dc.w 9112,$80
	dc.w 9112,$40
	dc.w 9112,$20
	dc.w 9112,$10
	dc.w 9272,$10
	dc.w 9432,$10
	dc.w 9592,$10
	dc.w 9752,$10
	dc.w 9912,$10
	dc.w 10072,$10
	dc.w 10232,$10
	dc.w -1,-1
	dc.w 10392,$10
	dc.w 10552,$10
	dc.w 10712,$10
	dc.w 10872,$10
	dc.w 11032,$10
	dc.w 11192,$10
	dc.w 11352,$10
	dc.w 11512,$10
	dc.w 11672,$10
	dc.w 11832,$10
	dc.w 11992,$10
	dc.w 12152,$10
	dc.w 12312,$10
	dc.w 12472,$10
	dc.w 12632,$10
	dc.w 12632,$20
	dc.w 12632,$40
	dc.w 12632,$80
	dc.w 12632,$100
	dc.w 12792,$100
	dc.w 12952,$100
	dc.w 13112,$100
	dc.w 13272,$100
	dc.w 13432,$100
	dc.w 13432,$200
	dc.w 13432,$400
	dc.w 13432,$800
	dc.w 13432,$1000
	dc.w 13592,$1000
	dc.w 13752,$1000
	dc.w 13912,$1000
	dc.w 14072,$1000
	dc.w 14232,$1000
	dc.w 14392,$1000
	dc.w 14552,$1000
	dc.w 14712,$1000
	dc.w 14872,$1000
	dc.w 15032,$1000
	dc.w 15192,$1000
	dc.w 15192,$800
	dc.w 15192,$400
	dc.w 15192,$200
	dc.w 15192,$100
	dc.w 15352,$100
	dc.w 15512,$100
	dc.w 15672,$100
	dc.w 15832,$100
	dc.w 15992,$100
	dc.w 16152,$100
	dc.w 16312,$100
	dc.w 16312,$80
	dc.w 16312,$40
	dc.w 16312,$20
	dc.w 16312,$10
	dc.w 16312,$8
	dc.w 16472,$8
	dc.w 16632,$8
	dc.w 16792,$8
	dc.w 16952,$8
	dc.w 17112,$8
	dc.w 17272,$8
	dc.w 17272,$4
	dc.w 17272,$2
	dc.w 17272,$1
	dc.w 9024,$8000
	dc.w 9016,$1
	dc.w 9016,$2
	dc.w 9016,$4
	dc.w 9016,$8
	dc.w 9016,$10
	dc.w 9016,$20
	dc.w 9016,$40
	dc.w 9016,$80
	dc.w 9016,$100
	dc.w 9016,$200
	dc.w 9016,$400
	dc.w 9016,$800
	dc.w 9016,$1000
	dc.w 9016,$2000
	dc.w 9016,$4000
	dc.w 9016,$8000
	dc.w 9008,$1
	dc.w 9008,$2
	dc.w 9008,$4
	dc.w 9008,$8
	dc.w 9008,$10
	dc.w 9008,$20
	dc.w 9008,$40
	dc.w 9008,$80
	dc.w 9008,$100
	dc.w 9008,$200
	dc.w 9008,$400
	dc.w 9168,$400
	dc.w 9328,$400
	dc.w 9488,$400
	dc.w 9648,$400
	dc.w 9808,$400
	dc.w 9968,$400
	dc.w 9968,$800
	dc.w 9968,$1000
	dc.w 9968,$2000
	dc.w 9968,$4000
	dc.w 9968,$8000
	dc.w 9960,$1
	dc.w 9960,$2
	dc.w 9960,$4
	dc.w 9960,$8
	dc.w 9960,$10
	dc.w 9960,$20
	dc.w 9960,$40
	dc.w 9960,$80
	dc.w 9960,$100
	dc.w 9960,$200
	dc.w 9960,$400
	dc.w 9960,$800
	dc.w 9960,$1000
	dc.w 9960,$2000
	dc.w 9960,$4000
	dc.w 9960,$8000
	dc.w 9952,$1
	dc.w 9952,$2
	dc.w 9952,$4
	dc.w 9952,$8
	dc.w 9952,$10
	dc.w 9952,$20
	dc.w 9952,$40
	dc.w 9952,$80
	dc.w 9952,$100
	dc.w 9952,$200
	dc.w 9952,$400
	dc.w 9952,$800
	dc.w 9952,$1000
	dc.w 9952,$2000
	dc.w 9952,$4000
	dc.w 9952,$8000
	dc.w 9944,$1
	dc.w 9944,$2
	dc.w 9944,$4
	dc.w 9944,$8
	dc.w 9944,$10
	dc.w 9944,$20
	dc.w 9944,$40
	dc.w 9944,$80
	dc.w 9944,$100
	dc.w 9944,$200
	dc.w 9944,$400
	dc.w 9784,$400
	dc.w 9624,$400
	dc.w 9464,$400
	dc.w 9304,$400
	dc.w 9144,$400
	dc.w 8984,$400
	dc.w 8984,$800
	dc.w 8984,$1000
	dc.w 8984,$2000
	dc.w 8984,$4000
	dc.w 8984,$8000
	dc.w 8976,$1
	dc.w 8976,$2
	dc.w 8976,$4
	dc.w 8976,$8
	dc.w 8976,$10
	dc.w 8976,$20
	dc.w 8976,$40
	dc.w 8976,$80
	dc.w 8976,$100
	dc.w 8976,$200
	dc.w 8976,$400
	dc.w 8976,$800
	dc.w 8976,$1000
	dc.w 8976,$2000
	dc.w 8976,$4000
	dc.w 8976,$8000
	dc.w 8968,$1
	dc.w 8968,$2
	dc.w 8968,$4
	dc.w 9128,$4
	dc.w 9288,$4
	dc.w 9448,$4
	dc.w 9608,$4
	dc.w 9768,$4
	dc.w 9928,$4
	dc.w 9928,$8
	dc.w 9928,$10
	dc.w 9928,$20
	dc.w 9928,$40
	dc.w 9928,$80
	dc.w 9928,$100
	dc.w 9928,$200
	dc.w 9928,$400
	dc.w 9928,$800
	dc.w 9928,$1000
	dc.w 9928,$2000
	dc.w 9928,$4000
	dc.w 9928,$8000
	dc.w 9920,$1
	dc.w 9920,$2
	dc.w 10080,$2
	dc.w 10240,$2
	dc.w 10400,$2
	dc.w 10560,$2
	dc.w 10720,$2
	dc.w 10880,$2
	dc.w 10880,$4
	dc.w 10880,$8
	dc.w 10880,$10
	dc.w 10880,$20
	dc.w 10880,$40
	dc.w 10880,$80
	dc.w 10880,$100
	dc.w 10880,$200
	dc.w 10880,$400
	dc.w 10880,$800
	dc.w 11040,$800
	dc.w 11200,$800
	dc.w 11360,$800
	dc.w 11520,$800
	dc.w 11680,$800
	dc.w 11840,$800
	dc.w 12000,$800
	dc.w 12160,$800
	dc.w 12320,$800
	dc.w 12480,$800
	dc.w 12640,$800
	dc.w 12800,$800
	dc.w 12960,$800
	dc.w 13120,$800
	dc.w 13120,$400
	dc.w 13120,$200
	dc.w 13120,$100
	dc.w 13120,$80
	dc.w 13120,$40
	dc.w 13120,$20
	dc.w 13280,$20
	dc.w 13440,$20
	dc.w 13600,$20
	dc.w 13760,$20
	dc.w -1,-1
	dc.w 13920,$20
	dc.w 14080,$20
	dc.w 14240,$20
	dc.w 14400,$20
	dc.w 14400,$40
	dc.w 14400,$80
	dc.w 14400,$100
	dc.w 14400,$200
	dc.w 14400,$400
	dc.w 14400,$800
	dc.w 14560,$800
	dc.w 14720,$800
	dc.w 14880,$800
	dc.w 15040,$800
	dc.w 15200,$800
	dc.w 15360,$800
	dc.w 15520,$800
	dc.w 15680,$800
	dc.w 15840,$800
	dc.w 16000,$800
	dc.w 16160,$800
	dc.w 16320,$800
	dc.w 16480,$800
	dc.w 16640,$800
	dc.w 16800,$800
	dc.w 16800,$1000
	dc.w 16800,$2000
	dc.w 16800,$4000
	dc.w 16800,$8000
	dc.w 16960,$8000
	dc.w 17120,$8000
	dc.w 17280,$8000
	dc.w 17440,$8000
	dc.w 17600,$8000
	dc.w 17760,$8000
	dc.w 17920,$8000
	dc.w 18080,$8000
	dc.w 18240,$8000
	dc.w 18400,$8000
	dc.w 18560,$8000
	dc.w 18720,$8000
	dc.w 18880,$8000
	dc.w 19040,$8000
	dc.w 19200,$8000
	dc.w 19360,$8000
	dc.w 19520,$8000
	dc.w 19680,$8000
	dc.w 19840,$8000
	dc.w 20000,$8000
	dc.w 20160,$8000
	dc.w 20320,$8000
	dc.w 20480,$8000
	dc.w 20640,$8000
	dc.w 20800,$8000
	dc.w 20800,$4000
	dc.w 20800,$2000
	dc.w 20800,$1000
	dc.w 20800,$800
	dc.w 20800,$400
	dc.w 20800,$200
	dc.w 20800,$100
	dc.w 20800,$80
	dc.w 20800,$40
	dc.w 20800,$20
	dc.w 20800,$10
	dc.w 20800,$8
	dc.w 20800,$4
	dc.w 20800,$2
	dc.w 20800,$1
	dc.w 20808,$8000
	dc.w 20808,$4000
	dc.w 20808,$2000
	dc.w 20808,$1000
	dc.w 20808,$800
	dc.w 20808,$400
	dc.w 20808,$200
	dc.w 20808,$100
	dc.w 20808,$80
	dc.w 20808,$40
	dc.w 20808,$20
	dc.w 20808,$10
	dc.w 20808,$8
	dc.w 20968,$8
	dc.w 21128,$8
	dc.w 21288,$8
	dc.w 21448,$8
	dc.w 21448,$4
	dc.w 21448,$2
	dc.w 21448,$1
	dc.w 21456,$8000
	dc.w 21456,$4000
	dc.w 21456,$2000
	dc.w 21456,$1000
	dc.w 21456,$800
	dc.w 21456,$400
	dc.w 21456,$200
	dc.w 21456,$100
	dc.w 21456,$80
	dc.w 21456,$40
	dc.w 21456,$20
	dc.w 21456,$10
	dc.w 21456,$8
	dc.w 21456,$4
	dc.w 21456,$2
	dc.w 21456,$1
	dc.w 21464,$8000
	dc.w 21464,$4000
	dc.w 21464,$2000
	dc.w 21464,$1000
	dc.w 21464,$800
	dc.w 21464,$400
	dc.w 21464,$200
	dc.w 21464,$100
	dc.w 21464,$80
	dc.w 21464,$40
	dc.w 21464,$20
	dc.w 21464,$10
	dc.w 21464,$8
	dc.w 21624,$8
	dc.w 21784,$8
	dc.w 21944,$8
	dc.w 22104,$8
	dc.w 22264,$8
	dc.w 22264,$4
	dc.w 22264,$2
	dc.w 22264,$1
	dc.w 22272,$8000
	dc.w 21752,$8000
	dc.w 21744,$1
	dc.w 21744,$2
	dc.w 21744,$4
	dc.w 21744,$8
	dc.w 21744,$10
	dc.w 21744,$20
	dc.w 21744,$40
	dc.w 21744,$80
	dc.w 21744,$100
	dc.w 21744,$200
	dc.w 21584,$200
	dc.w 21424,$200
	dc.w 21264,$200
	dc.w 21104,$200
	dc.w 20944,$200
	dc.w 20944,$400
	dc.w 20944,$800
	dc.w 20944,$1000
	dc.w 20944,$2000
	dc.w 20944,$4000
	dc.w 20944,$8000
	dc.w 20936,$1
	dc.w 20936,$2
	dc.w 20936,$4
	dc.w 20936,$8
	dc.w 20936,$10
	dc.w 20936,$20
	dc.w 20936,$40
	dc.w 20936,$80
	dc.w 20936,$100
	dc.w 20936,$200
	dc.w 20936,$400
	dc.w 20776,$400
	dc.w 20616,$400
	dc.w 20456,$400
	dc.w 20296,$400
	dc.w 20296,$800
	dc.w 20296,$1000
	dc.w 20296,$2000
	dc.w 20296,$4000
	dc.w 20296,$8000
	dc.w 20288,$1
	dc.w 20448,$1
	dc.w 20608,$1
	dc.w 20768,$1
	dc.w 20928,$1
	dc.w 21088,$1
	dc.w 21248,$1
	dc.w 21408,$1
	dc.w 21568,$1
	dc.w 21728,$1
	dc.w 21888,$1
	dc.w 22048,$1
	dc.w 22208,$1
	dc.w 22368,$1
	dc.w 22528,$1
	dc.w 22528,$2
	dc.w 22528,$4
	dc.w 22528,$8
	dc.w 22528,$10
	dc.w 22528,$20
	dc.w 22528,$40
	dc.w 22528,$80
	dc.w 22528,$100
	dc.w 22528,$200
	dc.w 22528,$400
	dc.w 22528,$800
	dc.w 22528,$1000
	dc.w 22528,$2000
	dc.w 22528,$4000
	dc.w 22528,$8000
	dc.w 22520,$1
	dc.w 22520,$2
	dc.w 22520,$4
	dc.w 22360,$4
	dc.w 22200,$4
	dc.w 22040,$4
	dc.w 21880,$4
	dc.w 21720,$4
	dc.w 21720,$8
	dc.w 21720,$10
	dc.w 21720,$20
	dc.w 21720,$40
	dc.w 21720,$80
	dc.w 21720,$100
	dc.w 21720,$200
	dc.w 21720,$400
	dc.w 21720,$800
	dc.w 21720,$1000
	dc.w 21720,$2000
	dc.w 21720,$4000
	dc.w 21720,$8000
	dc.w 21712,$1
	dc.w 21712,$2
	dc.w 21712,$4
	dc.w 21712,$8
	dc.w 21712,$10
	dc.w 21712,$20
	dc.w 21712,$40
	dc.w 21712,$80
	dc.w 21712,$100
	dc.w 21712,$200
	dc.w 21712,$400
	dc.w 21712,$800
	dc.w 21712,$1000
	dc.w 21712,$2000
	dc.w 21712,$4000
	dc.w -1,-1
	dc.w 21712,$8000
	dc.w 21704,$1
	dc.w 21704,$2
	dc.w 21704,$4
	dc.w 21704,$8
	dc.w 21704,$10
	dc.w 21704,$20
	dc.w 21704,$40
	dc.w 21704,$80
	dc.w 21704,$100
	dc.w 21704,$200
	dc.w 21704,$400
	dc.w 21704,$800
	dc.w 21704,$1000
	dc.w 21704,$2000
	dc.w 21704,$4000
	dc.w 21704,$8000
	dc.w 21864,$8000
	dc.w 22024,$8000
	dc.w 22184,$8000
	dc.w 22176,$1
	dc.w 22176,$2
	dc.w 22176,$4
	dc.w 22176,$8
	dc.w 22176,$10
	dc.w 22176,$20
	dc.w 22176,$40
	dc.w 22176,$80
	dc.w 22176,$100
	dc.w 22176,$200
	dc.w 22176,$400
	dc.w 22176,$800
	dc.w 22176,$1000
	dc.w 22176,$2000
	dc.w 22176,$4000
	dc.w 22176,$8000
	dc.w 22016,$8000
	dc.w 21856,$8000
	dc.w 21696,$8000
	dc.w 21536,$8000
	dc.w 21528,$1
	dc.w 21528,$4
	dc.w 21528,$2
	dc.w 21528,$8
	dc.w 21528,$10
	dc.w 21528,$20
	dc.w 21528,$40
	dc.w 21528,$80
	dc.w 21528,$100
	dc.w 21528,$200
	dc.w 21528,$400
	dc.w 21368,$400
	dc.w 21208,$400
	dc.w 21048,$400
	dc.w 20888,$400
	dc.w 20728,$400
	dc.w 20568,$400
	dc.w 20408,$400
	dc.w 20248,$400
	dc.w 20088,$400
	dc.w 19928,$400
	dc.w 19928,$800
	dc.w 19928,$1000
	dc.w 19928,$2000
	dc.w 19928,$4000
	dc.w 19928,$8000
	dc.w 19920,$1
	dc.w 19920,$2
	dc.w 19920,$4
	dc.w 19920,$8
	dc.w 19920,$10
	dc.w 19920,$20
	dc.w 19920,$40
	dc.w 19920,$80
	dc.w 19920,$100
	dc.w 19920,$200
	dc.w 19920,$400
	dc.w 19920,$800
	dc.w 20080,$800
	dc.w 20240,$800
	dc.w 20400,$800
	dc.w 20560,$800
	dc.w 20720,$800
	dc.w 20720,$1000
	dc.w 20720,$2000
	dc.w 20720,$4000
	dc.w 20720,$8000
	dc.w 20712,$1
	dc.w 20712,$2
	dc.w 20712,$4
	dc.w 20712,$8
	dc.w 20712,$10
	dc.w 20712,$20
	dc.w 20712,$40
	dc.w 20712,$80
	dc.w 20712,$100
	dc.w 20712,$200
	dc.w 20712,$400
	dc.w 20712,$800
	dc.w 20712,$1000
	dc.w 20712,$2000
	dc.w 20712,$4000
	dc.w 20712,$8000
	dc.w 20704,$1
	dc.w 20704,$2
	dc.w 20704,$4
	dc.w 20704,$8
	dc.w 20864,$8
	dc.w 21024,$8
	dc.w 21184,$8
	dc.w 21344,$8
	dc.w 21504,$8
	dc.w 21504,$10
	dc.w 21504,$20
	dc.w 21504,$40
	dc.w 21504,$80
	dc.w 21504,$100
	dc.w 21504,$200
	dc.w 21504,$400
	dc.w 21504,$800
	dc.w 21504,$1000
	dc.w 21504,$2000
	dc.w 21504,$4000
	dc.w 21504,$8000
	dc.w 21496,$1
	dc.w 21496,$2
	dc.w 21496,$4
	dc.w 21496,$8
	dc.w 21496,$10
	dc.w 21496,$20
	dc.w 21496,$40
	dc.w 21496,$80
	dc.w 21496,$100
	dc.w 21496,$200
	dc.w 21496,$400
	dc.w 21496,$800
	dc.w 21496,$1000
	dc.w 21496,$2000
	dc.w 21496,$4000
	dc.w 21496,$8000
	dc.w 21656,$8000
	dc.w 21816,$8000
	dc.w 21976,$8000
	dc.w 22136,$8000
	dc.w 22296,$8000
	dc.w 22288,$1
	dc.w 22288,$2
	dc.w 22288,$4
	dc.w 22288,$8
	dc.w 22288,$10
	dc.w 22288,$20
	dc.w 22288,$40
	dc.w 22288,$80
	dc.w 22288,$100
	dc.w 22288,$200
	dc.w 22288,$400
	dc.w 22288,$800
	dc.w 22288,$1000
	dc.w 22288,$2000
	dc.w 22288,$4000
	dc.w 22288,$8000
	dc.w 22280,$1
	dc.w 22280,$2
	dc.w 22280,$4
	dc.w 22280,$8
	dc.w 22280,$10
	dc.w 22280,$20
	dc.w 22280,$40
	dc.w 22280,$80
	dc.w 22280,$100
	dc.w 22280,$200
	dc.w 22280,$400
	dc.w 22280,$800
	dc.w 22280,$1000
	dc.w 22280,$2000
	dc.w 22280,$4000
	dc.w 22280,$8000
	dc.w 22272,$1
	dc.w 22272,$2
	dc.w 22272,$4
	dc.w 22272,$8
	dc.w 22272,$10
	dc.w 22272,$20
	dc.w 22272,$40
	dc.w 22272,$80
	dc.w 22272,$100
	dc.w 22272,$200
	dc.w 22272,$400
	dc.w 22272,$800
	dc.w 22272,$1000
	dc.w 22272,$2000
	dc.w 22272,$4000
	dc.w 21752,$4000
	dc.w 21752,$2000
	dc.w 21752,$1000
	dc.w 21752,$800
	dc.w 21752,$400
	dc.w 21752,$200
	dc.w 21752,$100
	dc.w 21752,$80
	dc.w 21752,$40
	dc.w 21592,$40
	dc.w 21432,$40
	dc.w 21272,$40
	dc.w 21112,$40
	dc.w 20952,$40
	dc.w 20952,$20
	dc.w 20952,$10
	dc.w 20952,$8
	dc.w 20952,$4
	dc.w 20952,$2
	dc.w 20952,$1
	dc.w 20792,$1
	dc.w 20632,$1
	dc.w 20472,$1
	dc.w 20312,$1
	dc.w 20152,$1
	dc.w 19992,$1
	dc.w 19832,$1
	dc.w 19672,$1
	dc.w 19512,$1
	dc.w 19352,$1
	dc.w 19192,$1
	dc.w 19032,$1
	dc.w 18872,$1
	dc.w 18712,$1
	dc.w 18552,$1
	dc.w 18392,$1
	dc.w 18232,$1
	dc.w 18072,$1
	dc.w 17912,$1
	dc.w 17752,$1
	dc.w 17592,$1
	dc.w 17432,$1
	dc.w -1,-1
