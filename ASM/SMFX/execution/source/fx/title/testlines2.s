	dc.w	-1,4,198,17632
	dc.w	-1,8,66,14784
	dc.w	-1,0,264,14328
	dc.w	-1,4,154,14832
	dc.w	-1,0,88,13648
	dc.w	-1,0,22,12568
	dc.w	-1,8,286,18824
	dc.w	-1,8,110,15648
	dc.w	-1,0,0,19480
	dc.w	-1,4,286,18112
	dc.w	-1,0,154,19256
	dc.w	-1,4,220,16072
	dc.w	-1,12,198,12704
	dc.w	-1,4,308,12984
	dc.w	-1,4,198,12256
	dc.w	-1,0,110,15384
	dc.w	-1,4,110,19616
	dc.w	-1,8,44,19776
	dc.w	-1,8,286,20136
	dc.w	-1,4,154,15560
	dc.w	-1,0,176,17192
	dc.w	-1,4,264,16744
	dc.w	-1,4,198,15256
	dc.w	-1,12,286,16064
	dc.w	-1,0,132,12424
	dc.w	-1,8,0,15240
	dc.w	-1,12,132,13176
	dc.w	-1,12,198,16616
	dc.w	-1,0,66,15608
	dc.w	-1,12,0,14768
	dc.w	-1,8,242,17368
	dc.w	-1,8,44,12104
	dc.w	-1,8,22,15872
	dc.w	-1,0,286,14848
	dc.w	-1,4,176,13952
	dc.w	-1,0,286,12680
	dc.w	-1,0,176,18856
	dc.w	-1,8,44,14120
	dc.w	-1,12,308,18632
	dc.w	-1,0,286,13856
	dc.w	-1,12,242,18536
	dc.w	-1,8,44,19160
	dc.w	-1,8,44,19792
	dc.w	-1,12,0,20136
	dc.w	-1,8,264,19552
	dc.w	-1,12,44,14688
	dc.w	-1,0,44,15232
	dc.w	-1,12,198,18520
	dc.w	-1,4,198,18688
	dc.w	-1,8,242,17824
	dc.w	-1,12,220,13072
	dc.w	-1,8,22,17808
	dc.w	-1,12,220,15488
	dc.w	-1,12,242,18688
	dc.w	-1,12,66,12600
	dc.w	-1,12,286,17472
	dc.w	-1,4,154,12192
	dc.w	-1,0,264,16616
	dc.w	-1,4,220,17952
	dc.w	-1,12,154,15464
	dc.w	-1,0,286,17088
	dc.w	-1,8,132,18944
	dc.w	-1,8,308,13992
	dc.w	-1,12,308,16840
	dc.w	-1,4,220,15288
	dc.w	-1,4,330,16592
	dc.w	-1,8,88,19744
	dc.w	-1,12,132,13080
	dc.w	-1,0,242,18352
	dc.w	-1,0,198,13872
	dc.w	-1,8,154,13816
	dc.w	-1,4,286,16432
	dc.w	-1,4,308,15160
	dc.w	-1,12,308,17360
	dc.w	-1,0,198,19656
	dc.w	-1,12,22,18920
	dc.w	-1,12,220,12136
	dc.w	-1,4,66,18192
	dc.w	-1,8,330,12824
	dc.w	-1,12,220,19408
	dc.w	-1,8,88,13032
	dc.w	-1,0,264,19912
	dc.w	-1,4,308,15736
	dc.w	-1,12,110,16592
	dc.w	-1,12,176,18120
	dc.w	-1,12,176,20080
	dc.w	-1,4,22,17008
	dc.w	-1,8,176,16688
	dc.w	-1,12,242,18264
	dc.w	-1,4,242,16440
	dc.w	-1,8,0,13528
	dc.w	-1,4,242,15248
	dc.w	-1,4,44,15704
	dc.w	-1,8,154,16832
	dc.w	-1,8,66,15568
	dc.w	-1,12,0,16728
	dc.w	-1,8,110,17480
	dc.w	-1,0,66,12584
	dc.w	-1,0,88,14960
	dc.w	-1,12,264,18448
	dc.w	-1,12,88,15128
	dc.w	-1,8,330,17800
	dc.w	-1,0,44,16136
	dc.w	-1,0,22,16456
	dc.w	-1,4,66,13360
	dc.w	-1,4,66,14336
	dc.w	-1,4,220,13192
	dc.w	-1,4,330,18296
	dc.w	-1,0,44,19648
	dc.w	-1,0,220,13008
	dc.w	-1,12,220,13936
	dc.w	-1,8,264,19712
	dc.w	-1,12,44,17664
	dc.w	-1,4,330,12440
	dc.w	-1,8,66,14584
	dc.w	-1,0,22,15416
	dc.w	-1,0,110,13976
	dc.w	-1,12,110,17232
	dc.w	-1,0,308,18504
	dc.w	-1,8,264,19456
	dc.w	-1,12,198,12520
	dc.w	-1,8,22,12848
	dc.w	-1,4,132,14632
	dc.w	-1,8,242,18352
	dc.w	-1,0,0,12984
	dc.w	-1,4,264,18944
	dc.w	-1,8,220,13168
	dc.w	-1,4,22,19728
	dc.w	-1,8,0,16208
	dc.w	-1,0,220,16544
	dc.w	-1,0,308,19128
	dc.w	-1,8,220,14984
	dc.w	-1,8,154,18264
	dc.w	-1,0,198,15968
	dc.w	-1,4,220,13536
	dc.w	-1,8,44,19584
	dc.w	-1,0,154,17808
	dc.w	-1,0,88,17792
	dc.w	-1,0,198,17872
	dc.w	-1,4,22,15976
	dc.w	-1,8,88,12112
	dc.w	-1,12,154,17632
	dc.w	-1,0,286,18520
	dc.w	-1,0,242,13952
	dc.w	-1,0,330,15720
	dc.w	-1,0,44,14944
	dc.w	-1,12,22,13296
	dc.w	-1,0,220,20104
	dc.w	-1,12,0,16272
	dc.w	-1,8,66,19616
	dc.w	-1,0,242,15864
	dc.w	-1,4,242,14168
	dc.w	-1,8,242,18528
	dc.w	-1,12,44,14336
	dc.w	-1,0,154,17824
	dc.w	-1,0,242,12936
	dc.w	-1,8,220,18280
	dc.w	-1,12,242,19168
	dc.w	-1,4,110,20120
	dc.w	-1,0,66,15312
	dc.w	-1,12,66,17400
	dc.w	-1,4,330,16248
	dc.w	-1,4,66,20072
	dc.w	-1,12,22,15776
	dc.w	-1,8,66,19440
	dc.w	-1,12,264,15736
	dc.w	-1,0,154,13320
	dc.w	-1,8,198,19936
	dc.w	-1,12,220,16024
	dc.w	-1,8,0,17896
	dc.w	-1,4,242,15400
	dc.w	-1,12,308,19600
	dc.w	-1,0,286,12664
	dc.w	-1,8,176,15472
	dc.w	-1,12,198,19936
	dc.w	-1,0,330,14848
	dc.w	-1,8,286,12352
	dc.w	-1,12,264,12832
	dc.w	-1,4,176,15408
	dc.w	-1,4,110,18480
	dc.w	-1,0,308,17072
	dc.w	-1,4,0,16384
	dc.w	-1,8,176,12752
	dc.w	-1,4,132,17776
	dc.w	-1,4,264,13312
	dc.w	-1,8,88,14696
	dc.w	-1,12,242,13800
	dc.w	-1,0,0,18288
	dc.w	-1,12,132,12376
	dc.w	-1,4,198,17936
	dc.w	-1,0,264,18800
	dc.w	-1,0,176,16712
	dc.w	-1,4,242,17400
	dc.w	-1,0,330,18680
	dc.w	-1,8,0,12432
	dc.w	-1,0,264,12456
	dc.w	-1,0,22,14328
	dc.w	-1,8,0,17392
	dc.w	-1,12,154,14736
	dc.w	-1,0,308,16536