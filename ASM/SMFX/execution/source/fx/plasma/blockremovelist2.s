	dc.w 52000,19328
	dc.w 48152,15480
	dc.w 6456,6552
	dc.w 2616,2712
	dc.w 11536,11632
	dc.w 32,128
	dc.w 62240,29568
	dc.w 63544,30872
	dc.w 32784,112
	dc.w 25632,25728
	dc.w 30736,30832
	dc.w 23048,23144
	dc.w 62232,29560
	dc.w 28160,28256
	dc.w 15392,15488
	dc.w 28168,28264
	dc.w 3880,3976
	dc.w 2576,2672
	dc.w 50720,18048
	dc.w 12800,12896
	dc.w 43064,10392
	dc.w 55832,23160
	dc.w 23096,23192
	dc.w 6424,6520
	dc.w 36624,3952
	dc.w 21808,21904
	dc.w 23080,23176
	dc.w 58392,25720
	dc.w 36608,3936
	dc.w 53280,20608
	dc.w 17928,18024
	dc.w 35360,2688
	dc.w 10272,10368
	dc.w 58384,25712
	dc.w 21760,21856
	dc.w 21784,21880
	dc.w 15360,15456
	dc.w 17920,18016
	dc.w 30728,30824
	dc.w 16640,16736
	dc.w 2568,2664
	dc.w 51976,19304
	dc.w 3872,3968
	dc.w 20512,20608
	dc.w 49408,16736
	dc.w 55856,23184
	dc.w 62208,29536
	dc.w 8976,9072
	dc.w 28192,28288
	dc.w 5136,5232
	dc.w 46872,14200
	dc.w 46904,14232
	dc.w 49456,16784
	dc.w 3864,3960
	dc.w 32800,128
	dc.w 29472,29568
	dc.w 24376,24472
	dc.w 54560,21888
	dc.w 45584,12912
	dc.w 2584,2680
	dc.w 54568,21896
	dc.w 6400,6496
	dc.w 63488,30816
	dc.w 43048,10376
	dc.w 23056,23152
	dc.w 23088,23184
	dc.w 30720,30816
	dc.w 7696,7792
	dc.w 10256,10352
	dc.w 39176,6504
	dc.w 15368,15464
	dc.w 6408,6504
	dc.w 29488,29584
	dc.w 49440,16768
	dc.w 48128,15456
	dc.w 39224,6552
	dc.w 30744,30840
	dc.w 20520,20616
	dc.w 40,136
	dc.w 12856,12952
	dc.w 1304,1400
	dc.w 28184,28280
	dc.w 55840,23168
	dc.w 11552,11648
	dc.w 10288,10384
	dc.w 46880,14208
	dc.w 29464,29560
	dc.w 60968,28296
	dc.w 58416,25744
	dc.w 57120,24448
	dc.w 11560,11656
	dc.w 59688,27016
	dc.w 1320,1416
	dc.w 40456,7784
	dc.w 35368,2696
	dc.w 5152,5248
	dc.w 58400,25728
	dc.w 26912,27008
	dc.w 24368,24464
	dc.w 19200,19296
	dc.w 39168,6496
	dc.w 43016,10344
	dc.w 58376,25704
	dc.w 3888,3984
	dc.w 2592,2688
	dc.w 60944,28272
	dc.w 50744,18072
	dc.w 34072,1400
	dc.w 15376,15472
	dc.w 1328,1424
	dc.w 41760,9088
	dc.w 26936,27032
	dc.w 20504,20600
	dc.w 37888,5216
	dc.w 25624,25720
	dc.w 34096,1424
	dc.w 26920,27016
	dc.w 57096,24424
	dc.w 41768,9096
	dc.w 49464,16792
	dc.w 43040,10368
	dc.w 41784,9112
	dc.w 17936,18032
	dc.w 37896,5224
	dc.w 24320,24416
	dc.w 16672,16768
	dc.w 30760,30856
	dc.w 35376,2704
	dc.w 29440,29536
	dc.w 48136,15464
	dc.w 45616,12944
	dc.w 34088,1416
	dc.w 6432,6528
	dc.w 11528,11624
	dc.w 10264,10360
	dc.w 16680,16776
	dc.w 12840,12936
	dc.w 14128,14224
	dc.w 51968,19296
	dc.w 50688,18016
	dc.w 39208,6536
	dc.w 8984,9080
	dc.w 59696,27024
	dc.w 36632,3960
	dc.w 43008,10336
	dc.w 7704,7800
	dc.w 21800,21896
	dc.w 24328,24424
	dc.w 24344,24440
	dc.w 30752,30848
	dc.w 40472,7800
	dc.w 9016,9112
	dc.w 45608,12936
	dc.w 21768,21864
	dc.w 11544,11640
	dc.w 26928,27024
	dc.w 60952,28280
	dc.w 45592,12920
	dc.w 15384,15480
	dc.w 25656,25752
	dc.w 16688,16784
	dc.w 53256,20584
	dc.w 63520,30848
	dc.w 5176,5272
	dc.w 39200,6528
	dc.w 24,120
	dc.w 14080,14176
	dc.w 63512,30840
	dc.w 39184,6512
	dc.w 25616,25712
	dc.w 54544,21872
	dc.w 2608,2704
	dc.w 23040,23136
	dc.w 16664,16760
	dc.w 17952,18048
	dc.w 55864,23192
	dc.w 60936,28264
	dc.w 5120,5216
	dc.w 34064,1392
	dc.w 46888,14216
	dc.w 45568,12896
	dc.w 59648,26976
	dc.w 57136,24464
	dc.w 3856,3952
	dc.w 6448,6544
	dc.w 53264,20592
	dc.w 60984,28312
	dc.w 36616,3944
	dc.w 21776,21872
	dc.w 57112,24440
	dc.w 36648,3976
	dc.w 14120,14216
	dc.w 24336,24432
	dc.w 46896,14224
	dc.w 59704,27032
	dc.w 50728,18056
	dc.w 7720,7816
	dc.w 39192,6520
	dc.w 14136,14232
	dc.w 35384,2712
	dc.w 48160,15488
	dc.w 37944,5272
	dc.w 14104,14200
	dc.w 19240,19336
	dc.w 50696,18024
	dc.w 48184,15512
	dc.w 19208,19304
	dc.w 40480,7808
	dc.w 62264,29592
	dc.w 59664,26992
	dc.w 62224,29552
	dc.w 9008,9104
	dc.w 62256,29584
	dc.w 55848,23176
	dc.w 17960,18056
	dc.w 3848,3944
	dc.w 43024,10352
	dc.w 56,152
	dc.w 49416,16744
	dc.w 49432,16760
	dc.w 7688,7784
	dc.w 37928,5256
	dc.w 48144,15472
	dc.w 12832,12928
	dc.w 60960,28288
	dc.w 44304,11632
	dc.w 52024,19352
	dc.w 29456,29552
	dc.w 40464,7792
	dc.w 10248,10344
	dc.w 25608,25704
	dc.w 2560,2656
	dc.w 25640,25736
	dc.w 17976,18072
	dc.w 15400,15496
	dc.w 24360,24456
	dc.w 8992,9088
	dc.w 20496,20592
	dc.w 20528,20624
	dc.w 16656,16752
	dc.w 40504,7832
	dc.w 55816,23144
	dc.w 8968,9064
	dc.w 48176,15504
	dc.w 26904,27000
	dc.w 32808,136
	dc.w 37904,5232
	dc.w 11568,11664
	dc.w 54536,21864
	dc.w 44336,11664
	dc.w 34080,1408
	dc.w 45624,12952
	dc.w 23072,23168
	dc.w 28208,28304
	dc.w 16648,16744
	dc.w 34104,1432
	dc.w 36640,3968
	dc.w 39216,6544
	dc.w 19256,19352
	dc.w 37936,5264
	dc.w 15416,15512
	dc.w 40496,7824
	dc.w 37920,5248
	dc.w 46848,14176
	dc.w 40488,7816
	dc.w 7728,7824
	dc.w 19224,19320
	dc.w 12824,12920
	dc.w 63496,30824
	dc.w 2600,2696
	dc.w 7736,7832
	dc.w 59680,27008
	dc.w 6440,6536
	dc.w 28176,28272
	dc.w 44328,11656
	dc.w 32824,152
	dc.w 41744,9072
	dc.w 46864,14192
	dc.w 44312,11640
	dc.w 20488,20584
	dc.w 48168,15496
	dc.w 51992,19320
	dc.w 51984,19312
	dc.w 16696,16792
	dc.w 29448,29544
	dc.w 43032,10360
	dc.w 35352,2680
	dc.w 53288,20616
	dc.w 45576,12904
	dc.w 12816,12912
	dc.w 16,112
	dc.w 35344,2672
	dc.w 57088,24416
	dc.w 19248,19344
	dc.w 49448,16776
	dc.w 50712,18040
	dc.w 24352,24448
	dc.w 26896,26992
	dc.w 3896,3992
	dc.w 29496,29592
	dc.w 60928,28256
	dc.w 23064,23160
	dc.w 1280,1376
	dc.w 6416,6512
	dc.w 8,104
	dc.w 54552,21880
	dc.w 62248,29576
	dc.w 44320,11648
	dc.w 54584,21912
	dc.w 57128,24456
	dc.w 1288,1384
	dc.w 55824,23152
	dc.w 54528,21856
	dc.w 9000,9096
	dc.w 15408,15504
	dc.w 63504,30832
	dc.w 63536,30864
	dc.w 46856,14184
	dc.w 55808,23136
	dc.w 10280,10376
	dc.w 14088,14184
	dc.w 25648,25744
	dc.w 41776,9104
	dc.w 5160,5256
	dc.w 59656,26984
	dc.w 57144,24472
	dc.w 14112,14208
	dc.w 32816,144
	dc.w 57104,24432
	dc.w 5168,5264
	dc.w 7712,7808
	dc.w 14096,14192
	dc.w 25600,25696
	dc.w 3840,3936
	dc.w 29480,29576
	dc.w 12848,12944
	dc.w 58408,25736
	dc.w 21816,21912
	dc.w 11520,11616
	dc.w 26880,26976
	dc.w 53304,20632
	dc.w 50704,18032
	dc.w 7680,7776
	dc.w 20536,20632
	dc.w 45600,12928
	dc.w 1336,1432
	dc.w 28216,28312
	dc.w 28200,28296
	dc.w 32768,96
	dc.w 62216,29544
	dc.w 34056,1384
	dc.w 41736,9064
	dc.w 19232,19328
	dc.w 44288,11616
	dc.w 50736,18064
	dc.w 44296,11624
	dc.w 48,144
	dc.w 41752,9080
	dc.w 20480,20576
	dc.w 43056,10384
	dc.w 40448,7776
	dc.w 36664,3992
	dc.w 54576,21904
	dc.w 12808,12904
	dc.w 36656,3984
	dc.w 58424,25752
	dc.w 35328,2656
	dc.w 60976,28304
	dc.w 30776,30872
	dc.w 21792,21888
	dc.w 53272,20600
	dc.w 0,96
	dc.w 5128,5224
	dc.w 5144,5240
	dc.w 17944,18040
	dc.w 32792,120
	dc.w 35336,2664
	dc.w 11576,11672
	dc.w 44344,11672
	dc.w 53248,20576
	dc.w 34048,1376
	dc.w 19216,19312
	dc.w 52016,19344
	dc.w 8960,9056
	dc.w 63528,30856
	dc.w 30768,30864
	dc.w 53296,20624
	dc.w 52008,19336
	dc.w 1312,1408
	dc.w 49424,16752
	dc.w 17968,18064
	dc.w 58368,25696
	dc.w 32776,104
	dc.w 59672,27000
	dc.w 10296,10392
	dc.w 37912,5240
	dc.w 26888,26984
	dc.w 10240,10336
	dc.w 41728,9056
	dc.w 1296,1392
