	dc.w	256
	dc.w	256
	dc.w	256
	dc.w	256
	dc.w	256
	dc.w	256
	dc.w	320
	dc.w	320
	dc.w	320
	dc.w	320
	dc.w	320
	dc.w	320
	dc.w	320
	dc.w	384
	dc.w	384
	dc.w	384
	dc.w	384
	dc.w	384
	dc.w	384
	dc.w	384
	dc.w	384
	dc.w	448
	dc.w	448
	dc.w	448
	dc.w	448
	dc.w	448
	dc.w	448
	dc.w	448
	dc.w	448
	dc.w	448
	dc.w	448
	dc.w	448
	dc.w	448
	dc.w	448
	dc.w	448
	dc.w	448
	dc.w	448
	dc.w	448
	dc.w	448
	dc.w	448
	dc.w	448
	dc.w	448
	dc.w	448
	dc.w	448
	dc.w	384
	dc.w	384
	dc.w	384
	dc.w	384
	dc.w	384
	dc.w	384
	dc.w	384
	dc.w	384
	dc.w	320
	dc.w	320
	dc.w	320
	dc.w	320
	dc.w	320
	dc.w	320
	dc.w	320
	dc.w	256
	dc.w	256
	dc.w	256
	dc.w	256
	dc.w	256
	dc.w	256
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	128
	dc.w	128
	dc.w	128
	dc.w	128
	dc.w	128
	dc.w	128
	dc.w	128
	dc.w	64
	dc.w	64
	dc.w	64
	dc.w	64
	dc.w	64
	dc.w	64
	dc.w	64
	dc.w	64
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	64
	dc.w	64
	dc.w	64
	dc.w	64
	dc.w	64
	dc.w	64
	dc.w	64
	dc.w	64
	dc.w	128
	dc.w	128
	dc.w	128
	dc.w	128
	dc.w	128
	dc.w	128
	dc.w	128
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192