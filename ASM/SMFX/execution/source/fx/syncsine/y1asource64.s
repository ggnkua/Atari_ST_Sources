	dc.w	7680
	dc.w	8480
	dc.w	9120
	dc.w	9920
	dc.w	10560
	dc.w	11360
	dc.w	12000
	dc.w	12480
	dc.w	13120
	dc.w	13600
	dc.w	14080
	dc.w	14400
	dc.w	14720
	dc.w	15040
	dc.w	15200
	dc.w	15360
	dc.w	15360
	dc.w	15360
	dc.w	15200
	dc.w	15040
	dc.w	14720
	dc.w	14400
	dc.w	14080
	dc.w	13600
	dc.w	13120
	dc.w	12480
	dc.w	12000
	dc.w	11360
	dc.w	10560
	dc.w	9920
	dc.w	9120
	dc.w	8480
	dc.w	7680
	dc.w	6880
	dc.w	6240
	dc.w	5440
	dc.w	4800
	dc.w	4000
	dc.w	3360
	dc.w	2880
	dc.w	2240
	dc.w	1760
	dc.w	1280
	dc.w	960
	dc.w	640
	dc.w	320
	dc.w	160
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	160
	dc.w	320
	dc.w	640
	dc.w	960
	dc.w	1280
	dc.w	1760
	dc.w	2240
	dc.w	2880
	dc.w	3360
	dc.w	4000
	dc.w	4800
	dc.w	5440
	dc.w	6240
	dc.w	6880			;---> 64