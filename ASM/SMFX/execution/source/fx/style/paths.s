	dc.w	29,10*160,1*160,-5,%0111101110010110
	dc.w	15,6*160,2*160,-10,%0111011101110111
	dc.w	29,10*160,1*160,-5,%0101100001000110
	dc.w	50,22*160,1*160,-3,%0000111101011100
	dc.w	15,19*160,4*160,-10,%0001000100010001
	dc.w	29,10*160,1*160,-5,%0010001101001111
	dc.w	15,19*160,4*160,-9,%1100110011001100
	dc.w	15,19*160,4*160,-9,%1010101010101010
	dc.w	50,22*160,1*160,-2,%1101110000101000
	dc.w	8,7*160,7*160,-17,%1010000000000000
	dc.w	8,7*160,7*160,-17,%0110000000000000
	dc.w	50,22*160,1*160,-2,%1011110101110000
	dc.w	8,10*160,8*160,-16,%1110000000000000
	dc.w	8,10*160,8*160,-16,%1010000000000000
	dc.w	8,10*160,8*160,-16,%0110000000000000
	dc.w	50,22*160,1*160,-2,%1001010001111010
	dc.w	50,22*160,1*160,-2,%1000101000111101
	dc.w	8,7*160,7*160,-15,%1010000000000000
	dc.w	15,6*160,2*160,-8,%0011001100110011
	dc.w	8,7*160,7*160,-15,%0010000000000000
	dc.w	50,22*160,1*160,-2,%0110000101000111
	dc.w	50,22*160,1*160,-2,%0101011100001010
	dc.w	8,7*160,7*160,-14,%0110000000000000
	dc.w	29,10*160,1*160,-3,%1110010110000100
	dc.w	15,19*160,4*160,-7,%0110011001100110
	dc.w	15,19*160,4*160,-7,%0100010001000100
	dc.w	15,19*160,4*160,-7,%0010001000100010
	dc.w	8,10*160,8*160,-13,%0010000000000000
	dc.w	8,10*160,8*160,-12,%1110000000000000
	dc.w	15,19*160,4*160,-6,%1011101110111011
	dc.w	29,10*160,1*160,-3,%0110100111101110
	dc.w	50,22*160,1*160,-1,%1111000010100011
	dc.w	50,22*160,1*160,-1,%1110011001100110
	dc.w	15,6*160,2*160,-6,%0011001100110011
	dc.w	8,10*160,8*160,-11,%0110000000000000
	dc.w	8,10*160,8*160,-11,%0010000000000000
	dc.w	29,10*160,1*160,-3,%0000000000000000
	dc.w	8,10*160,8*160,-10,%1010000000000000
	dc.w	15,6*160,2*160,-5,%1000100010001000
	dc.w	8,7*160,7*160,-10,%0010000000000000
	dc.w	15,6*160,2*160,-5,%0100010001000100
	dc.w	50,22*160,1*160,-1,%1000101000111101
	dc.w	8,7*160,7*160,-9,%0110000000000000
	dc.w	50,22*160,1*160,-1,%0111010111000010
	dc.w	29,10*160,1*160,-2,%0111001011000010
	dc.w	8,10*160,8*160,-8,%1010000000000000
	dc.w	8,7*160,7*160,-8,%0110000000000000
	dc.w	50,22*160,1*160,-1,%0100110011001100
	dc.w	29,10*160,1*160,-2,%0010110000100011
	dc.w	15,6*160,2*160,-4,%0001000100010001
	dc.w	15,19*160,4*160,-3,%1110111011101110
	dc.w	15,19*160,4*160,-3,%1100110011001100
	dc.w	50,22*160,1*160,-1,%0001100110011001
	dc.w	50,22*160,1*160,-1,%0000111101011100
	dc.w	8,10*160,8*160,-6,%0110000000000000
	dc.w	15,6*160,2*160,-3,%0100010001000100
	dc.w	15,6*160,2*160,-3,%0010001000100010
	dc.w	8,10*160,8*160,-5,%1010000000000000
	dc.w	15,6*160,2*160,-2,%1101110111011101
	dc.w	15,6*160,2*160,-2,%1011101110111011
	dc.w	8,10*160,8*160,-4,%1110000000000000
	dc.w	29,10*160,1*160,-1,%0100011010011110
	dc.w	8,10*160,8*160,-4,%0110000000000000
	dc.w	8,7*160,7*160,-4,%0010000000000000
	dc.w	8,7*160,7*160,-3,%1110000000000000
	dc.w	50,22*160,1*160,0,%1001010001111010
	dc.w	15,19*160,4*160,-1,%1100110011001100
	dc.w	8,10*160,8*160,-3,%0010000000000000
	dc.w	8,7*160,7*160,-2,%1110000000000000
	dc.w	50,22*160,1*160,0,%0110101110000101
	dc.w	50,22*160,1*160,0,%0110000101000111
	dc.w	50,22*160,1*160,0,%0101011100001010
	dc.w	8,7*160,7*160,-1,%1110000000000000
	dc.w	15,19*160,4*160,0,%1101110111011101
	dc.w	15,19*160,4*160,0,%1011101110111011
	dc.w	8,10*160,8*160,-1,%0010000000000000
	dc.w	15,6*160,2*160,0,%0111011101110111
	dc.w	29,10*160,1*160,0,%0010110000100011
	dc.w	8,7*160,7*160,0,%0110000000000000
	dc.w	15,19*160,4*160,0,%0001000100010001
	dc.w	29,10*160,1*160,0,%0000100011010011
	dc.w	50,22*160,1*160,0,%0000111101011100
	dc.w	8,10*160,8*160,0,%1010000000000000
	dc.w	15,6*160,2*160,0,%0111011101110111
	dc.w	15,6*160,2*160,0,%1001100110011001
	dc.w	15,19*160,4*160,0,%1011101110111011
	dc.w	29,10*160,1*160,0,%0111001011000010
	dc.w	8,10*160,8*160,1,%1110000000000000
	dc.w	15,19*160,4*160,1,%0010001000100010
	dc.w	15,19*160,4*160,1,%0100010001000100
	dc.w	29,10*160,1*160,0,%1011100101100001
	dc.w	8,7*160,7*160,2,%1110000000000000
	dc.w	8,10*160,8*160,3,%0010000000000000
	dc.w	50,22*160,1*160,0,%1000101000111101
	dc.w	15,6*160,2*160,1,%1110111011101110
	dc.w	8,10*160,8*160,3,%1110000000000000
	dc.w	50,22*160,1*160,0,%1010100011110101
	dc.w	8,7*160,7*160,4,%0110000000000000
	dc.w	8,10*160,8*160,4,%1010000000000000
	dc.w	15,19*160,4*160,2,%1001100110011001
	dc.w	8,10*160,8*160,5,%0010000000000000
	dc.w	29,10*160,1*160,1,%0111101110010110
	dc.w	15,19*160,4*160,3,%0000000000000000
	dc.w	15,19*160,4*160,3,%0010001000100010
	dc.w	15,6*160,2*160,3,%0100010001000100
	dc.w	15,6*160,2*160,3,%0110011001100110
	dc.w	15,6*160,2*160,3,%1000100010001000
	dc.w	15,19*160,4*160,3,%1010101010101010
	dc.w	8,7*160,7*160,7,%0010000000000000
	dc.w	8,10*160,8*160,7,%0110000000000000
	dc.w	50,22*160,1*160,1,%0011100001010001
	dc.w	15,19*160,4*160,4,%0011001100110011
	dc.w	15,6*160,2*160,4,%0101010101010101
	dc.w	15,19*160,4*160,4,%0111011101110111
	dc.w	8,7*160,7*160,8,%1010000000000000
	dc.w	29,10*160,1*160,2,%0111001011000010
	dc.w	50,22*160,1*160,1,%0111010111000010
	dc.w	8,7*160,7*160,9,%0110000000000000
	dc.w	29,10*160,1*160,2,%1010011110111001
	dc.w	15,19*160,4*160,5,%0100010001000100
	dc.w	50,22*160,1*160,1,%1001111010111000
	dc.w	50,22*160,1*160,1,%1010100011110101
	dc.w	15,6*160,2*160,5,%1010101010101010
	dc.w	29,10*160,1*160,3,%0000000000000000
	dc.w	50,22*160,1*160,1,%1100011110101110
	dc.w	15,6*160,2*160,6,%0001000100010001
	dc.w	29,10*160,1*160,3,%0011010011110111
	dc.w	29,10*160,1*160,3,%0100011010011110
	dc.w	15,19*160,4*160,6,%0111011101110111
	dc.w	29,10*160,1*160,3,%0110100111101110
	dc.w	29,10*160,1*160,3,%0111101110010110
	dc.w	15,6*160,2*160,6,%1101110111011101
	dc.w	29,10*160,1*160,3,%1001111011100101
	dc.w	29,10*160,1*160,3,%1011000010001101
	dc.w	15,19*160,4*160,7,%0100010001000100
	dc.w	15,6*160,2*160,7,%0110011001100110
	dc.w	15,6*160,2*160,7,%1000100010001000
	dc.w	15,6*160,2*160,7,%1010101010101010
	dc.w	15,19*160,4*160,7,%1100110011001100
	dc.w	50,22*160,1*160,2,%0110000101000111
	dc.w	29,10*160,1*160,4,%0010110000100011
	dc.w	8,7*160,7*160,15,%0110000000000000
	dc.w	8,10*160,8*160,15,%1010000000000000
	dc.w	8,10*160,8*160,15,%1110000000000000
	dc.w	29,10*160,1*160,4,%0111001011000010
	dc.w	8,7*160,7*160,16,%0110000000000000
	dc.w	15,6*160,2*160,8,%1101110111011101
	dc.w	50,22*160,1*160,2,%1011001100110011
	dc.w	8,7*160,7*160,17,%0010000000000000
	dc.w	15,19*160,4*160,9,%0100010001000100
	dc.w	29,10*160,1*160,4,%1101110010110000
	dc.w	8,7*160,7*160,17,%1110000000000000
	dc.w	15,6*160,2*160,9,%1010101010101010
	dc.w	50,22*160,1*160,2,%1111000010100011
	dc.w	8,7*160,7*160,18,%1010000000000000
	dc.w	50,22*160,1*160,3,%0000010100011110
	dc.w	50,22*160,1*160,3,%0000111101011100
	dc.w	50,22*160,1*160,3,%0001100110011001
	dc.w	29,10*160,1*160,5,%0110100111101110
	dc.w	15,19*160,4*160,10,%1001100110011001
	dc.w	13,14*160,4*160,-12,%0011101100010011
	dc.w	65,30*160,1*160,-2,%0110101001010110
	dc.w	33,28*160,2*160,-4,%1011001001101100
	dc.w	9,16*160,8*160,-17,%0000000000000000
	dc.w	9,9*160,6*160,-16,%1100011100011100
	dc.w	9,9*160,6*160,-16,%1000111000111000
	dc.w	9,9*160,6*160,-16,%0101010101010101
	dc.w	17,24*160,4*160,-8,%1000011110000111
	dc.w	17,24*160,4*160,-8,%0110100101101001
	dc.w	9,16*160,8*160,-15,%1010101010101010
	dc.w	13,25*160,6*160,-10,%1011000100111011
	dc.w	13,25*160,6*160,-10,%1000100111011000
	dc.w	9,16*160,8*160,-15,%0000000000000000
	dc.w	25,19*160,2*160,-5,%0101000111101011
	dc.w	17,9*160,2*160,-7,%1011010010110100
	dc.w	9,16*160,8*160,-14,%0101010101010101
	dc.w	17,24*160,4*160,-7,%0111100001111000
	dc.w	13,25*160,6*160,-9,%1001110110001001
	dc.w	9,16*160,8*160,-13,%1010101010101010
	dc.w	9,16*160,8*160,-13,%0111000111000111
	dc.w	13,14*160,4*160,-9,%0010011101100010
	dc.w	65,30*160,1*160,-1,%1100110011001100
	dc.w	33,28*160,2*160,-3,%0111110000011111
	dc.w	33,28*160,2*160,-3,%0110110010011011
	dc.w	9,16*160,8*160,-12,%0101010101010101
	dc.w	25,19*160,2*160,-4,%0101110000101000
	dc.w	65,30*160,1*160,-1,%1010010101101010
	dc.w	25,19*160,2*160,-4,%0011001100110011
	dc.w	13,14*160,4*160,-7,%1110110001001110
	dc.w	17,24*160,4*160,-5,%1111000011110000
	dc.w	17,24*160,4*160,-5,%1101001011010010
	dc.w	33,28*160,2*160,-2,%1111000001111100
	dc.w	33,28*160,2*160,-2,%1110000011111000
	dc.w	17,24*160,4*160,-5,%0111100001111000
	dc.w	65,30*160,1*160,-1,%0110011001100110
	dc.w	13,14*160,4*160,-6,%1101100010011101
	dc.w	13,14*160,4*160,-6,%1011000100111011
	dc.w	9,9*160,6*160,-9,%0111000111000111
	dc.w	9,16*160,8*160,-9,%0011100011100011
	dc.w	25,19*160,2*160,-3,%0011110101110000
	dc.w	13,14*160,4*160,-6,%0001001110110001
	dc.w	17,24*160,4*160,-4,%1000011110000111
	dc.w	65,30*160,1*160,-1,%0010011101100010
	dc.w	17,9*160,2*160,-4,%0100101101001011
	dc.w	9,9*160,6*160,-7,%1110001110001110
	dc.w	9,16*160,8*160,-7,%1010101010101010
	dc.w	65,30*160,1*160,-1,%0000011111100000
	dc.w	17,9*160,2*160,-3,%1101001011010010
	dc.w	9,9*160,6*160,-7,%0000000000000000
	dc.w	65,30*160,1*160,0,%1111000000111111
	dc.w	13,14*160,4*160,-4,%1000100111011000
	dc.w	13,25*160,6*160,-4,%0110001001110110
	dc.w	33,28*160,2*160,-1,%1010101010101010
	dc.w	13,14*160,4*160,-4,%0001001110110001
	dc.w	25,19*160,2*160,-2,%0000101000111101
	dc.w	13,14*160,4*160,-3,%1100010011101100
	dc.w	9,16*160,8*160,-5,%0011100011100011
	dc.w	9,16*160,8*160,-5,%0000000000000000
	dc.w	17,24*160,4*160,-2,%1000011110000111
	dc.w	25,19*160,2*160,-1,%1010001111010111
	dc.w	13,14*160,4*160,-3,%0000000000000000
	dc.w	9,16*160,8*160,-4,%0001110001110001
	dc.w	9,16*160,8*160,-3,%1110001110001110
	dc.w	17,24*160,4*160,-1,%1111000011110000
	dc.w	9,16*160,8*160,-3,%0111000111000111
	dc.w	9,9*160,6*160,-3,%0011100011100011
	dc.w	9,16*160,8*160,-3,%0000000000000000
	dc.w	9,16*160,8*160,-2,%1100011100011100
	dc.w	65,30*160,1*160,0,%0101101010010101
	dc.w	9,16*160,8*160,-2,%0101010101010101
	dc.w	17,24*160,4*160,-1,%0001111000011110
	dc.w	33,28*160,2*160,0,%1000001111100000
	dc.w	17,9*160,2*160,0,%1110000111100001
	dc.w	17,24*160,4*160,0,%1100001111000011
	dc.w	17,9*160,2*160,0,%1010010110100101
	dc.w	25,19*160,2*160,0,%0101110000101000
	dc.w	65,30*160,1*160,0,%0001101110010001
	dc.w	33,28*160,2*160,0,%0010011011001001
	dc.w	13,25*160,6*160,0,%0011101100010011
	dc.w	65,30*160,1*160,0,%0000001111110000
	dc.w	13,25*160,6*160,0,%0001001110110001
	dc.w	25,19*160,2*160,0,%0001111010111000
	dc.w	9,16*160,8*160,0,%1000111000111000
	dc.w	33,28*160,2*160,0,%0011011001001101
	dc.w	13,14*160,4*160,0,%1011000100111011
	dc.w	9,9*160,6*160,1,%0011100011100011
	dc.w	9,9*160,6*160,1,%0111000111000111
	dc.w	65,30*160,1*160,0,%0011101100010011
	dc.w	13,14*160,4*160,1,%0100111011000100
	dc.w	9,9*160,6*160,2,%0001110001110001
	dc.w	9,16*160,8*160,2,%0101010101010101
	dc.w	25,19*160,2*160,0,%1110101110000101
	dc.w	65,30*160,1*160,0,%0110001001110110
	dc.w	9,16*160,8*160,3,%0000000000000000
	dc.w	33,28*160,2*160,0,%1110000011111000
	dc.w	33,28*160,2*160,0,%1111000001111100
	dc.w	9,9*160,6*160,3,%1010101010101010
	dc.w	9,9*160,6*160,3,%1110001110001110
	dc.w	9,16*160,8*160,4,%0001110001110001
	dc.w	13,25*160,6*160,3,%0000000000000000
	dc.w	9,9*160,6*160,4,%1000111000111000
	dc.w	13,14*160,4*160,3,%0100111011000100
	dc.w	9,9*160,6*160,5,%0000000000000000
	dc.w	25,19*160,2*160,1,%1110000101000111
	dc.w	17,9*160,2*160,2,%1110000111100001
	dc.w	25,19*160,2*160,2,%0000101000111101
	dc.w	17,24*160,4*160,3,%0001111000011110
	dc.w	13,14*160,4*160,4,%0011101100010011
	dc.w	25,19*160,2*160,2,%0100011110101110
	dc.w	33,28*160,2*160,1,%1100100110110010
	dc.w	9,9*160,6*160,6,%1100011100011100
	dc.w	33,28*160,2*160,1,%1110100010111010
	dc.w	9,16*160,8*160,7,%0011100011100011
	dc.w	13,14*160,4*160,5,%0010011101100010
	dc.w	13,25*160,6*160,5,%0100111011000100
	dc.w	9,16*160,8*160,7,%1110001110001110
	dc.w	65,30*160,1*160,1,%0001111110000001
	dc.w	13,25*160,6*160,5,%1100010011101100
	dc.w	65,30*160,1*160,1,%0010111101000010
	dc.w	9,9*160,6*160,8,%1100011100011100
	dc.w	17,24*160,4*160,4,%1100001111000011
	dc.w	65,30*160,1*160,1,%0100011011100100
	dc.w	9,16*160,8*160,9,%0111000111000111
	dc.w	13,14*160,4*160,6,%1011000100111011
	dc.w	9,16*160,8*160,9,%1110001110001110
	dc.w	65,30*160,1*160,1,%0110011001100110
	dc.w	13,14*160,4*160,7,%0010011101100010
	dc.w	17,9*160,2*160,5,%1001011010010110
	dc.w	9,9*160,6*160,10,%1100011100011100
	dc.w	33,28*160,2*160,3,%0000000000000000
	dc.w	17,24*160,4*160,5,%1111000011110000
	dc.w	65,30*160,1*160,1,%1001010110101001
	dc.w	13,25*160,6*160,8,%0001001110110001
	dc.w	33,28*160,2*160,3,%0011111000001111
	dc.w	13,14*160,4*160,8,%0110001001110110
	dc.w	9,9*160,6*160,12,%0101010101010101
	dc.w	17,24*160,4*160,6,%1010010110100101
	dc.w	33,28*160,2*160,3,%0111110000011111
	dc.w	13,14*160,4*160,9,%0000000000000000
	dc.w	17,24*160,4*160,7,%0000000000000000
	dc.w	33,28*160,2*160,3,%1010101010101010
	dc.w	65,30*160,1*160,1,%1110010001101110
	dc.w	13,25*160,6*160,9,%1001110110001001
	dc.w	13,14*160,4*160,9,%1100010011101100
	dc.w	13,25*160,6*160,9,%1110110001001110
	dc.w	13,14*160,4*160,10,%0001001110110001
	dc.w	9,9*160,6*160,14,%1100011100011100
	dc.w	25,19*160,2*160,5,%0110011001100110
	dc.w	17,9*160,2*160,8,%0000111100001111
	dc.w	13,25*160,6*160,10,%1011000100111011
	dc.w	65,30*160,1*160,2,%0010101101010010
	dc.w	9,9*160,6*160,15,%1110001110001110
	dc.w	9,16*160,8*160,16,%0001110001110001
	dc.w	17,24*160,4*160,8,%1010010110100101
	dc.w	65,30*160,1*160,2,%0100101011010100
	dc.w	33,28*160,2*160,4,%1001001101100100
	dc.w	25,19*160,2*160,6,%0001111010111000
	dc.w	17,24*160,4*160,9,%0001111000011110
	dc.w	25,19*160,2*160,6,%0100011110101110
	dc.w	33,28*160,2*160,4,%1101000101110100
	dc.w	48,21*160,1*160,-3,%0101000000000000
	dc.w	48,21*160,1*160,-3,%0100010101010101
	dc.w	48,21*160,1*160,-3,%0011101010101010
	dc.w	48,21*160,1*160,-3,%0011000000000000
	dc.w	48,21*160,1*160,-3,%0010010101010101
	dc.w	48,21*160,1*160,-3,%0001101010101010
	dc.w	48,21*160,1*160,-3,%0001000000000000
	dc.w	48,21*160,1*160,-3,%0000010101010101
	dc.w	48,21*160,1*160,-2,%1111101010101010
	dc.w	48,21*160,1*160,-2,%1111000000000000
	dc.w	48,21*160,1*160,-2,%1110010101010101
	dc.w	48,21*160,1*160,-2,%1101101010101010
	dc.w	48,21*160,1*160,-2,%1101000000000000
	dc.w	48,21*160,1*160,-2,%1100010101010101
	dc.w	48,21*160,1*160,-2,%1011101010101010
	dc.w	48,21*160,1*160,-2,%1011000000000000
	dc.w	48,21*160,1*160,-2,%1010010101010101
	dc.w	48,21*160,1*160,-2,%1001101010101010
	dc.w	48,21*160,1*160,-2,%1001000000000000
	dc.w	48,21*160,1*160,-2,%1000010101010101
	dc.w	48,21*160,1*160,-2,%0111101010101010
	dc.w	48,21*160,1*160,-2,%0111000000000000
	dc.w	48,21*160,1*160,-2,%0110010101010101
	dc.w	48,21*160,1*160,-2,%0101101010101010
	dc.w	48,21*160,1*160,-2,%0101000000000000
	dc.w	48,21*160,1*160,-2,%0100010101010101
	dc.w	48,21*160,1*160,-2,%0011101010101010
	dc.w	48,21*160,1*160,-2,%0011000000000000
	dc.w	48,21*160,1*160,-2,%0010010101010101
	dc.w	48,21*160,1*160,-2,%0001101010101010
	dc.w	48,21*160,1*160,-2,%0001000000000000
	dc.w	48,21*160,1*160,-2,%0000010101010101
	dc.w	48,21*160,1*160,-1,%1111101010101010
	dc.w	48,21*160,1*160,-1,%1111000000000000
	dc.w	48,21*160,1*160,-1,%1110010101010101
	dc.w	48,21*160,1*160,-1,%1101101010101010
	dc.w	48,21*160,1*160,-1,%1101000000000000
	dc.w	48,21*160,1*160,-1,%1100010101010101
	dc.w	48,21*160,1*160,-1,%1011101010101010
	dc.w	48,21*160,1*160,-1,%1011000000000000
	dc.w	48,21*160,1*160,-1,%1010010101010101
	dc.w	48,21*160,1*160,-1,%1001101010101010
	dc.w	48,21*160,1*160,-1,%1001000000000000
	dc.w	48,21*160,1*160,-1,%1000010101010101
	dc.w	48,21*160,1*160,-1,%0111101010101010
	dc.w	48,21*160,1*160,-1,%0111000000000000
	dc.w	48,21*160,1*160,-1,%0110010101010101
	dc.w	48,21*160,1*160,-1,%0101101010101010
	dc.w	48,21*160,1*160,-1,%0101000000000000
	dc.w	48,21*160,1*160,-1,%0100010101010101
	dc.w	48,21*160,1*160,-1,%0011101010101010
	dc.w	48,21*160,1*160,-1,%0011000000000000
	dc.w	48,21*160,1*160,-1,%0010010101010101
	dc.w	48,21*160,1*160,-1,%0001101010101010
	dc.w	48,21*160,1*160,-1,%0001000000000000
	dc.w	48,21*160,1*160,-1,%0000010101010101
	dc.w	48,21*160,1*160,0,%1111101010101010
	dc.w	48,21*160,1*160,0,%1111000000000000
	dc.w	48,21*160,1*160,0,%1110010101010101
	dc.w	48,21*160,1*160,0,%1101101010101010
	dc.w	48,21*160,1*160,0,%1101000000000000
	dc.w	48,21*160,1*160,0,%1100010101010101
	dc.w	48,21*160,1*160,0,%1011101010101010
	dc.w	48,21*160,1*160,0,%1011000000000000
	dc.w	48,21*160,1*160,0,%1010010101010101
	dc.w	48,21*160,1*160,0,%1001101010101010
	dc.w	48,21*160,1*160,0,%1001000000000000
	dc.w	48,21*160,1*160,0,%1000010101010101
	dc.w	48,21*160,1*160,0,%0111101010101010
	dc.w	48,21*160,1*160,0,%0111000000000000
	dc.w	48,21*160,1*160,0,%0110010101010101
	dc.w	48,21*160,1*160,0,%0101101010101010
	dc.w	48,21*160,1*160,0,%0101000000000000
	dc.w	48,21*160,1*160,0,%0100010101010101
	dc.w	48,21*160,1*160,0,%0011101010101010
	dc.w	48,21*160,1*160,0,%0011000000000000
	dc.w	48,21*160,1*160,0,%0010010101010101
	dc.w	48,21*160,1*160,0,%0001101010101010
	dc.w	48,21*160,1*160,0,%0001000000000000
	dc.w	48,21*160,1*160,0,%0000010101010101
	dc.w	48,21*160,1*160,0,%0000010101010101
	dc.w	48,21*160,1*160,0,%0001000000000000
	dc.w	48,21*160,1*160,0,%0001101010101010
	dc.w	48,21*160,1*160,0,%0010010101010101
	dc.w	48,21*160,1*160,0,%0011000000000000
	dc.w	48,21*160,1*160,0,%0011101010101010
	dc.w	48,21*160,1*160,0,%0100010101010101
	dc.w	48,21*160,1*160,0,%0101000000000000
	dc.w	48,21*160,1*160,0,%0101101010101010
	dc.w	48,21*160,1*160,0,%0110010101010101
	dc.w	48,21*160,1*160,0,%0111000000000000
	dc.w	48,21*160,1*160,0,%0111101010101010
	dc.w	48,21*160,1*160,0,%1000010101010101
	dc.w	48,21*160,1*160,0,%1001000000000000
	dc.w	48,21*160,1*160,0,%1001101010101010
	dc.w	48,21*160,1*160,0,%1010010101010101
	dc.w	48,21*160,1*160,0,%1011000000000000
	dc.w	48,21*160,1*160,0,%1011101010101010
	dc.w	48,21*160,1*160,0,%1100010101010101
	dc.w	48,21*160,1*160,0,%1101000000000000
	dc.w	48,21*160,1*160,0,%1101101010101010
	dc.w	48,21*160,1*160,0,%1110010101010101
	dc.w	48,21*160,1*160,0,%1111000000000000
	dc.w	48,21*160,1*160,0,%1111101010101010
	dc.w	48,21*160,1*160,1,%0000010101010101
	dc.w	48,21*160,1*160,1,%0001000000000000
	dc.w	48,21*160,1*160,1,%0001101010101010
	dc.w	48,21*160,1*160,1,%0010010101010101
	dc.w	48,21*160,1*160,1,%0011000000000000
	dc.w	48,21*160,1*160,1,%0011101010101010
	dc.w	48,21*160,1*160,1,%0100010101010101
	dc.w	48,21*160,1*160,1,%0101000000000000
	dc.w	48,21*160,1*160,1,%0101101010101010
	dc.w	48,21*160,1*160,1,%0110010101010101
	dc.w	48,21*160,1*160,1,%0111000000000000
	dc.w	48,21*160,1*160,1,%0111101010101010
	dc.w	48,21*160,1*160,1,%1000010101010101
	dc.w	48,21*160,1*160,1,%1001000000000000
	dc.w	48,21*160,1*160,1,%1001101010101010
	dc.w	48,21*160,1*160,1,%1010010101010101
	dc.w	48,21*160,1*160,1,%1011000000000000
	dc.w	48,21*160,1*160,1,%1011101010101010
	dc.w	48,21*160,1*160,1,%1100010101010101
	dc.w	48,21*160,1*160,1,%1101000000000000
	dc.w	48,21*160,1*160,1,%1101101010101010
	dc.w	48,21*160,1*160,1,%1110010101010101
	dc.w	48,21*160,1*160,1,%1111000000000000
	dc.w	48,21*160,1*160,1,%1111101010101010
	dc.w	48,21*160,1*160,2,%0000010101010101
	dc.w	48,21*160,1*160,2,%0001000000000000
	dc.w	48,21*160,1*160,2,%0001101010101010
	dc.w	48,21*160,1*160,2,%0010010101010101
	dc.w	48,21*160,1*160,2,%0011000000000000
	dc.w	48,21*160,1*160,2,%0011101010101010
	dc.w	48,21*160,1*160,2,%0100010101010101
	dc.w	48,21*160,1*160,2,%0101000000000000
	dc.w	48,21*160,1*160,2,%0101101010101010
	dc.w	48,21*160,1*160,2,%0110010101010101
	dc.w	48,21*160,1*160,2,%0111000000000000
	dc.w	48,21*160,1*160,2,%0111101010101010
	dc.w	48,21*160,1*160,2,%1000010101010101
	dc.w	48,21*160,1*160,2,%1001000000000000
	dc.w	48,21*160,1*160,2,%1001101010101010
	dc.w	48,21*160,1*160,2,%1010010101010101
	dc.w	48,21*160,1*160,2,%1011000000000000
	dc.w	48,21*160,1*160,2,%1011101010101010
	dc.w	48,21*160,1*160,2,%1100010101010101
	dc.w	48,21*160,1*160,2,%1101000000000000
	dc.w	48,21*160,1*160,2,%1101101010101010
	dc.w	48,21*160,1*160,2,%1110010101010101
	dc.w	48,21*160,1*160,2,%1111000000000000
	dc.w	48,21*160,1*160,2,%1111101010101010
	dc.w	48,21*160,1*160,3,%0000010101010101
	dc.w	48,21*160,1*160,3,%0001000000000000
	dc.w	48,21*160,1*160,3,%0001101010101010
	dc.w	48,21*160,1*160,3,%0010010101010101
	dc.w	48,21*160,1*160,3,%0011000000000000
	dc.w	48,21*160,1*160,3,%0011101010101010
	dc.w	48,21*160,1*160,3,%0100010101010101
	dc.w	48,21*160,1*160,3,%0101000000000000
	dc.w	9,6*160,5*160,-17,%1010101010101010
	dc.w	9,6*160,5*160,-17,%0111000111000111
	dc.w	24,29*160,3*160,-6,%0111010101010101
	dc.w	24,18*160,2*160,-6,%0110000000000000
	dc.w	24,29*160,3*160,-6,%0100101010101010
	dc.w	9,6*160,5*160,-16,%1000111000111000
	dc.w	9,6*160,5*160,-16,%0101010101010101
	dc.w	24,18*160,2*160,-6,%0000101010101010
	dc.w	9,6*160,5*160,-15,%1110001110001110
	dc.w	9,6*160,5*160,-15,%1010101010101010
	dc.w	24,7*160,1*160,-5,%1100101010101010
	dc.w	24,29*160,3*160,-5,%1011010101010101
	dc.w	9,6*160,5*160,-15,%0000000000000000
	dc.w	9,6*160,5*160,-14,%1100011100011100
	dc.w	9,13*160,7*160,-14,%1000111000111000
	dc.w	24,18*160,2*160,-5,%0110000000000000
	dc.w	24,18*160,2*160,-5,%0100101010101010
	dc.w	9,6*160,5*160,-13,%1110001110001110
	dc.w	9,6*160,5*160,-13,%1010101010101010
	dc.w	24,29*160,3*160,-5,%0000101010101010
	dc.w	9,13*160,7*160,-13,%0011100011100011
	dc.w	24,29*160,3*160,-4,%1110000000000000
	dc.w	9,13*160,7*160,-12,%1100011100011100
	dc.w	9,13*160,7*160,-12,%1000111000111000
	dc.w	24,18*160,2*160,-4,%1010000000000000
	dc.w	24,7*160,1*160,-4,%1000101010101010
	dc.w	9,13*160,7*160,-11,%1110001110001110
	dc.w	9,6*160,5*160,-11,%1010101010101010
	dc.w	24,29*160,3*160,-4,%0100101010101010
	dc.w	24,7*160,1*160,-4,%0011010101010101
	dc.w	24,7*160,1*160,-4,%0010000000000000
	dc.w	9,6*160,5*160,-10,%1100011100011100
	dc.w	24,29*160,3*160,-3,%1111010101010101
	dc.w	24,18*160,2*160,-3,%1110000000000000
	dc.w	9,6*160,5*160,-10,%0001110001110001
	dc.w	9,13*160,7*160,-9,%1110001110001110
	dc.w	9,6*160,5*160,-9,%1010101010101010
	dc.w	24,18*160,2*160,-3,%1000101010101010
	dc.w	9,6*160,5*160,-9,%0011100011100011
	dc.w	24,18*160,2*160,-3,%0110000000000000
	dc.w	24,18*160,2*160,-3,%0100101010101010
	dc.w	24,18*160,2*160,-3,%0011010101010101
	dc.w	9,13*160,7*160,-8,%0101010101010101
	dc.w	9,6*160,5*160,-8,%0001110001110001
	dc.w	24,29*160,3*160,-2,%1111010101010101
	dc.w	9,6*160,5*160,-7,%1010101010101010
	dc.w	24,18*160,2*160,-2,%1100101010101010
	dc.w	24,18*160,2*160,-2,%1011010101010101
	dc.w	9,6*160,5*160,-7,%0000000000000000
	dc.w	9,13*160,7*160,-6,%1100011100011100
	dc.w	9,6*160,5*160,-6,%1000111000111000
	dc.w	24,7*160,1*160,-2,%0110000000000000
	dc.w	24,18*160,2*160,-2,%0100101010101010
	dc.w	9,6*160,5*160,-5,%1110001110001110
	dc.w	9,6*160,5*160,-5,%1010101010101010
	dc.w	9,6*160,5*160,-5,%0111000111000111
	dc.w	9,6*160,5*160,-5,%0011100011100011
	dc.w	24,18*160,2*160,-1,%1110000000000000
	dc.w	9,6*160,5*160,-4,%1100011100011100
	dc.w	9,6*160,5*160,-4,%1000111000111000
	dc.w	24,18*160,2*160,-1,%1010000000000000
	dc.w	24,29*160,3*160,-1,%1000101010101010
	dc.w	24,29*160,3*160,-1,%0111010101010101
	dc.w	9,6*160,5*160,-3,%1010101010101010
	dc.w	9,6*160,5*160,-3,%0111000111000111
	dc.w	24,7*160,1*160,-1,%0011010101010101
	dc.w	24,7*160,1*160,-1,%0010000000000000
	dc.w	24,7*160,1*160,-1,%0000101010101010
	dc.w	24,18*160,2*160,0,%1111010101010101
	dc.w	9,6*160,5*160,-2,%0101010101010101
	dc.w	24,29*160,3*160,0,%1100101010101010
	dc.w	9,13*160,7*160,-1,%1110001110001110
	dc.w	24,18*160,2*160,0,%1010000000000000
	dc.w	9,6*160,5*160,-1,%0111000111000111
	dc.w	24,18*160,2*160,0,%0111010101010101
	dc.w	24,29*160,3*160,0,%0110000000000000
	dc.w	24,18*160,2*160,0,%0100101010101010
	dc.w	24,7*160,1*160,0,%0011010101010101
	dc.w	24,29*160,3*160,0,%0010000000000000
	dc.w	24,7*160,1*160,0,%0000101010101010
	dc.w	24,29*160,3*160,0,%0000101010101010
	dc.w	9,6*160,5*160,0,%0101010101010101
	dc.w	24,7*160,1*160,0,%0011010101010101
	dc.w	24,18*160,2*160,0,%0100101010101010
	dc.w	9,6*160,5*160,1,%0000000000000000
	dc.w	9,6*160,5*160,1,%0011100011100011
	dc.w	24,29*160,3*160,0,%1000101010101010
	dc.w	24,7*160,1*160,0,%1010000000000000
	dc.w	24,18*160,2*160,0,%1011010101010101
	dc.w	9,13*160,7*160,2,%0001110001110001
	dc.w	24,29*160,3*160,0,%1110000000000000
	dc.w	24,29*160,3*160,0,%1111010101010101
	dc.w	9,6*160,5*160,2,%1100011100011100
	dc.w	9,6*160,5*160,3,%0000000000000000
	dc.w	24,29*160,3*160,1,%0011010101010101
	dc.w	9,6*160,5*160,3,%0111000111000111
	dc.w	24,18*160,2*160,1,%0110000000000000
	dc.w	9,13*160,7*160,3,%1110001110001110
	dc.w	9,6*160,5*160,4,%0001110001110001
	dc.w	24,18*160,2*160,1,%1010000000000000
	dc.w	24,29*160,3*160,1,%1011010101010101
	dc.w	24,29*160,3*160,1,%1100101010101010
	dc.w	9,6*160,5*160,5,%0000000000000000
	dc.w	9,13*160,7*160,5,%0011100011100011
	dc.w	9,6*160,5*160,5,%0111000111000111
	dc.w	9,13*160,7*160,5,%1010101010101010
	dc.w	24,18*160,2*160,2,%0011010101010101
	dc.w	24,7*160,1*160,2,%0100101010101010
	dc.w	24,29*160,3*160,2,%0110000000000000
	dc.w	24,18*160,2*160,2,%0111010101010101
	dc.w	9,6*160,5*160,6,%1100011100011100
	dc.w	9,6*160,5*160,7,%0000000000000000
	dc.w	9,13*160,7*160,7,%0011100011100011
	dc.w	24,29*160,3*160,2,%1100101010101010
	dc.w	9,6*160,5*160,7,%1010101010101010
	dc.w	24,18*160,2*160,2,%1111010101010101
	dc.w	9,6*160,5*160,8,%0001110001110001
	dc.w	9,6*160,5*160,8,%0101010101010101
	dc.w	24,29*160,3*160,3,%0011010101010101
	dc.w	24,7*160,1*160,3,%0100101010101010
	dc.w	9,6*160,5*160,9,%0000000000000000
	dc.w	24,7*160,1*160,3,%0111010101010101
	dc.w	24,29*160,3*160,3,%1000101010101010
	dc.w	9,6*160,5*160,9,%1010101010101010
	dc.w	24,29*160,3*160,3,%1011010101010101
	dc.w	9,13*160,7*160,10,%0001110001110001
	dc.w	24,7*160,1*160,3,%1110000000000000
	dc.w	9,13*160,7*160,10,%1000111000111000
	dc.w	24,29*160,3*160,4,%0000101010101010
	dc.w	9,6*160,5*160,11,%0000000000000000
	dc.w	24,18*160,2*160,4,%0011010101010101
	dc.w	24,18*160,2*160,4,%0100101010101010
	dc.w	24,29*160,3*160,4,%0110000000000000
	dc.w	24,7*160,1*160,4,%0111010101010101
	dc.w	24,29*160,3*160,4,%1000101010101010
	dc.w	24,29*160,3*160,4,%1010000000000000
	dc.w	24,7*160,1*160,4,%1011010101010101
	dc.w	24,7*160,1*160,4,%1100101010101010
	dc.w	24,18*160,2*160,4,%1110000000000000
	dc.w	24,18*160,2*160,4,%1111010101010101
	dc.w	9,6*160,5*160,13,%0111000111000111
	dc.w	9,13*160,7*160,13,%1010101010101010
	dc.w	24,18*160,2*160,5,%0011010101010101
	dc.w	24,29*160,3*160,5,%0100101010101010
	dc.w	24,29*160,3*160,5,%0110000000000000
	dc.w	9,6*160,5*160,14,%1000111000111000
	dc.w	9,13*160,7*160,14,%1100011100011100
	dc.w	24,18*160,2*160,5,%1010000000000000
	dc.w	24,29*160,3*160,5,%1011010101010101
	dc.w	9,13*160,7*160,15,%0111000111000111
	dc.w	9,6*160,5*160,15,%1010101010101010
	dc.w	9,13*160,7*160,15,%1110001110001110
	dc.w	9,6*160,5*160,16,%0001110001110001
	dc.w	24,29*160,3*160,6,%0010000000000000
	dc.w	24,7*160,1*160,6,%0011010101010101
	dc.w	24,18*160,2*160,6,%0100101010101010
	dc.w	24,18*160,2*160,6,%0110000000000000
	dc.w	24,18*160,2*160,6,%0111010101010101
	dc.w	9,13*160,7*160,17,%0111000111000111
	dc.w	9,6*160,5*160,17,%1010101010101010
	dc.w	13,9*160,3*160,-12,%0011101100010011
	dc.w	16,29*160,5*160,-9,%1101000000000000
	dc.w	11,27*160,8*160,-14,%0001011101000101
	dc.w	10,18*160,7*160,-15,%0100110011001100
	dc.w	13,20*160,5*160,-11,%1001110110001001
	dc.w	37,15*160,1*160,-4,%0000011011101011
	dc.w	13,20*160,5*160,-11,%0100111011000100
	dc.w	19,12*160,2*160,-7,%1010000110101111
	dc.w	19,12*160,2*160,-7,%1000011010111100
	dc.w	13,20*160,5*160,-10,%1101100010011101
	dc.w	37,15*160,1*160,-3,%1100000110111010
	dc.w	21,5*160,1*160,-6,%1000011000011000
	dc.w	46,20*160,1*160,-2,%1110111101001101
	dc.w	10,6*160,4*160,-13,%0100110011001100
	dc.w	7,5*160,8*160,-18,%1011011011011011
	dc.w	31,26*160,2*160,-4,%0010100101001010
	dc.w	13,20*160,5*160,-9,%1100010011101100
	dc.w	16,8*160,2*160,-7,%1101000000000000
	dc.w	10,22*160,8*160,-12,%0100110011001100
	dc.w	16,15*160,3*160,-7,%1001000000000000
	dc.w	13,20*160,5*160,-9,%0010011101100010
	dc.w	10,18*160,7*160,-11,%1011001100110011
	dc.w	37,15*160,1*160,-3,%0001101110101100
	dc.w	16,29*160,5*160,-7,%0001000000000000
	dc.w	19,29*160,4*160,-5,%1101011110010100
	dc.w	16,8*160,2*160,-6,%1101000000000000
	dc.w	21,5*160,1*160,-5,%0001100001100001
	dc.w	13,31*160,7*160,-8,%0001001110110001
	dc.w	19,29*160,4*160,-5,%0110101111001010
	dc.w	19,12*160,2*160,-5,%0101000011010111
	dc.w	10,22*160,8*160,-9,%1110011001100110
	dc.w	11,27*160,8*160,-8,%1101000101110100
	dc.w	46,20*160,1*160,-2,%0001000010110010
	dc.w	10,22*160,8*160,-9,%0100110011001100
	dc.w	13,20*160,5*160,-7,%0000000000000000
	dc.w	16,22*160,4*160,-5,%1001000000000000
	dc.w	16,8*160,2*160,-5,%0111000000000000
	dc.w	21,5*160,1*160,-4,%0000110000110000
	dc.w	31,26*160,2*160,-2,%1010110101101011
	dc.w	16,29*160,5*160,-5,%0001000000000000
	dc.w	13,31*160,7*160,-6,%0001001110110001
	dc.w	21,24*160,3*160,-3,%1010101010101010
	dc.w	37,15*160,1*160,-2,%0000011011101011
	dc.w	11,9*160,4*160,-6,%1010001011101000
	dc.w	13,9*160,3*160,-5,%0111011000100111
	dc.w	21,5*160,1*160,-3,%0100100100100100
	dc.w	10,10*160,5*160,-6,%1011001100110011
	dc.w	7,5*160,8*160,-9,%0100100100100100
	dc.w	16,22*160,4*160,-3,%1111000000000000
	dc.w	21,5*160,1*160,-2,%1110011110011110
	dc.w	11,18*160,6*160,-5,%0101110100010111
	dc.w	11,9*160,4*160,-5,%0010111010001011
	dc.w	16,29*160,5*160,-3,%0111000000000000
	dc.w	21,5*160,1*160,-2,%1000011000011000
	dc.w	11,18*160,6*160,-4,%1010001011101000
	dc.w	11,27*160,8*160,-4,%0111010001011101
	dc.w	13,20*160,5*160,-3,%1001110110001001
	dc.w	10,14*160,6*160,-4,%1000000000000000
	dc.w	21,24*160,3*160,-2,%0000110000110000
	dc.w	16,29*160,5*160,-2,%1001000000000000
	dc.w	21,5*160,1*160,-1,%1101101101101101
	dc.w	11,18*160,6*160,-3,%0101110100010111
	dc.w	7,5*160,8*160,-5,%0000000000000000
	dc.w	10,18*160,7*160,-3,%0100110011001100
	dc.w	31,26*160,2*160,-1,%0000000000000000
	dc.w	61,28*160,1*160,0,%0111100110110100
	dc.w	37,15*160,1*160,0,%1011101011001111
	dc.w	10,18*160,7*160,-2,%1000000000000000
	dc.w	37,15*160,1*160,0,%1001111100100010
	dc.w	16,8*160,2*160,-1,%0101000000000000
	dc.w	10,10*160,5*160,-1,%1110011001100110
	dc.w	19,29*160,4*160,0,%1110010100001101
	dc.w	7,5*160,8*160,-2,%0010010010010010
	dc.w	31,26*160,2*160,0,%0110101101011010
	dc.w	10,18*160,7*160,-1,%0001100110011001
	dc.w	31,26*160,2*160,0,%0100101001010010
	dc.w	10,14*160,6*160,0,%1011001100110011
	dc.w	10,18*160,7*160,0,%1000000000000000
	dc.w	10,18*160,7*160,0,%0100110011001100
	dc.w	13,20*160,5*160,0,%0001001110110001
	dc.w	16,15*160,3*160,0,%0001000000000000
	dc.w	19,29*160,4*160,0,%0010100001101011
	dc.w	11,9*160,4*160,0,%0111010001011101
	dc.w	21,5*160,1*160,0,%0101010101010101
	dc.w	10,10*160,5*160,0,%1110011001100110
	dc.w	10,22*160,8*160,1,%0001100110011001
	dc.w	16,22*160,4*160,0,%1101000000000000
	dc.w	11,18*160,6*160,1,%0101110100010111
	dc.w	10,14*160,6*160,1,%1011001100110011
	dc.w	16,29*160,5*160,1,%0011000000000000
	dc.w	16,8*160,2*160,1,%0101000000000000
	dc.w	10,14*160,6*160,2,%0100110011001100
	dc.w	13,20*160,5*160,1,%1110110001001110
	dc.w	13,31*160,7*160,2,%0001001110110001
	dc.w	10,10*160,5*160,2,%1110011001100110
	dc.w	16,8*160,2*160,1,%1111000000000000
	dc.w	16,15*160,3*160,2,%0001000000000000
	dc.w	11,9*160,4*160,3,%0010111010001011
	dc.w	19,29*160,4*160,1,%1111001010000110
	dc.w	31,26*160,2*160,1,%0100001000010000
	dc.w	16,22*160,4*160,2,%1001000000000000
	dc.w	10,22*160,8*160,4,%0100110011001100
	dc.w	19,29*160,4*160,2,%0101111001010000
	dc.w	11,18*160,6*160,4,%0100010111010001
	dc.w	46,20*160,1*160,1,%0001000010110010
	dc.w	16,8*160,2*160,3,%0011000000000000
	dc.w	19,29*160,4*160,2,%1100101000011010
	dc.w	10,14*160,6*160,5,%1000000000000000
	dc.w	11,18*160,6*160,5,%0010111010001011
	dc.w	10,14*160,6*160,5,%1110011001100110
	dc.w	10,10*160,5*160,6,%0001100110011001
	dc.w	46,20*160,1*160,1,%0101111010011011
	dc.w	10,22*160,8*160,6,%1000000000000000
	dc.w	10,10*160,5*160,6,%1011001100110011
	dc.w	10,14*160,6*160,6,%1110011001100110
	dc.w	21,5*160,1*160,3,%0110000110000110
	dc.w	13,31*160,7*160,5,%1001110110001001
	dc.w	16,29*160,5*160,4,%1011000000000000
	dc.w	16,22*160,4*160,4,%1101000000000000
	dc.w	21,5*160,1*160,3,%1100001100001100
	dc.w	21,24*160,3*160,3,%1101101101101101
	dc.w	31,26*160,2*160,2,%1010110101101011
	dc.w	11,18*160,6*160,7,%1011101000101110
	dc.w	31,26*160,2*160,2,%1100111001110011
	dc.w	11,27*160,8*160,8,%0001011101000101
	dc.w	19,29*160,4*160,4,%1100101000011010
	dc.w	16,29*160,5*160,5,%1101000000000000
	dc.w	21,5*160,1*160,4,%1000011000011000
	dc.w	10,10*160,5*160,9,%1011001100110011
	dc.w	11,9*160,4*160,9,%0000000000000000
	dc.w	10,10*160,5*160,10,%0001100110011001
	dc.w	16,15*160,3*160,6,%0111000000000000
	dc.w	19,29*160,4*160,5,%1000011010111100
	dc.w	10,22*160,8*160,10,%1011001100110011
	dc.w	19,29*160,4*160,5,%1011110010100001
	dc.w	21,5*160,1*160,5,%0100100100100100
	dc.w	16,15*160,3*160,7,%0001000000000000
	dc.w	16,8*160,2*160,7,%0011000000000000
	dc.w	13,31*160,7*160,9,%0000000000000000
	dc.w	21,24*160,3*160,5,%1010101010101010
	dc.w	19,12*160,2*160,6,%0101111001010000
	dc.w	16,29*160,5*160,7,%1011000000000000
	dc.w	13,9*160,3*160,9,%1001110110001001
	dc.w	19,12*160,2*160,6,%1010111100101000
	dc.w	7,5*160,8*160,18,%0110110110110110
	dc.w	7,5*160,8*160,18,%1011011011011011
	dc.w	7,5*160,8*160,19,%0000000000000000
	dc.w	10,18*160,7*160,13,%1000000000000000
	dc.w	13,20*160,5*160,10,%1000100111011000
	dc.w	19,12*160,2*160,7,%0101000011010111
	dc.w	7,5*160,8*160,20,%0010010010010010
	dc.w	10,14*160,6*160,14,%0100110011001100
	dc.w	31,26*160,2*160,4,%1010110101101011
	dc.w	16,15*160,3*160,9,%0011000000000000
	dc.w	13,9*160,3*160,11,%0111011000100111
	dc.w	13,20*160,5*160,11,%1001110110001001
	dc.w	19,29*160,4*160,8,%0000110101111001
	dc.w	61,28*160,1*160,2,%1000101001111101
	dc.w	10,18*160,7*160,15,%1011001100110011
	dc.w	13,9*160,3*160,12,%0011101100010011
	dc.w	12,17*160,5*160,-13,%0100000000000000
	dc.w	17,17*160,3*160,-9,%0011110000111100
	dc.w	12,22*160,6*160,-12,%1110101010101010
	dc.w	9,10*160,6*160,-17,%0000000000000000
	dc.w	12,27*160,7*160,-12,%1001010101010101
	dc.w	12,12*160,4*160,-12,%0110101010101010
	dc.w	17,17*160,3*160,-8,%1010010110100101
	dc.w	12,7*160,3*160,-12,%0001010101010101
	dc.w	17,17*160,3*160,-8,%0110100101101001
	dc.w	12,7*160,3*160,-11,%1100000000000000
	dc.w	9,17*160,8*160,-15,%0111000111000111
	dc.w	9,17*160,8*160,-15,%0011100011100011
	dc.w	17,17*160,3*160,-7,%1111000011110000
	dc.w	12,7*160,3*160,-11,%0001010101010101
	dc.w	12,12*160,4*160,-10,%1110101010101010
	dc.w	12,27*160,7*160,-10,%1100000000000000
	dc.w	23,17*160,2*160,-5,%1000010110010000
	dc.w	12,7*160,3*160,-10,%0110101010101010
	dc.w	12,17*160,5*160,-10,%0100000000000000
	dc.w	9,17*160,8*160,-13,%0111000111000111
	dc.w	12,17*160,5*160,-9,%1110101010101010
	dc.w	9,17*160,8*160,-13,%0000000000000000
	dc.w	12,7*160,3*160,-9,%1001010101010101
	dc.w	12,12*160,4*160,-9,%0110101010101010
	dc.w	12,7*160,3*160,-9,%0100000000000000
	dc.w	9,10*160,6*160,-12,%0001110001110001
	dc.w	9,17*160,8*160,-11,%1110001110001110
	dc.w	9,17*160,8*160,-11,%1010101010101010
	dc.w	23,17*160,2*160,-4,%0111101001101111
	dc.w	12,17*160,5*160,-8,%0110101010101010
	dc.w	9,17*160,8*160,-11,%0000000000000000
	dc.w	23,17*160,2*160,-4,%0011011110100110
	dc.w	12,7*160,3*160,-7,%1110101010101010
	dc.w	12,17*160,5*160,-7,%1100000000000000
	dc.w	12,17*160,5*160,-7,%1001010101010101
	dc.w	17,17*160,3*160,-5,%0011110000111100
	dc.w	12,27*160,7*160,-7,%0100000000000000
	dc.w	9,10*160,6*160,-9,%0111000111000111
	dc.w	12,7*160,3*160,-6,%1110101010101010
	dc.w	9,10*160,6*160,-9,%0000000000000000
	dc.w	12,7*160,3*160,-6,%1001010101010101
	dc.w	9,17*160,8*160,-8,%1000111000111000
	dc.w	23,17*160,2*160,-3,%0100001011001000
	dc.w	12,22*160,6*160,-6,%0001010101010101
	dc.w	23,17*160,2*160,-3,%0001011001000010
	dc.w	9,17*160,8*160,-7,%1010101010101010
	dc.w	9,17*160,8*160,-7,%0111000111000111
	dc.w	12,7*160,3*160,-5,%0110101010101010
	dc.w	12,7*160,3*160,-5,%0100000000000000
	dc.w	12,7*160,3*160,-5,%0001010101010101
	dc.w	12,12*160,4*160,-4,%1110101010101010
	dc.w	12,7*160,3*160,-4,%1100000000000000
	dc.w	9,17*160,8*160,-6,%0001110001110001
	dc.w	12,17*160,5*160,-4,%0110101010101010
	dc.w	9,10*160,6*160,-5,%1010101010101010
	dc.w	9,17*160,8*160,-5,%0111000111000111
	dc.w	12,22*160,6*160,-3,%1110101010101010
	dc.w	23,17*160,2*160,-1,%1111010011011110
	dc.w	9,10*160,6*160,-4,%1100011100011100
	dc.w	23,17*160,2*160,-1,%1100100001011001
	dc.w	12,17*160,5*160,-3,%0100000000000000
	dc.w	9,10*160,6*160,-4,%0001110001110001
	dc.w	12,12*160,4*160,-2,%1110101010101010
	dc.w	12,27*160,7*160,-2,%1100000000000000
	dc.w	12,27*160,7*160,-2,%1001010101010101
	dc.w	23,17*160,2*160,-1,%0100001011001000
	dc.w	9,17*160,8*160,-3,%0000000000000000
	dc.w	17,17*160,3*160,-1,%0111100001111000
	dc.w	23,17*160,2*160,-1,%0000000000000000
	dc.w	12,7*160,3*160,-1,%1100000000000000
	dc.w	17,17*160,3*160,-1,%0001111000011110
	dc.w	23,17*160,2*160,0,%1011110100110111
	dc.w	12,7*160,3*160,-1,%0100000000000000
	dc.w	17,17*160,3*160,0,%1100001111000011
	dc.w	9,17*160,8*160,-1,%0011100011100011
	dc.w	12,12*160,4*160,0,%1100000000000000
	dc.w	9,17*160,8*160,0,%1100011100011100
	dc.w	12,7*160,3*160,0,%0110101010101010
	dc.w	12,27*160,7*160,0,%0100000000000000
	dc.w	12,7*160,3*160,0,%0001010101010101
	dc.w	12,27*160,7*160,0,%0001010101010101
	dc.w	17,17*160,3*160,0,%0010110100101101
	dc.w	17,17*160,3*160,0,%0100101101001011
	dc.w	9,17*160,8*160,0,%1100011100011100
	dc.w	12,27*160,7*160,0,%1100000000000000
	dc.w	9,10*160,6*160,1,%0011100011100011
	dc.w	12,7*160,3*160,1,%0001010101010101
	dc.w	12,12*160,4*160,1,%0100000000000000
	dc.w	12,27*160,7*160,1,%0110101010101010
	dc.w	9,17*160,8*160,2,%0001110001110001
	dc.w	12,7*160,3*160,1,%1100000000000000
	dc.w	9,10*160,6*160,2,%1000111000111000
	dc.w	23,17*160,2*160,1,%0001011001000010
	dc.w	17,17*160,3*160,1,%1001011010010110
	dc.w	12,17*160,5*160,2,%0110101010101010
	dc.w	9,10*160,6*160,3,%0111000111000111
	dc.w	12,12*160,4*160,2,%1100000000000000
	dc.w	12,27*160,7*160,2,%1110101010101010
	dc.w	9,10*160,6*160,4,%0001110001110001
	dc.w	9,17*160,8*160,4,%0101010101010101
	dc.w	9,17*160,8*160,4,%1000111000111000
	dc.w	9,10*160,6*160,4,%1100011100011100
	dc.w	9,10*160,6*160,5,%0000000000000000
	dc.w	17,17*160,3*160,2,%1100001111000011
	dc.w	12,27*160,7*160,4,%0001010101010101
	dc.w	17,17*160,3*160,3,%0000000000000000
	dc.w	12,22*160,6*160,4,%0110101010101010
	dc.w	9,10*160,6*160,6,%0001110001110001
	dc.w	12,12*160,4*160,4,%1100000000000000
	dc.w	12,7*160,3*160,4,%1110101010101010
	dc.w	9,17*160,8*160,6,%1100011100011100
	dc.w	12,17*160,5*160,5,%0100000000000000
	dc.w	9,10*160,6*160,7,%0011100011100011
	dc.w	9,10*160,6*160,7,%0111000111000111
	dc.w	12,17*160,5*160,5,%1100000000000000
	dc.w	17,17*160,3*160,4,%0010110100101101
	dc.w	12,22*160,6*160,6,%0001010101010101
	dc.w	23,17*160,2*160,3,%0100001011001000
	dc.w	12,17*160,5*160,6,%0110101010101010
	dc.w	12,27*160,7*160,6,%1001010101010101
	dc.w	12,7*160,3*160,6,%1100000000000000
	dc.w	12,22*160,6*160,6,%1110101010101010
	dc.w	23,17*160,2*160,3,%1011001000010110
	dc.w	12,22*160,6*160,7,%0100000000000000
	dc.w	12,17*160,5*160,7,%0110101010101010
	dc.w	12,27*160,7*160,7,%1001010101010101
	dc.w	12,12*160,4*160,7,%1100000000000000
	dc.w	9,10*160,6*160,10,%1000111000111000
	dc.w	12,22*160,6*160,8,%0001010101010101
	dc.w	9,10*160,6*160,11,%0000000000000000
	dc.w	12,22*160,6*160,8,%0110101010101010
	dc.w	12,7*160,3*160,8,%1001010101010101
	dc.w	9,17*160,8*160,11,%1010101010101010
	dc.w	23,17*160,2*160,4,%1010011011110100
	dc.w	9,10*160,6*160,12,%0001110001110001
	dc.w	12,12*160,4*160,9,%0100000000000000
	dc.w	12,22*160,6*160,9,%0110101010101010
	dc.w	9,10*160,6*160,12,%1100011100011100
	dc.w	23,17*160,2*160,5,%0001011001000010
	dc.w	12,12*160,4*160,9,%1110101010101010
	dc.w	9,10*160,6*160,13,%0111000111000111
	dc.w	12,17*160,5*160,10,%0100000000000000
	dc.w	12,27*160,7*160,10,%0110101010101010
	dc.w	12,7*160,3*160,10,%1001010101010101
	dc.w	12,7*160,3*160,10,%1100000000000000
	dc.w	23,17*160,2*160,5,%1011001000010110
	dc.w	12,17*160,5*160,11,%0001010101010101
	dc.w	12,17*160,5*160,11,%0100000000000000
	dc.w	12,22*160,6*160,11,%0110101010101010
	dc.w	17,17*160,3*160,8,%0010110100101101
	dc.w	23,17*160,2*160,6,%0010000101100100
	dc.w	12,17*160,5*160,11,%1110101010101010
	dc.w	9,17*160,8*160,16,%0001110001110001
	dc.w	12,27*160,7*160,12,%0100000000000000
	dc.w	9,17*160,8*160,16,%1000111000111000
	dc.w	12,22*160,6*160,12,%1001010101010101
	dc.w	17,17*160,3*160,9,%0000000000000000
	dc.w	9,10*160,6*160,17,%0011100011100011
	dc.w	12,12*160,4*160,13,%0001010101010101
	dc.w	12,7*160,3*160,13,%0100000000000000
	dc.w	44,19*160,1*160,-3,%1001110100010111
	dc.w	44,19*160,1*160,-3,%1001000101110100
	dc.w	44,19*160,1*160,-3,%1000010111010001
	dc.w	44,19*160,1*160,-3,%0111101000101110
	dc.w	44,19*160,1*160,-3,%0110111010001011
	dc.w	44,19*160,1*160,-3,%0110001011101000
	dc.w	44,19*160,1*160,-3,%0101011101000101
	dc.w	44,19*160,1*160,-3,%0100101110100010
	dc.w	44,19*160,1*160,-3,%0100000000000000
	dc.w	44,19*160,1*160,-3,%0011010001011101
	dc.w	44,19*160,1*160,-3,%0010100010111010
	dc.w	44,19*160,1*160,-3,%0001110100010111
	dc.w	44,19*160,1*160,-3,%0001000101110100
	dc.w	44,19*160,1*160,-3,%0000010111010001
	dc.w	44,19*160,1*160,-2,%1111101000101110
	dc.w	44,19*160,1*160,-2,%1110111010001011
	dc.w	44,19*160,1*160,-2,%1110001011101000
	dc.w	44,19*160,1*160,-2,%1101011101000101
	dc.w	44,19*160,1*160,-2,%1100101110100010
	dc.w	44,19*160,1*160,-2,%1100000000000000
	dc.w	44,19*160,1*160,-2,%1011010001011101
	dc.w	44,19*160,1*160,-2,%1010100010111010
	dc.w	44,19*160,1*160,-2,%1001110100010111
	dc.w	44,19*160,1*160,-2,%1001000101110100
	dc.w	44,19*160,1*160,-2,%1000010111010001
	dc.w	44,19*160,1*160,-2,%0111101000101110
	dc.w	44,19*160,1*160,-2,%0110111010001011
	dc.w	44,19*160,1*160,-2,%0110001011101000
	dc.w	44,19*160,1*160,-2,%0101011101000101
	dc.w	44,19*160,1*160,-2,%0100101110100010
	dc.w	44,19*160,1*160,-2,%0100000000000000
	dc.w	44,19*160,1*160,-2,%0011010001011101
	dc.w	44,19*160,1*160,-2,%0010100010111010
	dc.w	44,19*160,1*160,-2,%0001110100010111
	dc.w	44,19*160,1*160,-2,%0001000101110100
	dc.w	44,19*160,1*160,-2,%0000010111010001
	dc.w	44,19*160,1*160,-1,%1111101000101110
	dc.w	44,19*160,1*160,-1,%1110111010001011
	dc.w	44,19*160,1*160,-1,%1110001011101000
	dc.w	44,19*160,1*160,-1,%1101011101000101
	dc.w	44,19*160,1*160,-1,%1100101110100010
	dc.w	44,19*160,1*160,-1,%1100000000000000
	dc.w	44,19*160,1*160,-1,%1011010001011101
	dc.w	44,19*160,1*160,-1,%1010100010111010
	dc.w	44,19*160,1*160,-1,%1001110100010111
	dc.w	44,19*160,1*160,-1,%1001000101110100
	dc.w	44,19*160,1*160,-1,%1000010111010001
	dc.w	44,19*160,1*160,-1,%0111101000101110
	dc.w	44,19*160,1*160,-1,%0110111010001011
	dc.w	44,19*160,1*160,-1,%0110001011101000
	dc.w	44,19*160,1*160,-1,%0101011101000101
	dc.w	44,19*160,1*160,-1,%0100101110100010
	dc.w	44,19*160,1*160,-1,%0100000000000000
	dc.w	44,19*160,1*160,-1,%0011010001011101
	dc.w	44,19*160,1*160,-1,%0010100010111010
	dc.w	44,19*160,1*160,-1,%0001110100010111
	dc.w	44,19*160,1*160,-1,%0001000101110100
	dc.w	44,19*160,1*160,-1,%0000010111010001
	dc.w	44,19*160,1*160,0,%1111101000101110
	dc.w	44,19*160,1*160,0,%1110111010001011
	dc.w	44,19*160,1*160,0,%1110001011101000
	dc.w	44,19*160,1*160,0,%1101011101000101
	dc.w	44,19*160,1*160,0,%1100101110100010
	dc.w	44,19*160,1*160,0,%1100000000000000
	dc.w	44,19*160,1*160,0,%1011010001011101
	dc.w	44,19*160,1*160,0,%1010100010111010
	dc.w	44,19*160,1*160,0,%1001110100010111
	dc.w	44,19*160,1*160,0,%1001000101110100
	dc.w	44,19*160,1*160,0,%1000010111010001
	dc.w	44,19*160,1*160,0,%0111101000101110
	dc.w	44,19*160,1*160,0,%0110111010001011
	dc.w	44,19*160,1*160,0,%0110001011101000
	dc.w	44,19*160,1*160,0,%0101011101000101
	dc.w	44,19*160,1*160,0,%0100101110100010
	dc.w	44,19*160,1*160,0,%0100000000000000
	dc.w	44,19*160,1*160,0,%0011010001011101
	dc.w	44,19*160,1*160,0,%0010100010111010
	dc.w	44,19*160,1*160,0,%0001110100010111
	dc.w	44,19*160,1*160,0,%0001000101110100
	dc.w	44,19*160,1*160,0,%0000010111010001
	dc.w	44,19*160,1*160,0,%0000010111010001
	dc.w	44,19*160,1*160,0,%0001000101110100
	dc.w	44,19*160,1*160,0,%0001110100010111
	dc.w	44,19*160,1*160,0,%0010100010111010
	dc.w	44,19*160,1*160,0,%0011010001011101
	dc.w	44,19*160,1*160,0,%0100000000000000
	dc.w	44,19*160,1*160,0,%0100101110100010
	dc.w	44,19*160,1*160,0,%0101011101000101
	dc.w	44,19*160,1*160,0,%0110001011101000
	dc.w	44,19*160,1*160,0,%0110111010001011
	dc.w	44,19*160,1*160,0,%0111101000101110
	dc.w	44,19*160,1*160,0,%1000010111010001
	dc.w	44,19*160,1*160,0,%1001000101110100
	dc.w	44,19*160,1*160,0,%1001110100010111
	dc.w	44,19*160,1*160,0,%1010100010111010
	dc.w	44,19*160,1*160,0,%1011010001011101
	dc.w	44,19*160,1*160,0,%1100000000000000
	dc.w	44,19*160,1*160,0,%1100101110100010
	dc.w	44,19*160,1*160,0,%1101011101000101
	dc.w	44,19*160,1*160,0,%1110001011101000
	dc.w	44,19*160,1*160,0,%1110111010001011
	dc.w	44,19*160,1*160,0,%1111101000101110
	dc.w	44,19*160,1*160,1,%0000010111010001
	dc.w	44,19*160,1*160,1,%0001000101110100
	dc.w	44,19*160,1*160,1,%0001110100010111
	dc.w	44,19*160,1*160,1,%0010100010111010
	dc.w	44,19*160,1*160,1,%0011010001011101
	dc.w	44,19*160,1*160,1,%0100000000000000
	dc.w	44,19*160,1*160,1,%0100101110100010
	dc.w	44,19*160,1*160,1,%0101011101000101
	dc.w	44,19*160,1*160,1,%0110001011101000
	dc.w	44,19*160,1*160,1,%0110111010001011
	dc.w	44,19*160,1*160,1,%0111101000101110
	dc.w	44,19*160,1*160,1,%1000010111010001
	dc.w	44,19*160,1*160,1,%1001000101110100
	dc.w	44,19*160,1*160,1,%1001110100010111
	dc.w	44,19*160,1*160,1,%1010100010111010
	dc.w	44,19*160,1*160,1,%1011010001011101
	dc.w	44,19*160,1*160,1,%1100000000000000
	dc.w	44,19*160,1*160,1,%1100101110100010
	dc.w	44,19*160,1*160,1,%1101011101000101
	dc.w	44,19*160,1*160,1,%1110001011101000
	dc.w	44,19*160,1*160,1,%1110111010001011
	dc.w	44,19*160,1*160,1,%1111101000101110
	dc.w	44,19*160,1*160,2,%0000010111010001
	dc.w	44,19*160,1*160,2,%0001000101110100
	dc.w	44,19*160,1*160,2,%0001110100010111
	dc.w	44,19*160,1*160,2,%0010100010111010
	dc.w	44,19*160,1*160,2,%0011010001011101
	dc.w	44,19*160,1*160,2,%0100000000000000
	dc.w	44,19*160,1*160,2,%0100101110100010
	dc.w	44,19*160,1*160,2,%0101011101000101
	dc.w	44,19*160,1*160,2,%0110001011101000
	dc.w	44,19*160,1*160,2,%0110111010001011
	dc.w	44,19*160,1*160,2,%0111101000101110
	dc.w	44,19*160,1*160,2,%1000010111010001
	dc.w	44,19*160,1*160,2,%1001000101110100
	dc.w	44,19*160,1*160,2,%1001110100010111
	dc.w	44,19*160,1*160,2,%1010100010111010
	dc.w	44,19*160,1*160,2,%1011010001011101
	dc.w	44,19*160,1*160,2,%1100000000000000
	dc.w	44,19*160,1*160,2,%1100101110100010
	dc.w	44,19*160,1*160,2,%1101011101000101
	dc.w	44,19*160,1*160,2,%1110001011101000
	dc.w	44,19*160,1*160,2,%1110111010001011
	dc.w	44,19*160,1*160,2,%1111101000101110
	dc.w	44,19*160,1*160,3,%0000010111010001
	dc.w	44,19*160,1*160,3,%0001000101110100
	dc.w	44,19*160,1*160,3,%0001110100010111
	dc.w	44,19*160,1*160,3,%0010100010111010
	dc.w	44,19*160,1*160,3,%0011010001011101
	dc.w	44,19*160,1*160,3,%0100000000000000
	dc.w	44,19*160,1*160,3,%0100101110100010
	dc.w	44,19*160,1*160,3,%0101011101000101
	dc.w	44,19*160,1*160,3,%0110001011101000
	dc.w	44,19*160,1*160,3,%0110111010001011
	dc.w	44,19*160,1*160,3,%0111101000101110
	dc.w	44,19*160,1*160,3,%1000010111010001
	dc.w	44,19*160,1*160,3,%1001000101110100
	dc.w	44,19*160,1*160,3,%1001110100010111
	dc.w	8,12*160,8*160,-19,%1110000000000000
	dc.w	7,6*160,8*160,-22,%0110110110110110
	dc.w	22,16*160,2*160,-7,%0000101110100010
	dc.w	15,20*160,4*160,-10,%0011001100110011
	dc.w	15,7*160,2*160,-10,%0001000100010001
	dc.w	9,14*160,7*160,-16,%1000111000111000
	dc.w	8,9*160,7*160,-18,%0110000000000000
	dc.w	15,7*160,2*160,-9,%1010101010101010
	dc.w	8,6*160,6*160,-17,%1110000000000000
	dc.w	22,6*160,1*160,-6,%0110100010111010
	dc.w	8,6*160,6*160,-17,%0110000000000000
	dc.w	22,26*160,3*160,-6,%0011101000101110
	dc.w	29,24*160,2*160,-4,%1010011110111001
	dc.w	9,14*160,7*160,-14,%1100011100011100
	dc.w	15,20*160,4*160,-8,%1011101110111011
	dc.w	29,24*160,2*160,-4,%0111001011000010
	dc.w	22,16*160,2*160,-5,%1100010111010001
	dc.w	29,24*160,2*160,-4,%0100111101110010
	dc.w	25,8*160,1*160,-4,%1110101110000101
	dc.w	13,26*160,6*160,-9,%0100111011000100
	dc.w	8,6*160,6*160,-14,%1110000000000000
	dc.w	25,8*160,1*160,-4,%1010111000010100
	dc.w	22,6*160,1*160,-5,%0011101000101110
	dc.w	7,6*160,8*160,-16,%0010010010010010
	dc.w	15,20*160,4*160,-7,%0110011001100110
	dc.w	15,7*160,2*160,-7,%0100010001000100
	dc.w	8,6*160,6*160,-13,%0110000000000000
	dc.w	8,9*160,7*160,-13,%0010000000000000
	dc.w	22,16*160,2*160,-4,%1010111010001011
	dc.w	8,6*160,6*160,-12,%1010000000000000
	dc.w	9,7*160,5*160,-11,%0000000000000000
	dc.w	8,9*160,7*160,-12,%0010000000000000
	dc.w	8,6*160,6*160,-11,%1110000000000000
	dc.w	29,24*160,2*160,-3,%0011010011110111
	dc.w	9,14*160,7*160,-10,%0001110001110001
	dc.w	22,26*160,3*160,-4,%0000101110100010
	dc.w	22,6*160,1*160,-3,%1111010001011101
	dc.w	22,6*160,1*160,-3,%1101110100010111
	dc.w	29,24*160,2*160,-2,%1101110010110000
	dc.w	8,9*160,7*160,-10,%0010000000000000
	dc.w	8,6*160,6*160,-9,%1110000000000000
	dc.w	25,8*160,1*160,-3,%0001010001111010
	dc.w	9,14*160,7*160,-8,%0101010101010101
	dc.w	25,8*160,1*160,-2,%1110101110000101
	dc.w	22,16*160,2*160,-3,%0011101000101110
	dc.w	13,26*160,6*160,-5,%0100111011000100
	dc.w	57,26*160,1*160,-1,%0010110011101001
	dc.w	8,12*160,8*160,-8,%0010000000000000
	dc.w	22,6*160,1*160,-2,%1101110100010111
	dc.w	25,31*160,3*160,-2,%0111000010100011
	dc.w	8,6*160,6*160,-7,%0110000000000000
	dc.w	15,20*160,4*160,-3,%1100110011001100
	dc.w	7,6*160,8*160,-7,%1101101101101101
	dc.w	9,7*160,5*160,-5,%1110001110001110
	dc.w	22,6*160,1*160,-2,%0101000101110100
	dc.w	13,26*160,6*160,-3,%1100010011101100
	dc.w	13,15*160,4*160,-3,%1001110110001001
	dc.w	15,7*160,2*160,-3,%0000000000000000
	dc.w	13,26*160,6*160,-3,%0100111011000100
	dc.w	22,16*160,2*160,-1,%1101110100010111
	dc.w	22,26*160,3*160,-1,%1100010111010001
	dc.w	25,8*160,1*160,-1,%0111101011100001
	dc.w	13,15*160,4*160,-2,%1011000100111011
	dc.w	7,6*160,8*160,-4,%1011011011011011
	dc.w	22,26*160,3*160,-1,%0110100010111010
	dc.w	8,12*160,8*160,-3,%1010000000000000
	dc.w	9,7*160,5*160,-3,%0000000000000000
	dc.w	13,15*160,4*160,-1,%1110110001001110
	dc.w	22,26*160,3*160,-1,%0000101110100010
	dc.w	7,6*160,8*160,-3,%0000000000000000
	dc.w	29,24*160,2*160,0,%1010011110111001
	dc.w	8,6*160,6*160,-2,%0010000000000000
	dc.w	9,7*160,5*160,-1,%1010101010101010
	dc.w	29,24*160,2*160,0,%0111001011000010
	dc.w	15,20*160,4*160,0,%1011101110111011
	dc.w	7,6*160,8*160,-1,%0100100100100100
	dc.w	8,6*160,6*160,0,%1110000000000000
	dc.w	7,6*160,8*160,0,%1011011011011011
	dc.w	25,31*160,3*160,0,%0001111010111000
	dc.w	15,20*160,4*160,0,%0001000100010001
	dc.w	29,24*160,2*160,0,%0000100011010011
	dc.w	25,8*160,1*160,0,%0001111010111000
	dc.w	57,26*160,1*160,0,%0001011001110100
	dc.w	22,6*160,1*160,0,%0101000101110100
	dc.w	9,7*160,5*160,1,%0000000000000000
	dc.w	15,7*160,2*160,0,%1011101110111011
	dc.w	9,14*160,7*160,1,%0111000111000111
	dc.w	15,20*160,4*160,1,%0000000000000000
	dc.w	25,8*160,1*160,0,%1010111000010100
	dc.w	25,31*160,3*160,0,%1100001010001111
	dc.w	13,15*160,4*160,1,%1001110110001001
	dc.w	15,7*160,2*160,1,%1000100010001000
	dc.w	25,31*160,3*160,1,%0000000000000000
	dc.w	9,7*160,5*160,3,%0000000000000000
	dc.w	15,20*160,4*160,1,%1110111011101110
	dc.w	7,6*160,8*160,4,%0110110110110110
	dc.w	15,7*160,2*160,2,%0011001100110011
	dc.w	7,6*160,8*160,5,%0000000000000000
	dc.w	8,9*160,7*160,4,%1010000000000000
	dc.w	22,26*160,3*160,1,%1100010111010001
	dc.w	15,20*160,4*160,2,%1011101110111011
	dc.w	25,8*160,1*160,1,%1011100001010001
	dc.w	29,24*160,2*160,1,%1000110100111101
	dc.w	15,20*160,4*160,3,%0010001000100010
	dc.w	15,20*160,4*160,3,%0100010001000100
	dc.w	22,16*160,2*160,2,%0101000101110100
	dc.w	15,20*160,4*160,3,%1000100010001000
	dc.w	9,14*160,7*160,6,%0001110001110001
	dc.w	8,6*160,6*160,7,%0010000000000000
	dc.w	15,20*160,4*160,3,%1110111011101110
	dc.w	8,9*160,7*160,7,%1010000000000000
	dc.w	7,6*160,8*160,9,%0000000000000000
	dc.w	29,24*160,2*160,2,%0011110111001011
	dc.w	9,7*160,5*160,7,%0111000111000111
	dc.w	15,7*160,2*160,4,%1001100110011001
	dc.w	13,26*160,6*160,5,%0111011000100111
	dc.w	9,7*160,5*160,8,%0001110001110001
	dc.w	25,31*160,3*160,3,%0000000000000000
	dc.w	15,7*160,2*160,5,%0010001000100010
	dc.w	22,26*160,3*160,3,%1001011101000101
	dc.w	25,8*160,1*160,3,%0011110101110000
	dc.w	8,6*160,6*160,10,%0110000000000000
	dc.w	8,9*160,7*160,10,%1010000000000000
	dc.w	15,7*160,2*160,5,%1100110011001100
	dc.w	15,7*160,2*160,5,%1110111011101110
	dc.w	15,7*160,2*160,6,%0001000100010001
	dc.w	15,20*160,4*160,6,%0011001100110011
	dc.w	22,26*160,3*160,4,%0101000101110100
	dc.w	22,6*160,1*160,4,%0110100010111010
	dc.w	8,6*160,6*160,12,%0110000000000000
	dc.w	15,20*160,4*160,6,%1011101110111011
	dc.w	9,14*160,7*160,11,%0111000111000111
	dc.w	8,9*160,7*160,13,%0010000000000000
	dc.w	29,24*160,2*160,3,%1011000010001101
	dc.w	9,7*160,5*160,12,%0001110001110001
	dc.w	29,24*160,2*160,3,%1101001111011100
	dc.w	57,26*160,1*160,1,%1111101110000010
	dc.w	22,26*160,3*160,5,%0011101000101110
	dc.w	29,24*160,2*160,4,%0000100011010011
	dc.w	13,15*160,4*160,9,%0010011101100010
	dc.w	22,26*160,3*160,5,%1000000000000000
	dc.w	57,26*160,1*160,2,%0010100001101011
	dc.w	7,6*160,8*160,17,%1101101101101101
	dc.w	29,24*160,2*160,4,%0110000100011010
	dc.w	25,8*160,1*160,5,%0010100011110101
	dc.w	8,6*160,6*160,16,%0110000000000000
	dc.w	57,26*160,1*160,2,%0101010101010101
	dc.w	29,24*160,2*160,4,%1010011110111001
	dc.w	9,7*160,5*160,15,%0011100011100011
	dc.w	13,15*160,4*160,10,%1011000100111011
	dc.w	8,9*160,7*160,17,%1010000000000000
	dc.w	13,26*160,6*160,11,%0000000000000000
	dc.w	8,9*160,7*160,18,%0010000000000000
	dc.w	9,7*160,5*160,16,%0101010101010101
	dc.w	8,6*160,6*160,18,%1010000000000000
	dc.w	22,6*160,1*160,6,%1101110100010111
	dc.w	22,26*160,3*160,6,%1111010001011101
	dc.w	15,7*160,2*160,10,%0101010101010101
	dc.w	7,6*160,8*160,22,%0110110110110110
	dc.w	22,26*160,3*160,7,%0011101000101110
	dc.w	42,18*160,1*160,-3,%1100100100100100
	dc.w	42,18*160,1*160,-3,%1011110011110011
	dc.w	42,18*160,1*160,-3,%1011000011000011
	dc.w	42,18*160,1*160,-3,%1010010010010010
	dc.w	42,18*160,1*160,-3,%1001100001100001
	dc.w	42,18*160,1*160,-3,%1000110000110000
	dc.w	42,18*160,1*160,-3,%1000000000000000
	dc.w	42,18*160,1*160,-3,%0111001111001111
	dc.w	42,18*160,1*160,-3,%0110011110011110
	dc.w	42,18*160,1*160,-3,%0101101101101101
	dc.w	42,18*160,1*160,-3,%0100111100111100
	dc.w	42,18*160,1*160,-3,%0100001100001100
	dc.w	42,18*160,1*160,-3,%0011011011011011
	dc.w	42,18*160,1*160,-3,%0010101010101010
	dc.w	42,18*160,1*160,-3,%0001111001111001
	dc.w	42,18*160,1*160,-3,%0001001001001001
	dc.w	42,18*160,1*160,-3,%0000011000011000
	dc.w	42,18*160,1*160,-2,%1111100111100111
	dc.w	42,18*160,1*160,-2,%1110110110110110
	dc.w	42,18*160,1*160,-2,%1110000110000110
	dc.w	42,18*160,1*160,-2,%1101010101010101
	dc.w	42,18*160,1*160,-2,%1100100100100100
	dc.w	42,18*160,1*160,-2,%1011110011110011
	dc.w	42,18*160,1*160,-2,%1011000011000011
	dc.w	42,18*160,1*160,-2,%1010010010010010
	dc.w	42,18*160,1*160,-2,%1001100001100001
	dc.w	42,18*160,1*160,-2,%1000110000110000
	dc.w	42,18*160,1*160,-2,%1000000000000000
	dc.w	42,18*160,1*160,-2,%0111001111001111
	dc.w	42,18*160,1*160,-2,%0110011110011110
	dc.w	42,18*160,1*160,-2,%0101101101101101
	dc.w	42,18*160,1*160,-2,%0100111100111100
	dc.w	42,18*160,1*160,-2,%0100001100001100
	dc.w	42,18*160,1*160,-2,%0011011011011011
	dc.w	42,18*160,1*160,-2,%0010101010101010
	dc.w	42,18*160,1*160,-2,%0001111001111001
	dc.w	42,18*160,1*160,-2,%0001001001001001
	dc.w	42,18*160,1*160,-2,%0000011000011000
	dc.w	42,18*160,1*160,-1,%1111100111100111
	dc.w	42,18*160,1*160,-1,%1110110110110110
	dc.w	42,18*160,1*160,-1,%1110000110000110
	dc.w	42,18*160,1*160,-1,%1101010101010101
	dc.w	42,18*160,1*160,-1,%1100100100100100
	dc.w	42,18*160,1*160,-1,%1011110011110011
	dc.w	42,18*160,1*160,-1,%1011000011000011
	dc.w	42,18*160,1*160,-1,%1010010010010010
	dc.w	42,18*160,1*160,-1,%1001100001100001
	dc.w	42,18*160,1*160,-1,%1000110000110000
	dc.w	42,18*160,1*160,-1,%1000000000000000
	dc.w	42,18*160,1*160,-1,%0111001111001111
	dc.w	42,18*160,1*160,-1,%0110011110011110
	dc.w	42,18*160,1*160,-1,%0101101101101101
	dc.w	42,18*160,1*160,-1,%0100111100111100
	dc.w	42,18*160,1*160,-1,%0100001100001100
	dc.w	42,18*160,1*160,-1,%0011011011011011
	dc.w	42,18*160,1*160,-1,%0010101010101010
	dc.w	42,18*160,1*160,-1,%0001111001111001
	dc.w	42,18*160,1*160,-1,%0001001001001001
	dc.w	42,18*160,1*160,-1,%0000011000011000
	dc.w	42,18*160,1*160,0,%1111100111100111
	dc.w	42,18*160,1*160,0,%1110110110110110
	dc.w	42,18*160,1*160,0,%1110000110000110
	dc.w	42,18*160,1*160,0,%1101010101010101
	dc.w	42,18*160,1*160,0,%1100100100100100
	dc.w	42,18*160,1*160,0,%1011110011110011
	dc.w	42,18*160,1*160,0,%1011000011000011
	dc.w	42,18*160,1*160,0,%1010010010010010
	dc.w	42,18*160,1*160,0,%1001100001100001
	dc.w	42,18*160,1*160,0,%1000110000110000
	dc.w	42,18*160,1*160,0,%1000000000000000
	dc.w	42,18*160,1*160,0,%0111001111001111
	dc.w	42,18*160,1*160,0,%0110011110011110
	dc.w	42,18*160,1*160,0,%0101101101101101
	dc.w	42,18*160,1*160,0,%0100111100111100
	dc.w	42,18*160,1*160,0,%0100001100001100
	dc.w	42,18*160,1*160,0,%0011011011011011
	dc.w	42,18*160,1*160,0,%0010101010101010
	dc.w	42,18*160,1*160,0,%0001111001111001
	dc.w	42,18*160,1*160,0,%0001001001001001
	dc.w	42,18*160,1*160,0,%0000011000011000
	dc.w	42,18*160,1*160,0,%0000011000011000
	dc.w	42,18*160,1*160,0,%0001001001001001
	dc.w	42,18*160,1*160,0,%0001111001111001
	dc.w	42,18*160,1*160,0,%0010101010101010
	dc.w	42,18*160,1*160,0,%0011011011011011
	dc.w	42,18*160,1*160,0,%0100001100001100
	dc.w	42,18*160,1*160,0,%0100111100111100
	dc.w	42,18*160,1*160,0,%0101101101101101
	dc.w	42,18*160,1*160,0,%0110011110011110
	dc.w	42,18*160,1*160,0,%0111001111001111
	dc.w	42,18*160,1*160,0,%1000000000000000
	dc.w	42,18*160,1*160,0,%1000110000110000
	dc.w	42,18*160,1*160,0,%1001100001100001
	dc.w	42,18*160,1*160,0,%1010010010010010
	dc.w	42,18*160,1*160,0,%1011000011000011
	dc.w	42,18*160,1*160,0,%1011110011110011
	dc.w	42,18*160,1*160,0,%1100100100100100
	dc.w	42,18*160,1*160,0,%1101010101010101
	dc.w	42,18*160,1*160,0,%1110000110000110
	dc.w	42,18*160,1*160,0,%1110110110110110
	dc.w	42,18*160,1*160,0,%1111100111100111
	dc.w	42,18*160,1*160,1,%0000011000011000
	dc.w	42,18*160,1*160,1,%0001001001001001
	dc.w	42,18*160,1*160,1,%0001111001111001
	dc.w	42,18*160,1*160,1,%0010101010101010
	dc.w	42,18*160,1*160,1,%0011011011011011
	dc.w	42,18*160,1*160,1,%0100001100001100
	dc.w	42,18*160,1*160,1,%0100111100111100
	dc.w	42,18*160,1*160,1,%0101101101101101
	dc.w	42,18*160,1*160,1,%0110011110011110
	dc.w	42,18*160,1*160,1,%0111001111001111
	dc.w	42,18*160,1*160,1,%1000000000000000
	dc.w	42,18*160,1*160,1,%1000110000110000
	dc.w	42,18*160,1*160,1,%1001100001100001
	dc.w	42,18*160,1*160,1,%1010010010010010
	dc.w	42,18*160,1*160,1,%1011000011000011
	dc.w	42,18*160,1*160,1,%1011110011110011
	dc.w	42,18*160,1*160,1,%1100100100100100
	dc.w	42,18*160,1*160,1,%1101010101010101
	dc.w	42,18*160,1*160,1,%1110000110000110
	dc.w	42,18*160,1*160,1,%1110110110110110
	dc.w	42,18*160,1*160,1,%1111100111100111
	dc.w	42,18*160,1*160,2,%0000011000011000
	dc.w	42,18*160,1*160,2,%0001001001001001
	dc.w	42,18*160,1*160,2,%0001111001111001
	dc.w	42,18*160,1*160,2,%0010101010101010
	dc.w	42,18*160,1*160,2,%0011011011011011
	dc.w	42,18*160,1*160,2,%0100001100001100
	dc.w	42,18*160,1*160,2,%0100111100111100
	dc.w	42,18*160,1*160,2,%0101101101101101
	dc.w	42,18*160,1*160,2,%0110011110011110
	dc.w	42,18*160,1*160,2,%0111001111001111
	dc.w	42,18*160,1*160,2,%1000000000000000
	dc.w	42,18*160,1*160,2,%1000110000110000
	dc.w	42,18*160,1*160,2,%1001100001100001
	dc.w	42,18*160,1*160,2,%1010010010010010
	dc.w	42,18*160,1*160,2,%1011000011000011
	dc.w	42,18*160,1*160,2,%1011110011110011
	dc.w	42,18*160,1*160,2,%1100100100100100
	dc.w	42,18*160,1*160,2,%1101010101010101
	dc.w	42,18*160,1*160,2,%1110000110000110
	dc.w	42,18*160,1*160,2,%1110110110110110
	dc.w	42,18*160,1*160,2,%1111100111100111
	dc.w	42,18*160,1*160,3,%0000011000011000
	dc.w	42,18*160,1*160,3,%0001001001001001
	dc.w	42,18*160,1*160,3,%0001111001111001
	dc.w	42,18*160,1*160,3,%0010101010101010
	dc.w	42,18*160,1*160,3,%0011011011011011
	dc.w	42,18*160,1*160,3,%0100001100001100
	dc.w	42,18*160,1*160,3,%0100111100111100
	dc.w	42,18*160,1*160,3,%0101101101101101
	dc.w	42,18*160,1*160,3,%0110011110011110
	dc.w	42,18*160,1*160,3,%0111001111001111
	dc.w	42,18*160,1*160,3,%1000000000000000
	dc.w	42,18*160,1*160,3,%1000110000110000
	dc.w	42,18*160,1*160,3,%1001100001100001
	dc.w	42,18*160,1*160,3,%1010010010010010
	dc.w	42,18*160,1*160,3,%1011000011000011
	dc.w	42,18*160,1*160,3,%1011110011110011
	dc.w	42,18*160,1*160,3,%1100100100100100
	dc.w	9,18*160,8*160,-17,%1010101010101010
	dc.w	9,18*160,8*160,-17,%0111000111000111
	dc.w	33,13*160,1*160,-4,%1011001001101100
	dc.w	11,19*160,6*160,-13,%1110100010111010
	dc.w	21,15*160,2*160,-7,%0011000011000011
	dc.w	11,10*160,4*160,-13,%1000101110100010
	dc.w	11,19*160,6*160,-13,%0101110100010111
	dc.w	17,10*160,2*160,-8,%1000011110000111
	dc.w	11,19*160,6*160,-13,%0000000000000000
	dc.w	21,15*160,2*160,-6,%1011011011011011
	dc.w	9,18*160,8*160,-15,%0111000111000111
	dc.w	11,28*160,8*160,-12,%0111010001011101
	dc.w	17,10*160,2*160,-7,%1111000011110000
	dc.w	11,28*160,8*160,-12,%0001011101000101
	dc.w	11,19*160,6*160,-11,%1110100010111010
	dc.w	17,10*160,2*160,-7,%1001011010010110
	dc.w	9,11*160,6*160,-14,%0001110001110001
	dc.w	9,11*160,6*160,-13,%1110001110001110
	dc.w	21,15*160,2*160,-5,%1101101101101101
	dc.w	21,15*160,2*160,-5,%1100001100001100
	dc.w	17,25*160,4*160,-7,%0000000000000000
	dc.w	9,11*160,6*160,-13,%0000000000000000
	dc.w	9,11*160,6*160,-12,%1100011100011100
	dc.w	21,15*160,2*160,-5,%0110000110000110
	dc.w	9,11*160,6*160,-12,%0101010101010101
	dc.w	9,18*160,8*160,-12,%0001110001110001
	dc.w	11,19*160,6*160,-9,%1011101000101110
	dc.w	21,15*160,2*160,-5,%0000000000000000
	dc.w	33,13*160,1*160,-3,%0001111100000111
	dc.w	11,28*160,8*160,-9,%0010111010001011
	dc.w	11,19*160,6*160,-9,%0000000000000000
	dc.w	11,28*160,8*160,-8,%1101000101110100
	dc.w	17,25*160,4*160,-5,%1001011010010110
	dc.w	33,13*160,1*160,-2,%1101000101110100
	dc.w	21,15*160,2*160,-4,%0101010101010101
	dc.w	33,13*160,1*160,-2,%1011001001101100
	dc.w	11,28*160,8*160,-7,%1110100010111010
	dc.w	33,13*160,1*160,-2,%1001001101100100
	dc.w	11,10*160,4*160,-7,%1000101110100010
	dc.w	9,11*160,6*160,-9,%0000000000000000
	dc.w	11,19*160,6*160,-7,%0010111010001011
	dc.w	17,10*160,2*160,-4,%1000011110000111
	dc.w	9,11*160,6*160,-8,%0101010101010101
	dc.w	17,25*160,4*160,-4,%0100101101001011
	dc.w	11,28*160,8*160,-6,%0111010001011101
	dc.w	17,25*160,4*160,-4,%0000111100001111
	dc.w	17,10*160,2*160,-3,%1111000011110000
	dc.w	21,15*160,2*160,-3,%0001100001100001
	dc.w	11,19*160,6*160,-5,%1011101000101110
	dc.w	9,11*160,6*160,-6,%1100011100011100
	dc.w	11,19*160,6*160,-5,%0101110100010111
	dc.w	33,13*160,1*160,-1,%1011101000101110
	dc.w	17,10*160,2*160,-3,%0011110000111100
	dc.w	33,13*160,1*160,-1,%1001101100100110
	dc.w	21,15*160,2*160,-2,%0110110110110110
	dc.w	21,15*160,2*160,-2,%0101010101010101
	dc.w	17,10*160,2*160,-2,%1100001111000011
	dc.w	11,19*160,6*160,-4,%0001011101000101
	dc.w	21,15*160,2*160,-2,%0000110000110000
	dc.w	17,10*160,2*160,-2,%0110100101101001
	dc.w	17,10*160,2*160,-2,%0100101101001011
	dc.w	33,13*160,1*160,-1,%0001111100000111
	dc.w	11,28*160,8*160,-3,%0010111010001011
	dc.w	33,13*160,1*160,-1,%0000000000000000
	dc.w	21,15*160,2*160,-1,%0111100111100111
	dc.w	11,10*160,4*160,-2,%1010001011101000
	dc.w	9,18*160,8*160,-3,%0000000000000000
	dc.w	11,28*160,8*160,-2,%0100010111010001
	dc.w	11,10*160,4*160,-2,%0001011101000101
	dc.w	17,25*160,4*160,-1,%0011110000111100
	dc.w	9,18*160,8*160,-2,%0001110001110001
	dc.w	17,25*160,4*160,-1,%0000000000000000
	dc.w	9,11*160,6*160,-1,%1010101010101010
	dc.w	9,11*160,6*160,-1,%0111000111000111
	dc.w	11,10*160,4*160,-1,%0000000000000000
	dc.w	9,18*160,8*160,-1,%0000000000000000
	dc.w	33,13*160,1*160,0,%0011011001001101
	dc.w	9,18*160,8*160,0,%1000111000111000
	dc.w	17,25*160,4*160,0,%0010110100101101
	dc.w	33,13*160,1*160,0,%0000011111000001
	dc.w	21,15*160,2*160,0,%0000110000110000
	dc.w	33,13*160,1*160,0,%0001011101000101
	dc.w	9,18*160,8*160,0,%1000111000111000
	dc.w	9,11*160,6*160,0,%1100011100011100
	dc.w	11,10*160,4*160,0,%1101000101110100
	dc.w	21,15*160,2*160,0,%1000011000011000
	dc.w	11,10*160,4*160,1,%0010111010001011
	dc.w	9,18*160,8*160,1,%1010101010101010
	dc.w	17,10*160,2*160,1,%0000000000000000
	dc.w	17,10*160,2*160,1,%0001111000011110
	dc.w	11,10*160,4*160,1,%1110100010111010
	dc.w	33,13*160,1*160,0,%1011001001101100
	dc.w	11,19*160,6*160,2,%0100010111010001
	dc.w	17,25*160,4*160,1,%1001011010010110
	dc.w	9,11*160,6*160,3,%0011100011100011
	dc.w	11,28*160,8*160,2,%1101000101110100
	dc.w	33,13*160,1*160,1,%0000000000000000
	dc.w	11,10*160,4*160,3,%0010111010001011
	dc.w	11,19*160,6*160,3,%0101110100010111
	dc.w	11,10*160,4*160,3,%1000101110100010
	dc.w	11,28*160,8*160,3,%1011101000101110
	dc.w	17,10*160,2*160,2,%1000011110000111
	dc.w	17,10*160,2*160,2,%1010010110100101
	dc.w	21,15*160,2*160,2,%0011110011110011
	dc.w	33,13*160,1*160,1,%0111110000011111
	dc.w	17,25*160,4*160,3,%0000000000000000
	dc.w	11,19*160,6*160,4,%1101000101110100
	dc.w	17,10*160,2*160,3,%0011110000111100
	dc.w	11,28*160,8*160,5,%0010111010001011
	dc.w	9,11*160,6*160,6,%1000111000111000
	dc.w	21,15*160,2*160,2,%1110011110011110
	dc.w	11,28*160,8*160,5,%1011101000101110
	dc.w	17,10*160,2*160,3,%1101001011010010
	dc.w	17,10*160,2*160,3,%1111000011110000
	dc.w	33,13*160,1*160,2,%0001011101000101
	dc.w	11,28*160,8*160,6,%0111010001011101
	dc.w	17,10*160,2*160,4,%0100101101001011
	dc.w	21,15*160,2*160,3,%1001001001001001
	dc.w	11,19*160,6*160,7,%0000000000000000
	dc.w	33,13*160,1*160,2,%0110010011011001
	dc.w	11,28*160,8*160,7,%0101110100010111
	dc.w	9,11*160,6*160,9,%0011100011100011
	dc.w	17,10*160,2*160,5,%0000000000000000
	dc.w	11,28*160,8*160,7,%1110100010111010
	dc.w	11,19*160,6*160,8,%0001011101000101
	dc.w	9,18*160,8*160,10,%0001110001110001
	dc.w	11,19*160,6*160,8,%0111010001011101
	dc.w	11,28*160,8*160,8,%1010001011101000
	dc.w	11,28*160,8*160,8,%1101000101110100
	dc.w	11,19*160,6*160,9,%0000000000000000
	dc.w	33,13*160,1*160,3,%0000111110000011
	dc.w	21,15*160,2*160,4,%1110011110011110
	dc.w	11,28*160,8*160,9,%1000101110100010
	dc.w	21,15*160,2*160,5,%0001100001100001
	dc.w	11,19*160,6*160,9,%1110100010111010
	dc.w	9,18*160,8*160,12,%0101010101010101
	dc.w	21,15*160,2*160,5,%0110000110000110
	dc.w	11,28*160,8*160,10,%0111010001011101
	dc.w	21,15*160,2*160,5,%1001001001001001
	dc.w	33,13*160,1*160,3,%1001101100100110
	dc.w	9,11*160,6*160,13,%0111000111000111
	dc.w	9,18*160,8*160,13,%1010101010101010
	dc.w	9,18*160,8*160,13,%1110001110001110
	dc.w	17,25*160,4*160,7,%0111100001111000
	dc.w	17,25*160,4*160,7,%1001011010010110
	dc.w	9,11*160,6*160,14,%1000111000111000
	dc.w	21,15*160,2*160,6,%0101010101010101
	dc.w	9,18*160,8*160,15,%0000000000000000
	dc.w	17,10*160,2*160,8,%0000111100001111
	dc.w	11,28*160,8*160,12,%1010001011101000
	dc.w	33,13*160,1*160,4,%0100010111010001
	dc.w	17,25*160,4*160,8,%0110100101101001
	dc.w	11,19*160,6*160,13,%0010111010001011
	dc.w	9,18*160,8*160,16,%0101010101010101
	dc.w	11,10*160,4*160,13,%1000101110100010
	dc.w	17,25*160,4*160,8,%1110000111100001
	dc.w	9,18*160,8*160,17,%0000000000000000
	dc.w	9,11*160,6*160,17,%0011100011100011
	dc.w	11,10*160,4*160,14,%0100010111010001
	dc.w	11,10*160,4*160,14,%0111010001011101
