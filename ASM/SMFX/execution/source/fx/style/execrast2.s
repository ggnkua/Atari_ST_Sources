	dc.w	1,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,0
	dc.w	1,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,0
	dc.w	0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,0
	dc.w	1,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,0
	dc.w	1,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,0
	dc.w	1,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,0
	dc.w	1,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,0
	dc.w	1,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,0
	dc.w	1,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,0
	dc.w	1,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,0
	dc.w	1,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,0
	dc.w	1,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,0
	dc.w	1,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,0
	dc.w	1,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,0
	dc.w	1,0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,0
	dc.w	1,0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,0
	dc.w	1,0,2,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,0
	dc.w	1,0,87,89,92,15,94,90,86,$0,$0,$0,$0,$0,$0,0
	dc.w	1,0,2,87,89,92,15,94,90,86,$0,$0,$0,$0,$0,0
	dc.w	1,0,86,11,94,15,93,82,2,$0,$0,$0,$0,$0,$0,0
	dc.w	1,0,2,86,11,94,15,93,82,$0,$0,$0,$0,$0,$0,0
	dc.w	1,0,64,35,15,84,67,82,83,60,2,$0,$0,$0,$0,0
	dc.w	1,0,2,64,35,15,84,67,82,83,60,$0,$0,$0,$0,0
	dc.w	1,0,7,102,103,45,15,90,101,2,$0,$0,$0,$0,$0,0
	dc.w	1,0,7,102,103,45,15,90,2,101,$0,$0,$0,$0,$0,0
	dc.w	1,0,6,15,8,9,10,2,$0,$0,$0,$0,$0,$0,$0,0
	dc.w	1,0,2,6,15,8,9,10,$0,$0,$0,$0,$0,$0,$0,0
	dc.w	1,0,10,9,8,7,6,5,14,11,12,2,$0,$0,$0,0
	dc.w	1,0,2,10,9,8,7,6,5,14,11,12,$0,$0,$0,0
	dc.w	1,0,6,11,15,14,8,2,4,7,9,$0,$0,$0,$0,0
	dc.w	1,0,6,11,15,14,8,4,7,9,$0,$0,$0,$0,$0,0
	dc.w	1,0,5,14,13,10,6,11,12,9,$0,$0,$0,$0,$0,0
	dc.w	1,0,2,5,14,13,10,6,11,12,9,$0,$0,$0,$0,0
	dc.w	1,0,13,14,9,10,12,11,7,8,15,2,$0,$0,$0,0
	dc.w	1,0,13,14,9,10,12,11,7,2,8,15,$0,$0,$0,0
	dc.w	1,0,2,6,14,10,12,9,15,11,13,7,8,$0,$0,0
	dc.w	1,0,2,6,14,10,12,9,15,11,13,7,8,$0,$0,0
	dc.w	1,0,16,22,21,20,18,17,2,15,14,23,19,24,$0,0
	dc.w	1,0,16,22,21,20,18,17,2,15,14,23,19,24,$0,0
	dc.w	1,0,2,12,14,15,13,8,7,4,3,5,6,9,11,10
	dc.w	1,0,12,14,15,13,8,2,7,4,3,5,6,9,11,10
	dc.w	1,0,32,15,36,33,34,35,30,31,27,29,25,28,2,26
	dc.w	1,0,32,15,36,33,34,35,2,30,31,27,29,25,28,26
	dc.w	1,0,13,15,11,6,8,10,9,12,7,14,2,4,5,0
	dc.w	1,0,13,15,11,6,8,10,9,12,7,2,14,4,5,0
	dc.w	1,0,46,15,44,43,31,41,2,37,39,40,18,42,45,38
	dc.w	1,0,46,15,44,43,31,41,37,39,40,18,42,45,2,38
	dc.w	1,0,52,13,50,19,49,25,15,48,32,39,51,2,47,0
	dc.w	1,0,2,52,13,50,19,49,25,15,48,32,39,51,47,0
	dc.w	1,0,4,14,9,8,7,6,2,15,11,12,5,13,10,0
	dc.w	1,0,4,14,9,8,7,6,2,15,11,12,5,13,10,0
	dc.w	1,0,59,15,58,57,53,37,55,60,61,56,21,54,2,0
	dc.w	1,0,59,15,58,57,53,37,55,60,2,61,56,21,54,0
	dc.w	1,0,49,15,44,67,64,16,63,2,59,66,62,68,65,25
	dc.w	1,0,49,15,44,67,64,16,63,59,66,62,68,65,2,25
	dc.w	1,0,2,12,15,13,9,11,6,8,10,14,7,4,5,0
	dc.w	1,0,12,15,13,9,11,2,6,8,10,14,7,4,5,0
	dc.w	1,0,2,68,15,74,73,28,72,33,8,70,71,5,69,75
	dc.w	1,0,68,15,74,73,28,2,72,33,8,70,71,5,69,75
	dc.w	1,0,2,79,80,40,72,24,15,31,77,81,61,78,76,0
	dc.w	1,0,79,80,40,72,24,15,31,77,2,81,61,78,76,0
	dc.w	1,0,2,4,7,5,6,9,8,10,12,14,15,13,11,3
	dc.w	1,0,4,7,5,6,9,8,10,12,14,15,13,11,3,2
	dc.w	1,0,2,85,88,11,91,89,90,94,82,92,93,86,15,87
	dc.w	1,0,85,88,11,91,89,90,94,82,92,93,86,15,2,87
	dc.w	1,0,2,12,10,11,13,9,8,5,6,4,7,15,14,0
	dc.w	1,0,12,10,11,13,9,8,5,6,4,7,15,14,2,0
	dc.w	1,0,2,5,8,7,9,10,12,11,3,6,13,15,14,4
	dc.w	1,0,5,8,7,9,10,12,11,2,3,6,13,15,14,4
	dc.w	1,0,2,3,4,6,11,14,9,7,12,13,10,15,8,5
	dc.w	1,0,3,4,6,11,14,9,7,12,13,2,10,15,8,5
	dc.w	1,0,2,8,10,11,13,12,15,14,6,9,5,7,$0,0
	dc.w	1,0,8,10,11,13,2,12,15,14,6,9,5,7,$0,0
	dc.w	1,0,2,7,9,10,11,15,13,8,12,5,6,14,4,0
	dc.w	1,0,7,9,10,11,15,13,8,12,2,5,6,14,4,0
	dc.w	1,0,2,7,8,10,12,14,9,3,4,11,15,5,6,0
	dc.w	1,0,7,8,10,12,14,9,3,4,11,2,15,5,6,0
	dc.w	1,0,2,56,90,60,4,7,101,15,104,103,$0,$0,$0,0
	dc.w	1,0,56,90,60,4,7,101,15,104,103,$0,$0,$0,$0,0
	dc.w	1,0,2,7,102,103,60,90,15,101,104,$0,$0,$0,$0,0
	dc.w	1,0,7,102,103,60,90,15,101,104,$0,$0,$0,$0,$0,0
	dc.w	1,0,2,7,101,4,56,102,60,45,$0,$0,$0,$0,$0,0
	dc.w	1,0,7,101,4,56,102,2,60,45,$0,$0,$0,$0,$0,0
	dc.w	1,0,2,76,15,73,9,98,97,$0,$0,$0,$0,$0,$0,0
	dc.w	1,0,76,15,73,9,98,97,2,$0,$0,$0,$0,$0,$0,0
	dc.w	1,0,95,46,100,73,99,79,$0,$0,$0,$0,$0,$0,$0,0
	dc.w	1,0,95,46,100,73,99,79,2,$0,$0,$0,$0,$0,$0,0
	dc.w	1,0,2,76,79,96,99,73,$0,$0,$0,$0,$0,$0,$0,0
	dc.w	1,0,76,79,96,99,73,$0,$0,$0,$0,$0,$0,$0,$0,0
	dc.w	1,0,2,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,0
	dc.w	1,0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,0
	dc.w	1,0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,0
	dc.w	1,0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,0
	dc.w	1,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,0
	dc.w	1,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,0
	dc.w	1,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,0
	dc.w	0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,0
	dc.w	1,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,0
	dc.w	1,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,$0,0

