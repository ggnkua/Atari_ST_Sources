	dc.w	-235
	dc.w	-235
	dc.w	-235
	dc.w	-235
	dc.w	-235
	dc.w	-234
	dc.w	-234
	dc.w	-233
	dc.w	-232
	dc.w	-232
	dc.w	-230
	dc.w	-229
	dc.w	-228
	dc.w	-226
	dc.w	-225
	dc.w	-223
	dc.w	-221
	dc.w	-219
	dc.w	-217
	dc.w	-215
	dc.w	-212
	dc.w	-210
	dc.w	-207
	dc.w	-204
	dc.w	-202
	dc.w	-199
	dc.w	-195
	dc.w	-192
	dc.w	-189
	dc.w	-185
	dc.w	-182
	dc.w	-178
	dc.w	-174
	dc.w	-170
	dc.w	-166
	dc.w	-162
	dc.w	-158
	dc.w	-153
	dc.w	-149
	dc.w	-145
	dc.w	-140
	dc.w	-135
	dc.w	-131
	dc.w	-126
	dc.w	-121
	dc.w	-116
	dc.w	-111
	dc.w	-106
	dc.w	-100
	dc.w	-95
	dc.w	-90
	dc.w	-85
	dc.w	-79
	dc.w	-74
	dc.w	-68
	dc.w	-63
	dc.w	-57
	dc.w	-51
	dc.w	-46
	dc.w	-40
	dc.w	-34
	dc.w	-29
	dc.w	-23
	dc.w	-17
	dc.w	-12
	dc.w	-6
	dc.w	0
	dc.w	6
	dc.w	12
	dc.w	17
	dc.w	23
	dc.w	29
	dc.w	34
	dc.w	40
	dc.w	46
	dc.w	51
	dc.w	57
	dc.w	63
	dc.w	68
	dc.w	74
	dc.w	79
	dc.w	85
	dc.w	90
	dc.w	95
	dc.w	100
	dc.w	106
	dc.w	111
	dc.w	116
	dc.w	121
	dc.w	126
	dc.w	131
	dc.w	135
	dc.w	140
	dc.w	145
	dc.w	149
	dc.w	153
	dc.w	158
	dc.w	162
	dc.w	166
	dc.w	170
	dc.w	174
	dc.w	178
	dc.w	182
	dc.w	185
	dc.w	189
	dc.w	192
	dc.w	195
	dc.w	199
	dc.w	202
	dc.w	204
	dc.w	207
	dc.w	210
	dc.w	212
	dc.w	215
	dc.w	217
	dc.w	219
	dc.w	221
	dc.w	223
	dc.w	225
	dc.w	226
	dc.w	228
	dc.w	229
	dc.w	230
	dc.w	232
	dc.w	232
	dc.w	233
	dc.w	234
	dc.w	234
	dc.w	235
	dc.w	235
	dc.w	235
	dc.w	235
	dc.w	235
	dc.w	234
	dc.w	234
	dc.w	233
	dc.w	232
	dc.w	232
	dc.w	230
	dc.w	229
	dc.w	228
	dc.w	226
	dc.w	225
	dc.w	223
	dc.w	221
	dc.w	219
	dc.w	217
	dc.w	215
	dc.w	212
	dc.w	210
	dc.w	207
	dc.w	204
	dc.w	202
	dc.w	199
	dc.w	195
	dc.w	192
	dc.w	189
	dc.w	185
	dc.w	182
	dc.w	178
	dc.w	174
	dc.w	170
	dc.w	166
	dc.w	162
	dc.w	158
	dc.w	153
	dc.w	149
	dc.w	145
	dc.w	140
	dc.w	135
	dc.w	131
	dc.w	126
	dc.w	121
	dc.w	116
	dc.w	111
	dc.w	106
	dc.w	100
	dc.w	95
	dc.w	90
	dc.w	85
	dc.w	79
	dc.w	74
	dc.w	68
	dc.w	63
	dc.w	57
	dc.w	51
	dc.w	46
	dc.w	40
	dc.w	34
	dc.w	29
	dc.w	23
	dc.w	17
	dc.w	12
	dc.w	6
	dc.w	0
	dc.w	-6
	dc.w	-12
	dc.w	-17
	dc.w	-23
	dc.w	-29
	dc.w	-34
	dc.w	-40
	dc.w	-46
	dc.w	-51
	dc.w	-57
	dc.w	-63
	dc.w	-68
	dc.w	-74
	dc.w	-79
	dc.w	-85
	dc.w	-90
	dc.w	-95
	dc.w	-100
	dc.w	-106
	dc.w	-111
	dc.w	-116
	dc.w	-121
	dc.w	-126
	dc.w	-131
	dc.w	-135
	dc.w	-140
	dc.w	-145
	dc.w	-149
	dc.w	-153
	dc.w	-158
	dc.w	-162
	dc.w	-166
	dc.w	-170
	dc.w	-174
	dc.w	-178
	dc.w	-182
	dc.w	-185
	dc.w	-189
	dc.w	-192
	dc.w	-195
	dc.w	-199
	dc.w	-202
	dc.w	-204
	dc.w	-207
	dc.w	-210
	dc.w	-212
	dc.w	-215
	dc.w	-217
	dc.w	-219
	dc.w	-221
	dc.w	-223
	dc.w	-225
	dc.w	-226
	dc.w	-228
	dc.w	-229
	dc.w	-230
	dc.w	-232
	dc.w	-232
	dc.w	-233
	dc.w	-234
	dc.w	-234
