	dc.w	64
	dc.w	64
	dc.w	66
	dc.w	66
	dc.w	68
	dc.w	68
	dc.w	68
	dc.w	70
	dc.w	70
	dc.w	72
	dc.w	72
	dc.w	72
	dc.w	74
	dc.w	74
	dc.w	74
	dc.w	76
	dc.w	76
	dc.w	78
	dc.w	78
	dc.w	78
	dc.w	80
	dc.w	80
	dc.w	82
	dc.w	82
	dc.w	82
	dc.w	84
	dc.w	84
	dc.w	86
	dc.w	86
	dc.w	86
	dc.w	88
	dc.w	88
	dc.w	88
	dc.w	90
	dc.w	90
	dc.w	92
	dc.w	92
	dc.w	92
	dc.w	94
	dc.w	94
	dc.w	96
	dc.w	96
	dc.w	96
	dc.w	98
	dc.w	98
	dc.w	98
	dc.w	100
	dc.w	100
	dc.w	102
	dc.w	102
	dc.w	102
	dc.w	104
	dc.w	104
	dc.w	104
	dc.w	106
	dc.w	106
	dc.w	108
	dc.w	108
	dc.w	108
	dc.w	110
	dc.w	110
	dc.w	110
	dc.w	112
	dc.w	112
	dc.w	112
	dc.w	114
	dc.w	114
	dc.w	116
	dc.w	116
	dc.w	116
	dc.w	118
	dc.w	118
	dc.w	118
	dc.w	120
	dc.w	120
	dc.w	120
	dc.w	122
	dc.w	122
	dc.w	122
	dc.w	124
	dc.w	124
	dc.w	126
	dc.w	126
	dc.w	126
	dc.w	128
	dc.w	128
	dc.w	128
	dc.w	130
	dc.w	130
	dc.w	130
	dc.w	132
	dc.w	132
	dc.w	132
	dc.w	134
	dc.w	134
	dc.w	134
	dc.w	136
	dc.w	136
	dc.w	136
	dc.w	138
	dc.w	138
	dc.w	138
	dc.w	138
	dc.w	140
	dc.w	140
	dc.w	140
	dc.w	142
	dc.w	142
	dc.w	142
	dc.w	144
	dc.w	144
	dc.w	144
	dc.w	146
	dc.w	146
	dc.w	146
	dc.w	148
	dc.w	148
	dc.w	148
	dc.w	148
	dc.w	150
	dc.w	150
	dc.w	150
	dc.w	152
	dc.w	152
	dc.w	152
	dc.w	152
	dc.w	154
	dc.w	154
	dc.w	154
	dc.w	156
	dc.w	156
	dc.w	156
	dc.w	156
	dc.w	158
	dc.w	158
	dc.w	158
	dc.w	158
	dc.w	160
	dc.w	160
	dc.w	160
	dc.w	160
	dc.w	162
	dc.w	162
	dc.w	162
	dc.w	162
	dc.w	164
	dc.w	164
	dc.w	164
	dc.w	164
	dc.w	166
	dc.w	166
	dc.w	166
	dc.w	166
	dc.w	168
	dc.w	168
	dc.w	168
	dc.w	168
	dc.w	170
	dc.w	170
	dc.w	170
	dc.w	170
	dc.w	170
	dc.w	172
	dc.w	172
	dc.w	172
	dc.w	172
	dc.w	172
	dc.w	174
	dc.w	174
	dc.w	174
	dc.w	174
	dc.w	174
	dc.w	176
	dc.w	176
	dc.w	176
	dc.w	176
	dc.w	176
	dc.w	178
	dc.w	178
	dc.w	178
	dc.w	178
	dc.w	178
	dc.w	180
	dc.w	180
	dc.w	180
	dc.w	180
	dc.w	180
	dc.w	180
	dc.w	182
	dc.w	182
	dc.w	182
	dc.w	182
	dc.w	182
	dc.w	182
	dc.w	182
	dc.w	184
	dc.w	184
	dc.w	184
	dc.w	184
	dc.w	184
	dc.w	184
	dc.w	184
	dc.w	186
	dc.w	186
	dc.w	186
	dc.w	186
	dc.w	186
	dc.w	186
	dc.w	186
	dc.w	186
	dc.w	186
	dc.w	188
	dc.w	188
	dc.w	188
	dc.w	188
	dc.w	188
	dc.w	188
	dc.w	188
	dc.w	188
	dc.w	188
	dc.w	188
	dc.w	190
	dc.w	190
	dc.w	190
	dc.w	190
	dc.w	190
	dc.w	190
	dc.w	190
	dc.w	190
	dc.w	190
	dc.w	190
	dc.w	190
	dc.w	190
	dc.w	190
	dc.w	190
	dc.w	190
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	190
	dc.w	190
	dc.w	190
	dc.w	190
	dc.w	190
	dc.w	190
	dc.w	190
	dc.w	190
	dc.w	190
	dc.w	190
	dc.w	190
	dc.w	190
	dc.w	190
	dc.w	190
	dc.w	190
	dc.w	188
	dc.w	188
	dc.w	188
	dc.w	188
	dc.w	188
	dc.w	188
	dc.w	188
	dc.w	188
	dc.w	188
	dc.w	188
	dc.w	186
	dc.w	186
	dc.w	186
	dc.w	186
	dc.w	186
	dc.w	186
	dc.w	186
	dc.w	186
	dc.w	186
	dc.w	184
	dc.w	184
	dc.w	184
	dc.w	184
	dc.w	184
	dc.w	184
	dc.w	184
	dc.w	182
	dc.w	182
	dc.w	182
	dc.w	182
	dc.w	182
	dc.w	182
	dc.w	182
	dc.w	180
	dc.w	180
	dc.w	180
	dc.w	180
	dc.w	180
	dc.w	180
	dc.w	178
	dc.w	178
	dc.w	178
	dc.w	178
	dc.w	178
	dc.w	176
	dc.w	176
	dc.w	176
	dc.w	176
	dc.w	176
	dc.w	174
	dc.w	174
	dc.w	174
	dc.w	174
	dc.w	174
	dc.w	172
	dc.w	172
	dc.w	172
	dc.w	172
	dc.w	172
	dc.w	170
	dc.w	170
	dc.w	170
	dc.w	170
	dc.w	170
	dc.w	168
	dc.w	168
	dc.w	168
	dc.w	168
	dc.w	166
	dc.w	166
	dc.w	166
	dc.w	166
	dc.w	164
	dc.w	164
	dc.w	164
	dc.w	164
	dc.w	162
	dc.w	162
	dc.w	162
	dc.w	162
	dc.w	160
	dc.w	160
	dc.w	160
	dc.w	160
	dc.w	158
	dc.w	158
	dc.w	158
	dc.w	158
	dc.w	156
	dc.w	156
	dc.w	156
	dc.w	156
	dc.w	154
	dc.w	154
	dc.w	154
	dc.w	152
	dc.w	152
	dc.w	152
	dc.w	152
	dc.w	150
	dc.w	150
	dc.w	150
	dc.w	148
	dc.w	148
	dc.w	148
	dc.w	148
	dc.w	146
	dc.w	146
	dc.w	146
	dc.w	144
	dc.w	144
	dc.w	144
	dc.w	142
	dc.w	142
	dc.w	142
	dc.w	140
	dc.w	140
	dc.w	140
	dc.w	138
	dc.w	138
	dc.w	138
	dc.w	138
	dc.w	136
	dc.w	136
	dc.w	136
	dc.w	134
	dc.w	134
	dc.w	134
	dc.w	132
	dc.w	132
	dc.w	132
	dc.w	130
	dc.w	130
	dc.w	130
	dc.w	128
	dc.w	128
	dc.w	128
	dc.w	126
	dc.w	126
	dc.w	126
	dc.w	124
	dc.w	124
	dc.w	122
	dc.w	122
	dc.w	122
	dc.w	120
	dc.w	120
	dc.w	120
	dc.w	118
	dc.w	118
	dc.w	118
	dc.w	116
	dc.w	116
	dc.w	116
	dc.w	114
	dc.w	114
	dc.w	112
	dc.w	112
	dc.w	112
	dc.w	110
	dc.w	110
	dc.w	110
	dc.w	108
	dc.w	108
	dc.w	108
	dc.w	106
	dc.w	106
	dc.w	104
	dc.w	104
	dc.w	104
	dc.w	102
	dc.w	102
	dc.w	102
	dc.w	100
	dc.w	100
	dc.w	98
	dc.w	98
	dc.w	98
	dc.w	96
	dc.w	96
	dc.w	96
	dc.w	94
	dc.w	94
	dc.w	92
	dc.w	92
	dc.w	92
	dc.w	90
	dc.w	90
	dc.w	88
	dc.w	88
	dc.w	88
	dc.w	86
	dc.w	86
	dc.w	86
	dc.w	84
	dc.w	84
	dc.w	82
	dc.w	82
	dc.w	82
	dc.w	80
	dc.w	80
	dc.w	78
	dc.w	78
	dc.w	78
	dc.w	76
	dc.w	76
	dc.w	74
	dc.w	74
	dc.w	74
	dc.w	72
	dc.w	72
	dc.w	72
	dc.w	70
	dc.w	70
	dc.w	68
	dc.w	68
	dc.w	68
	dc.w	66
	dc.w	66
	dc.w	64
	dc.w	64
	dc.w	64
	dc.w	62
	dc.w	62
	dc.w	60
	dc.w	60
	dc.w	60
	dc.w	58
	dc.w	58
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	54
	dc.w	54
	dc.w	54
	dc.w	52
	dc.w	52
	dc.w	50
	dc.w	50
	dc.w	50
	dc.w	48
	dc.w	48
	dc.w	46
	dc.w	46
	dc.w	46
	dc.w	44
	dc.w	44
	dc.w	42
	dc.w	42
	dc.w	42
	dc.w	40
	dc.w	40
	dc.w	40
	dc.w	38
	dc.w	38
	dc.w	36
	dc.w	36
	dc.w	36
	dc.w	34
	dc.w	34
	dc.w	32
	dc.w	32
	dc.w	32
	dc.w	30
	dc.w	30
	dc.w	30
	dc.w	28
	dc.w	28
	dc.w	26
	dc.w	26
	dc.w	26
	dc.w	24
	dc.w	24
	dc.w	24
	dc.w	22
	dc.w	22
	dc.w	20
	dc.w	20
	dc.w	20
	dc.w	18
	dc.w	18
	dc.w	18
	dc.w	16
	dc.w	16
	dc.w	16
	dc.w	14
	dc.w	14
	dc.w	12
	dc.w	12
	dc.w	12
	dc.w	10
	dc.w	10
	dc.w	10
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	6
	dc.w	6
	dc.w	6
	dc.w	4
	dc.w	4
	dc.w	2
	dc.w	2
	dc.w	2
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	-2
	dc.w	-2
	dc.w	-2
	dc.w	-4
	dc.w	-4
	dc.w	-4
	dc.w	-6
	dc.w	-6
	dc.w	-6
	dc.w	-8
	dc.w	-8
	dc.w	-8
	dc.w	-10
	dc.w	-10
	dc.w	-10
	dc.w	-10
	dc.w	-12
	dc.w	-12
	dc.w	-12
	dc.w	-14
	dc.w	-14
	dc.w	-14
	dc.w	-16
	dc.w	-16
	dc.w	-16
	dc.w	-18
	dc.w	-18
	dc.w	-18
	dc.w	-20
	dc.w	-20
	dc.w	-20
	dc.w	-20
	dc.w	-22
	dc.w	-22
	dc.w	-22
	dc.w	-24
	dc.w	-24
	dc.w	-24
	dc.w	-24
	dc.w	-26
	dc.w	-26
	dc.w	-26
	dc.w	-28
	dc.w	-28
	dc.w	-28
	dc.w	-28
	dc.w	-30
	dc.w	-30
	dc.w	-30
	dc.w	-30
	dc.w	-32
	dc.w	-32
	dc.w	-32
	dc.w	-32
	dc.w	-34
	dc.w	-34
	dc.w	-34
	dc.w	-34
	dc.w	-36
	dc.w	-36
	dc.w	-36
	dc.w	-36
	dc.w	-38
	dc.w	-38
	dc.w	-38
	dc.w	-38
	dc.w	-40
	dc.w	-40
	dc.w	-40
	dc.w	-40
	dc.w	-42
	dc.w	-42
	dc.w	-42
	dc.w	-42
	dc.w	-42
	dc.w	-44
	dc.w	-44
	dc.w	-44
	dc.w	-44
	dc.w	-44
	dc.w	-46
	dc.w	-46
	dc.w	-46
	dc.w	-46
	dc.w	-46
	dc.w	-48
	dc.w	-48
	dc.w	-48
	dc.w	-48
	dc.w	-48
	dc.w	-50
	dc.w	-50
	dc.w	-50
	dc.w	-50
	dc.w	-50
	dc.w	-52
	dc.w	-52
	dc.w	-52
	dc.w	-52
	dc.w	-52
	dc.w	-52
	dc.w	-54
	dc.w	-54
	dc.w	-54
	dc.w	-54
	dc.w	-54
	dc.w	-54
	dc.w	-54
	dc.w	-56
	dc.w	-56
	dc.w	-56
	dc.w	-56
	dc.w	-56
	dc.w	-56
	dc.w	-56
	dc.w	-58
	dc.w	-58
	dc.w	-58
	dc.w	-58
	dc.w	-58
	dc.w	-58
	dc.w	-58
	dc.w	-58
	dc.w	-58
	dc.w	-60
	dc.w	-60
	dc.w	-60
	dc.w	-60
	dc.w	-60
	dc.w	-60
	dc.w	-60
	dc.w	-60
	dc.w	-60
	dc.w	-60
	dc.w	-62
	dc.w	-62
	dc.w	-62
	dc.w	-62
	dc.w	-62
	dc.w	-62
	dc.w	-62
	dc.w	-62
	dc.w	-62
	dc.w	-62
	dc.w	-62
	dc.w	-62
	dc.w	-62
	dc.w	-62
	dc.w	-62
	dc.w	-64
	dc.w	-64
	dc.w	-64
	dc.w	-64
	dc.w	-64
	dc.w	-64
	dc.w	-64
	dc.w	-64
	dc.w	-64
	dc.w	-64
	dc.w	-64
	dc.w	-64
	dc.w	-64
	dc.w	-64
	dc.w	-64
	dc.w	-64
	dc.w	-64
	dc.w	-64
	dc.w	-64
	dc.w	-64
	dc.w	-64
	dc.w	-64
	dc.w	-64
	dc.w	-64
	dc.w	-64
	dc.w	-64
	dc.w	-64
	dc.w	-64
	dc.w	-64
	dc.w	-64
	dc.w	-64
	dc.w	-64
	dc.w	-64
	dc.w	-64
	dc.w	-64
	dc.w	-64
	dc.w	-64
	dc.w	-64
	dc.w	-64
	dc.w	-64
	dc.w	-64
	dc.w	-62
	dc.w	-62
	dc.w	-62
	dc.w	-62
	dc.w	-62
	dc.w	-62
	dc.w	-62
	dc.w	-62
	dc.w	-62
	dc.w	-62
	dc.w	-62
	dc.w	-62
	dc.w	-62
	dc.w	-62
	dc.w	-62
	dc.w	-60
	dc.w	-60
	dc.w	-60
	dc.w	-60
	dc.w	-60
	dc.w	-60
	dc.w	-60
	dc.w	-60
	dc.w	-60
	dc.w	-60
	dc.w	-58
	dc.w	-58
	dc.w	-58
	dc.w	-58
	dc.w	-58
	dc.w	-58
	dc.w	-58
	dc.w	-58
	dc.w	-58
	dc.w	-56
	dc.w	-56
	dc.w	-56
	dc.w	-56
	dc.w	-56
	dc.w	-56
	dc.w	-56
	dc.w	-54
	dc.w	-54
	dc.w	-54
	dc.w	-54
	dc.w	-54
	dc.w	-54
	dc.w	-54
	dc.w	-52
	dc.w	-52
	dc.w	-52
	dc.w	-52
	dc.w	-52
	dc.w	-52
	dc.w	-50
	dc.w	-50
	dc.w	-50
	dc.w	-50
	dc.w	-50
	dc.w	-48
	dc.w	-48
	dc.w	-48
	dc.w	-48
	dc.w	-48
	dc.w	-46
	dc.w	-46
	dc.w	-46
	dc.w	-46
	dc.w	-46
	dc.w	-44
	dc.w	-44
	dc.w	-44
	dc.w	-44
	dc.w	-44
	dc.w	-42
	dc.w	-42
	dc.w	-42
	dc.w	-42
	dc.w	-42
	dc.w	-40
	dc.w	-40
	dc.w	-40
	dc.w	-40
	dc.w	-38
	dc.w	-38
	dc.w	-38
	dc.w	-38
	dc.w	-36
	dc.w	-36
	dc.w	-36
	dc.w	-36
	dc.w	-34
	dc.w	-34
	dc.w	-34
	dc.w	-34
	dc.w	-32
	dc.w	-32
	dc.w	-32
	dc.w	-32
	dc.w	-30
	dc.w	-30
	dc.w	-30
	dc.w	-30
	dc.w	-28
	dc.w	-28
	dc.w	-28
	dc.w	-28
	dc.w	-26
	dc.w	-26
	dc.w	-26
	dc.w	-24
	dc.w	-24
	dc.w	-24
	dc.w	-24
	dc.w	-22
	dc.w	-22
	dc.w	-22
	dc.w	-20
	dc.w	-20
	dc.w	-20
	dc.w	-20
	dc.w	-18
	dc.w	-18
	dc.w	-18
	dc.w	-16
	dc.w	-16
	dc.w	-16
	dc.w	-14
	dc.w	-14
	dc.w	-14
	dc.w	-12
	dc.w	-12
	dc.w	-12
	dc.w	-10
	dc.w	-10
	dc.w	-10
	dc.w	-10
	dc.w	-8
	dc.w	-8
	dc.w	-8
	dc.w	-6
	dc.w	-6
	dc.w	-6
	dc.w	-4
	dc.w	-4
	dc.w	-4
	dc.w	-2
	dc.w	-2
	dc.w	-2
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	2
	dc.w	2
	dc.w	2
	dc.w	4
	dc.w	4
	dc.w	6
	dc.w	6
	dc.w	6
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	10
	dc.w	10
	dc.w	10
	dc.w	12
	dc.w	12
	dc.w	12
	dc.w	14
	dc.w	14
	dc.w	16
	dc.w	16
	dc.w	16
	dc.w	18
	dc.w	18
	dc.w	18
	dc.w	20
	dc.w	20
	dc.w	20
	dc.w	22
	dc.w	22
	dc.w	24
	dc.w	24
	dc.w	24
	dc.w	26
	dc.w	26
	dc.w	26
	dc.w	28
	dc.w	28
	dc.w	30
	dc.w	30
	dc.w	30
	dc.w	32
	dc.w	32
	dc.w	32
	dc.w	34
	dc.w	34
	dc.w	36
	dc.w	36
	dc.w	36
	dc.w	38
	dc.w	38
	dc.w	40
	dc.w	40
	dc.w	40
	dc.w	42
	dc.w	42
	dc.w	42
	dc.w	44
	dc.w	44
	dc.w	46
	dc.w	46
	dc.w	46
	dc.w	48
	dc.w	48
	dc.w	50
	dc.w	50
	dc.w	50
	dc.w	52
	dc.w	52
	dc.w	54
	dc.w	54
	dc.w	54
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	58
	dc.w	58
	dc.w	60
	dc.w	60
	dc.w	60
	dc.w	62
	dc.w	62
	dc.w	64
