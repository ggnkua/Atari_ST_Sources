	 dc.w 0	;	0
	 dc.w 4	;	1
	 dc.w 12	;	2
	 dc.w 16	;	3
	 dc.w 24	;	4
	 dc.w 28	;	5
	 dc.w 36	;	6
	 dc.w 40	;	7
	 dc.w 48	;	8
	 dc.w 52	;	9
	 dc.w 60	;	10
	 dc.w 64	;	11
	 dc.w 72	;	12
	 dc.w 76	;	13
	 dc.w 84	;	14
	 dc.w 88	;	15
	 dc.w 92	;	16
	 dc.w 100	;	17
	 dc.w 104	;	18
	 dc.w 108	;	19
	 dc.w 116	;	20
	 dc.w 120	;	21
	 dc.w 124	;	22
	 dc.w 132	;	23
	 dc.w 136	;	24
	 dc.w 140	;	25
	 dc.w 144	;	26
	 dc.w 152	;	27
	 dc.w 156	;	28
	 dc.w 160	;	29
	 dc.w 164	;	30
	 dc.w 168	;	31
	 dc.w 172	;	32
	 dc.w 176	;	33
	 dc.w 180	;	34
	 dc.w 184	;	35
	 dc.w 188	;	36
	 dc.w 192	;	37
	 dc.w 196	;	38
	 dc.w 200	;	39
	 dc.w 204	;	40
	 dc.w 208	;	41
	 dc.w 208	;	42
	 dc.w 212	;	43
	 dc.w 216	;	44
	 dc.w 216	;	45
	 dc.w 220	;	46
	 dc.w 224	;	47
	 dc.w 224	;	48
	 dc.w 228	;	49
	 dc.w 228	;	50
	 dc.w 232	;	51
	 dc.w 232	;	52
	 dc.w 236	;	53
	 dc.w 236	;	54
	 dc.w 240	;	55
	 dc.w 240	;	56
	 dc.w 240	;	57
	 dc.w 240	;	58
	 dc.w 244	;	59
	 dc.w 244	;	60
	 dc.w 244	;	61
	 dc.w 244	;	62
	 dc.w 244	;	63
	 dc.w 244	;	64
	 dc.w 244	;	65
	 dc.w 244	;	66
	 dc.w 244	;	67
	 dc.w 244	;	68
	 dc.w 244	;	69
	 dc.w 240	;	70
	 dc.w 240	;	71
	 dc.w 240	;	72
	 dc.w 240	;	73
	 dc.w 236	;	74
	 dc.w 236	;	75
	 dc.w 232	;	76
	 dc.w 232	;	77
	 dc.w 228	;	78
	 dc.w 228	;	79
	 dc.w 224	;	80
	 dc.w 224	;	81
	 dc.w 220	;	82
	 dc.w 216	;	83
	 dc.w 216	;	84
	 dc.w 212	;	85
	 dc.w 208	;	86
	 dc.w 208	;	87
	 dc.w 204	;	88
	 dc.w 200	;	89
	 dc.w 196	;	90
	 dc.w 192	;	91
	 dc.w 188	;	92
	 dc.w 184	;	93
	 dc.w 180	;	94
	 dc.w 176	;	95
	 dc.w 172	;	96
	 dc.w 168	;	97
	 dc.w 164	;	98
	 dc.w 160	;	99
	 dc.w 156	;	100
	 dc.w 152	;	101
	 dc.w 144	;	102
	 dc.w 140	;	103
	 dc.w 136	;	104
	 dc.w 132	;	105
	 dc.w 124	;	106
	 dc.w 120	;	107
	 dc.w 116	;	108
	 dc.w 108	;	109
	 dc.w 104	;	110
	 dc.w 100	;	111
	 dc.w 92	;	112
	 dc.w 88	;	113
	 dc.w 84	;	114
	 dc.w 76	;	115
	 dc.w 72	;	116
	 dc.w 64	;	117
	 dc.w 60	;	118
	 dc.w 52	;	119
	 dc.w 48	;	120
	 dc.w 40	;	121
	 dc.w 36	;	122
	 dc.w 28	;	123
	 dc.w 24	;	124
	 dc.w 16	;	125
	 dc.w 12	;	126
	 dc.w 4	;	127
	 dc.w 0	;	128						;64 steps
	 dc.w 4	;	129
	 dc.w 12	;	130
	 dc.w 16	;	131
	 dc.w 24	;	132
	 dc.w 28	;	133
	 dc.w 36	;	134
	 dc.w 40	;	135
	 dc.w 48	;	136
	 dc.w 52	;	137
	 dc.w 60	;	138
	 dc.w 64	;	139
	 dc.w 72	;	140
	 dc.w 76	;	141
	 dc.w 84	;	142
	 dc.w 88	;	143
	 dc.w 92	;	144
	 dc.w 100	;	145
	 dc.w 104	;	146
	 dc.w 108	;	147
	 dc.w 116	;	148
	 dc.w 120	;	149
	 dc.w 124	;	150
	 dc.w 132	;	151
	 dc.w 136	;	152
	 dc.w 140	;	153
	 dc.w 144	;	154
	 dc.w 152	;	155
	 dc.w 156	;	156
	 dc.w 160	;	157
	 dc.w 164	;	158
	 dc.w 168	;	159
	 dc.w 172	;	160
	 dc.w 176	;	161
	 dc.w 180	;	162
	 dc.w 184	;	163
	 dc.w 188	;	164
	 dc.w 192	;	165
	 dc.w 196	;	166
	 dc.w 200	;	167
	 dc.w 204	;	168
	 dc.w 208	;	169
	 dc.w 208	;	170
	 dc.w 212	;	171
	 dc.w 216	;	172
	 dc.w 216	;	173
	 dc.w 220	;	174
	 dc.w 224	;	175
	 dc.w 224	;	176
	 dc.w 228	;	177
	 dc.w 228	;	178
	 dc.w 232	;	179
	 dc.w 232	;	180
	 dc.w 236	;	181
	 dc.w 236	;	182
	 dc.w 240	;	183
	 dc.w 240	;	184
	 dc.w 240	;	185
	 dc.w 240	;	186
	 dc.w 244	;	187
	 dc.w 244	;	188
	 dc.w 244	;	189
	 dc.w 244	;	190
	 dc.w 244	;	191
	 dc.w 244	;	192
	 dc.w 244	;	193
	 dc.w 244	;	194
	 dc.w 244	;	195
	 dc.w 244	;	196
	 dc.w 244	;	197
	 dc.w 240	;	198
	 dc.w 240	;	199
	 dc.w 240	;	200
	 dc.w 240	;	201
	 dc.w 236	;	202
	 dc.w 236	;	203
	 dc.w 232	;	204
	 dc.w 232	;	205
	 dc.w 228	;	206
	 dc.w 228	;	207
	 dc.w 224	;	208
	 dc.w 224	;	209
	 dc.w 220	;	210
	 dc.w 216	;	211
	 dc.w 216	;	212
	 dc.w 212	;	213
	 dc.w 208	;	214
	 dc.w 208	;	215
	 dc.w 204	;	216
	 dc.w 200	;	217
	 dc.w 196	;	218
	 dc.w 192	;	219
	 dc.w 188	;	220
	 dc.w 184	;	221
	 dc.w 180	;	222
	 dc.w 176	;	223
	 dc.w 172	;	224
	 dc.w 168	;	225
	 dc.w 164	;	226
	 dc.w 160	;	227
	 dc.w 156	;	228
	 dc.w 152	;	229
	 dc.w 144	;	230
	 dc.w 140	;	231
	 dc.w 136	;	232
	 dc.w 132	;	233
	 dc.w 124	;	234
	 dc.w 120	;	235
	 dc.w 116	;	236
	 dc.w 108	;	237
	 dc.w 104	;	238
	 dc.w 100	;	239
	 dc.w 92	;	240
	 dc.w 88	;	241
	 dc.w 84	;	242
	 dc.w 76	;	243
	 dc.w 72	;	244
	 dc.w 64	;	245
	 dc.w 60	;	246
	 dc.w 52	;	247
	 dc.w 48	;	248
	 dc.w 40	;	249
	 dc.w 36	;	250
	 dc.w 28	;	251
	 dc.w 24	;	252
	 dc.w 16	;	253
	 dc.w 12	;	254
	 dc.w 4	;	255
