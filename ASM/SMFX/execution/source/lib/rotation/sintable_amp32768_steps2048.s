	dc.w	0
	dc.w	101
	dc.w	201
	dc.w	302
	dc.w	402
	dc.w	503
	dc.w	603
	dc.w	704
	dc.w	804
	dc.w	905
	dc.w	1005
	dc.w	1106
	dc.w	1206
	dc.w	1307
	dc.w	1407
	dc.w	1507
	dc.w	1608
	dc.w	1708
	dc.w	1809
	dc.w	1909
	dc.w	2009
	dc.w	2110
	dc.w	2210
	dc.w	2310
	dc.w	2410
	dc.w	2511
	dc.w	2611
	dc.w	2711
	dc.w	2811
	dc.w	2911
	dc.w	3012
	dc.w	3112
	dc.w	3212
	dc.w	3312
	dc.w	3412
	dc.w	3512
	dc.w	3612
	dc.w	3712
	dc.w	3811
	dc.w	3911
	dc.w	4011
	dc.w	4111
	dc.w	4210
	dc.w	4310
	dc.w	4410
	dc.w	4509
	dc.w	4609
	dc.w	4708
	dc.w	4808
	dc.w	4907
	dc.w	5007
	dc.w	5106
	dc.w	5205
	dc.w	5305
	dc.w	5404
	dc.w	5503
	dc.w	5602
	dc.w	5701
	dc.w	5800
	dc.w	5899
	dc.w	5998
	dc.w	6096
	dc.w	6195
	dc.w	6294
	dc.w	6393
	dc.w	6491
	dc.w	6590
	dc.w	6688
	dc.w	6786
	dc.w	6885
	dc.w	6983
	dc.w	7081
	dc.w	7179
	dc.w	7277
	dc.w	7375
	dc.w	7473
	dc.w	7571
	dc.w	7669
	dc.w	7767
	dc.w	7864
	dc.w	7962
	dc.w	8059
	dc.w	8157
	dc.w	8254
	dc.w	8351
	dc.w	8448
	dc.w	8545
	dc.w	8642
	dc.w	8739
	dc.w	8836
	dc.w	8933
	dc.w	9030
	dc.w	9126
	dc.w	9223
	dc.w	9319
	dc.w	9416
	dc.w	9512
	dc.w	9608
	dc.w	9704
	dc.w	9800
	dc.w	9896
	dc.w	9992
	dc.w	10087
	dc.w	10183
	dc.w	10278
	dc.w	10374
	dc.w	10469
	dc.w	10564
	dc.w	10659
	dc.w	10754
	dc.w	10849
	dc.w	10944
	dc.w	11039
	dc.w	11133
	dc.w	11228
	dc.w	11322
	dc.w	11417
	dc.w	11511
	dc.w	11605
	dc.w	11699
	dc.w	11793
	dc.w	11886
	dc.w	11980
	dc.w	12074
	dc.w	12167
	dc.w	12260
	dc.w	12353
	dc.w	12446
	dc.w	12539
	dc.w	12632
	dc.w	12725
	dc.w	12817
	dc.w	12910
	dc.w	13002
	dc.w	13094
	dc.w	13187
	dc.w	13279
	dc.w	13370
	dc.w	13462
	dc.w	13554
	dc.w	13645
	dc.w	13736
	dc.w	13828
	dc.w	13919
	dc.w	14010
	dc.w	14101
	dc.w	14191
	dc.w	14282
	dc.w	14372
	dc.w	14462
	dc.w	14553
	dc.w	14643
	dc.w	14732
	dc.w	14822
	dc.w	14912
	dc.w	15001
	dc.w	15090
	dc.w	15180
	dc.w	15269
	dc.w	15358
	dc.w	15446
	dc.w	15535
	dc.w	15623
	dc.w	15712
	dc.w	15800
	dc.w	15888
	dc.w	15976
	dc.w	16063
	dc.w	16151
	dc.w	16238
	dc.w	16325
	dc.w	16413
	dc.w	16499
	dc.w	16586
	dc.w	16673
	dc.w	16759
	dc.w	16846
	dc.w	16932
	dc.w	17018
	dc.w	17104
	dc.w	17189
	dc.w	17275
	dc.w	17360
	dc.w	17445
	dc.w	17530
	dc.w	17615
	dc.w	17700
	dc.w	17784
	dc.w	17869
	dc.w	17953
	dc.w	18037
	dc.w	18121
	dc.w	18204
	dc.w	18288
	dc.w	18371
	dc.w	18454
	dc.w	18537
	dc.w	18620
	dc.w	18703
	dc.w	18785
	dc.w	18868
	dc.w	18950
	dc.w	19032
	dc.w	19113
	dc.w	19195
	dc.w	19276
	dc.w	19357
	dc.w	19438
	dc.w	19519
	dc.w	19600
	dc.w	19680
	dc.w	19761
	dc.w	19841
	dc.w	19921
	dc.w	20000
	dc.w	20080
	dc.w	20159
	dc.w	20238
	dc.w	20317
	dc.w	20396
	dc.w	20475
	dc.w	20553
	dc.w	20631
	dc.w	20709
	dc.w	20787
	dc.w	20865
	dc.w	20942
	dc.w	21019
	dc.w	21096
	dc.w	21173
	dc.w	21250
	dc.w	21326
	dc.w	21403
	dc.w	21479
	dc.w	21554
	dc.w	21630
	dc.w	21705
	dc.w	21781
	dc.w	21856
	dc.w	21930
	dc.w	22005
	dc.w	22079
	dc.w	22154
	dc.w	22227
	dc.w	22301
	dc.w	22375
	dc.w	22448
	dc.w	22521
	dc.w	22594
	dc.w	22667
	dc.w	22739
	dc.w	22812
	dc.w	22884
	dc.w	22956
	dc.w	23027
	dc.w	23099
	dc.w	23170
	dc.w	23241
	dc.w	23311
	dc.w	23382
	dc.w	23452
	dc.w	23522
	dc.w	23592
	dc.w	23662
	dc.w	23731
	dc.w	23801
	dc.w	23870
	dc.w	23938
	dc.w	24007
	dc.w	24075
	dc.w	24143
	dc.w	24211
	dc.w	24279
	dc.w	24346
	dc.w	24413
	dc.w	24480
	dc.w	24547
	dc.w	24613
	dc.w	24680
	dc.w	24746
	dc.w	24811
	dc.w	24877
	dc.w	24942
	dc.w	25007
	dc.w	25072
	dc.w	25137
	dc.w	25201
	dc.w	25265
	dc.w	25329
	dc.w	25393
	dc.w	25456
	dc.w	25519
	dc.w	25582
	dc.w	25645
	dc.w	25708
	dc.w	25770
	dc.w	25832
	dc.w	25893
	dc.w	25955
	dc.w	26016
	dc.w	26077
	dc.w	26138
	dc.w	26198
	dc.w	26259
	dc.w	26319
	dc.w	26378
	dc.w	26438
	dc.w	26497
	dc.w	26556
	dc.w	26615
	dc.w	26674
	dc.w	26732
	dc.w	26790
	dc.w	26848
	dc.w	26905
	dc.w	26962
	dc.w	27019
	dc.w	27076
	dc.w	27133
	dc.w	27189
	dc.w	27245
	dc.w	27300
	dc.w	27356
	dc.w	27411
	dc.w	27466
	dc.w	27521
	dc.w	27575
	dc.w	27629
	dc.w	27683
	dc.w	27737
	dc.w	27790
	dc.w	27843
	dc.w	27896
	dc.w	27949
	dc.w	28001
	dc.w	28053
	dc.w	28105
	dc.w	28157
	dc.w	28208
	dc.w	28259
	dc.w	28310
	dc.w	28360
	dc.w	28411
	dc.w	28460
	dc.w	28510
	dc.w	28560
	dc.w	28609
	dc.w	28658
	dc.w	28706
	dc.w	28755
	dc.w	28803
	dc.w	28850
	dc.w	28898
	dc.w	28945
	dc.w	28992
	dc.w	29039
	dc.w	29085
	dc.w	29131
	dc.w	29177
	dc.w	29223
	dc.w	29268
	dc.w	29313
	dc.w	29358
	dc.w	29403
	dc.w	29447
	dc.w	29491
	dc.w	29534
	dc.w	29578
	dc.w	29621
	dc.w	29664
	dc.w	29706
	dc.w	29749
	dc.w	29791
	dc.w	29832
	dc.w	29874
	dc.w	29915
	dc.w	29956
	dc.w	29997
	dc.w	30037
	dc.w	30077
	dc.w	30117
	dc.w	30156
	dc.w	30195
	dc.w	30234
	dc.w	30273
	dc.w	30311
	dc.w	30349
	dc.w	30387
	dc.w	30424
	dc.w	30462
	dc.w	30498
	dc.w	30535
	dc.w	30571
	dc.w	30607
	dc.w	30643
	dc.w	30679
	dc.w	30714
	dc.w	30749
	dc.w	30783
	dc.w	30818
	dc.w	30852
	dc.w	30885
	dc.w	30919
	dc.w	30952
	dc.w	30985
	dc.w	31017
	dc.w	31050
	dc.w	31082
	dc.w	31113
	dc.w	31145
	dc.w	31176
	dc.w	31206
	dc.w	31237
	dc.w	31267
	dc.w	31297
	dc.w	31327
	dc.w	31356
	dc.w	31385
	dc.w	31414
	dc.w	31442
	dc.w	31470
	dc.w	31498
	dc.w	31526
	dc.w	31553
	dc.w	31580
	dc.w	31607
	dc.w	31633
	dc.w	31659
	dc.w	31685
	dc.w	31710
	dc.w	31736
	dc.w	31760
	dc.w	31785
	dc.w	31809
	dc.w	31833
	dc.w	31857
	dc.w	31880
	dc.w	31903
	dc.w	31926
	dc.w	31949
	dc.w	31971
	dc.w	31993
	dc.w	32014
	dc.w	32036
	dc.w	32057
	dc.w	32077
	dc.w	32098
	dc.w	32118
	dc.w	32137
	dc.w	32157
	dc.w	32176
	dc.w	32195
	dc.w	32213
	dc.w	32232
	dc.w	32250
	dc.w	32267
	dc.w	32285
	dc.w	32302
	dc.w	32318
	dc.w	32335
	dc.w	32351
	dc.w	32367
	dc.w	32382
	dc.w	32397
	dc.w	32412
	dc.w	32427
	dc.w	32441
	dc.w	32455
	dc.w	32469
	dc.w	32482
	dc.w	32495
	dc.w	32508
	dc.w	32521
	dc.w	32533
	dc.w	32545
	dc.w	32556
	dc.w	32567
	dc.w	32578
	dc.w	32589
	dc.w	32599
	dc.w	32609
	dc.w	32619
	dc.w	32628
	dc.w	32637
	dc.w	32646
	dc.w	32655
	dc.w	32663
	dc.w	32671
	dc.w	32678
	dc.w	32685
	dc.w	32692
	dc.w	32699
	dc.w	32705
	dc.w	32711
	dc.w	32717
	dc.w	32722
	dc.w	32728
	dc.w	32732
	dc.w	32737
	dc.w	32741
	dc.w	32745
	dc.w	32748
	dc.w	32752
	dc.w	32755
	dc.w	32757
	dc.w	32759
	dc.w	32761
	dc.w	32763
	dc.w	32765
	dc.w	32766
	dc.w	32766
	dc.w	32767
	dc.w	32767
	dc.w	32767
	dc.w	32766
	dc.w	32766
	dc.w	32765
	dc.w	32763
	dc.w	32761
	dc.w	32759
	dc.w	32757
	dc.w	32755
	dc.w	32752
	dc.w	32748
	dc.w	32745
	dc.w	32741
	dc.w	32737
	dc.w	32732
	dc.w	32728
	dc.w	32722
	dc.w	32717
	dc.w	32711
	dc.w	32705
	dc.w	32699
	dc.w	32692
	dc.w	32685
	dc.w	32678
	dc.w	32671
	dc.w	32663
	dc.w	32655
	dc.w	32646
	dc.w	32637
	dc.w	32628
	dc.w	32619
	dc.w	32609
	dc.w	32599
	dc.w	32589
	dc.w	32578
	dc.w	32567
	dc.w	32556
	dc.w	32545
	dc.w	32533
	dc.w	32521
	dc.w	32508
	dc.w	32495
	dc.w	32482
	dc.w	32469
	dc.w	32455
	dc.w	32441
	dc.w	32427
	dc.w	32412
	dc.w	32397
	dc.w	32382
	dc.w	32367
	dc.w	32351
	dc.w	32335
	dc.w	32318
	dc.w	32302
	dc.w	32285
	dc.w	32267
	dc.w	32250
	dc.w	32232
	dc.w	32213
	dc.w	32195
	dc.w	32176
	dc.w	32157
	dc.w	32137
	dc.w	32118
	dc.w	32098
	dc.w	32077
	dc.w	32057
	dc.w	32036
	dc.w	32014
	dc.w	31993
	dc.w	31971
	dc.w	31949
	dc.w	31926
	dc.w	31903
	dc.w	31880
	dc.w	31857
	dc.w	31833
	dc.w	31809
	dc.w	31785
	dc.w	31760
	dc.w	31736
	dc.w	31710
	dc.w	31685
	dc.w	31659
	dc.w	31633
	dc.w	31607
	dc.w	31580
	dc.w	31553
	dc.w	31526
	dc.w	31498
	dc.w	31470
	dc.w	31442
	dc.w	31414
	dc.w	31385
	dc.w	31356
	dc.w	31327
	dc.w	31297
	dc.w	31267
	dc.w	31237
	dc.w	31206
	dc.w	31176
	dc.w	31145
	dc.w	31113
	dc.w	31082
	dc.w	31050
	dc.w	31017
	dc.w	30985
	dc.w	30952
	dc.w	30919
	dc.w	30885
	dc.w	30852
	dc.w	30818
	dc.w	30783
	dc.w	30749
	dc.w	30714
	dc.w	30679
	dc.w	30643
	dc.w	30607
	dc.w	30571
	dc.w	30535
	dc.w	30498
	dc.w	30462
	dc.w	30424
	dc.w	30387
	dc.w	30349
	dc.w	30311
	dc.w	30273
	dc.w	30234
	dc.w	30195
	dc.w	30156
	dc.w	30117
	dc.w	30077
	dc.w	30037
	dc.w	29997
	dc.w	29956
	dc.w	29915
	dc.w	29874
	dc.w	29832
	dc.w	29791
	dc.w	29749
	dc.w	29706
	dc.w	29664
	dc.w	29621
	dc.w	29578
	dc.w	29534
	dc.w	29491
	dc.w	29447
	dc.w	29403
	dc.w	29358
	dc.w	29313
	dc.w	29268
	dc.w	29223
	dc.w	29177
	dc.w	29131
	dc.w	29085
	dc.w	29039
	dc.w	28992
	dc.w	28945
	dc.w	28898
	dc.w	28850
	dc.w	28803
	dc.w	28755
	dc.w	28706
	dc.w	28658
	dc.w	28609
	dc.w	28560
	dc.w	28510
	dc.w	28460
	dc.w	28411
	dc.w	28360
	dc.w	28310
	dc.w	28259
	dc.w	28208
	dc.w	28157
	dc.w	28105
	dc.w	28053
	dc.w	28001
	dc.w	27949
	dc.w	27896
	dc.w	27843
	dc.w	27790
	dc.w	27737
	dc.w	27683
	dc.w	27629
	dc.w	27575
	dc.w	27521
	dc.w	27466
	dc.w	27411
	dc.w	27356
	dc.w	27300
	dc.w	27245
	dc.w	27189
	dc.w	27133
	dc.w	27076
	dc.w	27019
	dc.w	26962
	dc.w	26905
	dc.w	26848
	dc.w	26790
	dc.w	26732
	dc.w	26674
	dc.w	26615
	dc.w	26556
	dc.w	26497
	dc.w	26438
	dc.w	26378
	dc.w	26319
	dc.w	26259
	dc.w	26198
	dc.w	26138
	dc.w	26077
	dc.w	26016
	dc.w	25955
	dc.w	25893
	dc.w	25832
	dc.w	25770
	dc.w	25708
	dc.w	25645
	dc.w	25582
	dc.w	25519
	dc.w	25456
	dc.w	25393
	dc.w	25329
	dc.w	25265
	dc.w	25201
	dc.w	25137
	dc.w	25072
	dc.w	25007
	dc.w	24942
	dc.w	24877
	dc.w	24811
	dc.w	24746
	dc.w	24680
	dc.w	24613
	dc.w	24547
	dc.w	24480
	dc.w	24413
	dc.w	24346
	dc.w	24279
	dc.w	24211
	dc.w	24143
	dc.w	24075
	dc.w	24007
	dc.w	23938
	dc.w	23870
	dc.w	23801
	dc.w	23731
	dc.w	23662
	dc.w	23592
	dc.w	23522
	dc.w	23452
	dc.w	23382
	dc.w	23311
	dc.w	23241
	dc.w	23170
	dc.w	23099
	dc.w	23027
	dc.w	22956
	dc.w	22884
	dc.w	22812
	dc.w	22739
	dc.w	22667
	dc.w	22594
	dc.w	22521
	dc.w	22448
	dc.w	22375
	dc.w	22301
	dc.w	22227
	dc.w	22154
	dc.w	22079
	dc.w	22005
	dc.w	21930
	dc.w	21856
	dc.w	21781
	dc.w	21705
	dc.w	21630
	dc.w	21554
	dc.w	21479
	dc.w	21403
	dc.w	21326
	dc.w	21250
	dc.w	21173
	dc.w	21096
	dc.w	21019
	dc.w	20942
	dc.w	20865
	dc.w	20787
	dc.w	20709
	dc.w	20631
	dc.w	20553
	dc.w	20475
	dc.w	20396
	dc.w	20317
	dc.w	20238
	dc.w	20159
	dc.w	20080
	dc.w	20000
	dc.w	19921
	dc.w	19841
	dc.w	19761
	dc.w	19680
	dc.w	19600
	dc.w	19519
	dc.w	19438
	dc.w	19357
	dc.w	19276
	dc.w	19195
	dc.w	19113
	dc.w	19032
	dc.w	18950
	dc.w	18868
	dc.w	18785
	dc.w	18703
	dc.w	18620
	dc.w	18537
	dc.w	18454
	dc.w	18371
	dc.w	18288
	dc.w	18204
	dc.w	18121
	dc.w	18037
	dc.w	17953
	dc.w	17869
	dc.w	17784
	dc.w	17700
	dc.w	17615
	dc.w	17530
	dc.w	17445
	dc.w	17360
	dc.w	17275
	dc.w	17189
	dc.w	17104
	dc.w	17018
	dc.w	16932
	dc.w	16846
	dc.w	16759
	dc.w	16673
	dc.w	16586
	dc.w	16499
	dc.w	16413
	dc.w	16325
	dc.w	16238
	dc.w	16151
	dc.w	16063
	dc.w	15976
	dc.w	15888
	dc.w	15800
	dc.w	15712
	dc.w	15623
	dc.w	15535
	dc.w	15446
	dc.w	15358
	dc.w	15269
	dc.w	15180
	dc.w	15090
	dc.w	15001
	dc.w	14912
	dc.w	14822
	dc.w	14732
	dc.w	14643
	dc.w	14553
	dc.w	14462
	dc.w	14372
	dc.w	14282
	dc.w	14191
	dc.w	14101
	dc.w	14010
	dc.w	13919
	dc.w	13828
	dc.w	13736
	dc.w	13645
	dc.w	13554
	dc.w	13462
	dc.w	13370
	dc.w	13279
	dc.w	13187
	dc.w	13094
	dc.w	13002
	dc.w	12910
	dc.w	12817
	dc.w	12725
	dc.w	12632
	dc.w	12539
	dc.w	12446
	dc.w	12353
	dc.w	12260
	dc.w	12167
	dc.w	12074
	dc.w	11980
	dc.w	11886
	dc.w	11793
	dc.w	11699
	dc.w	11605
	dc.w	11511
	dc.w	11417
	dc.w	11322
	dc.w	11228
	dc.w	11133
	dc.w	11039
	dc.w	10944
	dc.w	10849
	dc.w	10754
	dc.w	10659
	dc.w	10564
	dc.w	10469
	dc.w	10374
	dc.w	10278
	dc.w	10183
	dc.w	10087
	dc.w	9992
	dc.w	9896
	dc.w	9800
	dc.w	9704
	dc.w	9608
	dc.w	9512
	dc.w	9416
	dc.w	9319
	dc.w	9223
	dc.w	9126
	dc.w	9030
	dc.w	8933
	dc.w	8836
	dc.w	8739
	dc.w	8642
	dc.w	8545
	dc.w	8448
	dc.w	8351
	dc.w	8254
	dc.w	8157
	dc.w	8059
	dc.w	7962
	dc.w	7864
	dc.w	7767
	dc.w	7669
	dc.w	7571
	dc.w	7473
	dc.w	7375
	dc.w	7277
	dc.w	7179
	dc.w	7081
	dc.w	6983
	dc.w	6885
	dc.w	6786
	dc.w	6688
	dc.w	6590
	dc.w	6491
	dc.w	6393
	dc.w	6294
	dc.w	6195
	dc.w	6096
	dc.w	5998
	dc.w	5899
	dc.w	5800
	dc.w	5701
	dc.w	5602
	dc.w	5503
	dc.w	5404
	dc.w	5305
	dc.w	5205
	dc.w	5106
	dc.w	5007
	dc.w	4907
	dc.w	4808
	dc.w	4708
	dc.w	4609
	dc.w	4509
	dc.w	4410
	dc.w	4310
	dc.w	4210
	dc.w	4111
	dc.w	4011
	dc.w	3911
	dc.w	3811
	dc.w	3712
	dc.w	3612
	dc.w	3512
	dc.w	3412
	dc.w	3312
	dc.w	3212
	dc.w	3112
	dc.w	3012
	dc.w	2911
	dc.w	2811
	dc.w	2711
	dc.w	2611
	dc.w	2511
	dc.w	2410
	dc.w	2310
	dc.w	2210
	dc.w	2110
	dc.w	2009
	dc.w	1909
	dc.w	1809
	dc.w	1708
	dc.w	1608
	dc.w	1507
	dc.w	1407
	dc.w	1307
	dc.w	1206
	dc.w	1106
	dc.w	1005
	dc.w	905
	dc.w	804
	dc.w	704
	dc.w	603
	dc.w	503
	dc.w	402
	dc.w	302
	dc.w	201
	dc.w	101
	dc.w	0
	dc.w	-101
	dc.w	-201
	dc.w	-302
	dc.w	-402
	dc.w	-503
	dc.w	-603
	dc.w	-704
	dc.w	-804
	dc.w	-905
	dc.w	-1005
	dc.w	-1106
	dc.w	-1206
	dc.w	-1307
	dc.w	-1407
	dc.w	-1507
	dc.w	-1608
	dc.w	-1708
	dc.w	-1809
	dc.w	-1909
	dc.w	-2009
	dc.w	-2110
	dc.w	-2210
	dc.w	-2310
	dc.w	-2410
	dc.w	-2511
	dc.w	-2611
	dc.w	-2711
	dc.w	-2811
	dc.w	-2911
	dc.w	-3012
	dc.w	-3112
	dc.w	-3212
	dc.w	-3312
	dc.w	-3412
	dc.w	-3512
	dc.w	-3612
	dc.w	-3712
	dc.w	-3811
	dc.w	-3911
	dc.w	-4011
	dc.w	-4111
	dc.w	-4210
	dc.w	-4310
	dc.w	-4410
	dc.w	-4509
	dc.w	-4609
	dc.w	-4708
	dc.w	-4808
	dc.w	-4907
	dc.w	-5007
	dc.w	-5106
	dc.w	-5205
	dc.w	-5305
	dc.w	-5404
	dc.w	-5503
	dc.w	-5602
	dc.w	-5701
	dc.w	-5800
	dc.w	-5899
	dc.w	-5998
	dc.w	-6096
	dc.w	-6195
	dc.w	-6294
	dc.w	-6393
	dc.w	-6491
	dc.w	-6590
	dc.w	-6688
	dc.w	-6786
	dc.w	-6885
	dc.w	-6983
	dc.w	-7081
	dc.w	-7179
	dc.w	-7277
	dc.w	-7375
	dc.w	-7473
	dc.w	-7571
	dc.w	-7669
	dc.w	-7767
	dc.w	-7864
	dc.w	-7962
	dc.w	-8059
	dc.w	-8157
	dc.w	-8254
	dc.w	-8351
	dc.w	-8448
	dc.w	-8545
	dc.w	-8642
	dc.w	-8739
	dc.w	-8836
	dc.w	-8933
	dc.w	-9030
	dc.w	-9126
	dc.w	-9223
	dc.w	-9319
	dc.w	-9416
	dc.w	-9512
	dc.w	-9608
	dc.w	-9704
	dc.w	-9800
	dc.w	-9896
	dc.w	-9992
	dc.w	-10087
	dc.w	-10183
	dc.w	-10278
	dc.w	-10374
	dc.w	-10469
	dc.w	-10564
	dc.w	-10659
	dc.w	-10754
	dc.w	-10849
	dc.w	-10944
	dc.w	-11039
	dc.w	-11133
	dc.w	-11228
	dc.w	-11322
	dc.w	-11417
	dc.w	-11511
	dc.w	-11605
	dc.w	-11699
	dc.w	-11793
	dc.w	-11886
	dc.w	-11980
	dc.w	-12074
	dc.w	-12167
	dc.w	-12260
	dc.w	-12353
	dc.w	-12446
	dc.w	-12539
	dc.w	-12632
	dc.w	-12725
	dc.w	-12817
	dc.w	-12910
	dc.w	-13002
	dc.w	-13094
	dc.w	-13187
	dc.w	-13279
	dc.w	-13370
	dc.w	-13462
	dc.w	-13554
	dc.w	-13645
	dc.w	-13736
	dc.w	-13828
	dc.w	-13919
	dc.w	-14010
	dc.w	-14101
	dc.w	-14191
	dc.w	-14282
	dc.w	-14372
	dc.w	-14462
	dc.w	-14553
	dc.w	-14643
	dc.w	-14732
	dc.w	-14822
	dc.w	-14912
	dc.w	-15001
	dc.w	-15090
	dc.w	-15180
	dc.w	-15269
	dc.w	-15358
	dc.w	-15446
	dc.w	-15535
	dc.w	-15623
	dc.w	-15712
	dc.w	-15800
	dc.w	-15888
	dc.w	-15976
	dc.w	-16063
	dc.w	-16151
	dc.w	-16238
	dc.w	-16325
	dc.w	-16413
	dc.w	-16499
	dc.w	-16586
	dc.w	-16673
	dc.w	-16759
	dc.w	-16846
	dc.w	-16932
	dc.w	-17018
	dc.w	-17104
	dc.w	-17189
	dc.w	-17275
	dc.w	-17360
	dc.w	-17445
	dc.w	-17530
	dc.w	-17615
	dc.w	-17700
	dc.w	-17784
	dc.w	-17869
	dc.w	-17953
	dc.w	-18037
	dc.w	-18121
	dc.w	-18204
	dc.w	-18288
	dc.w	-18371
	dc.w	-18454
	dc.w	-18537
	dc.w	-18620
	dc.w	-18703
	dc.w	-18785
	dc.w	-18868
	dc.w	-18950
	dc.w	-19032
	dc.w	-19113
	dc.w	-19195
	dc.w	-19276
	dc.w	-19357
	dc.w	-19438
	dc.w	-19519
	dc.w	-19600
	dc.w	-19680
	dc.w	-19761
	dc.w	-19841
	dc.w	-19921
	dc.w	-20000
	dc.w	-20080
	dc.w	-20159
	dc.w	-20238
	dc.w	-20317
	dc.w	-20396
	dc.w	-20475
	dc.w	-20553
	dc.w	-20631
	dc.w	-20709
	dc.w	-20787
	dc.w	-20865
	dc.w	-20942
	dc.w	-21019
	dc.w	-21096
	dc.w	-21173
	dc.w	-21250
	dc.w	-21326
	dc.w	-21403
	dc.w	-21479
	dc.w	-21554
	dc.w	-21630
	dc.w	-21705
	dc.w	-21781
	dc.w	-21856
	dc.w	-21930
	dc.w	-22005
	dc.w	-22079
	dc.w	-22154
	dc.w	-22227
	dc.w	-22301
	dc.w	-22375
	dc.w	-22448
	dc.w	-22521
	dc.w	-22594
	dc.w	-22667
	dc.w	-22739
	dc.w	-22812
	dc.w	-22884
	dc.w	-22956
	dc.w	-23027
	dc.w	-23099
	dc.w	-23170
	dc.w	-23241
	dc.w	-23311
	dc.w	-23382
	dc.w	-23452
	dc.w	-23522
	dc.w	-23592
	dc.w	-23662
	dc.w	-23731
	dc.w	-23801
	dc.w	-23870
	dc.w	-23938
	dc.w	-24007
	dc.w	-24075
	dc.w	-24143
	dc.w	-24211
	dc.w	-24279
	dc.w	-24346
	dc.w	-24413
	dc.w	-24480
	dc.w	-24547
	dc.w	-24613
	dc.w	-24680
	dc.w	-24746
	dc.w	-24811
	dc.w	-24877
	dc.w	-24942
	dc.w	-25007
	dc.w	-25072
	dc.w	-25137
	dc.w	-25201
	dc.w	-25265
	dc.w	-25329
	dc.w	-25393
	dc.w	-25456
	dc.w	-25519
	dc.w	-25582
	dc.w	-25645
	dc.w	-25708
	dc.w	-25770
	dc.w	-25832
	dc.w	-25893
	dc.w	-25955
	dc.w	-26016
	dc.w	-26077
	dc.w	-26138
	dc.w	-26198
	dc.w	-26259
	dc.w	-26319
	dc.w	-26378
	dc.w	-26438
	dc.w	-26497
	dc.w	-26556
	dc.w	-26615
	dc.w	-26674
	dc.w	-26732
	dc.w	-26790
	dc.w	-26848
	dc.w	-26905
	dc.w	-26962
	dc.w	-27019
	dc.w	-27076
	dc.w	-27133
	dc.w	-27189
	dc.w	-27245
	dc.w	-27300
	dc.w	-27356
	dc.w	-27411
	dc.w	-27466
	dc.w	-27521
	dc.w	-27575
	dc.w	-27629
	dc.w	-27683
	dc.w	-27737
	dc.w	-27790
	dc.w	-27843
	dc.w	-27896
	dc.w	-27949
	dc.w	-28001
	dc.w	-28053
	dc.w	-28105
	dc.w	-28157
	dc.w	-28208
	dc.w	-28259
	dc.w	-28310
	dc.w	-28360
	dc.w	-28411
	dc.w	-28460
	dc.w	-28510
	dc.w	-28560
	dc.w	-28609
	dc.w	-28658
	dc.w	-28706
	dc.w	-28755
	dc.w	-28803
	dc.w	-28850
	dc.w	-28898
	dc.w	-28945
	dc.w	-28992
	dc.w	-29039
	dc.w	-29085
	dc.w	-29131
	dc.w	-29177
	dc.w	-29223
	dc.w	-29268
	dc.w	-29313
	dc.w	-29358
	dc.w	-29403
	dc.w	-29447
	dc.w	-29491
	dc.w	-29534
	dc.w	-29578
	dc.w	-29621
	dc.w	-29664
	dc.w	-29706
	dc.w	-29749
	dc.w	-29791
	dc.w	-29832
	dc.w	-29874
	dc.w	-29915
	dc.w	-29956
	dc.w	-29997
	dc.w	-30037
	dc.w	-30077
	dc.w	-30117
	dc.w	-30156
	dc.w	-30195
	dc.w	-30234
	dc.w	-30273
	dc.w	-30311
	dc.w	-30349
	dc.w	-30387
	dc.w	-30424
	dc.w	-30462
	dc.w	-30498
	dc.w	-30535
	dc.w	-30571
	dc.w	-30607
	dc.w	-30643
	dc.w	-30679
	dc.w	-30714
	dc.w	-30749
	dc.w	-30783
	dc.w	-30818
	dc.w	-30852
	dc.w	-30885
	dc.w	-30919
	dc.w	-30952
	dc.w	-30985
	dc.w	-31017
	dc.w	-31050
	dc.w	-31082
	dc.w	-31113
	dc.w	-31145
	dc.w	-31176
	dc.w	-31206
	dc.w	-31237
	dc.w	-31267
	dc.w	-31297
	dc.w	-31327
	dc.w	-31356
	dc.w	-31385
	dc.w	-31414
	dc.w	-31442
	dc.w	-31470
	dc.w	-31498
	dc.w	-31526
	dc.w	-31553
	dc.w	-31580
	dc.w	-31607
	dc.w	-31633
	dc.w	-31659
	dc.w	-31685
	dc.w	-31710
	dc.w	-31736
	dc.w	-31760
	dc.w	-31785
	dc.w	-31809
	dc.w	-31833
	dc.w	-31857
	dc.w	-31880
	dc.w	-31903
	dc.w	-31926
	dc.w	-31949
	dc.w	-31971
	dc.w	-31993
	dc.w	-32014
	dc.w	-32036
	dc.w	-32057
	dc.w	-32077
	dc.w	-32098
	dc.w	-32118
	dc.w	-32137
	dc.w	-32157
	dc.w	-32176
	dc.w	-32195
	dc.w	-32213
	dc.w	-32232
	dc.w	-32250
	dc.w	-32267
	dc.w	-32285
	dc.w	-32302
	dc.w	-32318
	dc.w	-32335
	dc.w	-32351
	dc.w	-32367
	dc.w	-32382
	dc.w	-32397
	dc.w	-32412
	dc.w	-32427
	dc.w	-32441
	dc.w	-32455
	dc.w	-32469
	dc.w	-32482
	dc.w	-32495
	dc.w	-32508
	dc.w	-32521
	dc.w	-32533
	dc.w	-32545
	dc.w	-32556
	dc.w	-32567
	dc.w	-32578
	dc.w	-32589
	dc.w	-32599
	dc.w	-32609
	dc.w	-32619
	dc.w	-32628
	dc.w	-32637
	dc.w	-32646
	dc.w	-32655
	dc.w	-32663
	dc.w	-32671
	dc.w	-32678
	dc.w	-32685
	dc.w	-32692
	dc.w	-32699
	dc.w	-32705
	dc.w	-32711
	dc.w	-32717
	dc.w	-32722
	dc.w	-32728
	dc.w	-32732
	dc.w	-32737
	dc.w	-32741
	dc.w	-32745
	dc.w	-32748
	dc.w	-32752
	dc.w	-32755
	dc.w	-32757
	dc.w	-32759
	dc.w	-32761
	dc.w	-32763
	dc.w	-32765
	dc.w	-32766
	dc.w	-32766
	dc.w	-32767
	dc.w	-32767
	dc.w	-32767
	dc.w	-32766
	dc.w	-32766
	dc.w	-32765
	dc.w	-32763
	dc.w	-32761
	dc.w	-32759
	dc.w	-32757
	dc.w	-32755
	dc.w	-32752
	dc.w	-32748
	dc.w	-32745
	dc.w	-32741
	dc.w	-32737
	dc.w	-32732
	dc.w	-32728
	dc.w	-32722
	dc.w	-32717
	dc.w	-32711
	dc.w	-32705
	dc.w	-32699
	dc.w	-32692
	dc.w	-32685
	dc.w	-32678
	dc.w	-32671
	dc.w	-32663
	dc.w	-32655
	dc.w	-32646
	dc.w	-32637
	dc.w	-32628
	dc.w	-32619
	dc.w	-32609
	dc.w	-32599
	dc.w	-32589
	dc.w	-32578
	dc.w	-32567
	dc.w	-32556
	dc.w	-32545
	dc.w	-32533
	dc.w	-32521
	dc.w	-32508
	dc.w	-32495
	dc.w	-32482
	dc.w	-32469
	dc.w	-32455
	dc.w	-32441
	dc.w	-32427
	dc.w	-32412
	dc.w	-32397
	dc.w	-32382
	dc.w	-32367
	dc.w	-32351
	dc.w	-32335
	dc.w	-32318
	dc.w	-32302
	dc.w	-32285
	dc.w	-32267
	dc.w	-32250
	dc.w	-32232
	dc.w	-32213
	dc.w	-32195
	dc.w	-32176
	dc.w	-32157
	dc.w	-32137
	dc.w	-32118
	dc.w	-32098
	dc.w	-32077
	dc.w	-32057
	dc.w	-32036
	dc.w	-32014
	dc.w	-31993
	dc.w	-31971
	dc.w	-31949
	dc.w	-31926
	dc.w	-31903
	dc.w	-31880
	dc.w	-31857
	dc.w	-31833
	dc.w	-31809
	dc.w	-31785
	dc.w	-31760
	dc.w	-31736
	dc.w	-31710
	dc.w	-31685
	dc.w	-31659
	dc.w	-31633
	dc.w	-31607
	dc.w	-31580
	dc.w	-31553
	dc.w	-31526
	dc.w	-31498
	dc.w	-31470
	dc.w	-31442
	dc.w	-31414
	dc.w	-31385
	dc.w	-31356
	dc.w	-31327
	dc.w	-31297
	dc.w	-31267
	dc.w	-31237
	dc.w	-31206
	dc.w	-31176
	dc.w	-31145
	dc.w	-31113
	dc.w	-31082
	dc.w	-31050
	dc.w	-31017
	dc.w	-30985
	dc.w	-30952
	dc.w	-30919
	dc.w	-30885
	dc.w	-30852
	dc.w	-30818
	dc.w	-30783
	dc.w	-30749
	dc.w	-30714
	dc.w	-30679
	dc.w	-30643
	dc.w	-30607
	dc.w	-30571
	dc.w	-30535
	dc.w	-30498
	dc.w	-30462
	dc.w	-30424
	dc.w	-30387
	dc.w	-30349
	dc.w	-30311
	dc.w	-30273
	dc.w	-30234
	dc.w	-30195
	dc.w	-30156
	dc.w	-30117
	dc.w	-30077
	dc.w	-30037
	dc.w	-29997
	dc.w	-29956
	dc.w	-29915
	dc.w	-29874
	dc.w	-29832
	dc.w	-29791
	dc.w	-29749
	dc.w	-29706
	dc.w	-29664
	dc.w	-29621
	dc.w	-29578
	dc.w	-29534
	dc.w	-29491
	dc.w	-29447
	dc.w	-29403
	dc.w	-29358
	dc.w	-29313
	dc.w	-29268
	dc.w	-29223
	dc.w	-29177
	dc.w	-29131
	dc.w	-29085
	dc.w	-29039
	dc.w	-28992
	dc.w	-28945
	dc.w	-28898
	dc.w	-28850
	dc.w	-28803
	dc.w	-28755
	dc.w	-28706
	dc.w	-28658
	dc.w	-28609
	dc.w	-28560
	dc.w	-28510
	dc.w	-28460
	dc.w	-28411
	dc.w	-28360
	dc.w	-28310
	dc.w	-28259
	dc.w	-28208
	dc.w	-28157
	dc.w	-28105
	dc.w	-28053
	dc.w	-28001
	dc.w	-27949
	dc.w	-27896
	dc.w	-27843
	dc.w	-27790
	dc.w	-27737
	dc.w	-27683
	dc.w	-27629
	dc.w	-27575
	dc.w	-27521
	dc.w	-27466
	dc.w	-27411
	dc.w	-27356
	dc.w	-27300
	dc.w	-27245
	dc.w	-27189
	dc.w	-27133
	dc.w	-27076
	dc.w	-27019
	dc.w	-26962
	dc.w	-26905
	dc.w	-26848
	dc.w	-26790
	dc.w	-26732
	dc.w	-26674
	dc.w	-26615
	dc.w	-26556
	dc.w	-26497
	dc.w	-26438
	dc.w	-26378
	dc.w	-26319
	dc.w	-26259
	dc.w	-26198
	dc.w	-26138
	dc.w	-26077
	dc.w	-26016
	dc.w	-25955
	dc.w	-25893
	dc.w	-25832
	dc.w	-25770
	dc.w	-25708
	dc.w	-25645
	dc.w	-25582
	dc.w	-25519
	dc.w	-25456
	dc.w	-25393
	dc.w	-25329
	dc.w	-25265
	dc.w	-25201
	dc.w	-25137
	dc.w	-25072
	dc.w	-25007
	dc.w	-24942
	dc.w	-24877
	dc.w	-24811
	dc.w	-24746
	dc.w	-24680
	dc.w	-24613
	dc.w	-24547
	dc.w	-24480
	dc.w	-24413
	dc.w	-24346
	dc.w	-24279
	dc.w	-24211
	dc.w	-24143
	dc.w	-24075
	dc.w	-24007
	dc.w	-23938
	dc.w	-23870
	dc.w	-23801
	dc.w	-23731
	dc.w	-23662
	dc.w	-23592
	dc.w	-23522
	dc.w	-23452
	dc.w	-23382
	dc.w	-23311
	dc.w	-23241
	dc.w	-23170
	dc.w	-23099
	dc.w	-23027
	dc.w	-22956
	dc.w	-22884
	dc.w	-22812
	dc.w	-22739
	dc.w	-22667
	dc.w	-22594
	dc.w	-22521
	dc.w	-22448
	dc.w	-22375
	dc.w	-22301
	dc.w	-22227
	dc.w	-22154
	dc.w	-22079
	dc.w	-22005
	dc.w	-21930
	dc.w	-21856
	dc.w	-21781
	dc.w	-21705
	dc.w	-21630
	dc.w	-21554
	dc.w	-21479
	dc.w	-21403
	dc.w	-21326
	dc.w	-21250
	dc.w	-21173
	dc.w	-21096
	dc.w	-21019
	dc.w	-20942
	dc.w	-20865
	dc.w	-20787
	dc.w	-20709
	dc.w	-20631
	dc.w	-20553
	dc.w	-20475
	dc.w	-20396
	dc.w	-20317
	dc.w	-20238
	dc.w	-20159
	dc.w	-20080
	dc.w	-20000
	dc.w	-19921
	dc.w	-19841
	dc.w	-19761
	dc.w	-19680
	dc.w	-19600
	dc.w	-19519
	dc.w	-19438
	dc.w	-19357
	dc.w	-19276
	dc.w	-19195
	dc.w	-19113
	dc.w	-19032
	dc.w	-18950
	dc.w	-18868
	dc.w	-18785
	dc.w	-18703
	dc.w	-18620
	dc.w	-18537
	dc.w	-18454
	dc.w	-18371
	dc.w	-18288
	dc.w	-18204
	dc.w	-18121
	dc.w	-18037
	dc.w	-17953
	dc.w	-17869
	dc.w	-17784
	dc.w	-17700
	dc.w	-17615
	dc.w	-17530
	dc.w	-17445
	dc.w	-17360
	dc.w	-17275
	dc.w	-17189
	dc.w	-17104
	dc.w	-17018
	dc.w	-16932
	dc.w	-16846
	dc.w	-16759
	dc.w	-16673
	dc.w	-16586
	dc.w	-16499
	dc.w	-16413
	dc.w	-16325
	dc.w	-16238
	dc.w	-16151
	dc.w	-16063
	dc.w	-15976
	dc.w	-15888
	dc.w	-15800
	dc.w	-15712
	dc.w	-15623
	dc.w	-15535
	dc.w	-15446
	dc.w	-15358
	dc.w	-15269
	dc.w	-15180
	dc.w	-15090
	dc.w	-15001
	dc.w	-14912
	dc.w	-14822
	dc.w	-14732
	dc.w	-14643
	dc.w	-14553
	dc.w	-14462
	dc.w	-14372
	dc.w	-14282
	dc.w	-14191
	dc.w	-14101
	dc.w	-14010
	dc.w	-13919
	dc.w	-13828
	dc.w	-13736
	dc.w	-13645
	dc.w	-13554
	dc.w	-13462
	dc.w	-13370
	dc.w	-13279
	dc.w	-13187
	dc.w	-13094
	dc.w	-13002
	dc.w	-12910
	dc.w	-12817
	dc.w	-12725
	dc.w	-12632
	dc.w	-12539
	dc.w	-12446
	dc.w	-12353
	dc.w	-12260
	dc.w	-12167
	dc.w	-12074
	dc.w	-11980
	dc.w	-11886
	dc.w	-11793
	dc.w	-11699
	dc.w	-11605
	dc.w	-11511
	dc.w	-11417
	dc.w	-11322
	dc.w	-11228
	dc.w	-11133
	dc.w	-11039
	dc.w	-10944
	dc.w	-10849
	dc.w	-10754
	dc.w	-10659
	dc.w	-10564
	dc.w	-10469
	dc.w	-10374
	dc.w	-10278
	dc.w	-10183
	dc.w	-10087
	dc.w	-9992
	dc.w	-9896
	dc.w	-9800
	dc.w	-9704
	dc.w	-9608
	dc.w	-9512
	dc.w	-9416
	dc.w	-9319
	dc.w	-9223
	dc.w	-9126
	dc.w	-9030
	dc.w	-8933
	dc.w	-8836
	dc.w	-8739
	dc.w	-8642
	dc.w	-8545
	dc.w	-8448
	dc.w	-8351
	dc.w	-8254
	dc.w	-8157
	dc.w	-8059
	dc.w	-7962
	dc.w	-7864
	dc.w	-7767
	dc.w	-7669
	dc.w	-7571
	dc.w	-7473
	dc.w	-7375
	dc.w	-7277
	dc.w	-7179
	dc.w	-7081
	dc.w	-6983
	dc.w	-6885
	dc.w	-6786
	dc.w	-6688
	dc.w	-6590
	dc.w	-6491
	dc.w	-6393
	dc.w	-6294
	dc.w	-6195
	dc.w	-6096
	dc.w	-5998
	dc.w	-5899
	dc.w	-5800
	dc.w	-5701
	dc.w	-5602
	dc.w	-5503
	dc.w	-5404
	dc.w	-5305
	dc.w	-5205
	dc.w	-5106
	dc.w	-5007
	dc.w	-4907
	dc.w	-4808
	dc.w	-4708
	dc.w	-4609
	dc.w	-4509
	dc.w	-4410
	dc.w	-4310
	dc.w	-4210
	dc.w	-4111
	dc.w	-4011
	dc.w	-3911
	dc.w	-3811
	dc.w	-3712
	dc.w	-3612
	dc.w	-3512
	dc.w	-3412
	dc.w	-3312
	dc.w	-3212
	dc.w	-3112
	dc.w	-3012
	dc.w	-2911
	dc.w	-2811
	dc.w	-2711
	dc.w	-2611
	dc.w	-2511
	dc.w	-2410
	dc.w	-2310
	dc.w	-2210
	dc.w	-2110
	dc.w	-2009
	dc.w	-1909
	dc.w	-1809
	dc.w	-1708
	dc.w	-1608
	dc.w	-1507
	dc.w	-1407
	dc.w	-1307
	dc.w	-1206
	dc.w	-1106
	dc.w	-1005
	dc.w	-905
	dc.w	-804
	dc.w	-704
	dc.w	-603
	dc.w	-503
	dc.w	-402
	dc.w	-302
	dc.w	-201
	dc.w	-101
	dc.w	-0
	dc.w	101
	dc.w	201
	dc.w	302
	dc.w	402
	dc.w	503
	dc.w	603
	dc.w	704
	dc.w	804
	dc.w	905
	dc.w	1005
	dc.w	1106
	dc.w	1206
	dc.w	1307
	dc.w	1407
	dc.w	1507
	dc.w	1608
	dc.w	1708
	dc.w	1809
	dc.w	1909
	dc.w	2009
	dc.w	2110
	dc.w	2210
	dc.w	2310
	dc.w	2410
	dc.w	2511
	dc.w	2611
	dc.w	2711
	dc.w	2811
	dc.w	2911
	dc.w	3012
	dc.w	3112
	dc.w	3212
	dc.w	3312
	dc.w	3412
	dc.w	3512
	dc.w	3612
	dc.w	3712
	dc.w	3811
	dc.w	3911
	dc.w	4011
	dc.w	4111
	dc.w	4210
	dc.w	4310
	dc.w	4410
	dc.w	4509
	dc.w	4609
	dc.w	4708
	dc.w	4808
	dc.w	4907
	dc.w	5007
	dc.w	5106
	dc.w	5205
	dc.w	5305
	dc.w	5404
	dc.w	5503
	dc.w	5602
	dc.w	5701
	dc.w	5800
	dc.w	5899
	dc.w	5998
	dc.w	6096
	dc.w	6195
	dc.w	6294
	dc.w	6393
	dc.w	6491
	dc.w	6590
	dc.w	6688
	dc.w	6786
	dc.w	6885
	dc.w	6983
	dc.w	7081
	dc.w	7179
	dc.w	7277
	dc.w	7375
	dc.w	7473
	dc.w	7571
	dc.w	7669
	dc.w	7767
	dc.w	7864
	dc.w	7962
	dc.w	8059
	dc.w	8157
	dc.w	8254
	dc.w	8351
	dc.w	8448
	dc.w	8545
	dc.w	8642
	dc.w	8739
	dc.w	8836
	dc.w	8933
	dc.w	9030
	dc.w	9126
	dc.w	9223
	dc.w	9319
	dc.w	9416
	dc.w	9512
	dc.w	9608
	dc.w	9704
	dc.w	9800
	dc.w	9896
	dc.w	9992
	dc.w	10087
	dc.w	10183
	dc.w	10278
	dc.w	10374
	dc.w	10469
	dc.w	10564
	dc.w	10659
	dc.w	10754
	dc.w	10849
	dc.w	10944
	dc.w	11039
	dc.w	11133
	dc.w	11228
	dc.w	11322
	dc.w	11417
	dc.w	11511
	dc.w	11605
	dc.w	11699
	dc.w	11793
	dc.w	11886
	dc.w	11980
	dc.w	12074
	dc.w	12167
	dc.w	12260
	dc.w	12353
	dc.w	12446
	dc.w	12539
	dc.w	12632
	dc.w	12725
	dc.w	12817
	dc.w	12910
	dc.w	13002
	dc.w	13094
	dc.w	13187
	dc.w	13279
	dc.w	13370
	dc.w	13462
	dc.w	13554
	dc.w	13645
	dc.w	13736
	dc.w	13828
	dc.w	13919
	dc.w	14010
	dc.w	14101
	dc.w	14191
	dc.w	14282
	dc.w	14372
	dc.w	14462
	dc.w	14553
	dc.w	14643
	dc.w	14732
	dc.w	14822
	dc.w	14912
	dc.w	15001
	dc.w	15090
	dc.w	15180
	dc.w	15269
	dc.w	15358
	dc.w	15446
	dc.w	15535
	dc.w	15623
	dc.w	15712
	dc.w	15800
	dc.w	15888
	dc.w	15976
	dc.w	16063
	dc.w	16151
	dc.w	16238
	dc.w	16325
	dc.w	16413
	dc.w	16499
	dc.w	16586
	dc.w	16673
	dc.w	16759
	dc.w	16846
	dc.w	16932
	dc.w	17018
	dc.w	17104
	dc.w	17189
	dc.w	17275
	dc.w	17360
	dc.w	17445
	dc.w	17530
	dc.w	17615
	dc.w	17700
	dc.w	17784
	dc.w	17869
	dc.w	17953
	dc.w	18037
	dc.w	18121
	dc.w	18204
	dc.w	18288
	dc.w	18371
	dc.w	18454
	dc.w	18537
	dc.w	18620
	dc.w	18703
	dc.w	18785
	dc.w	18868
	dc.w	18950
	dc.w	19032
	dc.w	19113
	dc.w	19195
	dc.w	19276
	dc.w	19357
	dc.w	19438
	dc.w	19519
	dc.w	19600
	dc.w	19680
	dc.w	19761
	dc.w	19841
	dc.w	19921
	dc.w	20000
	dc.w	20080
	dc.w	20159
	dc.w	20238
	dc.w	20317
	dc.w	20396
	dc.w	20475
	dc.w	20553
	dc.w	20631
	dc.w	20709
	dc.w	20787
	dc.w	20865
	dc.w	20942
	dc.w	21019
	dc.w	21096
	dc.w	21173
	dc.w	21250
	dc.w	21326
	dc.w	21403
	dc.w	21479
	dc.w	21554
	dc.w	21630
	dc.w	21705
	dc.w	21781
	dc.w	21856
	dc.w	21930
	dc.w	22005
	dc.w	22079
	dc.w	22154
	dc.w	22227
	dc.w	22301
	dc.w	22375
	dc.w	22448
	dc.w	22521
	dc.w	22594
	dc.w	22667
	dc.w	22739
	dc.w	22812
	dc.w	22884
	dc.w	22956
	dc.w	23027
	dc.w	23099
	dc.w	23170
	dc.w	23241
	dc.w	23311
	dc.w	23382
	dc.w	23452
	dc.w	23522
	dc.w	23592
	dc.w	23662
	dc.w	23731
	dc.w	23801
	dc.w	23870
	dc.w	23938
	dc.w	24007
	dc.w	24075
	dc.w	24143
	dc.w	24211
	dc.w	24279
	dc.w	24346
	dc.w	24413
	dc.w	24480
	dc.w	24547
	dc.w	24613
	dc.w	24680
	dc.w	24746
	dc.w	24811
	dc.w	24877
	dc.w	24942
	dc.w	25007
	dc.w	25072
	dc.w	25137
	dc.w	25201
	dc.w	25265
	dc.w	25329
	dc.w	25393
	dc.w	25456
	dc.w	25519
	dc.w	25582
	dc.w	25645
	dc.w	25708
	dc.w	25770
	dc.w	25832
	dc.w	25893
	dc.w	25955
	dc.w	26016
	dc.w	26077
	dc.w	26138
	dc.w	26198
	dc.w	26259
	dc.w	26319
	dc.w	26378
	dc.w	26438
	dc.w	26497
	dc.w	26556
	dc.w	26615
	dc.w	26674
	dc.w	26732
	dc.w	26790
	dc.w	26848
	dc.w	26905
	dc.w	26962
	dc.w	27019
	dc.w	27076
	dc.w	27133
	dc.w	27189
	dc.w	27245
	dc.w	27300
	dc.w	27356
	dc.w	27411
	dc.w	27466
	dc.w	27521
	dc.w	27575
	dc.w	27629
	dc.w	27683
	dc.w	27737
	dc.w	27790
	dc.w	27843
	dc.w	27896
	dc.w	27949
	dc.w	28001
	dc.w	28053
	dc.w	28105
	dc.w	28157
	dc.w	28208
	dc.w	28259
	dc.w	28310
	dc.w	28360
	dc.w	28411
	dc.w	28460
	dc.w	28510
	dc.w	28560
	dc.w	28609
	dc.w	28658
	dc.w	28706
	dc.w	28755
	dc.w	28803
	dc.w	28850
	dc.w	28898
	dc.w	28945
	dc.w	28992
	dc.w	29039
	dc.w	29085
	dc.w	29131
	dc.w	29177
	dc.w	29223
	dc.w	29268
	dc.w	29313
	dc.w	29358
	dc.w	29403
	dc.w	29447
	dc.w	29491
	dc.w	29534
	dc.w	29578
	dc.w	29621
	dc.w	29664
	dc.w	29706
	dc.w	29749
	dc.w	29791
	dc.w	29832
	dc.w	29874
	dc.w	29915
	dc.w	29956
	dc.w	29997
	dc.w	30037
	dc.w	30077
	dc.w	30117
	dc.w	30156
	dc.w	30195
	dc.w	30234
	dc.w	30273
	dc.w	30311
	dc.w	30349
	dc.w	30387
	dc.w	30424
	dc.w	30462
	dc.w	30498
	dc.w	30535
	dc.w	30571
	dc.w	30607
	dc.w	30643
	dc.w	30679
	dc.w	30714
	dc.w	30749
	dc.w	30783
	dc.w	30818
	dc.w	30852
	dc.w	30885
	dc.w	30919
	dc.w	30952
	dc.w	30985
	dc.w	31017
	dc.w	31050
	dc.w	31082
	dc.w	31113
	dc.w	31145
	dc.w	31176
	dc.w	31206
	dc.w	31237
	dc.w	31267
	dc.w	31297
	dc.w	31327
	dc.w	31356
	dc.w	31385
	dc.w	31414
	dc.w	31442
	dc.w	31470
	dc.w	31498
	dc.w	31526
	dc.w	31553
	dc.w	31580
	dc.w	31607
	dc.w	31633
	dc.w	31659
	dc.w	31685
	dc.w	31710
	dc.w	31736
	dc.w	31760
	dc.w	31785
	dc.w	31809
	dc.w	31833
	dc.w	31857
	dc.w	31880
	dc.w	31903
	dc.w	31926
	dc.w	31949
	dc.w	31971
	dc.w	31993
	dc.w	32014
	dc.w	32036
	dc.w	32057
	dc.w	32077
	dc.w	32098
	dc.w	32118
	dc.w	32137
	dc.w	32157
	dc.w	32176
	dc.w	32195
	dc.w	32213
	dc.w	32232
	dc.w	32250
	dc.w	32267
	dc.w	32285
	dc.w	32302
	dc.w	32318
	dc.w	32335
	dc.w	32351
	dc.w	32367
	dc.w	32382
	dc.w	32397
	dc.w	32412
	dc.w	32427
	dc.w	32441
	dc.w	32455
	dc.w	32469
	dc.w	32482
	dc.w	32495
	dc.w	32508
	dc.w	32521
	dc.w	32533
	dc.w	32545
	dc.w	32556
	dc.w	32567
	dc.w	32578
	dc.w	32589
	dc.w	32599
	dc.w	32609
	dc.w	32619
	dc.w	32628
	dc.w	32637
	dc.w	32646
	dc.w	32655
	dc.w	32663
	dc.w	32671
	dc.w	32678
	dc.w	32685
	dc.w	32692
	dc.w	32699
	dc.w	32705
	dc.w	32711
	dc.w	32717
	dc.w	32722
	dc.w	32728
	dc.w	32732
	dc.w	32737
	dc.w	32741
	dc.w	32745
	dc.w	32748
	dc.w	32752
	dc.w	32755
	dc.w	32757
	dc.w	32759
	dc.w	32761
	dc.w	32763
	dc.w	32765
	dc.w	32766
	dc.w	32766
	dc.w	32767
