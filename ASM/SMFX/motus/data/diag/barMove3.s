	dc.w	0
	dc.w	0
	dc.w	1
	dc.w	2
	dc.w	4
	dc.w	7
	dc.w	10
	dc.w	13
	dc.w	17
	dc.w	21
	dc.w	26
	dc.w	31
	dc.w	37
	dc.w	43
	dc.w	49
	dc.w	55
	dc.w	62
	dc.w	69
	dc.w	76
	dc.w	83
	dc.w	91
	dc.w	98
	dc.w	106
	dc.w	113
	dc.w	120
	dc.w	127
	dc.w	134
	dc.w	141
	dc.w	148
	dc.w	154
	dc.w	160
	dc.w	166
	dc.w	171
	dc.w	176
	dc.w	181
	dc.w	185
	dc.w	189
	dc.w	192
	dc.w	195
	dc.w	197
	dc.w	198
	dc.w	199
	dc.w	200
	dc.w	200
	dc.w	199
	dc.w	198
	dc.w	197
	dc.w	195
	dc.w	192
	dc.w	189
	dc.w	185
	dc.w	181
	dc.w	176
	dc.w	171
	dc.w	166
	dc.w	160
	dc.w	154
	dc.w	148
	dc.w	141
	dc.w	134
	dc.w	127
	dc.w	120
	dc.w	113
	dc.w	106
	dc.w	98
	dc.w	91
	dc.w	83
	dc.w	76
	dc.w	69
	dc.w	62
	dc.w	55
	dc.w	49
	dc.w	43
	dc.w	37
	dc.w	31
	dc.w	26
	dc.w	21
	dc.w	17
	dc.w	13
	dc.w	10
	dc.w	7
	dc.w	4
	dc.w	2
	dc.w	1
	dc.w	0
