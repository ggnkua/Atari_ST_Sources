	dc.w	0
	dc.w	402
	dc.w	804
	dc.w	1206
	dc.w	1608
	dc.w	2009
	dc.w	2410
	dc.w	2811
	dc.w	3212
	dc.w	3612
	dc.w	4011
	dc.w	4410
	dc.w	4808
	dc.w	5205
	dc.w	5602
	dc.w	5998
	dc.w	6393
	dc.w	6786
	dc.w	7179
	dc.w	7571
	dc.w	7962
	dc.w	8351
	dc.w	8739
	dc.w	9126
	dc.w	9512
	dc.w	9896
	dc.w	10278
	dc.w	10659
	dc.w	11039
	dc.w	11417
	dc.w	11793
	dc.w	12167
	dc.w	12539
	dc.w	12910
	dc.w	13279
	dc.w	13645
	dc.w	14010
	dc.w	14372
	dc.w	14732
	dc.w	15090
	dc.w	15446
	dc.w	15800
	dc.w	16151
	dc.w	16499
	dc.w	16846
	dc.w	17189
	dc.w	17530
	dc.w	17869
	dc.w	18204
	dc.w	18537
	dc.w	18868
	dc.w	19195
	dc.w	19519
	dc.w	19841
	dc.w	20159
	dc.w	20475
	dc.w	20787
	dc.w	21096
	dc.w	21403
	dc.w	21705
	dc.w	22005
	dc.w	22301
	dc.w	22594
	dc.w	22884
	dc.w	23170
	dc.w	23452
	dc.w	23731
	dc.w	24007
	dc.w	24279
	dc.w	24547
	dc.w	24811
	dc.w	25072
	dc.w	25329
	dc.w	25582
	dc.w	25832
	dc.w	26077
	dc.w	26319
	dc.w	26556
	dc.w	26790
	dc.w	27019
	dc.w	27245
	dc.w	27466
	dc.w	27683
	dc.w	27896
	dc.w	28105
	dc.w	28310
	dc.w	28510
	dc.w	28706
	dc.w	28898
	dc.w	29085
	dc.w	29268
	dc.w	29447
	dc.w	29621
	dc.w	29791
	dc.w	29956
	dc.w	30117
	dc.w	30273
	dc.w	30424
	dc.w	30571
	dc.w	30714
	dc.w	30852
	dc.w	30985
	dc.w	31113
	dc.w	31237
	dc.w	31356
	dc.w	31470
	dc.w	31580
	dc.w	31685
	dc.w	31785
	dc.w	31880
	dc.w	31971
	dc.w	32057
	dc.w	32137
	dc.w	32213
	dc.w	32285
	dc.w	32351
	dc.w	32412
	dc.w	32469
	dc.w	32521
	dc.w	32567
	dc.w	32609
	dc.w	32646
	dc.w	32678
	dc.w	32705
	dc.w	32728
	dc.w	32745
	dc.w	32757
	dc.w	32765
	dc.w	32767
	dc.w	32765
	dc.w	32757
	dc.w	32745
	dc.w	32728
	dc.w	32705
	dc.w	32678
	dc.w	32646
	dc.w	32609
	dc.w	32567
	dc.w	32521
	dc.w	32469
	dc.w	32412
	dc.w	32351
	dc.w	32285
	dc.w	32213
	dc.w	32137
	dc.w	32057
	dc.w	31971
	dc.w	31880
	dc.w	31785
	dc.w	31685
	dc.w	31580
	dc.w	31470
	dc.w	31356
	dc.w	31237
	dc.w	31113
	dc.w	30985
	dc.w	30852
	dc.w	30714
	dc.w	30571
	dc.w	30424
	dc.w	30273
	dc.w	30117
	dc.w	29956
	dc.w	29791
	dc.w	29621
	dc.w	29447
	dc.w	29268
	dc.w	29085
	dc.w	28898
	dc.w	28706
	dc.w	28510
	dc.w	28310
	dc.w	28105
	dc.w	27896
	dc.w	27683
	dc.w	27466
	dc.w	27245
	dc.w	27019
	dc.w	26790
	dc.w	26556
	dc.w	26319
	dc.w	26077
	dc.w	25832
	dc.w	25582
	dc.w	25329
	dc.w	25072
	dc.w	24811
	dc.w	24547
	dc.w	24279
	dc.w	24007
	dc.w	23731
	dc.w	23452
	dc.w	23170
	dc.w	22884
	dc.w	22594
	dc.w	22301
	dc.w	22005
	dc.w	21705
	dc.w	21403
	dc.w	21096
	dc.w	20787
	dc.w	20475
	dc.w	20159
	dc.w	19841
	dc.w	19519
	dc.w	19195
	dc.w	18868
	dc.w	18537
	dc.w	18204
	dc.w	17869
	dc.w	17530
	dc.w	17189
	dc.w	16846
	dc.w	16499
	dc.w	16151
	dc.w	15800
	dc.w	15446
	dc.w	15090
	dc.w	14732
	dc.w	14372
	dc.w	14010
	dc.w	13645
	dc.w	13279
	dc.w	12910
	dc.w	12539
	dc.w	12167
	dc.w	11793
	dc.w	11417
	dc.w	11039
	dc.w	10659
	dc.w	10278
	dc.w	9896
	dc.w	9512
	dc.w	9126
	dc.w	8739
	dc.w	8351
	dc.w	7962
	dc.w	7571
	dc.w	7179
	dc.w	6786
	dc.w	6393
	dc.w	5998
	dc.w	5602
	dc.w	5205
	dc.w	4808
	dc.w	4410
	dc.w	4011
	dc.w	3612
	dc.w	3212
	dc.w	2811
	dc.w	2410
	dc.w	2009
	dc.w	1608
	dc.w	1206
	dc.w	804
	dc.w	402
	dc.w	0
	dc.w	-402
	dc.w	-804
	dc.w	-1206
	dc.w	-1608
	dc.w	-2009
	dc.w	-2410
	dc.w	-2811
	dc.w	-3212
	dc.w	-3612
	dc.w	-4011
	dc.w	-4410
	dc.w	-4808
	dc.w	-5205
	dc.w	-5602
	dc.w	-5998
	dc.w	-6393
	dc.w	-6786
	dc.w	-7179
	dc.w	-7571
	dc.w	-7962
	dc.w	-8351
	dc.w	-8739
	dc.w	-9126
	dc.w	-9512
	dc.w	-9896
	dc.w	-10278
	dc.w	-10659
	dc.w	-11039
	dc.w	-11417
	dc.w	-11793
	dc.w	-12167
	dc.w	-12539
	dc.w	-12910
	dc.w	-13279
	dc.w	-13645
	dc.w	-14010
	dc.w	-14372
	dc.w	-14732
	dc.w	-15090
	dc.w	-15446
	dc.w	-15800
	dc.w	-16151
	dc.w	-16499
	dc.w	-16846
	dc.w	-17189
	dc.w	-17530
	dc.w	-17869
	dc.w	-18204
	dc.w	-18537
	dc.w	-18868
	dc.w	-19195
	dc.w	-19519
	dc.w	-19841
	dc.w	-20159
	dc.w	-20475
	dc.w	-20787
	dc.w	-21096
	dc.w	-21403
	dc.w	-21705
	dc.w	-22005
	dc.w	-22301
	dc.w	-22594
	dc.w	-22884
	dc.w	-23170
	dc.w	-23452
	dc.w	-23731
	dc.w	-24007
	dc.w	-24279
	dc.w	-24547
	dc.w	-24811
	dc.w	-25072
	dc.w	-25329
	dc.w	-25582
	dc.w	-25832
	dc.w	-26077
	dc.w	-26319
	dc.w	-26556
	dc.w	-26790
	dc.w	-27019
	dc.w	-27245
	dc.w	-27466
	dc.w	-27683
	dc.w	-27896
	dc.w	-28105
	dc.w	-28310
	dc.w	-28510
	dc.w	-28706
	dc.w	-28898
	dc.w	-29085
	dc.w	-29268
	dc.w	-29447
	dc.w	-29621
	dc.w	-29791
	dc.w	-29956
	dc.w	-30117
	dc.w	-30273
	dc.w	-30424
	dc.w	-30571
	dc.w	-30714
	dc.w	-30852
	dc.w	-30985
	dc.w	-31113
	dc.w	-31237
	dc.w	-31356
	dc.w	-31470
	dc.w	-31580
	dc.w	-31685
	dc.w	-31785
	dc.w	-31880
	dc.w	-31971
	dc.w	-32057
	dc.w	-32137
	dc.w	-32213
	dc.w	-32285
	dc.w	-32351
	dc.w	-32412
	dc.w	-32469
	dc.w	-32521
	dc.w	-32567
	dc.w	-32609
	dc.w	-32646
	dc.w	-32678
	dc.w	-32705
	dc.w	-32728
	dc.w	-32745
	dc.w	-32757
	dc.w	-32765
	dc.w	-32767
	dc.w	-32765
	dc.w	-32757
	dc.w	-32745
	dc.w	-32728
	dc.w	-32705
	dc.w	-32678
	dc.w	-32646
	dc.w	-32609
	dc.w	-32567
	dc.w	-32521
	dc.w	-32469
	dc.w	-32412
	dc.w	-32351
	dc.w	-32285
	dc.w	-32213
	dc.w	-32137
	dc.w	-32057
	dc.w	-31971
	dc.w	-31880
	dc.w	-31785
	dc.w	-31685
	dc.w	-31580
	dc.w	-31470
	dc.w	-31356
	dc.w	-31237
	dc.w	-31113
	dc.w	-30985
	dc.w	-30852
	dc.w	-30714
	dc.w	-30571
	dc.w	-30424
	dc.w	-30273
	dc.w	-30117
	dc.w	-29956
	dc.w	-29791
	dc.w	-29621
	dc.w	-29447
	dc.w	-29268
	dc.w	-29085
	dc.w	-28898
	dc.w	-28706
	dc.w	-28510
	dc.w	-28310
	dc.w	-28105
	dc.w	-27896
	dc.w	-27683
	dc.w	-27466
	dc.w	-27245
	dc.w	-27019
	dc.w	-26790
	dc.w	-26556
	dc.w	-26319
	dc.w	-26077
	dc.w	-25832
	dc.w	-25582
	dc.w	-25329
	dc.w	-25072
	dc.w	-24811
	dc.w	-24547
	dc.w	-24279
	dc.w	-24007
	dc.w	-23731
	dc.w	-23452
	dc.w	-23170
	dc.w	-22884
	dc.w	-22594
	dc.w	-22301
	dc.w	-22005
	dc.w	-21705
	dc.w	-21403
	dc.w	-21096
	dc.w	-20787
	dc.w	-20475
	dc.w	-20159
	dc.w	-19841
	dc.w	-19519
	dc.w	-19195
	dc.w	-18868
	dc.w	-18537
	dc.w	-18204
	dc.w	-17869
	dc.w	-17530
	dc.w	-17189
	dc.w	-16846
	dc.w	-16499
	dc.w	-16151
	dc.w	-15800
	dc.w	-15446
	dc.w	-15090
	dc.w	-14732
	dc.w	-14372
	dc.w	-14010
	dc.w	-13645
	dc.w	-13279
	dc.w	-12910
	dc.w	-12539
	dc.w	-12167
	dc.w	-11793
	dc.w	-11417
	dc.w	-11039
	dc.w	-10659
	dc.w	-10278
	dc.w	-9896
	dc.w	-9512
	dc.w	-9126
	dc.w	-8739
	dc.w	-8351
	dc.w	-7962
	dc.w	-7571
	dc.w	-7179
	dc.w	-6786
	dc.w	-6393
	dc.w	-5998
	dc.w	-5602
	dc.w	-5205
	dc.w	-4808
	dc.w	-4410
	dc.w	-4011
	dc.w	-3612
	dc.w	-3212
	dc.w	-2811
	dc.w	-2410
	dc.w	-2009
	dc.w	-1608
	dc.w	-1206
	dc.w	-804
	dc.w	-402
	dc.w	-0
	dc.w	402
	dc.w	804
	dc.w	1206
	dc.w	1608
	dc.w	2009
	dc.w	2410
	dc.w	2811
	dc.w	3212
	dc.w	3612
	dc.w	4011
	dc.w	4410
	dc.w	4808
	dc.w	5205
	dc.w	5602
	dc.w	5998
	dc.w	6393
	dc.w	6786
	dc.w	7179
	dc.w	7571
	dc.w	7962
	dc.w	8351
	dc.w	8739
	dc.w	9126
	dc.w	9512
	dc.w	9896
	dc.w	10278
	dc.w	10659
	dc.w	11039
	dc.w	11417
	dc.w	11793
	dc.w	12167
	dc.w	12539
	dc.w	12910
	dc.w	13279
	dc.w	13645
	dc.w	14010
	dc.w	14372
	dc.w	14732
	dc.w	15090
	dc.w	15446
	dc.w	15800
	dc.w	16151
	dc.w	16499
	dc.w	16846
	dc.w	17189
	dc.w	17530
	dc.w	17869
	dc.w	18204
	dc.w	18537
	dc.w	18868
	dc.w	19195
	dc.w	19519
	dc.w	19841
	dc.w	20159
	dc.w	20475
	dc.w	20787
	dc.w	21096
	dc.w	21403
	dc.w	21705
	dc.w	22005
	dc.w	22301
	dc.w	22594
	dc.w	22884
	dc.w	23170
	dc.w	23452
	dc.w	23731
	dc.w	24007
	dc.w	24279
	dc.w	24547
	dc.w	24811
	dc.w	25072
	dc.w	25329
	dc.w	25582
	dc.w	25832
	dc.w	26077
	dc.w	26319
	dc.w	26556
	dc.w	26790
	dc.w	27019
	dc.w	27245
	dc.w	27466
	dc.w	27683
	dc.w	27896
	dc.w	28105
	dc.w	28310
	dc.w	28510
	dc.w	28706
	dc.w	28898
	dc.w	29085
	dc.w	29268
	dc.w	29447
	dc.w	29621
	dc.w	29791
	dc.w	29956
	dc.w	30117
	dc.w	30273
	dc.w	30424
	dc.w	30571
	dc.w	30714
	dc.w	30852
	dc.w	30985
	dc.w	31113
	dc.w	31237
	dc.w	31356
	dc.w	31470
	dc.w	31580
	dc.w	31685
	dc.w	31785
	dc.w	31880
	dc.w	31971
	dc.w	32057
	dc.w	32137
	dc.w	32213
	dc.w	32285
	dc.w	32351
	dc.w	32412
	dc.w	32469
	dc.w	32521
	dc.w	32567
	dc.w	32609
	dc.w	32646
	dc.w	32678
	dc.w	32705
	dc.w	32728
	dc.w	32745
	dc.w	32757
	dc.w	32765
