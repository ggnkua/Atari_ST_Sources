	dc.w	100,-54
	dc.w	103,-54
	dc.w	106,-53
	dc.w	110,-52
	dc.w	113,-50
	dc.w	116,-49
	dc.w	119,-47
	dc.w	122,-46
	dc.w	124,-43
	dc.w	127,-42
	dc.w	130,-40
	dc.w	132,-37
	dc.w	135,-35
	dc.w	137,-31
	dc.w	139,-29
	dc.w	141,-25
	dc.w	142,-23
	dc.w	144,-19
	dc.w	145,-16
	dc.w	146,-13
	dc.w	147,-9
	dc.w	148,-6
	dc.w	149,-2
	dc.w	149,2
	dc.w	149,6
	dc.w	149,9
	dc.w	149,13
	dc.w	149,17
	dc.w	148,20
	dc.w	147,24
	dc.w	146,27
	dc.w	145,31
	dc.w	144,34
	dc.w	142,38
	dc.w	141,41
	dc.w	139,45
	dc.w	137,47
	dc.w	135,50
	dc.w	132,53
	dc.w	130,55
	dc.w	127,58
	dc.w	125,60
	dc.w	122,63
	dc.w	119,64
	dc.w	116,66
	dc.w	113,67
	dc.w	110,68
	dc.w	107,70
	dc.w	104,71
	dc.w	101,72
	dc.w	97,72
	dc.w	94,73
	dc.w	91,73
	dc.w	88,72
	dc.w	85,72
	dc.w	82,71
	dc.w	79,71
	dc.w	76,70
	dc.w	73,70
	dc.w	71,68
	dc.w	68,67
	dc.w	66,65
	dc.w	63,63
	dc.w	61,62
	dc.w	59,59
	dc.w	57,58
	dc.w	56,55
	dc.w	54,53
	dc.w	53,50
	dc.w	51,48
	dc.w	50,45
	dc.w	50,42
	dc.w	49,40
	dc.w	48,37
	dc.w	48,35
	dc.w	48,31
	dc.w	48,29
	dc.w	48,26
	dc.w	49,24
	dc.w	50,21
	dc.w	50,17
	dc.w	51,15
	dc.w	53,12
	dc.w	54,11
	dc.w	55,8
	dc.w	57,6
	dc.w	59,4
	dc.w	61,1
	dc.w	63,0
	dc.w	65,-2
	dc.w	68,-3
	dc.w	70,-5
	dc.w	73,-6
	dc.w	75,-7
	dc.w	78,-7
	dc.w	81,-8
	dc.w	83,-9
	dc.w	86,-9
	dc.w	89,-10
	dc.w	92,-9
	dc.w	95,-9
	dc.w	98,-8
	dc.w	101,-8
	dc.w	104,-6
	dc.w	107,-5
	dc.w	109,-4
	dc.w	112,-2
	dc.w	115,-1
	dc.w	117,1
	dc.w	120,3
	dc.w	122,6
	dc.w	124,8
	dc.w	126,10
	dc.w	128,13
	dc.w	130,16
	dc.w	132,19
	dc.w	133,22
	dc.w	135,26
	dc.w	136,29
	dc.w	137,33
	dc.w	138,36
	dc.w	139,39
	dc.w	139,43
	dc.w	140,46
	dc.w	140,50
	dc.w	140,54
	dc.w	140,58
	dc.w	139,61
	dc.w	139,64
	dc.w	138,68
	dc.w	137,72
	dc.w	136,76
	dc.w	135,79
	dc.w	133,82
	dc.w	132,85
	dc.w	130,88
	dc.w	128,91
	dc.w	126,94
	dc.w	124,97
	dc.w	122,99
	dc.w	120,102
	dc.w	117,104
	dc.w	115,106
	dc.w	112,108
	dc.w	110,109
	dc.w	107,111
	dc.w	104,112
	dc.w	101,114
	dc.w	98,115
	dc.w	96,116
	dc.w	93,116
	dc.w	90,116
	dc.w	87,117
	dc.w	84,116
	dc.w	81,116
	dc.w	79,115
	dc.w	76,115
	dc.w	74,114
	dc.w	71,113
	dc.w	69,112
	dc.w	66,110
	dc.w	64,109
	dc.w	62,107
	dc.w	60,106
	dc.w	58,103
	dc.w	56,101
	dc.w	55,99
	dc.w	53,96
	dc.w	52,95
	dc.w	51,92
	dc.w	50,90
	dc.w	49,87
	dc.w	49,83
	dc.w	48,81
	dc.w	48,78
	dc.w	48,76
	dc.w	48,73
	dc.w	48,71
	dc.w	49,67
	dc.w	49,64
	dc.w	50,62
	dc.w	51,59
	dc.w	52,57
	dc.w	53,54
	dc.w	55,53
	dc.w	56,50
	dc.w	58,47
	dc.w	60,46
	dc.w	62,44
	dc.w	64,43
	dc.w	66,41
	dc.w	68,40
	dc.w	70,38
	dc.w	73,37
	dc.w	75,37
	dc.w	78,36
	dc.w	80,36
	dc.w	83,35
	dc.w	85,34
	dc.w	88,35
	dc.w	91,35
	dc.w	93,36
	dc.w	96,36
	dc.w	98,38
	dc.w	101,39
	dc.w	103,40
	dc.w	106,42
	dc.w	108,43
	dc.w	111,45
	dc.w	113,47
	dc.w	115,50
	dc.w	117,52
	dc.w	119,54
	dc.w	121,57
	dc.w	122,60
	dc.w	124,63
	dc.w	125,66
	dc.w	127,69
	dc.w	128,72
	dc.w	129,75
	dc.w	129,79
	dc.w	130,82
	dc.w	131,87
	dc.w	131,90
	dc.w	131,93
	dc.w	131,97
	dc.w	131,100
	dc.w	131,105
	dc.w	130,108
	dc.w	129,111
	dc.w	129,115
	dc.w	128,118
	dc.w	127,122
	dc.w	125,125
	dc.w	124,128
	dc.w	122,131
	dc.w	121,134
	dc.w	119,137
	dc.w	117,139
	dc.w	115,142
	dc.w	113,144
	dc.w	111,146
	dc.w	108,149
	dc.w	106,150
	dc.w	104,152
	dc.w	101,154
	dc.w	99,155
	dc.w	96,156
	dc.w	94,157
	dc.w	91,158
	dc.w	88,158
	dc.w	86,159
	dc.w	83,159
	dc.w	81,158
	dc.w	78,158
	dc.w	76,158
	dc.w	73,157
	dc.w	71,156
	dc.w	69,155
	dc.w	67,154
	dc.w	65,152
	dc.w	63,151
	dc.w	61,149
	dc.w	59,147
	dc.w	57,146
	dc.w	56,143
	dc.w	54,141
	dc.w	53,139
	dc.w	52,137
	dc.w	51,134
	dc.w	50,131
	dc.w	49,129
	dc.w	49,126
	dc.w	48,124
	dc.w	48,121
	dc.w	48,117
	dc.w	48,115
	dc.w	48,112
	dc.w	49,110
	dc.w	49,107
	dc.w	50,104
	dc.w	51,102
	dc.w	52,99
	dc.w	53,97
	dc.w	54,94
	dc.w	55,92
	dc.w	57,90
	dc.w	59,88
	dc.w	60,87
	dc.w	62,85
	dc.w	64,83
	dc.w	66,82
	dc.w	68,80
	dc.w	70,80
	dc.w	72,79
	dc.w	75,77
	dc.w	77,78
	dc.w	79,77
	dc.w	82,77
	dc.w	84,77
	dc.w	87,77
	dc.w	89,78
	dc.w	91,78
	dc.w	94,80
	dc.w	96,81
	dc.w	98,82
	dc.w	100,84
	dc.w	103,85
	dc.w	105,87
	dc.w	107,89
	dc.w	109,91
	dc.w	110,94
	dc.w	112,96
	dc.w	114,98
	dc.w	115,101
	dc.w	117,104
	dc.w	118,108
	dc.w	119,110
	dc.w	120,113
	dc.w	121,117
	dc.w	122,120
	dc.w	122,124
	dc.w	123,127
	dc.w	123,130
	dc.w	123,134
	dc.w	123,138
	dc.w	123,142
	dc.w	123,145
	dc.w	122,148
	dc.w	122,152
	dc.w	121,155
	dc.w	120,158
	dc.w	119,162
	dc.w	118,165
	dc.w	117,169
	dc.w	115,171
	dc.w	114,174
	dc.w	112,177
	dc.w	110,179
	dc.w	109,182
	dc.w	107,184
	dc.w	105,186
	dc.w	103,189
	dc.w	101,190
	dc.w	98,191
	dc.w	96,194
	dc.w	94,194
	dc.w	92,196
	dc.w	89,197
	dc.w	87,197
	dc.w	85,198
	dc.w	82,198
	dc.w	80,199
	dc.w	78,198
	dc.w	75,197
	dc.w	73,198
	dc.w	71,196
	dc.w	69,195
	dc.w	67,195
	dc.w	65,193
	dc.w	63,192
	dc.w	61,190
	dc.w	59,188
	dc.w	58,187
	dc.w	56,185
	dc.w	55,182
	dc.w	54,181
	dc.w	52,178
	dc.w	51,176
	dc.w	51,173
	dc.w	50,170
	dc.w	49,168
	dc.w	49,165
	dc.w	48,162
	dc.w	48,160
	dc.w	48,157
	dc.w	48,155
	dc.w	48,152
	dc.w	49,149
	dc.w	49,146
	dc.w	50,143
	dc.w	50,141
	dc.w	51,139
	dc.w	52,136
	dc.w	54,133
	dc.w	55,132
	dc.w	56,129
	dc.w	58,128
	dc.w	59,126
	dc.w	61,123
	dc.w	63,123
	dc.w	64,121
	dc.w	66,119
	dc.w	68,119
	dc.w	70,118
	dc.w	72,116
	dc.w	74,117
	dc.w	76,116
	dc.w	79,116
	dc.w	81,116
	dc.w	83,116
	dc.w	85,117
	dc.w	87,117
	dc.w	89,118
	dc.w	91,120
	dc.w	93,121
	dc.w	95,122
	dc.w	97,124
	dc.w	99,125
	dc.w	101,128
	dc.w	103,130
	dc.w	104,132
	dc.w	106,135
	dc.w	107,137
	dc.w	109,139
	dc.w	110,143
	dc.w	111,145
	dc.w	112,148
	dc.w	113,152
	dc.w	114,155
	dc.w	115,158
	dc.w	115,162
	dc.w	116,165
	dc.w	116,169
	dc.w	116,172
	dc.w	116,175
	dc.w	116,179
	dc.w	116,182
	dc.w	115,186
	dc.w	115,190
	dc.w	114,193
	dc.w	113,196
	dc.w	112,199
	dc.w	111,202
