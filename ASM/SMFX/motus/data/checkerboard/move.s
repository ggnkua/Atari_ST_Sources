	dc.w	 0,0
	dc.w	 0,0
	dc.w	 0,0
	dc.w	 0,0
	dc.w	 0,0
	dc.w	 0,0
	dc.w	 0,0
	dc.w	 0,0
	dc.w	 0,0
	dc.w	 0,0
	dc.w	 0,0
	dc.w	 0,0
	dc.w	 0,0
	dc.w	 0,0
	dc.w	 0,0
	dc.w	 0,0
	dc.w	 0,0
	dc.w	 0,0
	dc.w	 0,0
;	dc.w	0*8,0*8
;	dc.w	1*8,0*8
;	dc.w	5*8,0*8
	dc.w	11*8,0*8
	dc.w	17*8,0*8
	dc.w	24*8,0*8
	dc.w	30*8,0*8
	dc.w	34*8,0*8
	dc.w	35*8,0*8
	dc.w	32*8,0*8
	dc.w	25*8,0*8
	dc.w	14*8,0*8
	dc.w	0*8,0*8
	dc.w	-17*8,0*8
	dc.w	-35*8,1*8
	dc.w	-53*8,5*8
	dc.w	-69*8,11*8
	dc.w	-82*8,17*8
	dc.w	-90*8,24*8
	dc.w	-92*8,30*8
	dc.w	-87*8,35*8
	dc.w	-74*8,40*8
	dc.w	-55*8,42*8
	dc.w	-30*8,35*8
	dc.w	-0*8,27*8
	dc.w	32*8,20*8
	dc.w	65*8,14*8
	dc.w	95*8,9*8
	dc.w	113*8,5*8
	dc.w	99*8,-15*8
	dc.w	81*8,-32*8
	dc.w	59*8,-43*8
	dc.w	36*8,-49*8
	dc.w	12*8,-49*8
	dc.w	-11*8,-43*8
	dc.w	-32*8,-32*8
	dc.w	-49*8,-17*8
	dc.w	-61*8,3*8
	dc.w	-68*8,24*8
	dc.w	-70*8,47*8
	dc.w	-66*8,68*8
	dc.w	-56*8,88*8
	dc.w	-42*8,105*8
	dc.w	-24*8,117*8
	dc.w	-3*8,125*8
	dc.w	18*8,126*8
	dc.w	40*8,123*8
	dc.w	59*8,114*8
	dc.w	76*8,100*8
	dc.w	89*8,83*8
	dc.w	98*8,63*8
	dc.w	101*8,41*8
	dc.w	99*8,19*8
	dc.w	91*8,-1*8
	dc.w	79*8,-19*8
	dc.w	63*8,-34*8
	dc.w	44*8,-44*8
	dc.w	23*8,-49*8
	dc.w	2*8,-49*8
	dc.w	-18*8,-44*8
	dc.w	-36*8,-34*8
	dc.w	-51*8,-20*8
	dc.w	-62*8,-3*8
	dc.w	-69*8,16*8
	dc.w	-70*8,35*8
	dc.w	-66*8,54*8
	dc.w	-58*8,72*8
	dc.w	-45*8,87*8
	dc.w	-29*8,98*8
	dc.w	-11*8,104*8
	dc.w	8*8,106*8
	dc.w	27*8,102*8
	dc.w	44*8,95*8
	dc.w	59*8,83*8
	dc.w	71*8,67*8
	dc.w	78*8,49*8
	dc.w	81*8,30*8
	dc.w	79*8,11*8
	dc.w	72*8,-7*8
	dc.w	62*8,-23*8
	dc.w	48*8,-36*8
	dc.w	31*8,-45*8
	dc.w	12*8,-49*8
	dc.w	-6*8,-49*8
	dc.w	-24*8,-45*8
	dc.w	-40*8,-36*8
	dc.w	-54*8,-24*8

	dc.w	-63*8,-9*8




	dc.w	-69*8,8*8
	dc.w	-70*8,25*8
	dc.w	-67*8,42*8
	dc.w	-59*8,58*8
	dc.w	-48*8,71*8
	dc.w	-34*8,80*8
	dc.w	-18*8,86*8
	dc.w	-1*8,87*8
	dc.w	15*8,84*8
	dc.w	31*8,78*8
	dc.w	44*8,67*8
	dc.w	54*8,55*8
	dc.w	61*8,41*8
	dc.w	63*8,37*8
	dc.w	61*8,26*8
	dc.w	56*8,19*8
	dc.w	46*8,14*8
	dc.w	34*8,11*8
	dc.w	19*8,7*8
	dc.w	7*8,4*8
	dc.w	0,0
	dc.w	0,0
	dc.w	0,0
	dc.w	0,0
	dc.w	0,0
	dc.w	0,0
	dc.w	0,0
	dc.w	0,0
	dc.w	0,0
	dc.w	0,0
	dc.w	0,0
	dc.w	0,0







	dc.w	-69*8,1*8
	dc.w	-70*8,16*8
	dc.w	-67*8,31*8
	dc.w	-60*8,45*8
	dc.w	-51*8,56*8
	dc.w	-38*8,65*8
	dc.w	-24*8,70*8
	dc.w	-9*8,71*8
	dc.w	5*8,69*8
	dc.w	19*8,63*8
	dc.w	31*8,53*8
	dc.w	40*8,41*8
	dc.w	45*8,27*8
	dc.w	47*8,12*8
	dc.w	46*8,-2*8
	dc.w	41*8,-17*8
	dc.w	33*8,-29*8
	dc.w	21*8,-39*8
	dc.w	8*8,-46*8
	dc.w	-6*8,-50*8
	dc.w	-20*8,-50*8
	dc.w	-34*8,-46*8
	dc.w	-47*8,-39*8
	dc.w	-57*8,-30*8
	dc.w	-65*8,-18*8
	dc.w	-69*8,-5*8
	dc.w	-70*8,9*8
	dc.w	-67*8,22*8
	dc.w	-62*8,34*8
	dc.w	-53*8,44*8
	dc.w	-42*8,51*8
	dc.w	-30*8,56*8
	dc.w	-17*8,57*8
	dc.w	-4*8,55*8
	dc.w	8*8,49*8
	dc.w	19*8,41*8
	dc.w	27*8,30*8
	dc.w	32*8,18*8
	dc.w	34*8,5*8
	dc.w	32*8,-8*8
	dc.w	28*8,-21*8
	dc.w	20*8,-31*8
	dc.w	11*8,-40*8
	dc.w	-1*8,-46*8
	dc.w	-13*8,-50*8
	dc.w	-26*8,-50*8
	dc.w	-39*8,-47*8
	dc.w	-50*8,-41*8
	dc.w	-59*8,-32*8
	dc.w	-65*8,-22*8
	dc.w	-69*8,-10*8
	dc.w	-70*8,2*8
	dc.w	-68*8,13*8
	dc.w	-63*8,24*8
	dc.w	-55*8,33*8
	dc.w	-45*8,39*8
	dc.w	-34*8,43*8
	dc.w	-23*8,44*8
	dc.w	-11*8,42*8
	dc.w	-1*8,38*8
	dc.w	8*8,30*8
	dc.w	15*8,21*8
	dc.w	20*8,10*8
	dc.w	21*8,-1*8
	dc.w	20*8,-13*8
	dc.w	16*8,-24*8
	dc.w	10*8,-34*8
	dc.w	1*8,-41*8
	dc.w	-9*8,-47*8
	dc.w	-20*8,-50*8
	dc.w	-31*8,-50*8
	dc.w	-42*8,-47*8
	dc.w	-52*8,-42*8
	dc.w	-60*8,-34*8
	dc.w	-66*8,-25*8
	dc.w	-69*8,-15*8
	dc.w	-70*8,-4*8
	dc.w	-68*8,6*8
	dc.w	-63*8,15*8
	dc.w	-57*8,23*8
	dc.w	-48*8,29*8
	dc.w	-39*8,32*8
	dc.w	-28*8,33*8
	dc.w	-18*8,31*8
	dc.w	-9*8,27*8
	dc.w	-1*8,21*8
	dc.w	5*8,13*8
	dc.w	9*8,3*8
	dc.w	11*8,-7*8
	dc.w	10*8,-17*8
	dc.w	6*8,-27*8
	dc.w	0*8,-36*8
	dc.w	-7*8,-42*8
	dc.w	-16*8,-47*8
	dc.w	-26*8,-50*8
	dc.w	-36*8,-50*8
	dc.w	-45*8,-47*8
	dc.w	-54*8,-43*8
	dc.w	-61*8,-36*8
	dc.w	-66*8,-28*8
	dc.w	-69*8,-19*8
	dc.w	-70*8,-10*8
	dc.w	-68*8,-1*8
	dc.w	-64*8,7*8
	dc.w	-58*8,14*8
	dc.w	-51*8,20*8
	dc.w	-42*8,23*8
	dc.w	-33*8,23*8
	dc.w	-24*8,22*8
	dc.w	-16*8,18*8
	dc.w	-9*8,12*8
	dc.w	-4*8,5*8
	dc.w	0*8,-3*8
	dc.w	1*8,-12*8
	dc.w	0*8,-21*8
	dc.w	-3*8,-30*8
	dc.w	-8*8,-37*8
	dc.w	-15*8,-43*8
	dc.w	-22*8,-48*8
	dc.w	-31*8,-50*8
	dc.w	-40*8,-50*8
	dc.w	-48*8,-48*8
	dc.w	-56*8,-43*8
	dc.w	-62*8,-38*8
	dc.w	-67*8,-31*8
	dc.w	-69*8,-23*8
	dc.w	-70*8,-15*8
	dc.w	-68*8,-7*8
	dc.w	-65*8,1*8
	dc.w	-60*8,7*8
	dc.w	-53*8,11*8
	dc.w	-46*8,14*8
	dc.w	-38*8,15*8
	dc.w	-30*8,13*8
	dc.w	-23*8,10*8
	dc.w	-16*8,5*8
	dc.w	-11*8,-1*8
	dc.w	-8*8,-9*8
	dc.w	-7*8,-17*8
	dc.w	-8*8,-25*8
	dc.w	-11*8,-32*8
	dc.w	-15*8,-39*8
	dc.w	-21*8,-44*8
	dc.w	-28*8,-48*8
	dc.w	-36*8,-50*8
	dc.w	-43*8,-50*8
	dc.w	-51*8,-48*8
	dc.w	-58*8,-44*8
	dc.w	-63*8,-39*8
	dc.w	-67*8,-33*8
	dc.w	-69*8,-26*8
	dc.w	-70*8,-19*8
	dc.w	-69*8,-12*8
	dc.w	-65*8,-5*8
	dc.w	-61*8,0*8
	dc.w	-55*8,4*8
	dc.w	-48*8,7*8
	dc.w	-41*8,7*8
	dc.w	-35*8,6*8
	dc.w	-28*8,3*8
	dc.w	-23*8,-1*8
	dc.w	-18*8,-7*8
	dc.w	-16*8,-14*8
	dc.w	-15*8,-21*8
	dc.w	-15*8,-28*8
	dc.w	-18*8,-34*8
	dc.w	-22*8,-40*8
	dc.w	-27*8,-45*8
	dc.w	-33*8,-48*8
	dc.w	-40*8,-50*8
	dc.w	-47*8,-50*8
	dc.w	-53*8,-48*8
	dc.w	-59*8,-45*8
	dc.w	-64*8,-40*8
	dc.w	-68*8,-35*8
	dc.w	-70*8,-29*8
	dc.w	-70*8,-22*8
	dc.w	-69*8,-16*8
	dc.w	-66*8,-11*8
	dc.w	-62*8,-6*8
	dc.w	-57*8,-2*8
	dc.w	-51*8,0*8
	dc.w	-45*8,0*8
	dc.w	-39*8,-1*8
	dc.w	-33*8,-3*8
	dc.w	-28*8,-7*8
	dc.w	-24*8,-12*8
	dc.w	-22*8,-18*8
	dc.w	-21*8,-24*8
	dc.w	-22*8,-30*8
	dc.w	-24*8,-36*8
	dc.w	-27*8,-41*8
	dc.w	-32*8,-45*8
	dc.w	-37*8,-48*8
	dc.w	-43*8,-50*8
	dc.w	-49*8,-50*8
	dc.w	-55*8,-48*8
	dc.w	-60*8,-46*8
	dc.w	-65*8,-42*8
	dc.w	-68*8,-37*8
	dc.w	-70*8,-31*8
	dc.w	-70*8,-26*8
	dc.w	-69*8,-20*8
	dc.w	-66*8,-15*8
	dc.w	-63*8,-11*8
	dc.w	-58*8,-8*8
	dc.w	-53*8,-6*8
	dc.w	-48*8,-6*8
	dc.w	-42*8,-6*8
	dc.w	-37*8,-9*8
	dc.w	-33*8,-12*8
	dc.w	-30*8,-17*8
	dc.w	-28*8,-22*8
	dc.w	-27*8,-27*8
	dc.w	-27*8,-33*8
	dc.w	-29*8,-38*8
	dc.w	-32*8,-42*8
	dc.w	-36*8,-46*8
	dc.w	-41*8,-49*8
	dc.w	-46*8,-50*8
	dc.w	-52*8,-50*8
	dc.w	-57*8,-49*8
	dc.w	-62*8,-46*8
	dc.w	-65*8,-43*8
	dc.w	-68*8,-38*8
	dc.w	-70*8,-33*8
	dc.w	-70*8,-29*8
	dc.w	-69*8,-24*8
	dc.w	-67*8,-19*8
	dc.w	-64*8,-16*8
	dc.w	-60*8,-13*8
	dc.w	-55*8,-11*8
	dc.w	-50*8,-11*8
	dc.w	-46*8,-12*8
	dc.w	-41*8,-14*8
	dc.w	-37*8,-17*8
	dc.w	-35*8,-20*8
	dc.w	-33*8,-25*8
	dc.w	-32*8,-30*8
	dc.w	-32*8,-35*8
	dc.w	-34*8,-39*8
	dc.w	-37*8,-43*8
	dc.w	-40*8,-46*8
	dc.w	-45*8,-49*8
	dc.w	-49*8,-50*8
	dc.w	-54*8,-50*8
	dc.w	-58*8,-49*8
	dc.w	-63*8,-47*8
	dc.w	-66*8,-43*8
	dc.w	-68*8,-40*8
	dc.w	-70*8,-35*8
	dc.w	-70*8,-31*8
	dc.w	-69*8,-27*8
	dc.w	-67*8,-23*8
	dc.w	-64*8,-20*8
	dc.w	-61*8,-17*8
	dc.w	-57*8,-16*8
	dc.w	-53*8,-15*8
	dc.w	-49*8,-16*8
	dc.w	-45*8,-18*8
	dc.w	-41*8,-21*8
	dc.w	-39*8,-24*8
	dc.w	-37*8,-28*8
	dc.w	-36*8,-32*8
	dc.w	-37*8,-36*8
	dc.w	-38*8,-40*8
	dc.w	-41*8,-44*8
	dc.w	-44*8,-47*8
	dc.w	-48*8,-49*8
	dc.w	-52*8,-50*8
	dc.w	-56*8,-50*8
	dc.w	-60*8,-49*8
	dc.w	-63*8,-47*8
	dc.w	-66*8,-44*8
	dc.w	-68*8,-41*8
	dc.w	-70*8,-37*8
	dc.w	-70*8,-33*8
	dc.w	-69*8,-30*8
	dc.w	-68*8,-26*8
	dc.w	-65*8,-23*8
	dc.w	-62*8,-21*8
	dc.w	-58*8,-20*8
	dc.w	-55*8,-19*8
	dc.w	-51*8,-20*8
	dc.w	-48*8,-22*8
	dc.w	-45*8,-24*8
	dc.w	-42*8,-27*8
	dc.w	-41*8,-31*8
	dc.w	-40*8,-34*8
	dc.w	-41*8,-38*8
	dc.w	-42*8,-42*8
	dc.w	-44*8,-45*8
	dc.w	-47*8,-47*8
	dc.w	-50*8,-49*8
	dc.w	-54*8,-50*8
	dc.w	-57*8,-50*8
	dc.w	-61*8,-49*8
	dc.w	-64*8,-47*8
	dc.w	-67*8,-45*8
	dc.w	-69*8,-42*8
	dc.w	-70*8,-39*8
	dc.w	-70*8,-35*8
	dc.w	-69*8,-32*8
	dc.w	-68*8,-29*8
	dc.w	-66*8,-26*8
	dc.w	-63*8,-24*8
	dc.w	-60*8,-23*8
	dc.w	-57*8,-23*8
	dc.w	-53*8,-24*8
	dc.w	-50*8,-25*8
	dc.w	-48*8,-27*8
	dc.w	-46*8,-30*8
	dc.w	-44*8,-33*8
	dc.w	-44*8,-36*8
	dc.w	-44*8,-39*8
	dc.w	-45*8,-43*8
	dc.w	-47*8,-45*8
	dc.w	-50*8,-48*8
	dc.w	-53*8,-49*8
	dc.w	-56*8,-50*8
	dc.w	-59*8,-50*8
	dc.w	-62*8,-49*8
	dc.w	-65*8,-48*8
	dc.w	-67*8,-45*8
	dc.w	-69*8,-43*8
	dc.w	-70*8,-40*8
	dc.w	-70*8,-37*8
	dc.w	-69*8,-34*8
	dc.w	-68*8,-31*8
	dc.w	-66*8,-29*8
	dc.w	-64*8,-27*8
	dc.w	-61*8,-26*8
	dc.w	-58*8,-26*8
	dc.w	-55*8,-27*8
	dc.w	-53*8,-28*8
	dc.w	-50*8,-30*8
	dc.w	-49*8,-32*8
	dc.w	-47*8,-35*8
	dc.w	-47*8,-38*8
	dc.w	-47*8,-41*8
	dc.w	-48*8,-43*8
	dc.w	-50*8,-46*8
	dc.w	-52*8,-48*8
	dc.w	-55*8,-49*8
	dc.w	-57*8,-50*8
	dc.w	-60*8,-50*8
	dc.w	-63*8,-49*8
	dc.w	-65*8,-48*8
	dc.w	-67*8,-46*8
	dc.w	-69*8,-44*8
	dc.w	-70*8,-41*8
	dc.w	-70*8,-39*8
	dc.w	-69*8,-36*8
	dc.w	-68*8,-34*8
	dc.w	-67*8,-32*8
	dc.w	-65*8,-30*8
	dc.w	-62*8,-29*8
	dc.w	-60*8,-29*8
	dc.w	-57*8,-29*8
	dc.w	-55*8,-31*8
	dc.w	-53*8,-32*8
	dc.w	-51*8,-34*8
	dc.w	-50*8,-37*8
	dc.w	-50*8,-39*8
	dc.w	-50*8,-42*8
	dc.w	-51*8,-44*8
	dc.w	-52*8,-46*8
	dc.w	-54*8,-48*8
	dc.w	-56*8,-49*8
	dc.w	-59*8,-50*8
	dc.w	-61*8,-50*8
	dc.w	-64*8,-49*8
	dc.w	-66*8,-48*8
	dc.w	-68*8,-46*8
	dc.w	-69*8,-44*8
	dc.w	-70*8,-42*8
	dc.w	-70*8,-40*8
	dc.w	-70*8,-38*8
	dc.w	-69*8,-36*8
	dc.w	-67*8,-34*8
	dc.w	-65*8,-32*8
	dc.w	-63*8,-32*8
	dc.w	-61*8,-32*8
	dc.w	-59*8,-32*8
	dc.w	-56*8,-33*8
	dc.w	-55*8,-34*8
	dc.w	-53*8,-36*8
	dc.w	-52*8,-38*8
	dc.w	-52*8,-40*8
	dc.w	-52*8,-43*8
	dc.w	-53*8,-45*8
	dc.w	-54*8,-47*8
	dc.w	-56*8,-48*8
	dc.w	-58*8,-49*8
	dc.w	-60*8,-50*8
	dc.w	-62*8,-50*8
	dc.w	-65*8,-49*8
	dc.w	-66*8,-48*8
	dc.w	-68*8,-47*8
	dc.w	-69*8,-45*8
	dc.w	-70*8,-43*8
	dc.w	-70*8,-41*8
	dc.w	-70*8,-39*8
	dc.w	-69*8,-37*8
	dc.w	-67*8,-36*8
	dc.w	-66*8,-35*8
	dc.w	-64*8,-34*8
