
	dc.w	1
	dc.w	1
	dc.w	2
	dc.w	2
	dc.w	3
	dc.w	4
	dc.w	5
	dc.w	7
	dc.w	8
	dc.w	10
	dc.w	11
	dc.w	13
	dc.w	15
	dc.w	17
	dc.w	19
	dc.w	22
	dc.w	24
	dc.w	27
	dc.w	29
	dc.w	32
	dc.w	35
	dc.w	38
	dc.w	42
	dc.w	45
	dc.w	49
	dc.w	52
	dc.w	56
	dc.w	60
	dc.w	64
	dc.w	68
	dc.w	73
	dc.w	77
	dc.w	82
	dc.w	86
	dc.w	91
	dc.w	96
	dc.w	101
	dc.w	107
	dc.w	112
	dc.w	118
	dc.w	123
	dc.w	129
	dc.w	135
	dc.w	141
	dc.w	147
	dc.w	154
	dc.w	160
	dc.w	167
	dc.w	173
	dc.w	180
	dc.w	187
	dc.w	194
	dc.w	200
	dc.w	199
	dc.w	199
	dc.w	198
	dc.w	197
	dc.w	197
	dc.w	196
	dc.w	195
	dc.w	195
	dc.w	194
	dc.w	193
	dc.w	193
	dc.w	194	
	dc.w	195	
	dc.w	196	
	dc.w	198
	dc.w	200
	dc.w	200
	dc.w	200
	dc.w	200
	dc.w	200
	dc.w	200

