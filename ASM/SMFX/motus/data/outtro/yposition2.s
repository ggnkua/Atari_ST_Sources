	dc.w	0*160
	dc.w	0*160
	dc.w	1*160
	dc.w	1*160
	dc.w	2*160
	dc.w	4*160
	dc.w	6*160
	dc.w	8*160
	dc.w	10*160
	dc.w	12*160
	dc.w	15*160
	dc.w	19*160
	dc.w	22*160
	dc.w	26*160
	dc.w	30*160
	dc.w	35*160
	dc.w	39*160
	dc.w	44*160
	dc.w	50*160
	dc.w	56*160
	dc.w	62*160
	dc.w	68*160
	dc.w	74*160
	dc.w	81*160
	dc.w	89*160
	dc.w	81*160
	dc.w	74*160
	dc.w	68*160
	dc.w	62*160
	dc.w	56*160
	dc.w	50*160
	dc.w	44*160
	dc.w	39*160
	dc.w	35*160
	dc.w	30*160
	dc.w	26*160
	dc.w	22*160
	dc.w	19*160
	dc.w	15*160
	dc.w	12*160
	dc.w	10*160
	dc.w	8*160
	dc.w	6*160
	dc.w	4*160
	dc.w	2*160
	dc.w	1*160
	dc.w	1*160
	dc.w	0*160
	dc.w	0*160
	dc.w	0*160
	dc.w	0*160
	dc.w	0*160
	dc.w	0*160
