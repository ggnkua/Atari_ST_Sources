	dc.l	185*160
	dc.l	182*160
	dc.l	178*160
	dc.l	175*160
	dc.l	172*160
	dc.l	169*160
	dc.l	166*160
	dc.l	162*160
	dc.l	159*160
	dc.l	156*160
	dc.l	153*160
	dc.l	150*160
	dc.l	147*160
	dc.l	144*160
	dc.l	141*160
	dc.l	138*160
	dc.l	135*160
	dc.l	132*160
	dc.l	130*160
	dc.l	127*160
	dc.l	124*160
	dc.l	121*160
	dc.l	118*160
	dc.l	116*160
	dc.l	113*160
	dc.l	110*160
	dc.l	108*160
	dc.l	105*160
	dc.l	103*160
	dc.l	100*160
	dc.l	98*160
	dc.l	95*160
	dc.l	93*160
	dc.l	90*160
	dc.l	88*160
	dc.l	85*160
	dc.l	83*160
	dc.l	81*160
	dc.l	78*160
	dc.l	76*160
	dc.l	74*160
	dc.l	72*160
	dc.l	70*160
	dc.l	67*160
	dc.l	65*160
	dc.l	63*160
	dc.l	61*160
	dc.l	59*160
	dc.l	57*160
	dc.l	55*160
	dc.l	53*160
	dc.l	51*160
	dc.l	49*160
	dc.l	47*160
	dc.l	46*160
	dc.l	44*160
	dc.l	42*160
	dc.l	40*160
	dc.l	38*160
	dc.l	37*160
	dc.l	35*160
	dc.l	33*160
	dc.l	32*160
	dc.l	30*160
	dc.l	29*160
	dc.l	27*160
	dc.l	26*160
	dc.l	24*160
	dc.l	23*160
	dc.l	21*160
	dc.l	20*160
	dc.l	18*160
	dc.l	17*160
	dc.l	16*160
	dc.l	14*160
	dc.l	13*160
	dc.l	12*160
	dc.l	11*160
	dc.l	10*160
	dc.l	8*160
	dc.l	7*160
	dc.l	6*160
	dc.l	5*160
	dc.l	4*160
	dc.l	3*160
	dc.l	2*160
	dc.l	1*160
	dc.l	0*160
	dc.l	-1*160
	dc.l	-2*160
	dc.l	-2*160
	dc.l	-3*160
	dc.l	-4*160
	dc.l	-5*160
	dc.l	-6*160
	dc.l	-6*160
	dc.l	-7*160
	dc.l	-8*160
	dc.l	-8*160
	dc.l	-9*160
	dc.l	-9*160
	dc.l	-10*160
	dc.l	-10*160
	dc.l	-11*160
	dc.l	-11*160
	dc.l	-12*160
	dc.l	-12*160
	dc.l	-13*160
	dc.l	-13*160
	dc.l	-13*160
	dc.l	-14*160
	dc.l	-14*160
	dc.l	-14*160
	dc.l	-14*160
	dc.l	-14*160
	dc.l	-15*160
	dc.l	-15*160
	dc.l	-15*160
	dc.l	-15*160
	dc.l	-15*160
	dc.l	-15*160
	dc.l	-15*160
	dc.l	-15*160
	dc.l	-15*160
	dc.l	-15*160
	dc.l	-15*160
	dc.l	-14*160
	dc.l	-14*160
	dc.l	-14*160
	dc.l	-14*160
	dc.l	-14*160
	dc.l	-13*160
	dc.l	-13*160
	dc.l	-13*160
	dc.l	-12*160
	dc.l	-12*160
	dc.l	-11*160
	dc.l	-11*160
	dc.l	-10*160
	dc.l	-10*160
	dc.l	-9*160
	dc.l	-9*160
	dc.l	-8*160
	dc.l	-8*160
	dc.l	-7*160
	dc.l	-6*160
	dc.l	-6*160
	dc.l	-5*160
	dc.l	-4*160
	dc.l	-3*160
	dc.l	-2*160
	dc.l	-2*160
	dc.l	-1*160
	dc.l	0*160
	dc.l	1*160
	dc.l	2*160
	dc.l	3*160
	dc.l	4*160
	dc.l	5*160
	dc.l	6*160
	dc.l	7*160
	dc.l	8*160
	dc.l	10*160
	dc.l	11*160
	dc.l	12*160
	dc.l	13*160
	dc.l	14*160
	dc.l	16*160
	dc.l	17*160
	dc.l	18*160
	dc.l	20*160
	dc.l	21*160
	dc.l	23*160
	dc.l	24*160
	dc.l	26*160
	dc.l	27*160
	dc.l	29*160
	dc.l	30*160
	dc.l	32*160
	dc.l	33*160
	dc.l	35*160
	dc.l	37*160
	dc.l	38*160
	dc.l	40*160
	dc.l	42*160
	dc.l	44*160
	dc.l	46*160
	dc.l	47*160
	dc.l	49*160
	dc.l	51*160
	dc.l	53*160
	dc.l	55*160
	dc.l	57*160
	dc.l	59*160
	dc.l	61*160
	dc.l	63*160
	dc.l	65*160
	dc.l	67*160
	dc.l	70*160
	dc.l	72*160
	dc.l	74*160
	dc.l	76*160
	dc.l	78*160
	dc.l	81*160
	dc.l	83*160
	dc.l	85*160
	dc.l	88*160
	dc.l	90*160
	dc.l	93*160
	dc.l	95*160
	dc.l	98*160
	dc.l	100*160
	dc.l	103*160
	dc.l	105*160
	dc.l	108*160
	dc.l	110*160
	dc.l	113*160
	dc.l	116*160
	dc.l	118*160
	dc.l	121*160
	dc.l	124*160
	dc.l	127*160
	dc.l	130*160
	dc.l	132*160
	dc.l	135*160
	dc.l	138*160
	dc.l	141*160
	dc.l	144*160
	dc.l	147*160
	dc.l	150*160
	dc.l	153*160
	dc.l	156*160
	dc.l	159*160
	dc.l	162*160
	dc.l	166*160
	dc.l	169*160
	dc.l	172*160
	dc.l	175*160
	dc.l	178*160
	dc.l	182*160
