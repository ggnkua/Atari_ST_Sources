	REPT 5
		dc.w	39<<7
	ENDR

;	dc.w	34<<7
;	dc.w	35<<7
;	dc.w	36<<7
;	dc.w	37<<7
;	dc.w	38<<7
	dc.w	39<<7
	dc.w	40<<7
	dc.w	41<<7
	dc.w	42<<7
	dc.w	43<<7
	dc.w	44<<7
	dc.w	45<<7
	dc.w	46<<7
	dc.w	47<<7
	dc.w	48<<7
	dc.w	49<<7
	dc.w	50<<7
	dc.w	51<<7
	dc.w	52<<7
	dc.w	53<<7
	dc.w	54<<7
	dc.w	55<<7
	dc.w	56<<7
	dc.w	57<<7
	dc.w	58<<7
	dc.w	59<<7
	dc.w	60<<7
	dc.w	61<<7
	dc.w	62<<7
	dc.w	63<<7
	dc.w	64<<7
	dc.w	65<<7
	dc.w	66<<7
	dc.w	66<<7
	dc.w	67<<7
	dc.w	68<<7
	dc.w	69<<7
	dc.w	70<<7
	dc.w	71<<7
	dc.w	72<<7
	dc.w	73<<7
	dc.w	74<<7
	dc.w	75<<7
	dc.w	76<<7
	dc.w	77<<7
	dc.w	78<<7
	dc.w	79<<7
	dc.w	80<<7
	dc.w	81<<7
	dc.w	82<<7
	dc.w	83<<7
	dc.w	84<<7
	dc.w	85<<7
	dc.w	86<<7
	dc.w	87<<7
	dc.w	88<<7
	dc.w	89<<7
	dc.w	90<<7
	dc.w	91<<7
	dc.w	92<<7
	dc.w	93<<7
	dc.w	94<<7
	dc.w	95<<7
	dc.w	96<<7
	dc.w	97<<7
	dc.w	98<<7
	dc.w	99<<7
	dc.w	100<<7
	dc.w	101<<7
	dc.w	102<<7
	dc.w	103<<7
	dc.w	104<<7
	dc.w	105<<7
	dc.w	106<<7
	dc.w	107<<7
	dc.w	108<<7
	dc.w	109<<7
	dc.w	110<<7
	dc.w	111<<7
	dc.w	112<<7
	dc.w	113<<7
	dc.w	114<<7
	dc.w	115<<7
	dc.w	116<<7
	dc.w	117<<7
	dc.w	118<<7
	dc.w	119<<7
	dc.w	120<<7
	dc.w	121<<7
	dc.w	122<<7
	dc.w	123<<7
	dc.w	124<<7
	dc.w	125<<7
	dc.w	126<<7
	dc.w	127<<7
	dc.w	128<<7
	dc.w	129<<7
	dc.w	130<<7
	dc.w	130<<7
	dc.w	131<<7
	dc.w	132<<7
	dc.w	133<<7
	dc.w	134<<7
	dc.w	135<<7
	dc.w	136<<7
	dc.w	137<<7
	dc.w	138<<7
	dc.w	139<<7
	dc.w	140<<7
	dc.w	141<<7
	dc.w	142<<7
	dc.w	143<<7
	dc.w	144<<7
	dc.w	145<<7
	dc.w	146<<7
	dc.w	147<<7
	dc.w	148<<7
	dc.w	149<<7
	dc.w	150<<7
	dc.w	151<<7
	dc.w	152<<7
	dc.w	153<<7
	dc.w	154<<7
	dc.w	155<<7
	dc.w	156<<7
	dc.w	157<<7
	dc.w	158<<7
	dc.w	159<<7
	dc.w	160<<7
	dc.w	161<<7
	dc.w	162<<7
	dc.w	163<<7
	dc.w	164<<7
	dc.w	165<<7
	dc.w	166<<7
	dc.w	167<<7
	dc.w	168<<7
	dc.w	169<<7
	dc.w	170<<7
	dc.w	171<<7
	dc.w	172<<7
	dc.w	173<<7
	dc.w	174<<7
	dc.w	175<<7
	dc.w	176<<7
	dc.w	177<<7
	dc.w	178<<7
	dc.w	179<<7
	dc.w	180<<7
	dc.w	181<<7
	dc.w	182<<7
	dc.w	183<<7
	dc.w	184<<7
	dc.w	185<<7
	dc.w	186<<7
	dc.w	187<<7
	dc.w	188<<7
	dc.w	189<<7
	dc.w	190<<7
	dc.w	191<<7
	dc.w	192<<7
	dc.w	193<<7
	dc.w	194<<7
	dc.w	194<<7
	dc.w	195<<7
	dc.w	196<<7
	dc.w	197<<7
	dc.w	198<<7
	dc.w	199<<7
	dc.w	200<<7
	dc.w	201<<7
	dc.w	202<<7
	dc.w	203<<7
	dc.w	204<<7
	dc.w	205<<7
	dc.w	206<<7
	dc.w	207<<7
	dc.w	208<<7
	dc.w	209<<7
	dc.w	210<<7
	dc.w	211<<7
	dc.w	212<<7
	dc.w	213<<7
	dc.w	214<<7
	dc.w	215<<7
	dc.w	216<<7
	dc.w	217<<7
	dc.w	218<<7
	dc.w	219<<7
	dc.w	220<<7
	dc.w	221<<7
	dc.w	222<<7
	dc.w	223<<7
	dc.w	224<<7
	dc.w	225<<7
	dc.w	226<<7
	dc.w	227<<7
	dc.w	228<<7
	dc.w	229<<7
	dc.w	230<<7
