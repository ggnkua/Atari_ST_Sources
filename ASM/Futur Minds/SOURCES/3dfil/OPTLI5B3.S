;	Structure: 7*8,12,7*8,12

	rept	20
	or.b	d7,(a6)
	add.w	a4,a6
	add.w	a3,d4
	dc.w	$64f8
	or.b	d6,(a6)
	add.w	a4,a6
	add.w	a3,d4
	dc.w	$64f8
	or.b	d5,(a6)
	add.w	a4,a6
	add.w	a3,d4
	dc.w	$64f8
	or.b	d3,(a6)
	add.w	a4,a6
	add.w	a3,d4
	dc.w	$64f8
	or.b	d2,(a6)
	add.w	a4,a6
	add.w	a3,d4
	dc.w	$64f8
	or.b	d1,(a6)
	add.w	a4,a6
	add.w	a3,d4
	dc.w	$64f8
	or.b	d0,(a6)
	add.w	a4,a6
	add.w	a3,d4
	dc.w	$64f8
	or.b	#$1,(a6)
	add.w	a4,a6
	add.w	a3,d4
	dc.w	$64f6
	addq.w	#1,a6
	or.b	d7,(a6)
	add.w	a4,a6
	add.w	a3,d4
	dc.w	$64f8
	or.b	d6,(a6)
	add.w	a4,a6
	add.w	a3,d4
	dc.w	$64f8
	or.b	d5,(a6)
	add.w	a4,a6
	add.w	a3,d4
	dc.w	$64f8
	or.b	d3,(a6)
	add.w	a4,a6
	add.w	a3,d4
	dc.w	$64f8
	or.b	d2,(a6)
	add.w	a4,a6
	add.w	a3,d4
	dc.w	$64f8
	or.b	d1,(a6)
	add.w	a4,a6
	add.w	a3,d4
	dc.w	$64f8
	or.b	d0,(a6)
	add.w	a4,a6
	add.w	a3,d4
	dc.w	$64f8
	or.b	#$1,(a6)
	add.w	a4,a6
	add.w	a3,d4
	dc.w	$64f6
	addq.w	#7,a6
	endr