	rept	20
	or.b	d7,(a6)
	add.w	a3,d4
	dc.w	$6402
	add.w	a4,a6
	or.b	d6,(a6)
	add.w	a3,d4
	dc.w	$6402
	add.w	a4,a6
	or.b	d5,(a6)
	add.w	a3,d4
	dc.w	$6402
	add.w	a4,a6
	or.b	d3,(a6)
	add.w	a3,d4
	dc.w	$6402
	add.w	a4,a6
	or.b	d2,(a6)
	add.w	a3,d4
	dc.w	$6402
	add.w	a4,a6
	or.b	d1,(a6)
	add.w	a3,d4
	dc.w	$6402
	add.w	a4,a6
	or.b	d0,(a6)
	add.w	a3,d4
	dc.w	$6402
	add.w	a4,a6
	or.b	#$1,(a6)+
	add.w	a3,d4
	dc.w	$6402
	add.w	a4,a6
	or.b	d7,(a6)
	add.w	a3,d4
	dc.w	$6402
	add.w	a4,a6
	or.b	d6,(a6)
	add.w	a3,d4
	dc.w	$6402
	add.w	a4,a6
	or.b	d5,(a6)
	add.w	a3,d4
	dc.w	$6402
	add.w	a4,a6
	or.b	d3,(a6)
	add.w	a3,d4
	dc.w	$6402
	add.w	a4,a6
	or.b	d2,(a6)
	add.w	a3,d4
	dc.w	$6402
	add.w	a4,a6
	or.b	d1,(a6)
	add.w	a3,d4
	dc.w	$6402
	add.w	a4,a6
	or.b	d0,(a6)
	add.w	a3,d4
	dc.w	$6402
	add.w	a4,a6
	or.b	#$1,(a6)
	add.w	a3,d4
	dc.w	$6402
	add.w	a4,a6
	addq.w	#7,a6
	endr
