	LEA BUFFER,A0
	LEA BUFFER_END,A1
	MOVE.L #$2BAF6789,D1
ENCLOOP
	EOR.L D1,(A0)+
	CMP.L A0,A1
	BLE.S ENCEND
	BRA.S ENCLOOP
ENCEND
	
LOOP	MOVE.W #2,-(SP)
	MOVE.W #1,-(SP)
	TRAP #13
	ADDQ.L #4,SP
	TST.W D0
	BEQ.S LOOP

	LEA BUFFER,A0		START OF DATA TO BE WRITTEN
	MOVEQ #41,D0		TRACK 70
	MOVEQ #1,D1		SECTOR 1
	MOVEQ #10,D2		WRITE 10 SECTORS
	MOVEQ #1,D3		SIDE 0

	MOVEQ #7,D4		11 TRACKS
WRITELOOP
	MOVEM.L D0-D7/A0-A6,-(SP)
	MOVE.W D2,-(SP)
	MOVE.W D3,-(SP)
	MOVE.W D0,-(SP)
	MOVE.W D1,-(SP)
	MOVE.W #0,-(SP)
	CLR.L -(SP)
	MOVE.L A0,-(SP)
	MOVE.W #9,-(SP)
	TRAP #14
	ADD.L #20,SP
	MOVEM.L (SP)+,D0-D7/A0-A6
	ADD.W #1,D0
	LEA 5120(A0),A0
	DBF D4,WRITELOOP

	CLR.W -(SP)
	TRAP #1

BUFFER	INCBIN "\STARS\STARS.PAK"
BUFFER_END