SCROLLINE
	DC.B "     OH MY GOD!, ITS FULL OF STARS.          WELL THATS PRETTY DAMN ORIGINAL ISN'T IT?     NO THIS ISN'T 2010 IT THE LOST BOYS VECTORS SCREEN. SLIGHTLY HIDDEN ON THE MINDBOMB DEMO.  YOU EITHER FIND YOUR WAY ONTO THIS SCREEN EASILY OR IF "
	DC.B "YOU ARE PARTIALLY STUPID (YOU CAN'T BE TOTALLY STUPID COS YOUR HERE NOW!  OR DID SOMEONE TELL YOU HOW TO GET HERE?!!) THEN YOU MAY HAVE FOUND THAT IT TOOK YOU QUITE A WHILE TO FIND OUT THAT YOU CAN WALK THROUGH THE TOP OF COLUMNS AND THEN"
	DC.B " FALL DOWN THE LENGTH OF THEM ON MY MAIN MENU! STILL I HOPE YOU THINK ITS WORTH THE TROUBLE. I WAS GOING TO DO A FEW MORE SHAPES AND STUFF IN THIS SCREEN BUT I HAVE JUST SEEN A SCREEN THAT IS RATHER TO SIMILAR TO THIS FOR MY LIKING "
	DC.B " BY AN COOL OF THE CAREBEARS AND SINCE EVERYONE IS GOING TO THINK THAT I COPIED HIM ANYWAY, I REALLY CAN'T BE BOTHERED. I AM QUITE PLEASED THAT I WROTE THE LINE PLOT ROUTINE ANYWAY AS IT BASICALLY SOLVES THE PROGRAMMING PROJECT THAT "
	DC.B "I HAVE BEEN SET FOR NEXT TERM IN UNIVERSITY. IT WAS SUPPOSED TO TAKE US ABOUT 15 HOURS, BUT I FINSHED IT IN 1 HOUR!!! PRETTY GOOD HUH!! AT THE MOMENT I AM BEING TAUGHT A COURSE ON 68000 ASSEMBLER AT UNIVERSITY, BUT I THINK I PROBABLY "
	DC.B "KNOW MORE ABOUT 68000 PROGRAMMING THAN THE BLOODY LECTURER SO ITS REALLY PRETTY BORING. ARRRGGGHHHH SHIT WHAT THE HELL IS THAT!!     SAMMY JOE HAS JUST PUT A REALLY CRAPPY RECORD ON, ITS CALLED RIDE THE LIGHTENING BY METTALICA, THE "
	DC.B "SONG IS CALLED FIGHT FIRE WITH FIRE AND IT BASICALLY CONSISTS OF SOMEBODY TWANGING A GUITAR AND SOMEBODY ELSE GROWLING SOME SHITTY LIRICKS ALONG WITH IT! IT IS UTTER SHITE! TODAY WE BOUGHT A RECORD CALLED 'ENJOY THE SILENCE' BY DEPECHE "
	DC.B "MODE AND WE ARE THINKING OF DOING A SAMPLE DEMO OF IT. IT HAS EMERGED AS A VAGUE POSSIBILITY THAT I WILL HAVE MORE SCREENS FOR THIS DEMO THAN I CAN FIT ONTO 1 DOUBLE SIDED DISK AND SO WE MAY HAVE TO USE A 2ND DISK FOR SOME EXTRA SCREENS "
	DC.B " AND THE SAMPLE WILL THERFORE BE USED AS A SPACE FILLER.  THE TROUBLE WITH THIS DEMO HAS ALWAYS BEEN THAT JUST WHEN I THINK IT IS FINISHED FOR GOOD SOMETHING OR SOMEONE POINTS ME TO A BUG OR GIVES ME ANOTHER SCREEN. TODAY WAS ONE OF THOSE"
	DC.B " DAYS, I WAS HAPPILY FINISHING MY DISK OFF WHEN STEFAN ANNOUNCED THAT HE HAD IN FACT FINISHED HIS THIRD DIGITAL INSANITY SCREEN. ALSO AENIGMATICA HAVE OFFERED US A SCREEN AND SO HAVE A NORWEGIAN GROUP! ALSO TO TOP IT ALL OFF SPAZ HAS JUST "
	DC.B " PRODUCED A REALLY EXCELLENT 4 TRACK SONG (AFTER I HAVE JUST FINISHED AND PACKED THE SYNTH SCREEN!!) AND I NOW WOULD REALLY LIKE TO PUT THIS IN THE DEMO AS WELL!  IS THERE NO END TO MY PROBLEMS.  OF COURSE NOT! TO ADD FURTHER PROBLEMS "
	DC.B " LAST WEEK WE BORROWED AN STE FOR A FEW HOURS SO THAT WE COULD TRY AND MAKE THE DEMO COMPATIBLE WITH THE STE, AFTER ABOUT 20 MINUTES OF TRYING WE SUCCEEDED ONLY TO FIND THAT OF ALL THINGS THE LOADER ROUTINE DIDN'T WORK ANY MORE! "
	DC.B " NOT THE FUCKING BORDERS OR THE SYNC SCROLLING BUT THE FUCKING SHITTY LITTLE LOADER!!!!!  ARRRRRRGGGGGGHHHHHHH!!!!   IF I HADN'T SPENT SO LONG ON THIS DEMOI WOULD PROBABLY  KICK THE LIVING SHIT OUT OF THIS COMPUTER AND ALL MY RUDDY"
	DC.B " DATA DISKS!!!        BEFORE I EXPLODE LETS WRAP!!!!!       "
	DC.B $FF
