
L20F64	MOVE.L	#$D6,D3
	LEA	$140.W,A1
	LEA	L20F64(PC),A2
	MOVE.L	(A2),D2
	CMP.L	(A1),D2
	BEQ	L20FB2
	MOVE.L	#$31415926,D0
	CLR.L	D1
	CMP.L	$426.W,D0
	BNE	L20F8E
	MOVE.L	$42A.W,D1
L20F8E	LEA	L20FB4(PC),A0
	MOVE.L	D1,(A0)
	MOVE.L	#$194,D2
	MOVE.L	D2,$42A.W
	MOVE.L	D0,$426.W
L20FA2	MOVE.W	(A2)+,(A1)+
	DBF	D3,L20FA2
	MOVE.L	#$FFFFFFFB,$2EA.W
	BSR.S	L21016
L20FB2	RTS
L20FB4	ORI.B	#0,D0
	MOVEA.L	$42E.W,A1
	SUBA.L	#$8000,A1
	SUBA.L	#$200,A1
	MOVE.L	A1,D1
	MOVE.L	#$12123456,(A1)+
	MOVE.L	D1,(A1)+
	LEA	L21016(PC),A3
	LEA	L21032(PC),A4
L20FDA	MOVE.W	(A3)+,(A1)+
	CMPA.L	A4,A3
	BLT.S	L20FDA
	LEA	L20F64(PC),A3
	MOVE.L	A3,(A1)+
	MOVEA.L	D1,A3
	CLR.W	D0
	MOVE.W	#$FE,D2
L20FEE	ADD.W	(A3)+,D0
	DBF	D2,L20FEE
	MOVE.W	#$5678,D2
	SUB.W	D0,D2
	MOVE.W	D2,(A3)
	MOVE.L	#0,$426.W
	MOVEA.L	L20FB4(PC),A1
	CMPA.L	#0,A1
	BNE	L21014
	JMP	(A6)
L21014	JMP	(A1)
L21016	MOVE.L	#$31415926,$426.W
	MOVE.L	$472.W,D0
	LEA	$2E2.W,A0
	MOVE.L	D0,(A0)
	LEA	$20E.W,A0
	MOVE.L	A0,$472.W
	RTS
L21032	MOVE.W	4(A7),D0
	CMP.W	#2,D0
	BGE	L21104
	MOVEM.L	D1-5/D7/A0-7,-(A7)
	MOVE.W	D0,D7
	MOVE.L	#1,-(A7)
	MOVE.L	#$10000,-(A7)
	MOVE.W	D7,-(A7)
	CLR.L	-(A7)
	LEA	$4C6.W,A5
	MOVEA.L	(A5),A5
	MOVEA.L	A5,A6
	MOVE.L	A5,-(A7)
	MOVE.W	#8,-(A7)
	TRAP	#14
	ADDA.L	#$14,A7
	TST.W	D0
	BMI	L21100
	MOVE.W	#$601C,(A5)
	ADDA.L	#$1E,A5
	LEA	L20F64(PC),A4
	LEA	L21114(PC),A3
L21082	MOVE.W	(A4)+,(A5)+
	CMPA.L	A3,A4
	BLT.S	L21082
	MOVEA.L	A6,A5
	MOVE.W	#$FE,D1
	MOVE.W	#$1234,D0
L21092	SUB.W	(A5)+,D0
	DBF	D1,L21092
	MOVE.W	D0,(A5)
	MOVE.L	#1,-(A7)
	MOVE.L	#$10000,-(A7)
	MOVE.W	D7,-(A7)
	CLR.L	-(A7)
	MOVE.L	A6,-(A7)
	MOVE.W	#9,-(A7)
	TRAP	#14
	ADDA.L	#$14,A7
	TST.W	D0
	BMI	L21100
	ADDI.L	#1,$2EA.W
	CMPI.L	#5,$2EA.W
	BNE	L21100
	CLR.L	$2EA.W
	MOVE.W	#$22,-(A7)
	TRAP	#14
	ADDQ.L	#2,A7
	ADD.L	#$10,D0
	EXG	D0,A0
	MOVE.L	(A0),-(A7)
	PEA	L2110A(PC)
	MOVE.L	#1,-(A7)
	TRAP	#14
	ADDA.L	#$C,A7
	EORI.B	#1,$2E6.W
L21100	MOVEM.L	(A7)+,D1-7/A0-6
L21104	JMP	$FC0DE6
L2110A	BTST	D0,D1
	BTST	D0,D1
	ORI.B	#4,D0
	DC.W	$FFFF
L21114	BGT.S	L21137
	MOVE.L	$2A2A(A2),D5
	MOVE.L	$2A2A(A2),D5
	MOVE.L	$2A2A(A2),D5
	MOVE.L	$2A2A(A2),D5
	ORI.B	#$71,D0
	BRA	L20F84
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#$77,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
