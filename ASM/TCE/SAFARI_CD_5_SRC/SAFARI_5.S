;
; SAFARI COMPIL 5
; MENU Reassembled and repaired by The Byte / TCE
;

	text
begin
	bra	start
	ds.w	200
ustack	ds.w	2
exec	pea	blank
	pea	blank
	pea	$200.l
	clr.w	-(a7)
	move.w	#$4b,-(a7)		;pexec
	trap	#1
	lea	16(a7),a7
	pea	l0002
	move.w	#$26,-(a7)		;supexec
	trap	#$e
l0002	move.l	4.w,-(a7)
	rts

blank	ds.w	2
start	movea.l	4(a7),a0
	movea.l	#ustack,a7
	move.l	#$2cc,-(a7)
	move.l	a0,-(a7)
	clr.w	-(a7)
	move.w	#$4a,-(a7)		;mshrink
	trap	#1
	lea	12(a7),a7
	clr.l	-(a7)
	move.w	#$20,-(a7)		;super
	trap	#1
	lea	6(a7),a7
	move.l	d0,sstore
	movea.l	#save_usp,a0
	move	usp,a1
	move.l	a1,(a0)
	bsr	init
	bsr	conv1
	bsr	conv2
main	bsr	scroll
	bsr	bars
rn1	cmpi.l	#1,vbltest
	bne	rn1
	move.l	#0,vbltest
	move.b	-$3fe.w,d5
	cmp.b	#$b,d5
	beq	hz_swap
	cmp.b	#2,d5
	beq	op1
	cmp.b	#3,d5
	beq	op2
	cmp.b	#4,d5
	beq	op3
	cmp.b	#5,d5
	beq	op4
	cmp.b	#6,d5
	beq	op5
	cmp.b	#$39,d5		;#'9'
	bne	main
	jmp	outw
hz_swap	move.l	hz_delay,d2
	cmp.l	#0,d2
	beq	qwe
	subi.l	#1,d2
	move.l	d2,hz_delay
	bra	main
qwe	move.l	#6,d2
	move.l	d2,hz_delay
	eori.b	#1,hz
	eori.w	#$309,fontpal
	bra	main
init	dc.b	$a0,0,$a0,$a,$11,$fc,0,$12
	dc.b	$fc,2
	movea.l	#storage,a0
	move.l	$70.w,(a0)+
	move.l	$120.w,(a0)+
	move.l	$118.w,(a0)+
	move.b	-$5e5.w,(a0)+
	move.b	-$5df.w,(a0)+
	move.b	-$5f9.w,(a0)+
	move.b	-$5f7.w,(a0)+
	move.b	-$5ed.w,(a0)+
	move.w	#2,-(a7)		;physbase
	trap	#$e
	addq.l	#2,a7
	move.l	d0,phys
	move.w	#3,-(a7)		;logbase
	trap	#$e
	addq.l	#2,a7
	move.l	d0,logi
	move.w	#4,-(a7)		;getrez
	trap	#$e
	addq.l	#2,a7
	move.l	d0,res
	movea.l	#screen,a5
	adda.l	#$100,a5
	move.l	a5,d5
	andi.b	#0,d5
	movea.l	d5,a5
	move.w	#0,-(a7)
	move.l	a5,-(a7)
	move.l	a5,-(a7)
	move.w	#5,-(a7)		;setscreen
	trap	#$e
	lea	12(a7),a7
	movea.l	d5,a0
	move.l	#$383f,d0
poi2	clr.l	(a0)+
	dbf	d0,poi2
	move.w	#3,-(a7)		;logbase
	trap	#$e
	addq.w	#2,a7
	move.l	d0,store
	bchg	#0,$484.l
	move.w	#3,-(a7)		;logbase
	trap	#$e
	addq.l	#2,a7
	movea.l	d0,a3
	movea.w	#-$7dc0,a2
	lea	sstore2,a1
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	movea.l	#picture,a1
	addq.l	#2,a1
	movea.w	#-$7dc0,a2
	move.w	(a1)+,(a2)+
	move.w	(a1)+,(a2)+
	move.w	(a1)+,(a2)+
	move.w	(a1)+,(a2)+
	move.w	(a1)+,(a2)+
	move.w	(a1)+,(a2)+
	move.w	(a1)+,(a2)+
	move.w	(a1)+,(a2)+
	move.w	(a1)+,(a2)+
	move.w	(a1)+,(a2)+
	move.w	(a1)+,(a2)+
	move.w	(a1)+,(a2)+
	move.w	(a1)+,(a2)+
	move.w	(a1)+,(a2)+
	move.w	(a1)+,(a2)+
	move.w	(a1)+,(a2)+
	move.l	#$3e7f,d4
srepeat	move.w	(a1)+,(a3)+
	dbf	d4,srepeat
	move.l	#0,d6
	move.l	d6,sstore3
	move.w	#0,$ffff8240.l
	move	#$2700,sr
	move.l	#vbl,$70.w
	move.l	#timer_b,$120.w
	move.l	#timer_c,$118.w
	clr.b	-$5f9.w
	clr.b	-$5f7.w
	ori.b	#1,-$5f9.w
	ori.b	#1,-$5ed.w
	clr.b	-$5e5.w
	move	#$2300,sr
	move.w	#1,d0
	bsr	music
	rts

conv1	movea.l	#text,a0
	bsr	upper
	movea.l	#order,a0
	bsr	upper
	movea.l	#text,a0
	move.l	#0,d4
cstart	move.l	#0,d0
	addq.l	#1,d4
	movea.l	#order,a1
	cmpi.b	#-1,(a0)
	beq	cend
	move.b	(a0),d2
cnext	move.b	(a1),d1
	cmp.b	d1,d2
	beq	cagain
	cmpi.b	#-1,(a1)+
	beq	not
	addq.l	#1,d0
	bra	cnext
cagain	move.b	d0,(a0)+
	bra	cstart
not	move.b	#0,(a0)+
	bra	cstart
cend	move.l	d0,count
	rts

upper	cmpi.b	#$41,(a0)
	blt	uagain
	cmpi.b	#$5a,(a0)
	bgt	uagain
	addi.b	#$20,(a0)
uagain	addq.l	#1,a0
	cmpi.b	#-1,(a0)
	bne	upper
	rts

order	dc.b	'ABCDEFGH'
	dc.b	'IJKLMNOP'
	dc.b	'QRSTUVWX'
	dc.b	'YZ!.,"-+'
	dc.b	';:',$27,'?()* '
	dc.b	'01234567'
	dc.b	'89',$ff,0

count	ds.w	2
conv2	movea.l	#font,a0
	addq.l	#2,a0
	movea.l	#fontpal,a1
	move.l	#8,d0
lagain	move.l	(a0)+,(a1)+
	subq.l	#1,d0
	cmp.b	#0,d0
	bne.s	lagain
	movea.l	#l00ce,a1
	move.l	#7,d1
lfull	subq.l	#1,d1
	move.l	#$a,d2
lagain2	move.l	#$1d,d0
lagain1	subq.l	#1,d0
	move.l	(a0)+,(a1)+
	move.l	(a0)+,(a1)+
	move.l	(a0)+,(a1)+
	move.l	(a0)+,(a1)+
	adda.l	#$90,a0
	cmp.b	#0,d0
	bne.s	lagain1
	suba.l	#$1210,a0
	subq.l	#1,d2
	cmp.b	#0,d2
	bne.s	lagain2
	adda.w	#$1180,a0
	cmp.b	#0,d1
	bne.s	lfull
	rts

op1	movea.l	#file1,a0
	movea.l	#file2,a1
	suba.l	a0,a1
	move.l	a1,d0
	bra	load
op2	movea.l	#file2,a0
	movea.l	#file3,a1
	suba.l	a0,a1
	move.l	a1,d0
	bra	load
op3	movea.l	#file3,a0
	movea.l	#file4,a1
	suba.l	a0,a1
	move.l	a1,d0
	bra	load
op4	movea.l	#file4,a0
	movea.l	#file5,a1
	suba.l	a0,a1
	move.l	a1,d0
	bra	load
op5	movea.l	#file5,a0
	movea.l	#file6,a1
	suba.l	a0,a1
	move.l	a1,d0
	bra	load
	movea.l	#file6,a0
	movea.l	#file6,a1
	suba.l	a0,a1
	move.l	a1,d0
	bra	load
load	movea.l	#$200,a1
mve	move.b	(a0)+,(a1)+
	subi.l	#1,d0
	cmp.l	#0,d0
	bne	mve
	move	#$2700,sr
	movea.l	#storage,a0
	move.l	(a0)+,$70.w
	move.l	(a0)+,$120.w
	move.l	(a0)+,$118.w
	move.b	(a0)+,-$5e5.w
	move.b	(a0)+,-$5df.w
	move.b	(a0)+,-$5f9.w
	move.b	(a0)+,-$5f7.w
	move.b	(a0)+,-$5ed.w
	move	#$2300,sr
	bchg	#0,$484.l
	move.b	#8,$ff8800.l
	clr.b	$ff8802.l
	move.b	#9,$ff8800.l
	clr.b	$ff8802.l
	move.b	#$a,$ff8800.l
	clr.b	$ff8802.l
	bset	#0,$484.l
	movea.w	#-$7dc0,a1
	lea	sstore2,a2
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.b	#8,-$3fe.w
	movea.l	store,a0
	move.l	#$1f3f,d0
yetty2	clr.l	(a0)+
	dbf	d0,yetty2
	move.w	res,-(a7)
	move.l	phys,-(a7)
	move.l	logi,-(a7)
	move.w	#5,-(a7)		;setscreen
	trap	#$e
	lea	12(a7),a7
	move	a7,usp
	move.w	hz,d0
	move.b	#0,-$7df6.w
	cmp.l	#0,d0
	bne	fred2
	move.b	#2,-$7df6.w
fred2	move.l	sstore,-(a7)
	move.w	#$20,-(a7)		;super
	trap	#1
	lea	6(a7),a7
	jmp	exec
scroll	addi.w	#1,sstore3
	move.w	sstore3,d6
	cmp.w	#4,d6
	bne	slines
	clr.l	sstore3
	bsr	llet
	movea.l	#buffer,a1
	movea.l	#l00ce,a0
	bra.s	slet2
slet	lea	464(a0),a0
slet2	dbf	d6,slet
	move.w	#$74,d6
send	move.l	(a0)+,(a1)+
	move.l	(a0)+,(a1)+
	move.l	(a0)+,(a1)+
	move.l	(a0)+,(a1)+
	dbf	d6,send
slines	movea.l	#buffer,a5
	movea.l	store,a4
	lea	32000(a4),a4
	move.l	#$1c,d6
again	movep.l	1(a4),d1
	movep.l	d1,0(a4)
	movep.l	8(a4),d1
	movep.l	d1,1(a4)
	movep.l	9(a4),d1
	movep.l	d1,8(a4)
	movep.l	16(a4),d1
	movep.l	d1,9(a4)
	movep.l	17(a4),d1
	movep.l	d1,16(a4)
	movep.l	24(a4),d1
	movep.l	d1,17(a4)
	movep.l	25(a4),d1
	movep.l	d1,24(a4)
	movep.l	32(a4),d1
	movep.l	d1,25(a4)
	movep.l	33(a4),d1
	movep.l	d1,32(a4)
	movep.l	40(a4),d1
	movep.l	d1,33(a4)
	movep.l	41(a4),d1
	movep.l	d1,40(a4)
	movep.l	48(a4),d1
	movep.l	d1,41(a4)
	movep.l	49(a4),d1
	movep.l	d1,48(a4)
	movep.l	56(a4),d1
	movep.l	d1,49(a4)
	movep.l	57(a4),d1
	movep.l	d1,56(a4)
	movep.l	64(a4),d1
	movep.l	d1,57(a4)
	movep.l	65(a4),d1
	movep.l	d1,64(a4)
	movep.l	72(a4),d1
	movep.l	d1,65(a4)
	movep.l	73(a4),d1
	movep.l	d1,72(a4)
	movep.l	80(a4),d1
	movep.l	d1,73(a4)
	lea	80(a4),a4
	movep.l	1(a4),d1
	movep.l	d1,0(a4)
	movep.l	8(a4),d1
	movep.l	d1,1(a4)
	movep.l	9(a4),d1
	movep.l	d1,8(a4)
	movep.l	16(a4),d1
	movep.l	d1,9(a4)
	movep.l	17(a4),d1
	movep.l	d1,16(a4)
	movep.l	24(a4),d1
	movep.l	d1,17(a4)
	movep.l	25(a4),d1
	movep.l	d1,24(a4)
	movep.l	32(a4),d1
	movep.l	d1,25(a4)
	movep.l	33(a4),d1
	movep.l	d1,32(a4)
	movep.l	40(a4),d1
	movep.l	d1,33(a4)
	movep.l	41(a4),d1
	movep.l	d1,40(a4)
	movep.l	48(a4),d1
	movep.l	d1,41(a4)
	movep.l	49(a4),d1
	movep.l	d1,48(a4)
	movep.l	56(a4),d1
	movep.l	d1,49(a4)
	movep.l	57(a4),d1
	movep.l	d1,56(a4)
	movep.l	64(a4),d1
	movep.l	d1,57(a4)
	movep.l	65(a4),d1
	movep.l	d1,64(a4)
	movep.l	72(a4),d1
	movep.l	d1,65(a4)
	movep.l	73(a4),d1
	movep.l	d1,72(a4)
	movep.l	0(a5),d1
	movep.l	d1,73(a4)
	movep.l	1(a5),d1
	movep.l	d1,0(a5)
	movep.l	8(a5),d1
	movep.l	d1,1(a5)
	movep.l	9(a5),d1
	movep.l	d1,8(a5)
	lea	80(a4),a4
	lea	16(a5),a5
	dbf	d6,again
	rts

llet	movea.l	#text,a0
	adda.l	flist,a0
	move.b	(a0),d6
	cmp.b	#-1,d6
	beq.s	bro
	addq.l	#1,flist
	bra.s	sla
bro	move.l	#0,flist
	move.l	#$33,d6
sla	rts

flist	ds.w	2
bars	move.l	store,d0
	movea.l	d0,a0
	adda.l	#$95a8,a0
	move.l	#7,d1
	move.b	#8,$ffff8800.l
	move.b	$ffff8800.l,d5
	lsr.b	#1,d5
	cmp.b	#7,d5
	bhi	to_high1
	cmp.b	#1,d5
	bcs	to_low1
again1	cmp.b	#0,d5
	beq	no_bar1
	move.w	#-1,(a0)
	clr.w	2(a0)
	clr.w	4(a0)
	move.w	#-1,6(a0)
	subi.b	#1,d5
cont1	subi.l	#1,d1
	suba.l	#$a0,a0
	cmp.l	#0,d1
	beq	chan2
	bra	again1
no_bar1	clr.w	(a0)
	clr.w	2(a0)
	clr.w	4(a0)
	clr.w	6(a0)
	bra	cont1
to_high1	move.b	#7,d5
	bra	again1
to_low1	move.b	#1,d5
	bra	again1
chan2	movea.l	d0,a0
	adda.l	#$95b0,a0
	move.l	#7,d1
	move.b	#9,$ffff8800.l
	move.b	$ffff8800.l,d5
	lsr.b	#1,d5
	cmp.b	#7,d5
	bhi	to_high2
	cmp.b	#1,d5
	bcs	to_low2
again2	cmp.b	#0,d5
	beq	no_bar2
	clr.w	(a0)
	move.w	#-1,2(a0)
	clr.w	4(a0)
	move.w	#-1,6(a0)
	subi.b	#1,d5
cont2	subi.l	#1,d1
	suba.l	#$a0,a0
	cmp.l	#0,d1
	beq	chan3
	bra	again2
no_bar2	clr.w	(a0)
	clr.w	2(a0)
	clr.w	4(a0)
	clr.w	6(a0)
	bra	cont2
to_high2	move.b	#7,d5
	bra	again2
to_low2	move.b	#1,d5
	bra	again2
chan3	movea.l	d0,a0
	adda.l	#$95b8,a0
	move.l	#7,d1
	move.b	#$a,$ffff8800.l
	move.b	$ffff8800.l,d5
	lsr.b	#1,d5
	cmp.b	#7,d5
	bhi	to_high3
	cmp.b	#1,d5
	bcs	to_low3
again3	cmp.b	#0,d5
	beq	no_bar3
	clr.w	(a0)
	clr.w	2(a0)
	move.w	#-1,4(a0)
	move.w	#-1,6(a0)
	subi.b	#1,d5
cont3	subi.l	#1,d1
	suba.l	#$a0,a0
	cmp.l	#0,d1
	beq	chan4
	bra	again3
no_bar3	clr.w	(a0)
	clr.w	2(a0)
	clr.w	4(a0)
	clr.w	6(a0)
	bra	cont3
to_high3	move.b	#7,d5
	bra	again3
to_low3	move.b	#1,d5
	bra	again3
chan4	movea.l	d0,a0
	adda.l	#$95a0,a0
	move.l	#7,d1
	move.b	#$a,$ffff8800.l
	move.b	$ffff8800.l,d5
	lsr.b	#1,d5
	cmp.b	#7,d5
	bhi	to_high4
	cmp.b	#1,d5
	bcs	to_low4
again4	cmp.b	#0,d5
	beq	no_bar4
	clr.w	(a0)
	clr.w	2(a0)
	move.w	#-1,4(a0)
	move.w	#-1,6(a0)
	subi.b	#1,d5
cont4	subi.l	#1,d1
	suba.l	#$a0,a0
	cmp.l	#0,d1
	beq	end
	bra	again4
no_bar4	clr.w	(a0)
	clr.w	2(a0)
	clr.w	4(a0)
	clr.w	6(a0)
	bra	cont4
to_high4	move.b	#7,d5
	bra	again4
to_low4	move.b	#1,d5
	bra	again4
end	rts

vbl	move.l	l00c6,$ffff8240.l
	move.l	l00c7,$ffff8244.l
	move.l	l00c8,$ffff8248.l
	move.l	l00c9,$ffff824c.l
	move.l	l00ca,$ffff8250.l
	move.l	l00cb,$ffff8254.l
	move.l	l00cc,$ffff8258.l
	move.l	l00cd,$ffff825c.l
	movem.l	a0-a6/d0-d7,-(a7)
	clr.b	-$5e5.w
	move.b	#-$39,$fffffa21.l
	move.b	#8,-$5e5.w
	move.l	#1,vbltest
	bsr	l0052
	movem.l	(a7)+,a0-a6/d0-d7
	rte

timer_b	move	sr,-(a7)
	move	#$2700,sr
	move.l	fontpal,$ffff8240.l
	move.l	l00be,$ffff8244.l
	move.l	l00bf,$ffff8248.l
	move.l	l00c0,$ffff824c.l
	move.l	l00c1,$ffff8250.l
	move.l	l00c2,$ffff8254.l
	move.l	l00c3,$ffff8258.l
	move.l	l00c4,$ffff825c.l
	clr.b	-$5e5.w
	movem.l	a0/d0,-(a7)
	movea.w	#-$5df,a0
	move.b	#-$38,(a0)
	move.b	#8,-$5e5.w
	move.b	(a0),d0
wa	cmp.b	(a0),d0
	beq	wa
	clr.b	-$7df6.w
	move.w	#2,d0
lo	nop
	dbf	d0,lo
	move.b	#2,-$7df6.w
	movem.l	(a7)+,a0/d0
	bclr	#0,-$5f1.w
	move	(a7)+,sr
	rte

timer_c	movem.l	d0,-(a7)
	move.b	-$3fe.w,d0
	bclr	#6,-$5ef.w
	movem.l	(a7)+,d0
	rte

outw	move	#$2700,sr
	movea.l	#storage,a0
	move.l	(a0)+,$70.w
	move.l	(a0)+,$120.w
	move.l	(a0)+,$118.w
	move.b	(a0)+,-$5e5.w
	move.b	(a0)+,-$5df.w
	move.b	(a0)+,-$5f9.w
	move.b	(a0)+,-$5f7.w
	move.b	(a0)+,-$5ed.w
	move	#$2300,sr
	bchg	#0,$484.l
	move.b	#8,$ff8800.l
	clr.b	$ff8802.l
	move.b	#9,$ff8800.l
	clr.b	$ff8802.l
	move.b	#$a,$ff8800.l
	clr.b	$ff8802.l
	bset	#0,$484.l
	movea.w	#-$7dc0,a1
	lea	sstore2,a2
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.w	(a2)+,(a1)+
	move.b	#8,-$3fe.w
	movea.l	store,a0
	move.l	#$1f3f,d0
yetty	clr.l	(a0)+
	dbf	d0,yetty
	move.w	res,-(a7)
	move.l	phys,-(a7)
	move.l	logi,-(a7)
	move.w	#5,-(a7)		;setscreen
	trap	#$e
	lea	12(a7),a7
	movea.l	save_usp,a1
	move	a1,usp
	move.w	hz,d0
	move.b	#0,-$7df6.w
	cmp.l	#0,d0
	bne	fred
	move.b	#2,-$7df6.w
fred	move.l	sstore,-(a7)
	move.w	#$20,-(a7)		;super
	trap	#1
	lea	6(a7),a7
	clr.w	-(a7)		;pterm0
	trap	#1
vbltest	ds.w	4
store	ds.w	4
music	bra	l0055
	bra	l0054
l0052	bra	l005a
	bra	l0053
	pea	(a0)
	lea	l00af(pc),a0
	move.b	d0,(a0)
	movea.l	(a7)+,a0
	rts

l0053	pea	(a0)
	andi.b	#$1f,d0
	lea	l009b(pc),a0
	move.b	d0,(a0)+
	move.b	d0,(a0)+
	move.b	#0,(a0)+
	movea.l	(a7)+,a0
	rts

l0054	movem.l	a0-a6/d0-d7,-(a7)
	lea	l00b1(pc),a0
	bsr	l0058
	movea.l	l00ab(pc),a1
	add.w	d0,d0
	add.w	d0,d0
	adda.w	d0,a1
	lea	l00ad(pc),a6
	move.w	(a1)+,(a6)
	moveq	#0,d0
	move.w	(a1)+,d0
	bsr	l0072
	movem.l	(a7)+,a0-a6/d0-d7
	rts

l0055	movem.l	a0-a6/d0-d7,-(a7)
	bsr.s	l0056
	movem.l	(a7)+,a0-a6/d0-d7
	rts

l0056	lea	l00b1(pc),a0
	bsr.s	l0058
	tst.w	d0
	beq.s	l0057
	subq.w	#1,d0
	movea.l	l00aa(pc),a1
	mulu	#6,d0
	adda.w	d0,a1
	move.w	(a1)+,d0
	move.w	(a1)+,d1
	lea	l009e(pc),a6
	move.w	(a1)+,(a6)
	bsr	l006f
	rts

l0057	lea	l009f(pc),a0
	st	(a0)
	bra	l005a
l0058	move.w	l0099(pc),d7
	bne.s	l0059
	lea	l00ae(pc),a6
	move.l	a0,(a6)
	movea.l	4(a0),a1
	adda.l	a0,a1
	lea	l00a7(pc),a6
	move.l	a1,(a6)
	movea.l	8(a0),a1
	adda.l	a0,a1
	lea	l00a8(pc),a6
	move.l	a1,(a6)
	movea.l	12(a0),a1
	adda.l	a0,a1
	lea	l00a6(pc),a6
	move.l	a1,(a6)
	movea.l	16(a0),a1
	adda.l	a0,a1
	lea	l00a9(pc),a6
	move.l	a1,(a6)
	movea.l	20(a0),a1
	adda.l	a0,a1
	lea	l00aa(pc),a6
	move.l	a1,(a6)+
	movea.l	24(a0),a1
	adda.l	a0,a1
	move.l	a1,(a6)+
	lea	l0099(pc),a6
	st	(a6)
	lea	l00ac(pc),a6
	move.w	#0,(a6)
l0059	rts

l005a	lea	l009b(pc),a0
	tst.b	(a0)
	beq.s	l005c
	subq.b	#1,1(a0)
	bpl.s	l005c
	move.b	(a0),1(a0)
	addq.w	#1,2(a0)
	move.w	2(a0),d0
	cmp.w	#$a,d0
	bne.s	l005b
	clr.l	(a0)
	lea	l009f(pc),a0
	st	(a0)
	bra.s	l005c
l005b	lea	l009a(pc),a0
	move.b	0(a0,d0.w),d0
	lea	l00a1(pc),a0
	move.b	d0,(a0)
	move.b	d0,54(a0)
	move.b	d0,108(a0)
l005c	lea	l0097(pc),a6
	lea	l009d(pc),a5
	tst.b	4(a5)
	beq.s	l005e
	tst.b	5(a5)
	bne.s	l005d
	st	5(a5)
	moveq	#0,d0
	move.b	d0,34(a6)
	move.b	d0,38(a6)
	move.b	d0,42(a6)
	move.b	l00af(pc),d1
	bne.s	l005d
	movem.l	28(a6),d0-d3
	movem.l	d0-d3,-$7800.w
l005d	rts

l005e	subq.w	#1,(a5)+
	bne.s	l005f
	move.w	(a5),-(a5)
	moveq	#0,d5
	moveq	#0,d4
	lea	l00a0(pc),a0
	bsr	l0063
	st	d4
	lea	l00a2(pc),a0
	bsr	l0063
	lea	l00a3(pc),a0
	bsr	l0063
l005f	lea	l009c(pc),a5
	lea	l00a0(pc),a0
	bsr	l0074
	move.w	d0,-(a7)
	move.b	(a7)+,6(a6)
	move.b	d0,2(a6)
	move.b	d1,34(a6)
	lea	l00a2(pc),a0
	bsr	l0074
	move.w	d0,-(a7)
	move.b	(a7)+,14(a6)
	move.b	d0,10(a6)
	move.b	d1,38(a6)
	lea	l00a3(pc),a0
	bsr	l0074
	move.w	d0,-(a7)
	move.b	(a7)+,22(a6)
	move.b	d0,18(a6)
	move.b	d1,42(a6)
	move.w	4(a5),d0
	beq.s	l0061
	move.w	d0,-(a7)
	lea	l00a4(pc),a0
	bsr	l0074
	movea.l	8(a0),a1
	adda.w	12(a0),a1
	cmpi.b	#-$1f,(a1)
	bne.s	l0060
	clr.w	4(a5)
l0060	move.w	(a7)+,d7
	lea	l0098(pc),a1
	add.w	d7,d7
	add.w	d7,d7
	adda.w	d7,a1
	moveq	#0,d6
	move.b	(a1)+,d6
	move.w	d0,-(a7)
	move.b	d0,0(a6,d6.w)
	move.b	(a1)+,d6
	move.b	(a7)+,0(a6,d6.w)
	move.b	(a1)+,d6
	move.b	d1,0(a6,d6.w)
l0061	move.b	(a5)+,d7
	ori.b	#-$40,d7
	move.b	d7,30(a6)
	move.b	(a5)+,26(a6)
	move.b	l00af(pc),d0
	bne.s	l0062
	movem.l	(a6),a0-a2/d0-d7
	movem.l	a0-a2/d0-d7,-$77c0.w
l0062	rts

l0063	subq.b	#1,44(a0)
	bpl.s	l0062
	move.b	45(a0),44(a0)
l0064	movea.l	40(a0),a1
l0065	move.b	(a1)+,d0
	cmp.b	#-1,d0
	bne	l0069
	movea.l	0(a0),a2
	adda.w	4(a0),a2
	tst.b	d4
	bne.s	l0066
	subq.w	#1,50(a0)
	bpl.s	l0066
	move.w	l00a5(pc),50(a0)
	move.w	d5,4(a0)
	move.w	d5,58(a0)
	move.w	d5,112(a0)
	movea.l	0(a0),a2
l0066	moveq	#0,d1
	move.b	(a2),d1
	move.b	1(a2),21(a0)
	move.b	2(a2),20(a0)
	move.b	3(a2),d0
	move.b	d0,d2
	andi.w	#$f0,d2
	cmp.w	#$f0,d2
	bne.s	l0067
	move.b	d0,d2
	andi.b	#$f,d2
	move.b	d2,36(a0)
	bra.s	l0068
l0067	cmp.b	#-$20,d2
	bne.s	l0068
	move.b	d0,d2
	andi.w	#$f,d2
	move.w	d2,2(a5)
l0068	add.w	d1,d1
	movea.l	l00a6(pc),a3
	movea.w	0(a3,d1.w),a3
	adda.l	l00ae(pc),a3
	move.l	a3,40(a0)
	addi.w	#$c,4(a0)
	bra	l0064
l0069	cmp.b	#-2,d0
	bne.s	l006a
	move.b	(a1),45(a0)
	move.b	(a1)+,44(a0)
	bra	l0065
l006a	cmp.b	#-3,d0
	bne.s	l006b
	move.b	(a1),45(a0)
	move.b	(a1)+,44(a0)
	move.l	a1,40(a0)
	rts

l006b	move.b	d0,6(a0)
	move.b	(a1)+,d1
	move.b	d1,7(a0)
	andi.w	#$e0,d1
	beq.s	l006c
	move.b	(a1)+,32(a0)
l006c	move.l	a1,40(a0)
	move.l	d5,46(a0)
	tst.b	d0
	bmi.s	l006e
	move.b	7(a0),d1
	move.b	d1,d0
	andi.w	#$1f,d1
	add.b	20(a0),d1
	movea.l	l00a8(pc),a2
	add.w	d1,d1
	movea.w	0(a2,d1.w),a2
	adda.l	l00ae(pc),a2
	move.w	d5,12(a0)
	move.b	(a2),23(a0)
	move.b	(a2)+,22(a0)
	moveq	#0,d1
	move.b	(a2)+,d1
	move.b	(a2)+,27(a0)
	move.b	#$40,31(a0)
	move.b	(a2),28(a0)
	move.b	(a2)+,29(a0)
	move.b	(a2)+,30(a0)
	move.l	a2,8(a0)
	andi.b	#$40,d0
	beq.s	l006d
	move.b	32(a0),d1
l006d	movea.l	l00a7(pc),a2
	add.w	d1,d1
	movea.w	0(a2,d1.w),a2
	adda.l	l00ae(pc),a2
	move.l	a2,14(a0)
	move.w	d5,18(a0)
	move.b	d5,25(a0)
	move.b	d5,24(a0)
l006e	rts

l006f	lea	l009b(pc),a0
	clr.l	(a0)
	move.l	d0,d7
	move.l	d1,d6
	sub.l	d0,d1
	addq.l	#1,d6
	mulu	#$c,d7
	mulu	#$c,d6
	lea	l00a5(pc),a0
	move.w	d1,(a0)
	moveq	#2,d0
	lea	l00a0(pc),a0
	lea	l0095(pc),a1
	lea	l0096(pc),a2
l0070	move.l	a1,14(a0)
	clr.w	18(a0)
	move.l	a1,8(a0)
	clr.w	12(a0)
	sf	6(a0)
	sf	7(a0)
	sf	26(a0)
	sf	35(a0)
	move.b	#1,23(a0)
	move.b	#1,22(a0)
	sf	24(a0)
	sf	25(a0)
	sf	27(a0)
	sf	28(a0)
	sf	29(a0)
	sf	30(a0)
	sf	32(a0)
	sf	33(a0)
	move.b	(a2),d3
	andi.w	#$f,d3
	add.w	d3,d3
	add.w	d3,d3
	move.b	(a2)+,34(a0)
	movea.l	l00a9(pc),a3
	adda.l	d7,a3
	adda.w	d3,a3
	move.l	a3,0(a0)
	move.w	#$c,4(a0)
	move.w	l00a5(pc),50(a0)
	moveq	#0,d1
	move.b	(a3)+,d1
	add.w	d1,d1
	movea.l	l00a6(pc),a4
	movea.w	0(a4,d1.w),a4
	adda.l	l00ae(pc),a4
	move.l	a4,40(a0)
	clr.w	44(a0)
	move.b	#2,38(a0)
	move.b	(a3)+,21(a0)
	move.b	(a3)+,20(a0)
	sf	37(a0)
	sf	36(a0)
	move.b	(a3)+,d1
	move.b	d1,d2
	andi.w	#$f0,d1
	cmp.w	#$f0,d1
	bne.s	l0071
	sub.b	d1,d2
	move.b	d2,36(a0)
l0071	clr.l	46(a0)
	lea	54(a0),a0
	dbf	d0,l0070
	lea	l009d(pc),a0
	move.w	#1,(a0)
	clr.w	4(a0)
	rts

l0072	move.w	l00ad(pc),d2
	move.w	l00ac(pc),d1
	tst.w	d2
	beq	l0073
	lea	l00a4(pc),a0
	lea	l009c(pc),a5
	move.b	d2,6(a0)
	move.b	d1,34(a0)
	sf	21(a0)
	moveq	#0,d5
	andi.w	#$ff,d0
	movea.l	l00a8(pc),a2
	add.w	d0,d0
	movea.w	0(a2,d0.w),a2
	adda.l	l00ae(pc),a2
	move.w	d5,12(a0)
	move.b	(a2),23(a0)
	move.b	(a2)+,22(a0)
	move.b	(a2)+,d0
	andi.w	#$ff,d0
	move.b	(a2)+,27(a0)
	move.b	#$40,31(a0)
	move.b	(a2),28(a0)
	move.b	(a2)+,29(a0)
	move.b	(a2)+,30(a0)
	move.l	a2,8(a0)
	movea.l	l00a7(pc),a2
	add.w	d0,d0
	movea.w	0(a2,d0.w),a2
	adda.l	l00ae(pc),a2
	move.l	a2,14(a0)
	move.w	d5,18(a0)
	sf	24(a0)
	sf	25(a0)
	clr.l	46(a0)
	sf	36(a0)
	sf	32(a0)
	addq.w	#1,d1
	move.w	d1,4(a5)
l0073	rts

l0074	moveq	#0,d7
	move.b	d7,33(a0)
l0075	tst.b	25(a0)
	beq.s	l0076
	subq.b	#1,25(a0)
	bra	l007b
l0076	movea.l	14(a0),a1
	adda.w	18(a0),a1
l0077	move.b	(a1)+,d0
	moveq	#0,d1
	move.b	d0,d1
	subi.w	#$e0,d1
	bmi	l007a
	add.w	d1,d1
	move.w	l0078(pc,d1.w),d1
	jmp	l0079(pc,d1.w)
l0078	dc.b	0,0,0,$10,0,$1a,0,'*'
	dc.b	0,':',0,'J',0,'X',0,'f'
	dc.b	0,$80,0,$8c,0,$aa
l0079	moveq	#0,d0
	move.b	(a1)+,d0
	move.w	d0,18(a0)
	movea.l	14(a0),a1
	adda.l	d0,a1
	bra.s	l0077
	move.b	-2(a1),26(a0)
	bra	l007b
	move.w	d7,12(a0)
	move.b	#1,22(a0)
	addq.w	#1,18(a0)
	bra.s	l0077
	move.b	(a1)+,27(a0)
	move.b	(a1)+,28(a0)
	addq.w	#3,18(a0)
	bra	l0077
	move.b	d7,38(a0)
	move.b	(a1)+,33(a0)
	addq.w	#2,18(a0)
	bra	l0077
	move.b	#1,38(a0)
	addq.w	#1,18(a0)
	bra	l0077
	move.b	#2,38(a0)
	addq.w	#1,18(a0)
	bra	l0077
	move.b	#0,d1
	move.b	(a1)+,d1
	lsl.w	#6,d1
	movea.l	l00a7(pc),a1
	adda.w	d1,a1
	move.l	a1,14(a0)
	move.w	d7,18(a0)
	bra	l0077
	move.b	(a1)+,25(a0)
	addq.w	#2,18(a0)
	bra	l0075
	movea.w	#-$7790,a3
	move.b	#$b,(a3)
	move.b	(a1)+,2(a3)
	move.l	#$c000d0a,d0
	movep.l	d0,8(a3)
	addq.w	#2,18(a0)
	bra	l0077
	move.b	#$20,7(a0)
	move.b	(a1)+,32(a0)
	addq.w	#2,18(a0)
	bra	l0077
l007a	move.b	d0,26(a0)
	addq.w	#1,18(a0)
l007b	tst.b	24(a0)
	beq.s	l007c
	subq.b	#1,24(a0)
	bra.s	l0081
l007c	subq.b	#1,22(a0)
	bne.s	l0081
	move.b	23(a0),22(a0)
	movea.l	8(a0),a1
	adda.w	12(a0),a1
l007d	moveq	#0,d1
	move.b	(a1)+,d0
	move.b	d0,d1
	subi.w	#$e0,d1
	bmi.s	l0080
	add.w	d1,d1
	move.w	l007e(pc,d1.w),d1
	jmp	l007f(pc,d1.w)
l007e	dc.b	0,2,0,$14,0,0,0,0
	ds.w	4
	dc.b	0,$1c
l007f	rts

	moveq	#0,d1
	move.b	(a1)+,d1
	subq.w	#5,d1
	move.w	d1,12(a0)
	movea.l	8(a0),a1
	adda.w	d1,a1
	bra.s	l007d
	move.b	-2(a1),35(a0)
	bra.s	l0081
	addq.w	#2,12(a0)
	move.b	(a1),24(a0)
	bra.s	l007b
l0080	move.b	d0,35(a0)
	addq.w	#1,12(a0)
l0081	move.b	26(a0),d0
	bmi.s	l0082
	add.b	6(a0),d0
	add.b	21(a0),d0
l0082	andi.w	#$7f,d0
	lea	l00b0(pc),a1
	add.w	d0,d0
	move.w	d0,d1
	move.w	0(a1,d0.w),d0
	move.b	34(a0),d3
	move.b	38(a0),d2
	bne.s	l0083
	bclr	d3,(a5)
	addq.w	#3,d3
	bclr	d3,(a5)
	bra.s	l0086
l0083	cmp.b	#1,d2
	bne.s	l0085
	bset	d3,(a5)
	addq.w	#3,d3
	bclr	d3,(a5)
	move.b	6(a0),33(a0)
	move.b	26(a0),d4
	bpl.s	l0084
	andi.b	#$7f,d4
	move.b	d4,33(a0)
	bra.s	l0086
l0084	add.b	d4,33(a0)
	bra.s	l0086
l0085	bclr	d3,(a5)
	addq.w	#3,d3
	bset	d3,(a5)
l0086	tst.b	33(a0)
	beq.s	l0087
	move.b	33(a0),d3
	not.b	d3
	andi.b	#$1f,d3
	move.b	d3,1(a5)
l0087	move.b	31(a0),d6
	tst.b	30(a0)
	beq.s	l0088
	subq.b	#1,30(a0)
	bra.s	l0092
l0088	move.b	d1,d5
	move.b	28(a0),d4
	bmi.s	l0089
	add.b	d4,d4
	bra.s	l008a
l0089	andi.b	#$7f,d4
l008a	move.b	29(a0),d1
	tst.b	d6
	bpl.s	l008b
	btst	d7,d6
	bne.s	l008e
l008b	btst	#5,d6
	bne.s	l008c
	sub.b	27(a0),d1
	bcc.s	l008d
	bset	#5,d6
	moveq	#0,d1
	bra.s	l008d
l008c	add.b	27(a0),d1
	cmp.b	d4,d1
	bcs.s	l008d
	bclr	#5,d6
	move.b	d4,d1
l008d	move.b	d1,29(a0)
l008e	lsr.b	#1,d4
	sub.b	d4,d1
	bcc.s	l008f
	subi.w	#$100,d1
l008f	addi.b	#-$60,d5
	bcs.s	l0091
l0090	add.w	d1,d1
	addi.b	#$18,d5
	bcc.s	l0090
l0091	add.w	d1,d0
l0092	bchg	d7,d6
	move.b	d6,31(a0)
	btst	#5,7(a0)
	beq.s	l0093
	moveq	#0,d1
	move.b	32(a0),d1
	ext.w	d1
	swap	d1
	asr.l	#4,d1
	move.l	46(a0),d2
	add.l	d1,d2
	move.l	d2,46(a0)
	swap	d2
	sub.w	d2,d0
l0093	move.b	35(a0),d1
	sub.b	36(a0),d1
	sub.b	37(a0),d1
	bpl.s	l0094
	moveq	#0,d1
l0094	rts

l0095	dc.b	1,0,0,0,0,0,0,$e1
l0096	dc.b	0,1,2,0
l0097	dc.b	0,0,':',0,1,1,1,0
	dc.b	2,2,$c,0,3,3,1,0
	dc.b	4,4,$ee,0,5,5,$e,0
	dc.b	6,6,0,0,7,7,$f8,$ff
	dc.b	8,8,$d,0,9,9,7,0
	dc.b	$a,$a,0,0
l0098	ds.w	2
	dc.b	2,6,'"',0,$a,$e,'&',0
	dc.b	$12,$16,'*',0
l0099	dc.b	0,0
l009a	dc.b	0,1,2,3,4,5,6,7
	dc.b	8,9,$a,$b,$f,$f,$f,$f
	dc.b	$f,$f
l009b	ds.w	2
l009c	dc.b	'8',0,0,0,0,0,0,0
l009d	dc.b	0,3
l009e	dc.b	0,4
l009f	dc.b	0,0
l00a0	dc.b	0,8,'-\',0,'$+',0
	dc.b	0,8,')',$d,0,3,0,8
	dc.b	'(',$a2,0,4,0,0,1,2
	dc.b	0,0,0,1,2,0,0,'@'
	dc.b	0,0,0,$d,0
l00a1	dc.b	0,2,0,0,8,'+',$a2,2,3
	ds.w	2
	dc.b	0,'X',0,0
l00a2	dc.b	0,8,'-`',0,'$0',0
	dc.b	0,8,')',$d,0,$b,0,8
	dc.b	'(',$a2,0,4,0,$fe,1,2
	dc.b	0,0,0,1,2,2,0,'@'
	dc.b	0,0,1,7,0,0,2,0
	dc.b	0,8,'+',$bf,0,5,0,0
	dc.b	0,0,0,'Z',0,0
l00a3	dc.b	0,8,'-d',0,'$',0,0
	dc.b	0,8,'%',$e2,0,7,0,8
	dc.b	'%',$e2,0,7,0,0,1,1
	ds.w	5
	dc.b	2,0,$f,0,2,0,0,8
	dc.b	')',$de,$10,$1f,0,0,0,0
	dc.b	0,'Z',0,0
l00a4	ds.w	27
	dc.b	0,'@'
l00a5	dc.b	0,'Z'
l00a6	dc.b	0,8,')',$92
l00a7	dc.b	0,8,'(',$90
l00a8	dc.b	0,8,'(',$f6
l00a9	dc.b	0,8,'-\',0,0
l00aa	dc.b	0,8,'1',$a0
l00ab	dc.b	0,8,'1',$b2
l00ac	dc.b	0,0
l00ad	dc.b	0,0
l00ae	dc.b	0,8,'(P'
l00af	dc.b	0,0
l00b0	dc.b	$e,$ee,$e,$17,$d,'M',$c,$8e
	dc.b	$b,$d9,$b,'/',$a,$8e,9,$f7
	dc.b	9,'g',8,$e0,8,'a',7,$e8
	dc.b	7,'w',7,$b,6,$a6,6,'G'
	dc.b	5,$ec,5,$97,5,'G',4,$fb
	dc.b	4,$b3,4,'p',4,'0',3,$f4
	dc.b	3,$bb,3,$85,3,'S',3,'#'
	dc.b	2,$f6,2,$cb,2,$a3,2,'}'
	dc.b	2,'Y',2,'8',2,$18,1,$fa
	dc.b	1,$dd,1,$c2,1,$a9,1,$91
	dc.b	1,'{',1,'e',1,'Q',1,'>'
	dc.b	1,',',1,$1c,1,$c,0,$fd
	dc.b	0,$ee,0,$e1,0,$d4,0,$c8
	dc.b	0,$bd,0,$b2,0,$a8,0,$9f
	dc.b	0,$96,0,$8e,0,$86,0,'~'
	dc.b	0,'w',0,'p',0,'j',0,'d'
	dc.b	0,'^',0,'Y',0,'T',0,'O'
	dc.b	0,'K',0,'G',0,'C',0,'?'
	dc.b	0,';',0,'8',0,'5',0,'2'
	dc.b	0,'/',0,',',0,'*',0,$27
	dc.b	0,'%',0,'#',0,'!',0,$1f
	dc.b	0,$1d,0,$1c,0,$1a,0,$19
	dc.b	0,$17,0,$16,0,$15,0,$13
	dc.b	0,$12,0,$11,0,$10,0,$f
	ds.w	32
l00b1	dc.b	'COSO',0,0,0,'@'
	dc.b	0,0,0,$a6,0,0,1,'B'
	dc.b	0,0,5,$c,0,0,9,'P'
	dc.b	0,0,9,'b',0,0,0,0
	dc.b	'TFMX',0,8,0,8
	dc.b	0,'$',0,'Z',0,'@',0,4
	dc.b	0,2,0,0,0,0,0,0
	ds.w	4
	dc.b	0,'R',0,'W',0,']',0,'d'
	dc.b	0,'m',0,'|',0,$81,0,$85
	dc.b	0,$9a,$e2,$e6,0,0,$e1,$e2
	dc.b	$e9,$1e,$e6,0,$e1,$e2,$e9,'!'
	dc.b	$e6,$c,0,$e1,$e2,$e5,$94,$e6
	dc.b	$97,$93,$90,$82,$e1,$e2,$e5,$94
	dc.b	$e6,$9d,$9f,$e5,$94,$90,$96,$94
	dc.b	$92,$90,0,$e1,$e2,$e6,$c,0
	dc.b	$e1,$e2,$e6,0,$e1,$e2,$e5,$9a
	dc.b	$e6,$f,$e,$d,$c,$b,$a,9
	dc.b	8,7,6,5,4,3,2,1
	dc.b	0,$e1,$e2,$e6,0,$e8,$10,0
	dc.b	$e3,2,4,0,$e1,0,0,$b8
	dc.b	0,$d0,0,$d7,0,$de,0,$ea
	dc.b	1,3,1,$1a,1,'"',1,'9'
	dc.b	2,0,1,2,4,$d,$e,$d
	dc.b	$c,$b,$a,$b,$a,9,8,7
	dc.b	6,5,4,3,2,1,0,$e1
	dc.b	1,1,0,0,0,$10,$e1,1
	dc.b	2,0,0,0,$10,$e1,1,3
	dc.b	0,0,0,$d,$f,$f,$10,$a
	dc.b	0,$e1,1,4,0,0,0,$d
	dc.b	$f,$f,$e,$d,$c,$b,$a,9
	dc.b	8,7,6,5,5,4,3,2
	dc.b	1,0,$e1,1,5,1,2,0
	dc.b	$c,$d,$e,$d,$c,$b,$a,9
	dc.b	8,7,6,5,4,3,2,1
	dc.b	0,$e1,1,6,2,4,$a,$f
	dc.b	$e,$e1,1,7,0,0,0,$d
	dc.b	$f,$e,$d,$c,$b,$a,9,8
	dc.b	7,6,5,4,3,2,1,0
	dc.b	$e1,1,8,1,1,0,$f,$e
	dc.b	$e1,0,1,$8c,1,$8f,1,$bc
	dc.b	1,$cf,1,$e2,1,$f3,2,4
	dc.b	2,'A',2,'|',2,$b5,2,$f4
	dc.b	3,$17,3,':',3,'g',3,'x'
	dc.b	3,$a5,3,$b0,3,$b5,3,$be
	dc.b	3,$c6,3,$d6,3,$db,3,$e2
	dc.b	3,$ed,3,$f6,4,$19,4,':'
	dc.b	4,'_',4,$82,4,$a5,4,$c8
	dc.b	4,$cd,4,$dd,4,$e8,4,$f1
	dc.b	4,$f6,4,$fb,$fd,$1f,$ff,$fe
	dc.b	1,'+',0,$fe,3,'0',0,$fe
	dc.b	1,'+',0,$fe,3,'0',0,$fe
	dc.b	1,'+',0,$fe,3,'0',0,$fe
	dc.b	1,'+',0,$fe,3,'0',0,$fe
	dc.b	1,'+',0,$fe,3,'0',0,$fe
	dc.b	1,'+',0,$ff,$fe,3,$c,0
	dc.b	$c,0,$c,0,$c,0,$c,0
	dc.b	$c,0,$c,0,$c,0,$ff,$fd
	dc.b	3,$fe,5,'7',0,'5',0,'3'
	dc.b	0,'2',0,$fe,1,'3',0,'5'
	dc.b	0,$ff,$fd,3,$fe,5,'7',0
	dc.b	'5',0,'4',0,'2',0,$fe,3
	dc.b	'5',0,$ff,$fd,3,$fe,5,'7'
	dc.b	0,'5',0,'4',0,'2',0,$fe
	dc.b	3,'4',0,$ff,$fe,0,$c,3
	dc.b	$18,1,$fe,1,$c,1,$c,1
	dc.b	$c,1,$c,4,$c,1,$c,1
	dc.b	$c,1,$fe,0,$c,3,$18,1
	dc.b	$fe,1,$c,1,$fe,0,$c,3
	dc.b	$18,1,$fe,1,$c,1,$c,4
	dc.b	$fe,0,$c,3,$18,1,$fe,1
	dc.b	$c,1,$fe,0,$c,3,$18,1
	dc.b	$ff,$fe,1,$c,3,$fe,3,$c
	dc.b	1,$fe,1,$c,1,$c,4,$c
	dc.b	1,$fe,0,$c,3,$18,1,$fe
	dc.b	1,$c,1,$c,1,$fe,0,$c
	dc.b	3,$18,1,$c,0,$c,1,$c
	dc.b	3,$18,1,$fe,1,$c,4,$c
	dc.b	1,$fe,0,$c,3,$18,1,$fe
	dc.b	1,$c,1,$ff,$fe,0,$c,3
	dc.b	$18,2,$fe,1,$c,2,$c,2
	dc.b	$c,2,$c,4,$c,2,$c,2
	dc.b	$c,2,$fe,0,$c,3,$18,2
	dc.b	$fe,1,$c,2,$fe,0,$c,3
	dc.b	$18,2,$fe,1,$c,2,$c,4
	dc.b	$fe,0,$c,3,$18,2,$fe,1
	dc.b	$c,2,$c,3,$ff,$fe,0,$c
	dc.b	3,$18,2,$fe,1,$c,2,$c
	dc.b	2,$c,2,$c,4,$c,2,$fe
	dc.b	0,$c,3,$18,2,$fe,1,$c
	dc.b	2,$fe,0,$c,3,$18,2,$fe
	dc.b	1,$c,4,$fe,0,$c,3,$18
	dc.b	2,$fe,1,$c,2,$c,4,$c
	dc.b	2,$fe,0,$c,2,$18,2,$fe
	dc.b	1,$c,4,$ff,$fe,1,'+',0
	dc.b	'0',0,'7',0,'+',0,'0',0
	dc.b	'5',0,'+',0,'0',0,'3',0
	dc.b	'+',0,'0',0,'2',0,'+',0
	dc.b	'0',0,'3',0,'5',0,$ff,$fe
	dc.b	1,')',0,'.',0,'5',0,')'
	dc.b	0,'.',0,'3',0,')',0,'.'
	dc.b	0,'2',0,')',0,'.',0,'0'
	dc.b	0,')',0,'.',0,'2',0,'3'
	dc.b	0,$ff,$fe,1,'$',0,$fe,3
	dc.b	'+',0,$fe,1,'$',0,$fe,3
	dc.b	'+',0,$fe,1,'$',0,$fe,3
	dc.b	'+',0,$fe,1,'$',0,$fe,3
	dc.b	'+',0,$fe,1,'$',0,$fe,3
	dc.b	'+',0,$fe,1,'+',0,$ff,$fd
	dc.b	3,$fe,5,'0',0,'0',0,'0'
	dc.b	0,'0',0,$fe,3,'0',0,$ff
	dc.b	$fe,1,'$',0,$fe,3,')',0
	dc.b	$fe,1,'$',0,$fe,3,')',0
	dc.b	$fe,1,'$',0,$fe,3,')',0
	dc.b	$fe,1,'$',0,$fe,3,')',0
	dc.b	$fe,1,'$',0,$fe,3,')',0
	dc.b	$fe,1,')',0,$ff,$fe,$17,$8c
	dc.b	' ',$7f,$fe,7,$16,'  ',$ff
	dc.b	$fe,$1f,$18,0,$ff,$fd,$17,$fe
	dc.b	3,$1a,0,$18,0,$ff,$fe,$f
	dc.b	$16,' ',$14,$98,0,$ff,$fd,$17
	dc.b	$fe,3,$16,0,$fe,0,$15,' '
	dc.b	$80,$fe,2,$93,0,$ff,$fe,$1f
	dc.b	$11,0,$ff,$fd,$17,$fe,7,$f
	dc.b	0,$ff,$fe,0,$11,0,$f,0
	dc.b	$fe,$1d,$c,0,$ff,$fe,$1d,$c
	dc.b	3,$fe,1,$c,3,$ff,$fe,1
	dc.b	'$',0,'+',0,'0',0,'$',0
	dc.b	'+',0,'0',0,'$',0,'+',0
	dc.b	'0',0,'$',0,'+',0,'0',0
	dc.b	'$',0,'+',0,'0',0,'+',0
	dc.b	$ff,$fe,3,$c,3,$c,7,$fe
	dc.b	1,$a,7,$fe,5,$a,7,$fe
	dc.b	1,8,7,$fe,3,7,7,7
	dc.b	7,$fe,1,5,7,$fe,3,5
	dc.b	7,$ff,$fe,1,$c,3,$c,0
	dc.b	$c,0,$c,0,$fe,3,$c,4
	dc.b	$fe,1,$c,0,$c,3,$c,3
	dc.b	$c,0,$c,3,$c,0,$c,4
	dc.b	$c,0,$fe,3,$c,0,$ff,$fe
	dc.b	1,'$',0,'+',0,'.',0,'$'
	dc.b	0,'+',0,'.',0,'$',0,'+'
	dc.b	0,'.',0,'$',0,'+',0,'.'
	dc.b	0,'$',0,'+',0,'.',0,'+'
	dc.b	0,$ff,$fe,1,'$',0,')',0
	dc.b	'.',0,'$',0,')',0,'.',0
	dc.b	'$',0,')',0,'.',0,'$',0
	dc.b	')',0,'.',0,'$',0,')',0
	dc.b	'.',0,')',0,$ff,$fe,1,'$'
	dc.b	0,')',0,'-',0,'$',0,')'
	dc.b	0,'-',0,'$',0,')',0,'-'
	dc.b	0,'$',0,')',0,'-',0,'$'
	dc.b	0,')',0,'-',0,')',0,$ff
	dc.b	$fe,$1f,'$',0,$ff,$fe,3,'*'
	dc.b	' ',$10,$fe,$17,$ab,0,$fe,1
	dc.b	')',0,$27,0,$ff,$fe,$1b,')'
	dc.b	0,$fe,1,'+',0,')',0,$ff
	dc.b	$fd,$f,$fe,7,$27,0,')',0
	dc.b	$ff,$fe,$1f,'+',0,$ff,$fe,$1f
	dc.b	'0',0,$ff,$fe,3,'* ',8
	dc.b	$fe,$17,$ab,0,$fe,1,')',0
	dc.b	$27,0,$ff,0,$c,0,0,$f0
	dc.b	$d,0,0,$f0,0,0,0,$ff
	dc.b	$c,0,0,0,$d,0,0,0
	ds.w	2
	dc.b	$c,0,0,0,$d,$fe,0,0
	ds.w	2
	dc.b	$c,0,0,0,$d,$fe,0,0
	ds.w	2
	dc.b	$e,0,0,0,$d,$fe,0,0
	ds.w	2
	dc.b	$e,0,0,0,$d,$fd,0,0
	ds.w	2
	dc.b	$c,0,0,0,$d,0,0,0
	ds.w	2
	dc.b	$c,0,0,0,$d,0,0,0
	dc.b	$f,0,6,$f0,$c,0,0,0
	dc.b	$d,0,0,0,$10,0,6,0
	dc.b	$c,0,0,0,$d,0,0,0
	dc.b	$11,0,6,0,$c,0,0,0
	dc.b	$d,$fe,0,0,$12,0,6,0
	dc.b	$c,0,0,0,$d,$fe,0,0
	dc.b	$13,0,6,0,$e,0,0,0
	dc.b	$d,$fe,0,0,$14,0,6,0
	dc.b	$e,0,0,0,$d,$fd,0,0
	dc.b	$15,0,6,0,$c,0,0,0
	dc.b	$d,0,0,0,$16,0,6,0
	dc.b	$c,0,0,0,$d,0,0,0
	dc.b	$f,0,6,0,$18,0,0,0
	dc.b	6,0,0,0,$10,0,6,0
	dc.b	$18,0,0,0,7,0,0,0
	dc.b	$11,0,6,0,$1b,0,0,0
	dc.b	8,$fe,0,0,$12,0,6,0
	dc.b	$1b,0,0,0,9,$fe,0,0
	dc.b	$13,0,6,0,$1c,0,0,0
	dc.b	$1a,$f9,0,0,$14,0,6,0
	dc.b	$1d,0,0,0,$1a,$f9,0,0
	dc.b	$15,0,6,0,$18,0,0,0
	dc.b	6,0,0,0,$16,0,6,'P'
	dc.b	$18,0,0,0,7,0,0,0
	dc.b	0,0,6,0,1,0,0,0
	dc.b	3,0,0,0,6,0,0,0
	dc.b	1,0,0,0,3,0,0,0
	dc.b	7,0,0,0,1,$fe,0,0
	dc.b	4,$fe,0,0,8,$fe,0,0
	dc.b	1,$fe,0,0,5,$fe,0,0
	dc.b	9,$fe,0,0,1,0,0,0
	dc.b	3,0,0,0,6,0,0,0
	dc.b	1,0,0,0,3,0,0,0
	dc.b	7,0,0,0,1,$fe,0,0
	dc.b	5,$fe,0,0,8,$fe,0,0
	dc.b	1,$fe,0,0,4,$fe,0,0
	dc.b	9,$fe,0,0,$a,0,0,0
	dc.b	$1e,0,8,$f1,6,0,0,0
	dc.b	$a,0,0,0,$1f,0,8,0
	dc.b	7,0,0,0,$b,0,0,0
	dc.b	' ',0,8,0,8,$fe,0,0
	dc.b	$b,0,0,0,'!',0,8,0
	dc.b	9,$fe,0,0,$a,0,0,0
	dc.b	'"',0,8,$f1,6,0,0,0
	dc.b	$a,0,0,0,'#',0,8,$f1
	dc.b	7,0,0,0,$b,0,0,0
	dc.b	' ',0,8,0,8,$fe,0,0
	dc.b	$b,0,0,0,0,0,8,0
	dc.b	9,$fe,0,0,$a,0,0,0
	dc.b	$c,0,0,$f1,6,0,0,0
	dc.b	$a,0,0,0,$c,0,0,0
	dc.b	7,0,0,0,$b,0,0,0
	dc.b	$c,$fe,0,0,8,$fe,0,0
	dc.b	$b,0,0,0,$c,$fe,0,0
	dc.b	9,$fe,0,0,$a,0,0,0
	dc.b	$c,0,0,$f1,6,0,0,0
	dc.b	$a,0,0,0,$c,0,0,0
	dc.b	7,0,0,0,$b,0,0,0
	dc.b	$c,$fe,0,0,8,$fe,0,0
	dc.b	$b,0,0,0,$c,$fe,0,0
	dc.b	9,$fe,0,0,$a,0,0,0
	dc.b	$1e,$c,8,$f1,6,0,0,0
	dc.b	$a,0,0,0,'$',$c,8,0
	dc.b	7,0,0,0,$b,0,0,0
	dc.b	' ',$c,8,0,8,$fe,0,0
	dc.b	$b,0,0,0,'!',$c,8,0
	dc.b	9,$fe,0,0,$a,0,0,0
	dc.b	'"',$c,8,$f1,6,0,0,0
	dc.b	$a,0,0,0,'#',$c,8,$f1
	dc.b	7,0,0,0,$b,0,0,0
	dc.b	' ',$c,8,0,8,$fe,0,0
	dc.b	$b,0,0,0,0,$c,8,0
	dc.b	9,$fe,0,0,1,0,0,0
	dc.b	3,0,0,0,6,0,0,0
	dc.b	1,0,0,0,3,0,0,0
	dc.b	7,0,0,0,1,$fe,0,0
	dc.b	5,$fe,0,0,8,$fe,0,0
	dc.b	1,$fe,0,0,4,$fe,0,0
	dc.b	9,$fe,0,0,1,0,0,0
	dc.b	3,0,0,0,6,0,0,0
	dc.b	1,0,0,0,3,0,0,0
	dc.b	7,0,0,0,1,$fe,0,0
	dc.b	5,$fe,0,0,8,$fe,0,0
	dc.b	1,$fe,0,0,4,$fe,0,0
	dc.b	9,$fe,0,0,$18,0,0,0
	dc.b	6,0,0,$f0,$10,0,6,0
	dc.b	$18,0,0,0,7,0,0,0
	dc.b	$11,0,6,0,$1b,0,0,0
	dc.b	8,$fe,0,0,$12,0,6,0
	dc.b	$1b,0,0,0,9,$fe,0,0
	dc.b	$13,0,6,0,$1c,0,0,0
	dc.b	$1a,$f9,0,0,$14,0,6,0
	dc.b	$1d,0,0,0,$1a,$f9,0,0
	dc.b	$15,0,6,0,$18,0,0,0
	dc.b	6,0,0,0,$16,0,6,'P'
	dc.b	$18,0,0,0,7,0,0,0
	dc.b	0,0,6,0,$18,0,0,0
	dc.b	6,0,0,0,$10,0,6,0
	dc.b	$18,0,0,0,7,0,0,0
	dc.b	$11,0,6,0,$1b,0,0,0
	dc.b	8,$fe,0,0,$12,0,6,0
	dc.b	$1b,0,0,0,9,$fe,0,0
	dc.b	$13,0,6,0,$1c,0,0,0
	dc.b	$1a,$f9,0,0,$14,0,6,0
	dc.b	$1d,0,0,0,$1a,$f9,0,0
	dc.b	$15,0,6,0,$18,0,0,0
	dc.b	6,0,0,0,$16,0,6,0
	dc.b	$18,0,0,0,7,0,0,0
	dc.b	0,0,6,0,$18,0,0,$f1
	dc.b	6,0,0,0,$c,$fb,0,$f1
	dc.b	$18,0,0,$f2,7,0,0,0
	dc.b	$c,$fc,0,$f2,$18,0,0,$f3
	dc.b	6,0,0,0,$c,$fe,0,$f3
	dc.b	$18,0,0,$f4,7,0,0,0
	dc.b	$c,0,0,$f4,$18,0,0,$f7
	dc.b	6,0,0,0,$c,0,0,$f7
	dc.b	$18,0,0,$ff,7,0,0,0
	dc.b	0,0,0,$ff,$c,0,0,$f3
	dc.b	$d,0,0,$f3,$1a,0,0,$f0
	dc.b	$c,0,0,$f2,$d,0,0,$f2
	dc.b	$1a,0,0,$f1,$c,0,0,$f1
	dc.b	$d,0,0,$f1,$1a,0,0,$f2
	dc.b	$c,0,0,$f0,$d,0,0,$f0
	dc.b	$1a,0,0,$f3,$c,0,0,$f0
	dc.b	$d,0,0,$f0,$1a,0,0,$f4
	dc.b	0,0,0,'Z',0,4,0,0
	dc.b	0,'Z',0,4,0,0,0,0
	ds.w	4
	dc.b	'`',0
hz	ds.w	2
sstore	ds.w	2
sstore2	ds.w	32
sstore3	ds.w	2
storage	ds.w	40
phys	ds.w	2
logi	ds.w	2
res	ds.w	2
hz_delay	ds.w	2
text	dc.b	'HELLO FOLKS AND WELCOME TO SAFARI MENU 5. ITS RHINO ON '
	dc.b	'THE KEYBOARD AND WHAT GOODIES DO WE HAVE FOR YOU THIS '
	dc.b	'TIME I HERE YOU ASK. WELL THERES  .....DISCOVERY......'
	dc.b	'HACKED BY QUARTEX.........PACKED BY JR2......OXXONIAN......'
	dc.b	'HACKED BY CYNIX ......RESET SCREEN FROM TLBS WHAT A SCORCHER DEMO'
	dc.b	'......RIPPED BY JR2......68000 TUTORIAL 1 WRITTEN BY PANTHER......'
	dc.b	'AND FINALLY THE NEWEST VERSION OF MULTI-DEPACK VERSION 1.5.'
	dc.b	'HERES AN AMAZING FACT FOR YOU PANTHER IS ALSO BECOME A MEMBER '
	dc.b	'IN ADRENELIN WHICH MEANS IM GONNA HAVE TO GET OFF MY LAZY ARSE '
	dc.b	'AND TRY TO CODE SOME MENUS. ANYWAY ILL HAND YOU OVER TO JOLLY '
	dc.b	'ROGER 2ND FOR ABIT.........YES THIS IS IT IM TYPING A SCROLLER '
	dc.b	'FOR THAT NEW AMAZING GROUP CALLED SAFARI  IM THE NEW MEMBER '
	dc.b	'WHO GOES BY THE NAME OF JOLLY ROGER II   LET ME TELL YOU ABIT '
	dc.b	'ABOUT MYSELF IM 24 YEARS OLD AND A PISS HEAD MOST NIGHTS OF THE '
	dc.b	'WEEK,I LIKE GUNS N ROSES AND IVE BEEN MARRIED TO MY BELOVED '
	dc.b	'ATARI FOR TWO YEAR SIX OR SEVENEN MONTHS THREE DAYS FOUR HOURS '
	dc.b	'NINE MINUTES HOWS THAT FOR A MEMORY NOT BAD FOR A PISS HEAD......'
	dc.b	'AND MY FUNCTION IN THIS GROUP IS HACKING,PACKING,SPEADING,AND '
	dc.b	'SOON MODEM SWAPS + GETTING PISSED WELL I HOPE I HAVNT BORED YOU '
	dc.b	'YET INTO PRESSING ANY KEYS BECAUSE IVE YET TO DO THE MEGA BORING '
	dc.b	'AS NORMAL GREETS TO ALL THE MEGA COOL GUYS OUT THERE BUT THAT COMES '
	dc.b	'LATER OK  BUT FIRST LET ME SAY A BIG THANKS TO RHINO  FOR LETTING '
	dc.b	'ME WAFFLE ON THIS SCROLL TEXT CHEERS MATE....WELL THE SIMPSONS ARE '
	dc.b	'ON SKY T.V.IN ABOUT TWO HOURS SO I BETTER FINISH MY PARCEL FOR RHINO '
	dc.b	'BUTBOY WHAT A PROGRAM TO WATCH ISNT HOMER GREAT TALK ABOUT A PISS '
	dc.b	'HEAD GOD I WISH HE WAS MY DRINKING PARTNER ANYWAY ENOUGH OF THE '
	dc.b	'SIMPSONS LET ME SAY A MEGA WICKED AWESOME KICK IN THE ASS GREETS'
	dc.b	'TO ALL MY CONTACTS HERE GOES........ALL MEMBERS OF CRIMINALS IN '
	dc.b	'   DISGUISE   (ESP JUDGE DREDD)........ALL MEMBERS  OF  PIRAMANIX'
	dc.b	'     (ESP    INSPIRAL)....TO   DOUG   IN  CASTLE BROMWICH...ALL MEMBERS '
	dc.b	'OF THE  CHESHIRE   CATS  (ESP TROLL NICE MENUS KEEP UP THE GOOD WORK)'
	dc.b	'....TO LEONARD  IN INVERNESS....TO ALLTHE OTHER MEMBERS OF SAFARI PLUS'
	dc.b	' TO ALL THE LOCAL LADS ORVILLE..DAVID..JOHN..TOM (IF YOU ARE READING '
	dc.b	'THIS)..MELVIN..THE WELSH WIZARD...AXELL....THAT  IT  FOR  NOW  LET ME '
	dc.b	'THANK RHINO ONCE AGAIN AND NOW BACK TO WHOEVER SEE YA..........RHINO '
	dc.b	'BACK AGAIN TO MELT YOUR BRAIN. PANTHER NOT WRITING THIS SCROLLER '
	dc.b	'BECAUSE HE ISNT VERY HAPPY WITH ME WHEN I MANAGED TO CORRUPT HIS '
	dc.b	'MAIN SOURCE CODING DISK TOTALLY BY ACCIDENT OF COURSE.'
	dc.b	'HERES THE GREETS FOR ALL THOSE PEOPLE WAITING TO SEE IF THEY GET '
	dc.b	'A MENTION. BECAUSE IF YOU WANT ONE GET IN TOUCH.....GREETS ZOOM OUT '
	dc.b	'TO......ADRENELIN (ESP MOOKIE)......MAGNETIC MINDS (ESP BOD)......'
	dc.b	'DNF......C.I.D. (ESP POD)......SYNCRO SYSTEMS (ESP AUBREY AND RAZOR)'
	dc.b	'......DANY FROM TOOTING......SONIC.....GERRY IN SCOTLAND......MARK'
	dc.b	'......JOBE......STEVE......JEREMY......WILF......M.M.M......MATT......'
	dc.b	'AND ANYONE ELSE WHO BELIEVES WE SHOULD GREET THEM........GOODBYE UNTIL '
	dc.b	'MENU 6...........WRAP..................................................'
	dc.b	'THIS IS THE RECODED MENU 5 (V2) BY TCE.....THE ORIGINAL VERSION WAS CRASHED '
	dc.b	'BECAUSE THE INTRO MUSIC IS DEFECT. NEW VERSION COMES WITH REASSEMBLED INTROSOURCE FROM ORIGINAL MENU'
	dc.b	', ORIGINAL GFX AND REPAIRED MUZAX........HAVE FUN!!!!!..............................................',$ff

font		dc.w	$0000,$0000,$0300,$0500,$0610,$0720,$0730,$0740
		dc.w	$0700,$0030,$0030,$0030,$0030,$0030,$0030,$0030
		dc.w	$0777,$009C,$0043,$003F,$0000,$9D00,$E200,$FC00
		dc.w	$0000,$87F0,$BFFF,$7FFF,$0000,$0200,$FD00,$FE00
		dc.w	$0000,$8000,$BFFF,$7FFF,$0000,$03E0,$FFE0,$FFF0
		dc.w	$0000,$8000,$BFFF,$7FFF,$0000,$0100,$FE80,$FF00
		dc.w	$0000,$8000,$BFFF,$7FFF,$0000,$03E0,$FFE0,$FFF0
		dc.w	$0000,$87F0,$BFFF,$7FFF,$0000,$03E0,$FFE0,$FFF0
		dc.w	$0000,$8000,$BFFF,$7FFF,$0000,$03E0,$FFE0,$FFF0
		dc.w	$0000,$B9F8,$87F8,$7FF8,$0000,$1F9D,$1FE1,$1FFE
		dc.w	$0000,$00B9,$0087,$007F,$0000,$3A00,$C200,$FC00
		dc.w	$0000,$0000,$0000,$0000,$0000,$B93A,$87C2,$7FFC
		dc.w	$0000,$0036,$0011,$000F,$0000,$0400,$F800,$F000
		dc.w	$0000,$607E,$2FFF,$1FFF,$0000,$0FC0,$FF00,$FF80
		dc.w	$0000,$6000,$2FFF,$1FFF,$0000,$07D0,$FFC0,$FFF0
		dc.w	$0000,$6000,$2FFF,$1FFF,$0000,$07E0,$FF80,$FFC0
		dc.w	$0000,$6000,$2FFF,$1FFF,$0000,$07D0,$FFC0,$FFF0
		dc.w	$0000,$607E,$2FFF,$1FFF,$0000,$07D0,$FFC0,$FFF0
		dc.w	$0000,$6000,$2FFF,$1FFF,$0000,$07D0,$FFC0,$FFF0
		dc.w	$0000,$6C60,$23E0,$1FF0,$0000,$0636,$07C4,$0FF8
		dc.w	$0000,$006C,$0023,$001F,$0000,$6C00,$8800,$F000
		dc.w	$0000,$0000,$0000,$0000,$0000,$6C6C,$2388,$1FF0
		dc.w	$0000,$000D,$0014,$0003,$0000,$2000,$7800,$F000
		dc.w	$0000,$1807,$0BFF,$07FF,$0000,$BFE0,$FF80,$FFC0
		dc.w	$0000,$1800,$0BFF,$07FF,$0000,$1FA0,$FF90,$FFF0
		dc.w	$0000,$1800,$0BFF,$07FF,$0000,$1FF0,$FFC0,$FFE0
		dc.w	$0000,$1800,$0BFF,$07FF,$0000,$1FA0,$FF90,$FFF0
		dc.w	$0000,$1807,$0BFF,$07FF,$0000,$9FA0,$FF90,$FFF0
		dc.w	$0000,$1800,$0BFF,$07FF,$0000,$1FA0,$FF90,$FFF0
		dc.w	$0000,$1B00,$08E0,$07E0,$0000,$00D8,$0710,$01E0
		dc.w	$0000,$001B,$0008,$0007,$0000,$B000,$2000,$C000
		dc.w	$0000,$0000,$0000,$0000,$0000,$1BB0,$0820,$07C0
		dc.w	$0000,$0012,$000E,$0001,$0000,$3000,$3800,$F800
		dc.w	$0000,$03FF,$0C00,$0100,$0000,$F9E0,$01C0,$07E0
		dc.w	$0000,$03FF,$0C00,$0100,$0000,$1E40,$E1B0,$0070
		dc.w	$0000,$037F,$0C80,$0100,$0000,$0FF8,$F1E0,$03F0
		dc.w	$0000,$03FF,$0C80,$0100,$0000,$1E40,$E1B0,$0070
		dc.w	$0000,$037F,$0C00,$0180,$0000,$1E40,$E1B0,$0070
		dc.w	$0000,$03FF,$0C80,$0100,$0000,$1E40,$E1B0,$0070
		dc.w	$0000,$1220,$0CC0,$01E0,$0000,$0578,$0600,$00F0
		dc.w	$0000,$0012,$000C,$0001,$0000,$F000,$0000,$E000
		dc.w	$0000,$0000,$0000,$0000,$0000,$12F0,$0C00,$01E0
		dc.w	$0000,$0004,$001C,$0003,$0000,$1800,$3800,$FC00
		dc.w	$0000,$09F2,$0E8F,$0180,$0000,$3EF0,$C1E0,$00E0
		dc.w	$0000,$09F3,$0E8F,$0180,$0000,$F310,$FCF0,$0030
		dc.w	$0000,$09B3,$0E4F,$0180,$0000,$F7EC,$F870,$00F8
		dc.w	$0000,$09F3,$0E4F,$0180,$0000,$F310,$FCF0,$0030
		dc.w	$0000,$09B3,$0E0F,$01C0,$0000,$F310,$FCF0,$0030
		dc.w	$0000,$09F3,$0E4F,$0180,$0000,$F310,$FCF0,$0030
		dc.w	$0000,$0900,$0EE0,$01E0,$0000,$04E0,$0710,$00F0
		dc.w	$0000,$0009,$000E,$0001,$0000,$C000,$2000,$E000
		dc.w	$0000,$0000,$0000,$0000,$0000,$09C0,$0E20,$01E0
		dc.w	$0000,$0025,$001D,$0002,$0000,$DC00,$9C00,$7C00
		dc.w	$0000,$0DEC,$0EDF,$01C0,$0000,$7C20,$83E0,$0070
		dc.w	$0000,$0DEC,$0EDC,$01C3,$0000,$0E90,$0F70,$F010
		dc.w	$0000,$0DCC,$0EBC,$01C3,$0000,$19E4,$1E38,$E078
		dc.w	$0000,$0DEC,$0EBC,$01C3,$0000,$0E90,$0F70,$F010
		dc.w	$0000,$0DCC,$0E9C,$01E3,$0000,$0E90,$0F70,$F010
		dc.w	$0000,$0DEC,$0EBC,$01C3,$0000,$0E90,$0F70,$F010
		dc.w	$0000,$0D80,$0EE0,$01E0,$0000,$0680,$0770,$00F0
		dc.w	$0000,$000D,$000E,$0001,$0000,$0000,$E000,$E000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0D00,$0EE0,$01E0
		dc.w	$0000,$0019,$0039,$0006,$0000,$0C00,$DC00,$3E00
		dc.w	$0000,$0700,$06E0,$09E0,$0000,$0410,$03E0,$0070
		dc.w	$0000,$0700,$06E0,$09E0,$0000,$0010,$0030,$0010
		dc.w	$0000,$0720,$06C0,$09E0,$0000,$0FC4,$0038,$003C
		dc.w	$0000,$0720,$06C0,$09E0,$0000,$0010,$0030,$0010
		dc.w	$0000,$0720,$06C0,$09E0,$0000,$0010,$0030,$0010
		dc.w	$0000,$0720,$06C0,$09E0,$0000,$0010,$0030,$0010
		dc.w	$0000,$0700,$06E0,$09E0,$0000,$04B0,$0770,$00F0
		dc.w	$0000,$0007,$0006,$0009,$0000,$6000,$E000,$E000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0760,$06E0,$09E0
		dc.w	$0000,$005A,$003D,$0006,$0000,$EE00,$0E00,$1E00
		dc.w	$0000,$01C0,$00E0,$0FE0,$0000,$0200,$03F0,$0070
		dc.w	$0000,$0100,$00E0,$0FE0,$0000,$0000,$0000,$0010
		dc.w	$0000,$0100,$00E0,$0FE0,$0000,$03E2,$001C,$003C
		dc.w	$0000,$0100,$00E0,$0FE0,$0000,$0000,$0000,$0010
		dc.w	$0000,$01C0,$00E0,$0FE0,$0000,$0000,$0000,$0010
		dc.w	$0000,$0100,$00E0,$0FE0,$0000,$0000,$0000,$0010
		dc.w	$0000,$01C0,$00E0,$0FE0,$0000,$03B0,$0470,$00F0
		dc.w	$0000,$0001,$0000,$000F,$0000,$6000,$E000,$E000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0160,$00E0,$0FE0
		dc.w	$0000,$0018,$0057,$002E,$0000,$EE00,$0E00,$1F00
		dc.w	$0000,$05C0,$00E0,$0FE0,$0000,$0730,$03C0,$0070
		dc.w	$0000,$0500,$00E0,$0FE0,$0000,$0000,$0000,$0000
		dc.w	$0000,$0500,$00E0,$0FE0,$0000,$0186,$007A,$001C
		dc.w	$0000,$0D00,$00E0,$0FE0,$0000,$0040,$0000,$0020
		dc.w	$0000,$05C0,$00E0,$0FE0,$0000,$0040,$0000,$0020
		dc.w	$0000,$0500,$00E0,$0FE0,$0000,$0000,$0000,$0000
		dc.w	$0000,$05C0,$00E0,$0FE0,$0000,$07F0,$0070,$00F0
		dc.w	$0000,$0005,$0000,$000F,$0000,$E000,$E000,$E000
		dc.w	$0000,$0000,$0000,$0000,$0000,$05E0,$00E0,$0FE0
		dc.w	$0000,$0094,$001F,$006E,$0000,$7700,$0700,$0F00
		dc.w	$0000,$07FE,$00FF,$0FFF,$0000,$77F0,$C780,$F870
		dc.w	$0000,$0760,$00E0,$0FE0,$0000,$0000,$0000,$0000
		dc.w	$0000,$0760,$00E0,$0FE0,$0000,$010E,$00F0,$001E
		dc.w	$0000,$077E,$00FF,$0FFF,$0000,$00A0,$FF80,$FFE0
		dc.w	$0000,$07FE,$00FF,$0FFF,$0000,$70A0,$FF80,$FFE0
		dc.w	$0000,$0720,$00E0,$0FE0,$0000,$0000,$0000,$0000
		dc.w	$0000,$07FE,$00FF,$0FFF,$0000,$7FF0,$FA70,$FCF0
		dc.w	$0000,$0007,$0000,$000F,$0000,$E000,$E000,$E000
		dc.w	$0000,$0000,$0000,$0000,$0000,$07E0,$00E0,$0FE0
		dc.w	$0000,$0064,$00AE,$005E,$0000,$7700,$0700,$0F80
		dc.w	$0000,$03FC,$00FF,$0FFF,$0000,$63E0,$8318,$FCF0
		dc.w	$0000,$03E0,$00E0,$0FE0,$0000,$0000,$0000,$0000
		dc.w	$0000,$03E0,$00E0,$0FE0,$0000,$0018,$00E0,$001E
		dc.w	$0000,$03FC,$00FF,$0FFF,$0000,$0180,$FFA0,$FFE0
		dc.w	$0000,$03FC,$00FF,$0FFF,$0000,$6180,$FFA0,$FFE0
		dc.w	$0000,$0360,$00E0,$0FE0,$0000,$0FF0,$0FF0,$0FF0
		dc.w	$0000,$03FC,$00FF,$0FFF,$0000,$7FF0,$FF70,$FEF0
		dc.w	$0000,$0003,$0000,$000F,$0000,$E000,$E000,$E000
		dc.w	$0000,$0000,$0000,$0000,$0000,$03E0,$00E0,$0FE0
		dc.w	$0000,$019C,$001C,$00FE,$0000,$3980,$0380,$0780
		dc.w	$0000,$09E0,$08FF,$07FF,$0000,$6268,$8214,$FDF8
		dc.w	$0000,$09E0,$08E0,$07E0,$0000,$0004,$0000,$0000
		dc.w	$0000,$09E0,$08E0,$07E0,$0000,$0098,$00E0,$001E
		dc.w	$0000,$09E0,$08FF,$07FF,$0000,$1E41,$FF20,$FFE0
		dc.w	$0000,$09E0,$08FF,$07FF,$0000,$1E40,$FF20,$FFE0
		dc.w	$0000,$0960,$08E0,$07E0,$0000,$0BE0,$07E0,$03F0
		dc.w	$0000,$09E0,$08FF,$07FF,$0000,$07F0,$FF70,$FFF0
		dc.w	$0000,$0009,$0008,$0007,$0000,$E000,$E000,$E000
		dc.w	$0000,$CFC0,$3FC0,$FFC0,$0000,$09E0,$08E0,$07E0
		dc.w	$0000,$000C,$005C,$01BC,$0000,$3980,$0380,$07C0
		dc.w	$0000,$0FC3,$0E3C,$0100,$0000,$F8AC,$0798,$007C
		dc.w	$0000,$0FE0,$0EE0,$01E0,$0000,$0000,$0000,$0004
		dc.w	$0000,$0FE0,$0EE0,$01E0,$0000,$00D0,$00E0,$001E
		dc.w	$0000,$0FC3,$0E3C,$0100,$0000,$FF01,$0061,$00E0
		dc.w	$0000,$0FC3,$0E3C,$0100,$0000,$FF00,$0060,$00E0
		dc.w	$0000,$0F60,$0EE0,$01E0,$0000,$01D0,$06C0,$01F0
		dc.w	$0000,$0FC3,$0E3C,$0100,$0000,$C3F0,$3C70,$00F0
		dc.w	$0000,$000F,$000E,$0001,$0000,$E000,$E000,$E000
		dc.w	$0000,$6300,$1F00,$FF80,$0000,$0FE0,$0EE0,$01E0
		dc.w	$0000,$02B8,$0098,$017C,$0000,$1CC0,$01C0,$03C0
		dc.w	$0000,$073E,$0EFF,$0180,$0000,$7C54,$83AE,$001C
		dc.w	$0000,$0760,$0EE0,$01E0,$0000,$0008,$0000,$0004
		dc.w	$0000,$0760,$0EE0,$01E0,$0000,$00E0,$00E0,$001E
		dc.w	$0000,$073E,$0EFF,$0180,$0000,$7FA2,$8060,$0061
		dc.w	$0000,$073E,$0EFF,$0180,$0000,$7FA0,$8060,$0060
		dc.w	$0000,$0760,$0EE0,$01E0,$0000,$07B0,$0380,$00F0
		dc.w	$0000,$073E,$0EFF,$0180,$0000,$7DF0,$BE70,$00F0
		dc.w	$0000,$0007,$000E,$0001,$0000,$E000,$E000,$E000
		dc.w	$0000,$5F00,$4000,$BF00,$0000,$07E0,$0EE0,$01E0
		dc.w	$0000,$0298,$02B8,$0178,$0000,$0CC0,$11C0,$03E0
		dc.w	$0000,$0381,$0EC1,$01FE,$0000,$BE16,$C1FC,$000E
		dc.w	$0000,$0320,$0EE0,$01E0,$0000,$0008,$0008,$0004
		dc.w	$0000,$0320,$0EE0,$01E0,$0000,$0164,$0064,$009A
		dc.w	$0000,$0301,$0EC1,$01FE,$0000,$8FA2,$F022,$0061
		dc.w	$0000,$0381,$0EC1,$01FE,$0000,$8FA0,$F020,$0060
		dc.w	$0000,$0320,$0EE0,$01E0,$0000,$0060,$0010,$03F0
		dc.w	$0000,$0381,$0EC1,$01FE,$0000,$83F0,$C070,$3CF0
		dc.w	$0000,$0003,$000E,$0001,$0000,$E000,$E000,$E000
		dc.w	$0000,$4C00,$4C00,$B300,$0000,$03E0,$0EE0,$01E0
		dc.w	$0000,$0750,$03BF,$007F,$0000,$72E0,$8060,$FDE0
		dc.w	$0000,$0900,$06E0,$01E0,$0000,$0090,$007E,$000E
		dc.w	$0000,$0900,$06E0,$01E0,$0000,$0010,$001C,$0008
		dc.w	$0000,$0900,$06E0,$01E0,$0000,$003E,$013E,$00C0
		dc.w	$0000,$0900,$06E0,$01E0,$0000,$0064,$0027,$0022
		dc.w	$0000,$09C0,$06E0,$01E0,$0000,$0060,$0000,$0020
		dc.w	$0000,$0900,$06E0,$01E0,$0000,$00C0,$0030,$03F0
		dc.w	$0000,$09C0,$06E0,$01E0,$0000,$01B0,$0670,$00F0
		dc.w	$0000,$0009,$0006,$0001,$0000,$6000,$E000,$E000
		dc.w	$0000,$7800,$F800,$0700,$0000,$0160,$0EE0,$01E0
		dc.w	$0000,$007F,$073F,$00FF,$0000,$FC20,$E060,$FFF0
		dc.w	$0000,$0D00,$02E0,$01E0,$0000,$0042,$007C,$000E
		dc.w	$0000,$0D00,$02E0,$01E0,$0000,$0024,$0038,$0010
		dc.w	$0000,$0D00,$02E0,$01E0,$0000,$0238,$003E,$01C0
		dc.w	$0000,$0D00,$02E0,$01E0,$0000,$0009,$000E,$0004
		dc.w	$0000,$0D40,$02E0,$01E0,$0000,$0000,$0000,$0000
		dc.w	$0000,$0D00,$02E0,$01E0,$0000,$0780,$0070,$03F0
		dc.w	$0000,$0D40,$02E0,$01E0,$0000,$07B0,$0670,$00F0
		dc.w	$0000,$000D,$0002,$0001,$0000,$6000,$E000,$E000
		dc.w	$0000,$B880,$7800,$0700,$0000,$1560,$0AE0,$01E0
		dc.w	$0000,$0A5F,$0460,$0180,$0000,$8020,$7F70,$00F0
		dc.w	$0000,$0DC0,$02E0,$01E0,$0000,$00E6,$0078,$000E
		dc.w	$0000,$0DC0,$02E0,$01E0,$0000,$0064,$0058,$0030
		dc.w	$0000,$0DC0,$02E0,$01E0,$0000,$0A12,$043C,$03C0
		dc.w	$0000,$0DC0,$02E0,$01E0,$0000,$0019,$0016,$000C
		dc.w	$0000,$0D00,$02E0,$01E0,$0000,$0000,$0000,$0000
		dc.w	$0000,$0DC0,$02E0,$01E0,$0000,$1420,$0BF0,$07F0
		dc.w	$0000,$0D00,$02E0,$01E0,$0000,$0790,$0670,$00F0
		dc.w	$0000,$000D,$0002,$0001,$0000,$2000,$E000,$E000
		dc.w	$0000,$90E0,$7800,$0780,$0000,$6520,$1AE0,$01E0
		dc.w	$0000,$0E6F,$0070,$0180,$0000,$F000,$0F70,$00F8
		dc.w	$0000,$09C0,$067F,$01FF,$0000,$CEFA,$F8F2,$FF0C
		dc.w	$0000,$09C0,$06FF,$01FF,$0000,$06C0,$F838,$FFE0
		dc.w	$0000,$09C0,$06FF,$01FF,$0000,$03C0,$FC7C,$FF80
		dc.w	$0000,$09C0,$06FF,$01FF,$0000,$01B0,$FE0E,$FFF8
		dc.w	$0000,$0900,$06E0,$01E0,$0000,$0000,$0000,$0000
		dc.w	$0000,$09C0,$06FF,$01FF,$0000,$0160,$FEF0,$FFF0
		dc.w	$0000,$0900,$06E0,$01E0,$0000,$01C0,$0630,$00F0
		dc.w	$0000,$0009,$0006,$0001,$0000,$8000,$6000,$E000
		dc.w	$0000,$0386,$7C7F,$03FF,$0000,$5180,$9E60,$E1E0
		dc.w	$0000,$1DE0,$01C0,$0200,$0000,$0288,$0130,$0078
		dc.w	$0000,$03F0,$0EDF,$01FF,$0000,$8C76,$F060,$FF9C
		dc.w	$0000,$03F0,$0EFF,$01FF,$0000,$0C88,$F078,$FFC0
		dc.w	$0000,$03F0,$0EFF,$01FF,$0000,$0784,$F8F8,$FF00
		dc.w	$0000,$03F0,$0EFF,$01FF,$0000,$0322,$FC1E,$FFF0
		dc.w	$0000,$02C0,$0E20,$01E0,$0000,$0000,$0000,$0000
		dc.w	$0000,$03F0,$0EFF,$01FF,$0000,$0360,$FCF0,$FFF0
		dc.w	$0000,$0280,$0E60,$01E0,$0000,$0370,$0400,$01F0
		dc.w	$0000,$0002,$000E,$0001,$0000,$E000,$0000,$E000
		dc.w	$0000,$41C7,$3E3F,$01FF,$0000,$2AE0,$CE00,$F1E0
		dc.w	$0000,$1D80,$0180,$0240,$0000,$0380,$0004,$0078
		dc.w	$0000,$0DFE,$0C0F,$03FF,$0000,$0C44,$F040,$FFB8
		dc.w	$0000,$0DFE,$0CFF,$03FF,$0000,$3910,$C0F8,$FFC0
		dc.w	$0000,$0DFE,$0CFF,$03FF,$0000,$37D8,$CA20,$FC00
		dc.w	$0000,$0DFE,$0CFF,$03FF,$0000,$0E44,$F03E,$FFF0
		dc.w	$0000,$0C40,$0C20,$03E0,$0000,$0000,$0000,$0000
		dc.w	$0000,$0DFE,$0CFF,$03FF,$0000,$0E60,$F0F0,$FFF0
		dc.w	$0000,$0C40,$0C20,$03E0,$0000,$0630,$0030,$03C0
		dc.w	$0000,$000C,$000C,$0003,$0000,$6000,$6000,$8000
		dc.w	$0000,$27DB,$1827,$007F,$0000,$9460,$E460,$FB80
		dc.w	$0000,$21E0,$1EE0,$0000,$0000,$0580,$0264,$0000
		dc.w	$0000,$16E0,$001F,$0F00,$0000,$7F78,$80F0,$0000
		dc.w	$0000,$16E0,$001F,$0F00,$0000,$60B8,$9FF0,$0080
		dc.w	$0000,$16E0,$001F,$0F00,$0000,$7FF0,$8000,$0000
		dc.w	$0000,$17E0,$001F,$0E00,$0000,$782E,$87FC,$0020
		dc.w	$0000,$1190,$0648,$0830,$0000,$0000,$0000,$0000
		dc.w	$0000,$1660,$009F,$0F00,$0000,$78E0,$8770,$00F0
		dc.w	$0000,$1180,$0640,$0820,$0000,$0188,$0260,$0410
		dc.w	$0000,$0011,$0006,$0008,$0000,$1000,$C000,$2000
		dc.w	$0000,$17F8,$0807,$0000,$0000,$8110,$FEC0,$0020
		dc.w	$0000,$0700,$78F0,$0000,$0000,$00E0,$0F18,$0006
		dc.w	$0000,$5B1F,$00FF,$3C00,$0000,$CF10,$F0E0,$0000
		dc.w	$0000,$5B1F,$00FF,$3C00,$0000,$70F0,$8F70,$0080
		dc.w	$0000,$5B1F,$00FF,$3C00,$0000,$7FE0,$8000,$0000
		dc.w	$0000,$5F1F,$00FF,$3800,$0000,$7C3C,$83DC,$0020
		dc.w	$0000,$4704,$18F2,$200C,$0000,$0000,$0000,$0000
		dc.w	$0000,$591F,$02FF,$3C00,$0000,$1C20,$E3F0,$0070
		dc.w	$0000,$4700,$18F0,$2000,$0000,$00E2,$0F18,$0004
		dc.w	$0000,$0047,$0018,$0020,$0000,$C400,$3000,$0800
		dc.w	$0000,$07F3,$000F,$0000,$0000,$3BC4,$3C30,$C008
		dc.w	$0000,$1CE0,$E3F8,$0000,$0000,$0738,$1FC6,$0001
		dc.w	$0000,$2CE1,$03E1,$F01E,$0000,$37C0,$3800,$C000
		dc.w	$0000,$2CE1,$03E1,$F01E,$0000,$B8C0,$C740,$00B0
		dc.w	$0000,$2CE1,$03E1,$F01E,$0000,$BF80,$C000,$0000
		dc.w	$0000,$3CE1,$03E1,$E01E,$0000,$BE34,$C1D4,$0028
		dc.w	$0000,$9CE0,$63FD,$0002,$0000,$0000,$0000,$0000
		dc.w	$0000,$24E1,$0BE1,$F01E,$0000,$8E60,$F1B0,$0070
		dc.w	$0000,$1CE0,$63F8,$8000,$0000,$0738,$1FC6,$0001
		dc.w	$0000,$001C,$0063,$0080,$0000,$7000,$8C00,$0200
		dc.w	$0000,$01C2,$003E,$0001,$0000,$1C70,$1F8C,$E002
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0E00,$0110,$00E0
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$03A0,$0044,$0038
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0300,$00B0,$0070
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$02D0,$0180,$0060
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$00D4,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$00B0,$0070,$0030
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0140,$0080,$0060
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0030,$0030
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0140,$0080,$0060
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0070,$0010,$0030
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0040,$00A0,$0040
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0030,$0008,$0010
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0010,$0010,$0030
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$B9F8,$87F8,$7FF8,$0000,$1F9D,$1FE1,$1FFE
		dc.w	$0000,$B9F8,$87F8,$7FF8,$0000,$0000,$0000,$0000
		dc.w	$0000,$B9F8,$87F8,$7FF8,$0000,$0F9D,$0FE1,$1FFE
		dc.w	$0000,$B9F8,$87F8,$7FF8,$0000,$1F9D,$1FE1,$1FFE
		dc.w	$0000,$0087,$003F,$007F,$0000,$E400,$FA00,$FC00
		dc.w	$0000,$87F0,$BFFF,$7FFF,$0000,$0100,$FC00,$FE00
		dc.w	$0000,$0087,$003F,$007F,$0000,$E400,$FA00,$FC00
		dc.w	$0000,$87F0,$BFFF,$7FFF,$0000,$0100,$FC00,$FE00
		dc.w	$0000,$00A0,$001F,$007F,$0000,$187C,$FFFC,$FFFE
		dc.w	$0000,$0F80,$0FFF,$1FFF,$0000,$03E0,$FFE0,$FFF0
		dc.w	$0000,$6C70,$23E0,$1FF0,$0000,$0636,$07C4,$0FF8
		dc.w	$0000,$6C70,$23E0,$1FF0,$0000,$0000,$0000,$0000
		dc.w	$0000,$6C70,$23E0,$1FF0,$0000,$0636,$07C4,$0FF8
		dc.w	$0000,$6C70,$23E0,$1FF0,$0000,$0E36,$07C4,$0FF8
		dc.w	$0000,$00E3,$021F,$01FF,$0000,$FD00,$FE80,$FF00
		dc.w	$0000,$607E,$2FFF,$1FFF,$0000,$0F40,$FF00,$FF80
		dc.w	$0000,$00E3,$021F,$01FF,$0000,$FD00,$FE80,$FF00
		dc.w	$0000,$607E,$2FFF,$1FFF,$0000,$0F40,$FF00,$FF80
		dc.w	$0000,$0220,$00FF,$01FF,$0000,$F8FA,$FFF8,$FFFE
		dc.w	$0000,$37C0,$07FF,$1FFF,$0000,$07D8,$FFC0,$FFF0
		dc.w	$0000,$1B00,$08E0,$07E0,$0000,$0ED8,$0110,$01E0
		dc.w	$0000,$1B00,$08E0,$07E0,$0000,$0000,$0000,$0000
		dc.w	$0000,$1B18,$08F0,$07F0,$0000,$00D8,$0710,$01E0
		dc.w	$0000,$1B00,$08E0,$07E0,$0000,$00D8,$0710,$01E0
		dc.w	$0000,$0BF9,$0607,$01FF,$0000,$FF40,$FF80,$FFC0
		dc.w	$0000,$1807,$0BFF,$07FF,$0000,$BF20,$FF80,$FFC0
		dc.w	$0000,$0BF9,$0607,$01FF,$0000,$FF40,$FF80,$FFC0
		dc.w	$0000,$1807,$0BFF,$07FF,$0000,$BF20,$FF80,$FFC0
		dc.w	$0000,$019B,$047F,$03FF,$0000,$C3F4,$FFF2,$FFFE
		dc.w	$0000,$3BF0,$03FF,$1FFF,$0000,$1FA8,$FF90,$FFF0
		dc.w	$0000,$1220,$0CC0,$01E0,$0000,$1270,$0C00,$01F0
		dc.w	$0000,$1220,$0CC0,$01E0,$0000,$0000,$0000,$0000
		dc.w	$0000,$0210,$0CF0,$01F8,$0000,$0D78,$0600,$00F0
		dc.w	$0000,$0230,$0CC0,$01F0,$0000,$0578,$0600,$00F0
		dc.w	$0000,$1007,$0838,$07C0,$0000,$E7A0,$0FE0,$1FC0
		dc.w	$0000,$037F,$0C00,$0180,$0000,$F980,$01C0,$07E0
		dc.w	$0000,$1007,$0838,$07C0,$0000,$E7A0,$0FE0,$1FC0
		dc.w	$0000,$037F,$0C00,$0180,$0000,$F980,$01C0,$07E0
		dc.w	$0000,$0B3F,$0000,$07C0,$0000,$FBC8,$0436,$000E
		dc.w	$0000,$1CF1,$230E,$1C00,$0000,$F240,$FDB8,$0070
		dc.w	$0000,$0900,$0EE0,$01E0,$0000,$2140,$1C40,$03A0
		dc.w	$0000,$0900,$0EE0,$01E0,$0000,$0000,$0000,$0000
		dc.w	$0000,$093C,$0ED8,$01F8,$0000,$1CE0,$0710,$00F0
		dc.w	$0000,$0908,$0EF0,$01F8,$0000,$04E0,$0710,$00F0
		dc.w	$0000,$0001,$10FE,$0F00,$0000,$F9D0,$03E0,$07E0
		dc.w	$0000,$0932,$0E8F,$01C0,$0000,$3ED0,$C1E0,$00E0
		dc.w	$0000,$0001,$10FE,$0F00,$0000,$F9D0,$03E0,$07E0
		dc.w	$0000,$0932,$0E8F,$01C0,$0000,$3ED0,$C1E0,$00E0
		dc.w	$0000,$00F8,$0907,$0600,$0000,$9E62,$E79E,$0006
		dc.w	$0000,$3981,$267E,$1801,$0000,$9918,$9EF8,$6030
		dc.w	$0000,$0D80,$0EE0,$01E0,$0000,$4100,$3200,$0FC0
		dc.w	$0000,$0D80,$0EE0,$01E0,$0000,$0000,$0000,$0000
		dc.w	$0000,$0DAC,$0ED8,$01FC,$0000,$0680,$1770,$08F0
		dc.w	$0000,$0D04,$0EF8,$01FC,$0000,$0680,$0770,$00F0
		dc.w	$0000,$3803,$19FC,$0600,$0000,$FDE0,$01E0,$03F0
		dc.w	$0000,$0D8C,$0EDF,$01E0,$0000,$7C00,$83F0,$0060
		dc.w	$0000,$3803,$19FC,$0600,$0000,$FDE0,$01E0,$03F0
		dc.w	$0000,$0D8C,$0EDF,$01E0,$0000,$7C00,$83F0,$0060
		dc.w	$0000,$107C,$0383,$0C00,$0000,$01D2,$F9EE,$0602
		dc.w	$0000,$021F,$0DFE,$3001,$0000,$EC90,$0F78,$F018
		dc.w	$0000,$0700,$06E0,$09E0,$0000,$9000,$7700,$0F80
		dc.w	$0000,$0700,$06E0,$09E0,$0000,$0000,$0000,$0000
		dc.w	$0000,$073C,$06CE,$09FC,$0000,$06B0,$3370,$0CF0
		dc.w	$0000,$0702,$06FC,$09FE,$0000,$04B0,$0770,$00F0
		dc.w	$0000,$1CD0,$3FE0,$0000,$0000,$3EC8,$00F0,$01F0
		dc.w	$0000,$0700,$06E0,$09E0,$0000,$0410,$03E0,$0070
		dc.w	$0000,$1CD0,$3FE0,$0000,$0000,$3EC8,$00F0,$01F0
		dc.w	$0000,$0700,$06E0,$09E0,$0000,$0410,$03E0,$0070
		dc.w	$0000,$0040,$1380,$0C00,$0000,$0002,$0006,$0002
		dc.w	$0000,$080F,$000E,$3001,$0000,$2030,$C018,$E018
		dc.w	$0000,$01C1,$00E0,$0FE0,$0000,$EF00,$CE00,$3F00
		dc.w	$0000,$0100,$00E0,$0FE0,$0000,$0000,$0000,$0000
		dc.w	$0000,$0174,$009C,$0FEE,$0000,$07B0,$2A70,$1CF0
		dc.w	$0000,$0181,$00EE,$0FFF,$0000,$03B0,$0470,$00F0
		dc.w	$0000,$7DC0,$3D80,$0200,$0000,$0F40,$00F8,$00F0
		dc.w	$0000,$01C0,$00E0,$0FE0,$0000,$0210,$03E0,$0070
		dc.w	$0000,$7DC0,$3D80,$0200,$0000,$0F40,$00F8,$00F0
		dc.w	$0000,$01C0,$00E0,$0FE0,$0000,$0210,$03E0,$0070
		dc.w	$0000,$0080,$1380,$0C00,$0000,$0000,$0000,$0002
		dc.w	$0000,$3003,$2002,$000D,$0000,$0000,$E008,$E018
		dc.w	$0000,$05C0,$00E0,$0FE3,$0000,$1E00,$1C00,$FE00
		dc.w	$0000,$0500,$00E0,$0FE0,$0000,$0000,$0000,$0000
		dc.w	$0000,$0506,$00DD,$0FEE,$0000,$0FF0,$6270,$1CF0
		dc.w	$0000,$0597,$00E7,$0FFF,$0000,$87F0,$0070,$80F0
		dc.w	$0000,$3900,$7980,$0600,$0000,$0608,$0178,$00F0
		dc.w	$0000,$05C0,$00E0,$0FE0,$0000,$0730,$03C0,$0070
		dc.w	$0000,$3900,$7980,$0600,$0000,$0608,$0178,$00F0
		dc.w	$0000,$05C0,$00E0,$0FE0,$0000,$0730,$03C0,$0070
		dc.w	$0000,$0DC0,$1F80,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$2005,$2000,$000F,$0000,$C000,$E008,$E008
		dc.w	$0000,$07F9,$00FE,$0FFF,$0000,$8400,$3800,$FC00
		dc.w	$0000,$0760,$00E0,$0FE0,$0000,$0000,$0000,$0000
		dc.w	$0000,$0732,$00DF,$0FEE,$0000,$8FF0,$5270,$3CF0
		dc.w	$0000,$07DB,$00E3,$0FFF,$0000,$C7F0,$8070,$C0F0
		dc.w	$0000,$3880,$7800,$0700,$0000,$0408,$03F0,$0078
		dc.w	$0000,$07FE,$00FF,$0FFF,$0000,$77E0,$C790,$F860
		dc.w	$0000,$3880,$7800,$0700,$0000,$0408,$03F0,$0078
		dc.w	$0000,$07FE,$00FF,$0FFF,$0000,$77E0,$C790,$F860
		dc.w	$0000,$1FA7,$0F9F,$007F,$0000,$8020,$FF80,$FFC0
		dc.w	$0000,$0007,$2000,$000F,$0000,$E000,$E000,$E008
		dc.w	$0000,$03FC,$00FF,$0FFF,$0000,$0800,$F000,$F800
		dc.w	$0000,$03E0,$00E0,$0FE0,$0000,$0000,$0000,$0000
		dc.w	$0000,$033A,$00DE,$0FE7,$0000,$CFF0,$D670,$38F0
		dc.w	$0000,$03C4,$00F5,$0FFB,$0000,$07F0,$C070,$E0F0
		dc.w	$0000,$7800,$7800,$0700,$0000,$0018,$03E0,$0078
		dc.w	$0000,$03FC,$00FF,$0FFF,$0000,$63B0,$8300,$FCE0
		dc.w	$0000,$7800,$7800,$0700,$0000,$0018,$03E0,$0078
		dc.w	$0000,$03FC,$00FF,$0FFF,$0000,$63B0,$8300,$FCE0
		dc.w	$0000,$0D30,$8F0F,$00FF,$0000,$C1E8,$FFE0,$FFF0
		dc.w	$0000,$0003,$0000,$000F,$0000,$E000,$E000,$E000
		dc.w	$0000,$09E3,$08FC,$07FF,$0000,$9800,$6000,$F800
		dc.w	$0000,$09E0,$08E0,$07E0,$0000,$0004,$0000,$0000
		dc.w	$0000,$09A3,$08EE,$07D7,$0000,$DFF0,$E670,$38F0
		dc.w	$0000,$09F8,$08EC,$07E3,$0000,$47F0,$8070,$F0F0
		dc.w	$0000,$3800,$7800,$0700,$0000,$0238,$03C0,$0078
		dc.w	$0000,$09E0,$08FF,$07FF,$0000,$6200,$8220,$FDC0
		dc.w	$0000,$3800,$7800,$0700,$0000,$0238,$03C0,$0078
		dc.w	$0000,$09E0,$08FF,$07FF,$0000,$6201,$8220,$FDC0
		dc.w	$0000,$0818,$0707,$80FF,$0000,$37E4,$FFF0,$FFF8
		dc.w	$0000,$0009,$0008,$0007,$0000,$E000,$E000,$E000
		dc.w	$0000,$0FC0,$0E3C,$0103,$0000,$A400,$5800,$FC00
		dc.w	$0000,$0FE0,$0EE0,$01E0,$0000,$0000,$0000,$0004
		dc.w	$0000,$0FBF,$0EDF,$01C3,$0000,$9FF0,$A470,$78F0
		dc.w	$0000,$0FE8,$0EE7,$01E0,$0000,$57F0,$1070,$E8F0
		dc.w	$0000,$1900,$7800,$0700,$0000,$0338,$03C0,$0078
		dc.w	$0000,$0FC3,$0E3C,$0100,$0000,$FBA0,$07C0,$0000
		dc.w	$0000,$1900,$7800,$0700,$0000,$0378,$0380,$007A
		dc.w	$0000,$0F03,$0E3D,$01C0,$0000,$8C20,$8000,$7FC1
		dc.w	$0000,$04FF,$4300,$8000,$0000,$FF30,$0038,$00FC
		dc.w	$0000,$000F,$000E,$0001,$0000,$E000,$E000,$E000
		dc.w	$0000,$0720,$0EFF,$0180,$0000,$1E00,$1C00,$FE00
		dc.w	$0000,$0760,$0EE0,$01E0,$0000,$0008,$0000,$0004
		dc.w	$0000,$0749,$0ED7,$01CB,$0000,$B1F0,$AA70,$70F0
		dc.w	$0000,$0764,$0EE3,$01E0,$0000,$8BF0,$0C70,$70F0
		dc.w	$0000,$0300,$7800,$0700,$0000,$03E0,$0380,$0078
		dc.w	$0000,$073E,$0EFF,$0180,$0000,$7840,$8780,$0000
		dc.w	$0000,$0380,$7800,$0700,$0000,$0070,$0004,$03FA
		dc.w	$0000,$073E,$0EBF,$01C0,$0000,$6E42,$E000,$1F81
		dc.w	$0000,$03FF,$4000,$C000,$0000,$C7DA,$383C,$001C
		dc.w	$0000,$0007,$000E,$0001,$0000,$E000,$E000,$E000
		dc.w	$0000,$0382,$0EC5,$01F8,$0000,$6F00,$8E00,$7F00
		dc.w	$0000,$0320,$0EE0,$01E0,$0000,$0008,$0008,$0004
		dc.w	$0000,$039B,$0EC3,$01CD,$0000,$5BF0,$6070,$F0F0
		dc.w	$0000,$03A3,$0EE0,$01E0,$0000,$D9F0,$1E70,$20F0
		dc.w	$0000,$0780,$7800,$0700,$0000,$05C0,$0180,$0278
		dc.w	$0000,$0381,$0EC1,$01FE,$0000,$BD00,$C200,$0000
		dc.w	$0000,$0780,$7800,$0700,$0000,$06D0,$0094,$036E
		dc.w	$0000,$0385,$0EC5,$01FA,$0000,$BB02,$F402,$0F01
		dc.w	$0000,$00FE,$E001,$4000,$0000,$0F80,$F07E,$000C
		dc.w	$0000,$0003,$000E,$0001,$0000,$E000,$E000,$E000
		dc.w	$0000,$09C0,$06E0,$01E0,$0000,$9000,$5700,$2F80
		dc.w	$0000,$0900,$06E0,$01E0,$0000,$0010,$001C,$0008
		dc.w	$0000,$09CD,$06CB,$01C5,$0000,$21B0,$4270,$F0F0
		dc.w	$0000,$09C1,$06E0,$01E0,$0000,$E1B0,$0E70,$10F0
		dc.w	$0000,$4700,$3880,$0700,$0000,$0088,$0488,$0370
		dc.w	$0000,$09C0,$06E0,$01E0,$0000,$0000,$0000,$0000
		dc.w	$0000,$4700,$3880,$0700,$0000,$02D0,$04DE,$032C
		dc.w	$0000,$09C0,$06E0,$01E0,$0000,$5904,$3607,$0F02
		dc.w	$0000,$8000,$7000,$2000,$0000,$0082,$007C,$000E
		dc.w	$0000,$0009,$0006,$0001,$0000,$6000,$E000,$E000
		dc.w	$0000,$0D40,$02E0,$01E0,$0000,$6100,$3200,$0FC0
		dc.w	$0000,$0D00,$02E0,$01E0,$0000,$0024,$0038,$0010
		dc.w	$0000,$0D47,$02C8,$01C7,$0000,$43B0,$F270,$E0F0
		dc.w	$0000,$0D40,$02E0,$01E0,$0000,$F5B0,$0670,$08F0
		dc.w	$0000,$43C0,$3800,$0780,$0000,$08D0,$00D8,$0720
		dc.w	$0000,$0D40,$02E0,$01E0,$0000,$0000,$0000,$0000
		dc.w	$0000,$43C0,$3800,$0780,$0000,$0A42,$005C,$07B8
		dc.w	$0000,$0D40,$02E0,$01E0,$0000,$6809,$170E,$0F04
		dc.w	$0000,$9000,$6800,$3000,$0000,$0042,$007C,$000E
		dc.w	$0000,$000D,$0002,$0001,$0000,$6000,$E000,$E000
		dc.w	$0000,$0D00,$02E0,$01E0,$0000,$2140,$1C40,$03A0
		dc.w	$0000,$0DC0,$02E0,$01E0,$0000,$0064,$0058,$0030
		dc.w	$0000,$0D0E,$02C0,$01C7,$0000,$F390,$C270,$E0F0
		dc.w	$0000,$0D00,$02E0,$01E0,$0000,$7B90,$0470,$00F0
		dc.w	$0000,$0310,$3CE0,$03C0,$0000,$28F8,$18F0,$0700
		dc.w	$0000,$0D00,$02E0,$01E0,$0000,$0000,$0000,$0000
		dc.w	$0000,$0310,$3CE0,$03C0,$0000,$2F32,$102C,$0FD8
		dc.w	$0000,$0D00,$02E0,$01E0,$0000,$6E19,$1716,$0F0C
		dc.w	$0000,$0800,$7400,$1800,$0000,$00E6,$0078,$000E
		dc.w	$0000,$000D,$0002,$0001,$0000,$2000,$E000,$E000
		dc.w	$0000,$0900,$06E0,$01E0,$0000,$1220,$0C30,$01C0
		dc.w	$0000,$09C0,$06FF,$01FF,$0000,$06C0,$F838,$FFE0
		dc.w	$0000,$0904,$06C4,$01C3,$0000,$C1C0,$C230,$E0F0
		dc.w	$0000,$0900,$06E0,$01E0,$0000,$3FC0,$0030,$00F0
		dc.w	$0000,$2000,$1FFF,$01FF,$0000,$0FC0,$F1F0,$FE00
		dc.w	$0000,$0900,$06E0,$01E0,$0000,$0000,$0000,$0000
		dc.w	$0000,$2000,$1FFF,$01FF,$0000,$0360,$FC1C,$FFF0
		dc.w	$0000,$0900,$06E0,$01E0,$0000,$4EB0,$370E,$0FF8
		dc.w	$0000,$441D,$78FE,$0FFF,$0000,$CEFC,$38F2,$FF0C
		dc.w	$0000,$0009,$0006,$0001,$0000,$8000,$6000,$E000
		dc.w	$0000,$02C0,$0E20,$01E0,$0000,$0F78,$0000,$01F0
		dc.w	$0000,$03F0,$0EFF,$01FF,$0000,$0C88,$F078,$FFC0
		dc.w	$0000,$02C0,$0E04,$01C3,$0000,$8370,$E000,$C1F0
		dc.w	$0000,$02C0,$0E20,$01E0,$0000,$1F70,$0000,$01F0
		dc.w	$0000,$007F,$1F7F,$00FF,$0000,$CD00,$F3E0,$FC00
		dc.w	$0000,$02C0,$0E20,$01E0,$0000,$0000,$0000,$0000
		dc.w	$0000,$007F,$1F7F,$00FF,$0000,$C644,$F83C,$FFE0
		dc.w	$0000,$02C0,$0E20,$01E0,$0000,$1F22,$771E,$0FF0
		dc.w	$0000,$21B0,$7C7F,$0FFF,$0000,$CC76,$3060,$FF9C
		dc.w	$0000,$0002,$000E,$0001,$0000,$E000,$0000,$E000
		dc.w	$0000,$0C40,$0C20,$03E0,$0000,$0634,$0038,$03C0
		dc.w	$0000,$0DFE,$0CFF,$03FF,$0000,$3910,$C0F8,$FFC0
		dc.w	$0000,$0C44,$0C00,$03C3,$0000,$E230,$8030,$C3C0
		dc.w	$0000,$0C40,$0C20,$03E0,$0000,$0E30,$0030,$03C0
		dc.w	$0000,$1BDF,$040F,$003F,$0000,$E020,$FFC0,$F000
		dc.w	$0000,$0C40,$0C20,$03E0,$0000,$0000,$0000,$0000
		dc.w	$0000,$1BDF,$040F,$003F,$0000,$DC88,$E07C,$FFE0
		dc.w	$0000,$0C40,$0C20,$03E0,$0000,$6F44,$673E,$1FF0
		dc.w	$0000,$74B0,$3C7F,$07FF,$0000,$CC40,$3044,$FFB8
		dc.w	$0000,$000C,$000C,$0003,$0000,$6000,$6000,$8000
		dc.w	$0000,$1180,$0640,$0820,$0000,$0182,$0264,$0418
		dc.w	$0000,$17E0,$001F,$0E00,$0000,$60B8,$9FF0,$0080
		dc.w	$0000,$1182,$0642,$0821,$0000,$0188,$8260,$C410
		dc.w	$0000,$1180,$0640,$0820,$0000,$0188,$0260,$0410
		dc.w	$0000,$0FF8,$0007,$0000,$0000,$FE40,$0180,$0000
		dc.w	$0000,$1190,$0648,$0830,$0000,$0000,$0000,$0000
		dc.w	$0000,$0FF8,$0007,$0000,$0000,$F05C,$0FF8,$0040
		dc.w	$0000,$1180,$0650,$0820,$0000,$BF2E,$00FC,$7020
		dc.w	$0000,$3C3C,$3BC3,$0400,$0000,$3F74,$C0F8,$0000
		dc.w	$0000,$0011,$0006,$0008,$0000,$1000,$C000,$2000
		dc.w	$0000,$4700,$18F0,$2000,$0000,$00E0,$0F18,$0006
		dc.w	$0000,$5F1F,$00FF,$3800,$0000,$70F0,$8F70,$0080
		dc.w	$0000,$4700,$18F2,$2001,$0000,$80E2,$4F18,$8004
		dc.w	$0000,$4700,$18F0,$2000,$0000,$00E2,$0F18,$0004
		dc.w	$0000,$03FD,$0006,$0000,$0000,$EF00,$1000,$0000
		dc.w	$0000,$4704,$18F2,$200C,$0000,$0000,$0000,$0000
		dc.w	$0000,$03FD,$0006,$0000,$0000,$F878,$07B8,$0040
		dc.w	$0000,$4702,$18F8,$2001,$0000,$F83C,$07DC,$C020
		dc.w	$0000,$0C7F,$0B80,$3400,$0000,$8F08,$70F0,$0000
		dc.w	$0000,$0047,$0018,$0020,$0000,$C400,$3000,$0800
		dc.w	$0000,$1CE0,$63F8,$8000,$0000,$0738,$1FC6,$0001
		dc.w	$0000,$3CE1,$03E1,$E01E,$0000,$B8C0,$C740,$00B0
		dc.w	$0000,$1CE0,$63F9,$8000,$0000,$0738,$9FC6,$0001
		dc.w	$0000,$9CE0,$63F8,$8000,$0000,$0738,$1FC6,$0001
		dc.w	$0000,$00E0,$001F,$0000,$0000,$7C00,$8000,$0000
		dc.w	$0000,$1CE0,$63FD,$8002,$0000,$0000,$0000,$0000
		dc.w	$0000,$00E0,$001F,$0000,$0000,$7CE8,$83A8,$0050
		dc.w	$0000,$1CE1,$63F8,$8007,$0000,$E730,$1FD0,$002C
		dc.w	$0000,$05FE,$2201,$1C00,$0000,$03A0,$FC40,$0000
		dc.w	$0000,$001C,$0063,$0080,$0000,$7000,$8C00,$0200
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0E00,$0110,$00E0
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0780,$0088,$0070
		dc.w	$0000,$0000,$0000,$0000,$0000,$0380,$0044,$0038
		dc.w	$0000,$2B00,$0400,$1800,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$02D0,$0180,$0060
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$01E8,$0040,$0030
		dc.w	$0000,$0000,$0000,$0000,$0000,$00B4,$0060,$0018
		dc.w	$0000,$0A00,$0400,$1800,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0140,$0080,$0060
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$00A0,$0040,$0030
		dc.w	$0000,$0000,$0000,$0000,$0000,$0050,$0020,$0018
		dc.w	$0000,$0A00,$0400,$1800,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0140,$0080,$0060
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$00A0,$0040,$0030
		dc.w	$0000,$0000,$0000,$0000,$0000,$0050,$0020,$0018
		dc.w	$0000,$0C00,$1000,$0800,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0040,$00A0,$0040
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0060,$0010,$0020
		dc.w	$0000,$0000,$0000,$0000,$0000,$0010,$0028,$0010
		dc.w	$0000,$1C00,$0000,$0800,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$B9F8,$87F8,$7FF8,$0000,$1F9D,$1FE1,$1FFE
		dc.w	$0000,$B9F8,$87F8,$7FF8,$0000,$1F9D,$1FE1,$1FFE
		dc.w	$0000,$B9F8,$87F9,$7FF8,$0000,$1F9D,$9FE1,$1FFE
		dc.w	$0000,$B9F8,$87F8,$7FF8,$0000,$1F9D,$1FE1,$1FFE
		dc.w	$0000,$B9F8,$87F8,$7FF8,$0000,$1F9D,$1FE1,$1FFE
		dc.w	$0000,$8000,$BFFF,$7FFF,$0000,$03E0,$FFE0,$FFF0
		dc.w	$0000,$005C,$0043,$003F,$0000,$9D00,$E100,$FE00
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0038,$0000,$0000,$0000,$0E00,$0000,$0000
		dc.w	$0000,$6C60,$23E0,$1FF0,$0000,$0636,$07C4,$0FF8
		dc.w	$0000,$6C60,$2380,$1FF0,$0000,$0636,$07C4,$0FF8
		dc.w	$0000,$6C62,$23E0,$1FF1,$0000,$0636,$C7C4,$8FF8
		dc.w	$0000,$6C60,$23E0,$1FF0,$0000,$0636,$07C4,$0FF8
		dc.w	$0000,$6C60,$23E0,$1FF0,$0000,$0636,$07C4,$0FF8
		dc.w	$0000,$6000,$2FFF,$1FFF,$0000,$07D0,$FFC0,$FFF0
		dc.w	$0000,$0036,$0011,$000F,$0000,$3600,$C400,$F800
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0096,$0048,$003C,$0000,$2580,$1200,$0F00
		dc.w	$0000,$1B00,$08E0,$07E0,$0000,$00D8,$0710,$01E0
		dc.w	$0000,$3BE0,$0800,$07E0,$0000,$00D8,$0714,$00E0
		dc.w	$0000,$1B02,$08E2,$07E1,$0000,$86D8,$8510,$C3E0
		dc.w	$0000,$3B00,$08E0,$07E0,$0000,$00DC,$0710,$01E0
		dc.w	$0000,$3B00,$08E0,$07E0,$0000,$00DC,$0710,$01E0
		dc.w	$0000,$1800,$0BFF,$07FF,$0000,$1FA0,$FF90,$FFF0
		dc.w	$0000,$000D,$0004,$0003,$0000,$D800,$1000,$E000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0052,$00CC,$003E,$0000,$1480,$3300,$0F80
		dc.w	$0000,$1220,$0CC0,$01E0,$0000,$0578,$0600,$00F0
		dc.w	$0000,$1D80,$0000,$03C0,$0000,$0200,$0184,$0078
		dc.w	$0000,$0C46,$0C02,$03C1,$0000,$A230,$C030,$C3C0
		dc.w	$0000,$1030,$0EC0,$01E0,$0000,$0D78,$0600,$00F0
		dc.w	$0000,$1030,$0EC0,$01E0,$0000,$0D78,$0600,$00F0
		dc.w	$0000,$03FF,$0500,$0000,$0000,$1E40,$E1B0,$0070
		dc.w	$0000,$0009,$0006,$0000,$0000,$7800,$0000,$F000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$01E7,$00EE,$001E,$0000,$79C0,$3B80,$0780
		dc.w	$0000,$0D00,$02E0,$01E0,$0000,$04E0,$0710,$00F0
		dc.w	$0000,$1C00,$0020,$03C0,$0000,$03B8,$0000,$0078
		dc.w	$0000,$02C2,$0E06,$01C1,$0000,$C370,$E000,$C1F0
		dc.w	$0000,$0C68,$0310,$00F0,$0000,$18F0,$0600,$01E0
		dc.w	$0000,$0C68,$0310,$00F0,$0000,$18F0,$0600,$01E0
		dc.w	$0000,$00F3,$018F,$0000,$0000,$E310,$FC30,$00F0
		dc.w	$0000,$0004,$0007,$0000,$0000,$E000,$1000,$F000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0121,$00EE,$001E,$0000,$4840,$3B80,$0780
		dc.w	$0000,$0D80,$02E0,$01E0,$0000,$0680,$0770,$00F0
		dc.w	$0000,$0E20,$0000,$01E0,$0000,$0760,$0018,$00F0
		dc.w	$0000,$0906,$06C6,$01C1,$0000,$C1C0,$C230,$E0F0
		dc.w	$0000,$062C,$0198,$0078,$0000,$31A0,$0C40,$03C0
		dc.w	$0000,$062C,$0198,$0078,$0000,$31A0,$0C40,$03C0
		dc.w	$0000,$006C,$005C,$0003,$0000,$0030,$1F10,$E0F0
		dc.w	$0000,$0006,$0007,$0000,$0000,$8000,$7000,$F000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0115,$00E2,$000E,$0000,$4540,$3880,$0380
		dc.w	$0000,$0F00,$00E0,$01E0,$0000,$04B0,$0770,$00F0
		dc.w	$0000,$0A60,$0410,$01E0,$0000,$0360,$0410,$00F0
		dc.w	$0000,$0D0A,$02C6,$01C1,$0000,$D390,$E270,$E0F0
		dc.w	$0000,$0306,$00DC,$003C,$0000,$6040,$1B80,$0780
		dc.w	$0000,$0306,$00DC,$003C,$0000,$6040,$1B80,$0780
		dc.w	$0000,$0000,$0000,$0000,$0000,$1070,$0E10,$01E0
		dc.w	$0000,$0003,$0003,$0004,$0000,$B000,$7000,$F000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$01CA,$0038,$0006,$0000,$7280,$0E00,$0180
		dc.w	$0000,$0FC0,$00E0,$01E0,$0000,$03B0,$0470,$00F0
		dc.w	$0000,$0060,$0710,$00F0,$0000,$08C0,$0630,$01E0
		dc.w	$0000,$0D49,$02CC,$01C3,$0000,$43B0,$F270,$E0F0
		dc.w	$0000,$0187,$006E,$001E,$0000,$F080,$3700,$0F00
		dc.w	$0000,$0187,$006E,$001E,$0000,$F080,$3700,$0F00
		dc.w	$0000,$0000,$0000,$0000,$0000,$3CE0,$0020,$03C0
		dc.w	$0000,$0000,$0000,$0007,$0000,$B000,$7000,$F000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$01D2,$0030,$000C,$0000,$7480,$0C00,$0300
		dc.w	$0000,$0F40,$00E0,$01E0,$0000,$07B0,$0070,$00F0
		dc.w	$0000,$0640,$01B8,$0070,$0000,$0080,$0E60,$01E0
		dc.w	$0000,$09C1,$06CF,$01C1,$0000,$21B0,$6270,$F0F0
		dc.w	$0000,$00C0,$003F,$000F,$0000,$EB00,$6E00,$1E00
		dc.w	$0000,$00C0,$0037,$000F,$0000,$EB00,$6E00,$1E00
		dc.w	$0000,$0000,$0000,$0000,$0000,$79C0,$0040,$0780
		dc.w	$0000,$0006,$0000,$0007,$0000,$F000,$7000,$F000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0124,$00E8,$0010,$0000,$4900,$3A00,$0400
		dc.w	$0000,$0F20,$00E0,$01E0,$0000,$01F0,$0670,$00F0
		dc.w	$0000,$0300,$00B8,$0078,$0000,$1000,$0DE0,$03C0
		dc.w	$0000,$0191,$0ECD,$01C3,$0000,$6BF0,$7070,$F0F0
		dc.w	$0000,$0064,$001B,$0007,$0000,$1E00,$5C00,$BC00
		dc.w	$0000,$0060,$0019,$0007,$0000,$FE00,$FC00,$1C00
		dc.w	$0000,$0000,$0000,$0000,$0000,$F180,$0280,$0F00
		dc.w	$0000,$0003,$0000,$0007,$0000,$F000,$6000,$F000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0350,$00E0,$0000,$0000,$D400,$3800,$0000
		dc.w	$0000,$0300,$0CE0,$01E0,$0000,$00F0,$0770,$00F0
		dc.w	$0000,$0328,$009C,$0078,$0000,$0080,$1DC0,$03C0
		dc.w	$0000,$0141,$0EDF,$01C3,$0000,$F1E0,$FA70,$70F0
		dc.w	$0000,$0030,$000D,$0003,$0000,$3C00,$B800,$F800
		dc.w	$0000,$0021,$001C,$0003,$0000,$FC00,$F800,$3800
		dc.w	$0000,$0001,$0000,$0000,$0000,$E200,$0700,$1C00
		dc.w	$0000,$0001,$0000,$0007,$0000,$F000,$0000,$F000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0100,$0EE0,$01E0,$0000,$04F0,$0770,$00F0
		dc.w	$0000,$0108,$00DC,$003C,$0000,$2080,$1BC0,$0780
		dc.w	$0000,$01A3,$0EDF,$01C3,$0000,$97E0,$B470,$78F0
		dc.w	$0000,$0019,$0007,$0000,$0000,$1800,$F000,$F000
		dc.w	$0000,$0011,$000F,$0000,$0000,$F800,$F000,$7000
		dc.w	$0000,$0003,$0000,$0000,$0000,$8401,$5C00,$3A00
		dc.w	$0000,$0004,$0004,$0003,$0000,$C000,$0000,$F000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0120,$0EC0,$01E0,$0000,$06F0,$0770,$00F0
		dc.w	$0000,$019C,$005E,$003C,$0000,$1100,$2B80,$0780
		dc.w	$0000,$03A2,$0EDA,$01C7,$0000,$DCC0,$E770,$38F0
		dc.w	$0000,$001D,$0003,$0000,$0000,$9800,$F000,$7000
		dc.w	$0000,$0009,$000F,$0000,$0000,$F000,$7000,$F000
		dc.w	$0000,$0004,$0003,$0000,$0000,$1000,$2000,$FC01
		dc.w	$0000,$0007,$0007,$0000,$0000,$9000,$1000,$E000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0160,$0F80,$00E0,$0000,$07F0,$0770,$00F0
		dc.w	$0000,$00A4,$004E,$001E,$0000,$7700,$0780,$0F00
		dc.w	$0000,$0F32,$0EDE,$01C7,$0000,$CEC0,$D770,$38F0
		dc.w	$0000,$003F,$0002,$0000,$0000,$8C00,$3800,$7800
		dc.w	$0000,$0007,$000F,$0000,$0000,$F000,$7000,$F000
		dc.w	$0000,$000D,$0007,$0000,$0000,$0002,$7000,$F801
		dc.w	$0000,$0007,$0003,$0000,$0000,$C000,$7000,$8000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$01F0,$0F00,$00E0,$0000,$0BF0,$0370,$04F0
		dc.w	$0000,$0080,$006F,$001E,$0000,$7600,$0700,$0F00
		dc.w	$0000,$0932,$08D7,$07CE,$0000,$8EE0,$5370,$3CF0
		dc.w	$0000,$007F,$0006,$0000,$0000,$C200,$1C00,$3C00
		dc.w	$0000,$0003,$000F,$0000,$0000,$F000,$7000,$F000
		dc.w	$0000,$0014,$000E,$0001,$0000,$F002,$E002,$F001
		dc.w	$0000,$0007,$0000,$0000,$0000,$F000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$08E0,$0710,$00E0,$0000,$01B0,$0970,$06F0
		dc.w	$0000,$0048,$0037,$000E,$0000,$EE00,$0F00,$1E00
		dc.w	$0000,$0304,$02DD,$0DEE,$0000,$0EF0,$7370,$1CF0
		dc.w	$0000,$00F7,$0003,$000C,$0000,$CD00,$2200,$1E00
		dc.w	$0000,$0009,$0007,$0000,$0000,$F000,$7000,$F000
		dc.w	$0000,$0028,$001D,$0003,$0000,$2004,$C007,$E002
		dc.w	$0000,$0001,$0000,$0000,$0000,$C000,$0000,$0000
		dc.w	$0000,$0003,$0000,$0000,$0000,$8000,$0000,$0000
		dc.w	$0000,$0003,$0000,$0000,$0000,$8000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0878,$0700,$00F0,$0000,$11B0,$0170,$0EF0
		dc.w	$0000,$0062,$0015,$000E,$0000,$E400,$0E00,$1E00
		dc.w	$0000,$0D65,$0E9C,$01EE,$0000,$06B0,$6B70,$1CF0
		dc.w	$0000,$012F,$00C0,$001E,$0000,$C680,$3000,$0F00
		dc.w	$0000,$000D,$0003,$0000,$0000,$F000,$7000,$F000
		dc.w	$0000,$0078,$003B,$0007,$0000,$4009,$800E,$C004
		dc.w	$0000,$0004,$0000,$0003,$0000,$9000,$6000,$E000
		dc.w	$0000,$0009,$0000,$0007,$0000,$2000,$C000,$C000
		dc.w	$0000,$0009,$0004,$0003,$0000,$6000,$8000,$C000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0862,$079C,$0078,$0000,$5090,$2170,$1EF0
		dc.w	$0000,$0029,$0011,$0006,$0000,$0400,$DE00,$3C00
		dc.w	$0000,$093C,$0ECE,$01FC,$0000,$05B0,$3170,$0EF0
		dc.w	$0000,$0246,$019C,$003C,$0000,$6240,$1800,$0780
		dc.w	$0000,$000D,$0003,$0000,$0000,$B000,$7000,$F000
		dc.w	$0000,$00A0,$0077,$000F,$0000,$8019,$0016,$800C
		dc.w	$0000,$0006,$0006,$0001,$0000,$9000,$7000,$F000
		dc.w	$0000,$000D,$000C,$0003,$0000,$2000,$E000,$E000
		dc.w	$0000,$0005,$000C,$0003,$0000,$2000,$C000,$E000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0400,$03FF,$003F,$0000,$1CC0,$E330,$FCF0
		dc.w	$0000,$003D,$0005,$0002,$0000,$E000,$9C00,$7C00
		dc.w	$0000,$01AA,$0ED8,$01FC,$0000,$0680,$3470,$0BF0
		dc.w	$0000,$04AC,$0338,$0078,$0000,$3520,$0C00,$03C0
		dc.w	$0000,$0009,$0007,$0000,$0000,$8000,$7000,$F000
		dc.w	$0000,$0100,$00FF,$000F,$0000,$01B0,$FE0E,$FFF8
		dc.w	$0000,$000F,$0007,$0000,$0000,$3800,$7000,$F000
		dc.w	$0000,$001E,$000E,$0001,$0000,$7000,$E000,$E000
		dc.w	$0000,$001E,$000E,$0001,$0000,$7000,$E000,$E000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$040E,$03EF,$001F,$0000,$3870,$C700,$F8F0
		dc.w	$0000,$0012,$000E,$0001,$0000,$C000,$3C00,$F800
		dc.w	$0000,$0138,$0ED8,$01FC,$0000,$1CE0,$0710,$00F0
		dc.w	$0000,$0C78,$0370,$00F0,$0000,$1610,$0E00,$01E0
		dc.w	$0000,$0003,$000F,$0000,$0000,$F000,$0000,$F000
		dc.w	$0000,$02D0,$01FF,$001F,$0000,$0322,$FC1E,$FFF0
		dc.w	$0000,$0009,$0007,$0000,$0000,$0800,$7000,$F000
		dc.w	$0000,$0012,$000E,$0001,$0000,$1000,$E000,$E000
		dc.w	$0000,$0012,$000E,$0001,$0000,$1000,$E000,$E000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$037A,$0081,$0007,$0000,$3E30,$C130,$E0C0
		dc.w	$0000,$001C,$000C,$0003,$0000,$4000,$3800,$F800
		dc.w	$0000,$0218,$0CFC,$01F8,$0000,$1D70,$0600,$00F0
		dc.w	$0000,$1C50,$0C20,$03E0,$0000,$0E38,$0630,$01C0
		dc.w	$0000,$000C,$000C,$0003,$0000,$7000,$7000,$8000
		dc.w	$0000,$07FE,$01BF,$003F,$0000,$0E44,$F03E,$FFF0
		dc.w	$0000,$000B,$0004,$0000,$0000,$A800,$1000,$7000
		dc.w	$0000,$0017,$0008,$0000,$0000,$5000,$2000,$E000
		dc.w	$0000,$0011,$000E,$0000,$0000,$5000,$2000,$E000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$01FF,$0000,$0000,$0000,$FF88,$0060,$0010
		dc.w	$0000,$0001,$0006,$0018,$0000,$9000,$4800,$3000
		dc.w	$0000,$1164,$0610,$08F8,$0000,$1988,$0A60,$0410
		dc.w	$0000,$2180,$0640,$1820,$0000,$0184,$0260,$0418
		dc.w	$0000,$0011,$0006,$0008,$0000,$0800,$C000,$3000
		dc.w	$0000,$0B60,$079F,$0000,$0000,$582E,$A7FC,$0020
		dc.w	$0000,$0006,$0001,$0000,$0000,$5000,$C000,$3000
		dc.w	$0000,$000C,$0003,$0000,$0000,$A000,$8000,$6000
		dc.w	$0000,$001C,$0003,$0000,$0000,$A000,$8000,$6000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$00FF,$0000,$0000,$0000,$FFE2,$0018,$0004
		dc.w	$0000,$0007,$0018,$0020,$0000,$0400,$F000,$0C00
		dc.w	$0000,$4710,$18E0,$2018,$0000,$00E2,$0F18,$0004
		dc.w	$0000,$4700,$18F0,$2000,$0000,$00E2,$0F18,$0004
		dc.w	$0000,$0047,$0018,$0020,$0000,$C200,$3000,$0C00
		dc.w	$0000,$179F,$0FFF,$0000,$0000,$5C3C,$A3DC,$0020
		dc.w	$0000,$0006,$0001,$0000,$0000,$F000,$E000,$0000
		dc.w	$0000,$000D,$0003,$0000,$0000,$E000,$C000,$0000
		dc.w	$0000,$001D,$0003,$0000,$0000,$2000,$0000,$C000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$001D,$0002,$0000,$0000,$F838,$00C6,$0001
		dc.w	$0000,$001C,$0063,$0000,$0000,$E000,$FC00,$0200
		dc.w	$0000,$1CE8,$63F0,$8000,$0000,$0F38,$07C6,$0001
		dc.w	$0000,$1CE0,$63F8,$8000,$0000,$0738,$1FC6,$0001
		dc.w	$0000,$001C,$0063,$0080,$0000,$7000,$8E00,$0100
		dc.w	$0000,$3EE1,$03E1,$001E,$0000,$AE30,$F1D0,$002C
		dc.w	$0000,$0001,$0000,$0000,$0000,$C000,$0000,$0000
		dc.w	$0000,$0003,$0000,$0000,$0000,$8000,$0000,$0000
		dc.w	$0000,$0012,$000E,$0001,$0000,$4000,$8000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0380,$0044,$0038
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0035,$000E,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$00B4,$0060,$0018
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0050,$0020,$0018
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0050,$0020,$0018
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0010,$0000,$0010
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0003,$0000,$0000,$0000,$8000,$0000,$0000
		dc.w	$0000,$87F0,$BFFF,$7FFF,$0000,$0100,$FC00,$FE00
		dc.w	$0000,$0004,$0001,$0003,$0000,$1800,$F800,$FC00
		dc.w	$0000,$000F,$000F,$001F,$0000,$9000,$E800,$F000
		dc.w	$0000,$F078,$7FF0,$FFF8,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0003,$0000,$0000,$0000,$8000,$0000,$0000
		dc.w	$0000,$0003,$0000,$0000,$0000,$8000,$0000,$0000
		dc.w	$0000,$0009,$0004,$0003,$0000,$6000,$8000,$C000
		dc.w	$0000,$607E,$2FFF,$1FFF,$0000,$0F40,$FF00,$FF80
		dc.w	$0000,$0007,$0010,$000F,$0000,$3400,$F000,$FC00
		dc.w	$0000,$0017,$0007,$001F,$0000,$F400,$FA00,$FC00
		dc.w	$0000,$DB90,$25E8,$C018,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0004,$0008,$0007,$0000,$4000,$2000,$E000
		dc.w	$0000,$0009,$0000,$0007,$0000,$2000,$C000,$C000
		dc.w	$0000,$0009,$0000,$0007,$0000,$2000,$C000,$C000
		dc.w	$0000,$0005,$000C,$0003,$0000,$2000,$C000,$E000
		dc.w	$0000,$1807,$0BFF,$07FF,$0000,$BF20,$FF80,$FFC0
		dc.w	$0000,$005F,$0030,$000F,$0000,$A800,$6400,$FC00
		dc.w	$0000,$000B,$0013,$001F,$0000,$FD00,$FE00,$FF00
		dc.w	$0000,$0F48,$7C78,$8388,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0002,$000C,$0003,$0000,$8000,$6000,$E000
		dc.w	$0000,$000D,$000C,$0003,$0000,$2000,$E000,$E000
		dc.w	$0000,$000D,$000C,$0003,$0000,$2000,$E000,$E000
		dc.w	$0000,$001E,$000E,$0001,$0000,$7000,$E000,$E000
		dc.w	$0000,$023F,$05C0,$0000,$0000,$F980,$01C0,$07E0
		dc.w	$0000,$0080,$0041,$003E,$0000,$1000,$EC00,$1C00
		dc.w	$0000,$0007,$0018,$001C,$0000,$9E80,$3F80,$7F00
		dc.w	$0000,$8200,$8100,$0708,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0001,$000E,$0001,$0000,$0000,$E000,$E000
		dc.w	$0000,$001E,$000E,$0001,$0000,$7000,$E000,$E000
		dc.w	$0000,$001E,$000E,$0001,$0000,$7000,$E000,$E000
		dc.w	$0000,$0012,$000E,$0001,$0000,$1000,$E000,$E000
		dc.w	$0000,$0192,$01EF,$0000,$0000,$3ED0,$C1E0,$00E0
		dc.w	$0000,$0000,$0087,$0078,$0000,$4400,$BC00,$0C00
		dc.w	$0000,$0013,$001C,$0018,$0000,$E740,$0F80,$1F80
		dc.w	$0000,$0700,$0100,$0700,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$000D,$000E,$0001,$0000,$0000,$E000,$E000
		dc.w	$0000,$0012,$000E,$0001,$0000,$1000,$E000,$E000
		dc.w	$0000,$0012,$000E,$0001,$0000,$1000,$E000,$E000
		dc.w	$0000,$0011,$000E,$0000,$0000,$5000,$2000,$E000
		dc.w	$0000,$004C,$007F,$0000,$0000,$7C00,$83F0,$0060
		dc.w	$0000,$01C0,$00CF,$0030,$0000,$2400,$DC00,$0400
		dc.w	$0000,$0013,$001C,$0010,$0000,$F780,$0780,$0FC0
		dc.w	$0000,$0300,$0100,$0700,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0007,$0006,$0009,$0000,$6000,$E000,$E000
		dc.w	$0000,$0017,$0008,$0000,$0000,$5000,$2000,$E000
		dc.w	$0000,$0017,$0008,$0000,$0000,$5000,$2000,$E000
		dc.w	$0000,$001C,$0003,$0000,$0000,$A000,$8000,$6000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0410,$03E0,$0070
		dc.w	$0000,$00E6,$01FF,$0000,$0000,$0400,$0C00,$0400
		dc.w	$0000,$0010,$0018,$0010,$0000,$FB20,$03C0,$07C0
		dc.w	$0000,$0700,$0500,$0300,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0001,$0000,$000F,$0000,$6000,$E000,$E000
		dc.w	$0000,$000C,$0003,$0000,$0000,$A000,$8000,$6000
		dc.w	$0000,$000C,$0003,$0000,$0000,$A000,$8000,$6000
		dc.w	$0000,$001D,$0003,$0000,$0000,$2000,$0000,$C000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0210,$03E0,$0070
		dc.w	$0000,$03EE,$01EC,$0010,$0000,$0000,$0000,$0400
		dc.w	$0000,$0000,$0000,$0010,$0000,$3D00,$03E0,$03C0
		dc.w	$0000,$0300,$0500,$0300,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0200,$01FF,$01FF,$0000,$1F00,$FF00,$FF80
		dc.w	$0000,$020D,$01F0,$01FF,$0000,$FF00,$FF00,$FF80
		dc.w	$0000,$000D,$0003,$0000,$0000,$E000,$C000,$0000
		dc.w	$0000,$000D,$0003,$0000,$0000,$E000,$C000,$0000
		dc.w	$0000,$0012,$000E,$0001,$0000,$4000,$8000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0730,$03C0,$0070
		dc.w	$0000,$01C8,$03CC,$0030,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$1820,$05E0,$03C0
		dc.w	$0000,$0600,$0100,$0300,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0300,$00FF,$00FF,$0000,$3E80,$FE00,$FF80
		dc.w	$0000,$0307,$00F8,$00FF,$0000,$FE80,$FE00,$FF80
		dc.w	$0000,$0003,$0000,$0000,$0000,$8000,$0000,$0000
		dc.w	$0000,$0003,$0000,$0000,$0000,$8000,$0000,$0000
		dc.w	$0000,$0035,$000E,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$02FE,$00FF,$01FF,$0000,$77E0,$C790,$F860
		dc.w	$0000,$01C4,$03C0,$0038,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$1020,$0FC0,$01E0
		dc.w	$0000,$0132,$042E,$031E,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0080,$037F,$007F,$0000,$FD00,$FC80,$FF80
		dc.w	$0000,$0083,$0378,$007F,$0000,$FD00,$FC80,$FF80
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$067C,$01FF,$03FF,$0000,$63B0,$8300,$FCE0
		dc.w	$0000,$03C0,$03C0,$0038,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0060,$0F80,$01E0
		dc.w	$0000,$020A,$0514,$0886,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$00F8,$0307,$0000,$0000,$F200,$0D80,$0380
		dc.w	$0000,$00E1,$0318,$0007,$0000,$5200,$6D80,$8380
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$03E0,$047F,$03FF,$0000,$6200,$8220,$FDC0
		dc.w	$0000,$01C0,$03C0,$0038,$0000,$0000,$0000,$0020
		dc.w	$0000,$0000,$0000,$0200,$0000,$08E0,$0F00,$01E0
		dc.w	$0000,$0D94,$125E,$0006,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$011F,$02FF,$0000,$0000,$9880,$E780,$0180
		dc.w	$0000,$0113,$02FE,$0001,$0000,$8880,$1780,$E180
		dc.w	$0000,$0003,$0000,$0000,$0000,$8000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0FC3,$063C,$0100,$0000,$FBA0,$07C0,$0000
		dc.w	$0000,$00C8,$03C0,$0038,$0000,$0000,$0000,$0020
		dc.w	$0000,$0000,$0000,$0200,$0000,$0CE0,$0F00,$01E0
		dc.w	$0000,$0000,$0006,$001E,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0060,$03E0,$001F,$0000,$7480,$7B80,$8080
		dc.w	$0000,$0065,$03EE,$0011,$0000,$5480,$9B80,$E080
		dc.w	$0000,$0009,$0004,$0003,$0000,$6000,$8000,$C000
		dc.w	$0000,$0003,$0000,$0000,$0000,$8000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$073E,$0E7F,$0180,$0000,$7840,$8780,$0000
		dc.w	$0000,$0018,$03C0,$0038,$0000,$0040,$0000,$0020
		dc.w	$0000,$0100,$0000,$0200,$0000,$1F80,$0E00,$01E0
		dc.w	$0000,$000A,$0006,$001E,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0001,$000E,$0001,$0000,$6000,$E000,$E000
		dc.w	$0000,$0005,$000C,$0003,$0000,$2000,$C000,$E000
		dc.w	$0000,$0009,$0000,$0007,$0000,$2000,$C000,$C000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0301,$0E01,$01FE,$0000,$BD00,$C200,$0000
		dc.w	$0000,$003C,$03C0,$0038,$0000,$0040,$0040,$0020
		dc.w	$0000,$0100,$0100,$0200,$0000,$1700,$0600,$09E0
		dc.w	$0000,$0016,$0016,$000E,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0009,$0006,$0001,$0000,$6000,$E000,$E000
		dc.w	$0000,$001E,$000E,$0001,$0000,$7000,$E000,$E000
		dc.w	$0000,$000D,$000C,$0003,$0000,$2000,$E000,$E000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0F00,$0F00,$00E0,$0000,$0000,$0000,$0000
		dc.w	$0000,$0238,$01C4,$0038,$0000,$0080,$00E0,$0040
		dc.w	$0000,$0080,$0380,$0100,$0000,$0220,$1220,$0DC0
		dc.w	$0000,$000A,$001E,$0006,$0000,$0000,$0100,$0100
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$000D,$0002,$0001,$0000,$6000,$E000,$E000
		dc.w	$0000,$0012,$000E,$0001,$0000,$1000,$E000,$E000
		dc.w	$0000,$001E,$000E,$0001,$0000,$7000,$E000,$E000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$01C0,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$021E,$01C0,$003C,$0000,$0120,$01C0,$0080
		dc.w	$0000,$0240,$01C0,$0080,$0000,$2340,$0360,$1C80
		dc.w	$0000,$0010,$000E,$0006,$0000,$0000,$0100,$0100
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0003,$000E,$0001,$0000,$0000,$E000,$E000
		dc.w	$0000,$0011,$000E,$0000,$0000,$5000,$2000,$E000
		dc.w	$0000,$0012,$000E,$0001,$0000,$1000,$E000,$E000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0490,$0060,$03E0,$0000,$0000,$0000,$0000
		dc.w	$0000,$0018,$01E7,$001E,$0000,$0720,$00C0,$0380
		dc.w	$0000,$0270,$01A0,$00C0,$0000,$A3E0,$63C0,$1C00
		dc.w	$0000,$0014,$000E,$0006,$0000,$0200,$0100,$0200
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0004,$000C,$0003,$0000,$8000,$6000,$E000
		dc.w	$0000,$001C,$0003,$0000,$0000,$A000,$8000,$6000
		dc.w	$0000,$0017,$0008,$0000,$0000,$5000,$2000,$E000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0690,$0670,$01F0,$0000,$0000,$0000,$0000
		dc.w	$0000,$0100,$00FF,$000F,$0000,$3600,$C1C0,$FF00
		dc.w	$0000,$0034,$01C3,$007F,$0000,$3F00,$C7C0,$F800
		dc.w	$0000,$0014,$000F,$0007,$0000,$0C00,$F300,$FE00
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0008,$0008,$0007,$0000,$0000,$2000,$E000
		dc.w	$0000,$001D,$0003,$0000,$0000,$2000,$0000,$C000
		dc.w	$0000,$000C,$0003,$0000,$0000,$A000,$8000,$6000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0F38,$0770,$00F0,$0000,$0000,$0000,$0000
		dc.w	$0000,$0003,$00FB,$0007,$0000,$6440,$83C0,$FE00
		dc.w	$0000,$0115,$01E3,$003F,$0000,$3440,$CF80,$F000
		dc.w	$0000,$0017,$0017,$000F,$0000,$B000,$C700,$FC00
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0012,$000E,$0001,$0000,$4000,$8000,$0000
		dc.w	$0000,$000D,$0003,$0000,$0000,$E000,$C000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0908,$0770,$00F0,$0000,$0000,$0000,$0000
		dc.w	$0000,$00DE,$0020,$0001,$0000,$C880,$07C0,$FE00
		dc.w	$0000,$008B,$01F1,$003F,$0000,$8080,$FF00,$C000
		dc.w	$0000,$0019,$0007,$0030,$0000,$9E00,$BFF4,$7FF8
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0035,$000E,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0003,$0000,$0000,$0000,$8000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0BA8,$0410,$0070,$0000,$0000,$0000,$0000
		dc.w	$0000,$007F,$0000,$0000,$0000,$05C0,$FF80,$0400
		dc.w	$0000,$01D3,$00FC,$0010,$0000,$F900,$0600,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$21BC,$0FFE,$1FFC
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0650,$01C0,$0030,$0000,$0000,$0000,$0000
		dc.w	$0000,$001F,$0000,$0000,$0000,$8780,$7B80,$0400
		dc.w	$0000,$00F3,$00EC,$0010,$0000,$BE00,$4000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0E34,$11C4,$080E
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$06F0,$01E0,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0007,$0000,$0000,$0000,$C600,$3A00,$0580
		dc.w	$0000,$0031,$002E,$00D0,$0000,$F000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$1812,$160E,$0C06
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$01C0,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$7400,$0880,$0700
		dc.w	$0000,$0017,$0088,$0070,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$1C1A,$040C,$1C06
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$1A80,$0400,$0300
		dc.w	$0000,$00AC,$0010,$0060,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0F4C,$078B,$1FF6
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0A00,$0400,$0300
		dc.w	$0000,$0028,$0010,$0060,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$1CE0,$131A,$0807
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0A00,$0400,$0300
		dc.w	$0000,$0028,$0010,$0060,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$080B,$1407,$0C01
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0600,$0100,$0200
		dc.w	$0000,$0030,$0040,$0020,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$180C,$0407,$0C01
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0043,$001F,$003F,$0000,$F200,$FD00,$FE00
		dc.w	$0000,$0004,$0003,$000F,$0000,$8000,$F000,$F000
		dc.w	$0000,$07E1,$001F,$03FF,$0000,$C040,$BF00,$FF80
		dc.w	$0000,$1BE1,$041F,$03FF,$0000,$EEC0,$8F00,$F000
		dc.w	$0000,$0000,$0000,$0000,$0000,$C000,$3FC0,$3FF0
		dc.w	$0000,$07F0,$0FFF,$0FFF,$0000,$187C,$FFFC,$FFFE
		dc.w	$0000,$05F0,$030F,$00FF,$0000,$7C00,$FF40,$FF80
		dc.w	$0000,$0000,$1FFF,$3FFF,$0000,$01F0,$FFF0,$FFF8
		dc.w	$0000,$00C0,$00BF,$007F,$0000,$0200,$FD00,$FE00
		dc.w	$0000,$07F0,$020F,$01FF,$0000,$8020,$FF80,$FFC0
		dc.w	$0000,$0071,$010F,$00FF,$0000,$FE80,$FF40,$FF80
		dc.w	$0000,$0012,$0011,$000F,$0000,$0000,$F000,$F000
		dc.w	$0000,$21E1,$001F,$1FFF,$0000,$C3D0,$3FC0,$FFE0
		dc.w	$0000,$21E1,$001F,$1FFF,$0000,$C7D0,$0600,$F9E0
		dc.w	$0000,$0000,$0000,$0000,$0000,$6000,$1E00,$1FC0
		dc.w	$0000,$0078,$0FFF,$0FFF,$0000,$F8FA,$FFF8,$FFFE
		dc.w	$0000,$10F0,$080F,$07FF,$0000,$FF00,$FFE8,$FFF0
		dc.w	$0000,$3000,$17FF,$0FFF,$0000,$03E8,$FFE0,$FFF8
		dc.w	$0000,$0100,$02FF,$01FF,$0000,$0F80,$FF40,$FF80
		dc.w	$0000,$10F0,$000F,$0FFF,$0000,$C1E8,$FFE0,$FFF0
		dc.w	$0000,$05FC,$0303,$00FF,$0000,$FFA0,$FFC0,$FFE0
		dc.w	$0000,$003D,$003C,$0003,$0000,$8000,$7000,$F000
		dc.w	$0000,$40C7,$003F,$3FFF,$0000,$EFC8,$3FE0,$FFF0
		dc.w	$0000,$40C7,$003F,$3FFF,$0000,$C4C8,$0420,$FBF0
		dc.w	$0000,$0000,$0000,$0000,$0000,$F180,$0080,$0F00
		dc.w	$0000,$0803,$0BFF,$07FF,$0000,$C3F4,$FFF2,$FFFE
		dc.w	$0000,$2061,$101F,$0FFF,$0000,$FFC0,$FFF4,$FFF8
		dc.w	$0000,$0C00,$05FF,$03FF,$0000,$0FD0,$FFC8,$FFF8
		dc.w	$0000,$0005,$07FF,$03FF,$0000,$BFC0,$FFA0,$FFC0
		dc.w	$0000,$2063,$001F,$1FFF,$0000,$F7E4,$FFF0,$FFF8
		dc.w	$0000,$0803,$041C,$03E0,$0000,$F3D0,$07F0,$0FE0
		dc.w	$0000,$0009,$007E,$0000,$0000,$0000,$7000,$F000
		dc.w	$0000,$623F,$63C0,$1C00,$0000,$FE60,$0070,$01F8
		dc.w	$0000,$623F,$63C0,$1C00,$0000,$F150,$0F30,$00F8
		dc.w	$0000,$0001,$0000,$0000,$0000,$E700,$0100,$1E00
		dc.w	$0000,$03FF,$0C00,$0100,$0000,$FBC8,$0436,$000E
		dc.w	$0000,$111F,$31E0,$0E00,$0000,$F89E,$07E0,$007C
		dc.w	$0000,$01FF,$0200,$0000,$0000,$8F20,$70D8,$0038
		dc.w	$0000,$0443,$03FC,$0780,$0000,$F9E0,$01C0,$07E0
		dc.w	$0000,$311F,$31E0,$0E00,$0000,$E330,$FC38,$00FC
		dc.w	$0000,$0000,$087F,$0780,$0000,$FCE8,$01F0,$03F0
		dc.w	$0000,$0064,$001F,$0000,$0000,$8000,$7000,$F000
		dc.w	$0000,$787F,$7F80,$0000,$0000,$CFB4,$3078,$0038
		dc.w	$0000,$787F,$7F80,$0000,$0000,$F8AC,$0758,$0038
		dc.w	$0000,$0003,$0000,$0000,$0000,$C600,$0A00,$3C00
		dc.w	$0000,$09F0,$0E8F,$0180,$0000,$9E62,$E79E,$0006
		dc.w	$0000,$7F3F,$3FC0,$0000,$0000,$FC6E,$03E0,$001C
		dc.w	$0000,$00F9,$0007,$0000,$0000,$F188,$FE18,$0078
		dc.w	$0000,$0EE0,$09FF,$0700,$0000,$3EE0,$C1F0,$00E0
		dc.w	$0000,$7F3F,$3FC0,$0000,$0000,$C7DA,$783C,$001C
		dc.w	$0000,$1C01,$0CFE,$0300,$0000,$FEF0,$00F0,$01F8
		dc.w	$0000,$001E,$0007,$0000,$0000,$8000,$7000,$F000
		dc.w	$0000,$201F,$3FE0,$0000,$0000,$DF00,$20FC,$0018
		dc.w	$0000,$201F,$3FE0,$0000,$0000,$FC28,$03F8,$001C
		dc.w	$0000,$0007,$0000,$0000,$0000,$88FF,$1CFF,$70FF
		dc.w	$0000,$0DEC,$0EDB,$01C0,$0000,$01D2,$F9EE,$0602
		dc.w	$0000,$3FCF,$7FF0,$0000,$0000,$FE34,$01F0,$0008
		dc.w	$0000,$0036,$000E,$0001,$0000,$0018,$0F88,$F078
		dc.w	$0000,$06F0,$00FF,$0F00,$0000,$7C30,$8360,$00F0
		dc.w	$0000,$7FCF,$7FF0,$0000,$0000,$CF80,$F07E,$000C
		dc.w	$0000,$0E68,$1FF0,$0000,$0000,$3F64,$0078,$00F8
		dc.w	$0000,$000B,$0003,$0004,$0000,$B000,$7000,$F000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0104,$00F8,$001C
		dc.w	$0000,$0000,$0000,$0000,$0000,$0220,$03FC,$001C
		dc.w	$0000,$000E,$0001,$0000,$0000,$10BE,$705E,$E83F
		dc.w	$0000,$0700,$06E0,$09E0,$0000,$0002,$0006,$0002
		dc.w	$0000,$7700,$7600,$0800,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0838,$0708,$00F0
		dc.w	$0000,$0620,$0000,$0FC0,$0000,$0410,$03F0,$0070
		dc.w	$0000,$7700,$7600,$0800,$0000,$0182,$017C,$000E
		dc.w	$0000,$3EE0,$1EC0,$0100,$0000,$77A0,$087C,$0078
		dc.w	$0000,$0000,$0000,$0007,$0000,$B000,$7000,$F000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0084,$00F8,$001C
		dc.w	$0000,$0000,$0000,$0000,$0000,$0184,$01F8,$001C
		dc.w	$0000,$0010,$000C,$0003,$0000,$401D,$806C,$F01F
		dc.w	$0000,$01C0,$00E0,$0FE0,$0000,$0000,$0000,$0002
		dc.w	$0000,$3000,$7000,$0E00,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$1E70,$0010,$01E0
		dc.w	$0000,$0200,$0000,$0FC0,$0000,$0200,$03F0,$0070
		dc.w	$0000,$3000,$7000,$0E00,$0000,$00C2,$00FC,$000E
		dc.w	$0000,$1C80,$3CC0,$0300,$0000,$E704,$08BC,$1078
		dc.w	$0000,$0002,$0000,$0007,$0000,$F000,$7000,$F000
		dc.w	$0000,$0000,$0000,$0000,$0000,$01CC,$00F0,$001C
		dc.w	$0000,$0000,$0000,$0000,$0000,$01CC,$01F0,$021C
		dc.w	$0000,$0034,$001D,$0003,$0000,$007B,$C030,$E00F
		dc.w	$0000,$05C0,$00E0,$0FE0,$0000,$0000,$0000,$0000
		dc.w	$0000,$3D00,$7000,$0E00,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$3CE0,$0020,$03C0
		dc.w	$0000,$0120,$0000,$0FC0,$0000,$0730,$03C0,$0070
		dc.w	$0000,$0D00,$7000,$0E00,$0000,$00C6,$00C8,$003E
		dc.w	$0000,$1C41,$3C00,$0380,$0000,$D204,$1DF8,$203C
		dc.w	$0000,$0003,$0000,$0007,$0000,$F000,$7000,$F000
		dc.w	$0000,$0280,$007F,$01FF,$0000,$DDF8,$F1E4,$FE18
		dc.w	$0000,$0007,$07FF,$07FF,$0000,$FDF8,$F1E4,$FE18
		dc.w	$0000,$0053,$003B,$0007,$0000,$C006,$8001,$C03F
		dc.w	$0000,$07FF,$00FF,$0FFF,$0000,$80E0,$FF80,$FFC0
		dc.w	$0000,$1FC3,$703F,$0FFF,$0000,$0020,$FF80,$FFC0
		dc.w	$0000,$0000,$0000,$0000,$0000,$78C0,$0140,$0780
		dc.w	$0000,$01F0,$000F,$0FFF,$0000,$F7F0,$C780,$F870
		dc.w	$0000,$4FC3,$303F,$0FFF,$0000,$FE0E,$F800,$FFFE
		dc.w	$0000,$3C03,$3C00,$0380,$0000,$B80C,$39F0,$403C
		dc.w	$0000,$0001,$0000,$0007,$0000,$F000,$7000,$F000
		dc.w	$0000,$0880,$03FF,$07FF,$0000,$98EC,$E0C0,$FF38
		dc.w	$0000,$0C01,$03FF,$03FF,$0000,$98F8,$E0C4,$FF38
		dc.w	$0000,$00A0,$0077,$000F,$0000,$800C,$0003,$803F
		dc.w	$0000,$01F8,$00FF,$8FFF,$0000,$FE38,$FFE0,$FFF0
		dc.w	$0000,$1F80,$707F,$0FFF,$0000,$C1E8,$FFE0,$FFF0
		dc.w	$0000,$0000,$0000,$0000,$0000,$F100,$0380,$0E00
		dc.w	$0000,$10F0,$000F,$0FFF,$0000,$E3E0,$8318,$FCF0
		dc.w	$0000,$0F80,$387F,$07FF,$0000,$CC04,$F002,$FFFE
		dc.w	$0000,$1C03,$3C04,$0380,$0000,$311C,$31E0,$C03C
		dc.w	$0000,$0004,$0004,$0003,$0000,$F000,$7000,$F000
		dc.w	$0000,$066B,$11FF,$0FFF,$0000,$1882,$E088,$FF70
		dc.w	$0000,$0200,$0DFF,$01FF,$0000,$18F0,$E088,$FF78
		dc.w	$0000,$01E1,$00EE,$001F,$0000,$0078,$0007,$003F
		dc.w	$0000,$04E0,$0CFF,$83FF,$0000,$007C,$FFE0,$FFF8
		dc.w	$0000,$1F80,$707F,$0FFF,$0000,$F7E4,$FFF0,$FFF8
		dc.w	$0000,$0001,$0000,$0000,$0000,$C200,$2E00,$1D00
		dc.w	$0000,$2063,$101F,$0FFF,$0000,$E268,$8214,$FDF8
		dc.w	$0000,$2380,$1C7F,$03FF,$0000,$0C04,$F002,$FFFE
		dc.w	$0000,$0C80,$3C0E,$0381,$0000,$019C,$01E0,$E03C
		dc.w	$0000,$0007,$0007,$0000,$0000,$F000,$7000,$F000
		dc.w	$0000,$2CFF,$0000,$1F00,$0000,$3EE8,$C1F0,$0002
		dc.w	$0000,$03EE,$0C11,$0000,$0000,$00E0,$FFFC,$0018
		dc.w	$0000,$0282,$01DC,$003E,$0000,$0102,$007F,$00FF
		dc.w	$0000,$461F,$4FE0,$8000,$0000,$FFCC,$0038,$003C
		dc.w	$0000,$0F1F,$7FE0,$0000,$0000,$FF30,$0038,$00FC
		dc.w	$0000,$0002,$0001,$0000,$0000,$0800,$9000,$7E00
		dc.w	$0000,$511F,$31E0,$0E00,$0000,$F8AC,$0798,$007C
		dc.w	$0000,$10FF,$0F00,$0000,$0000,$000C,$FFE2,$001E
		dc.w	$0000,$01D9,$3C1C,$0383,$0000,$03F0,$01C0,$C03C
		dc.w	$0000,$0003,$0007,$0000,$0000,$F000,$7000,$F000
		dc.w	$0000,$03E7,$2418,$1800,$0000,$9E14,$61E0,$0002
		dc.w	$0000,$047F,$0B80,$0000,$0000,$8028,$7FFC,$0018
		dc.w	$0000,$0400,$03FF,$003F,$0000,$0416,$FBEF,$FFFF
		dc.w	$0000,$00FF,$4F00,$C000,$0000,$FFE6,$0018,$001C
		dc.w	$0000,$0F3E,$7FC1,$0000,$0000,$07DA,$F83C,$001C
		dc.w	$0000,$0006,$0003,$0000,$0000,$8000,$B800,$7C00
		dc.w	$0000,$7F3F,$3FC0,$0000,$0000,$FC54,$03AE,$001C
		dc.w	$0000,$08FF,$0700,$0000,$0000,$C004,$3FFA,$000E
		dc.w	$0000,$03DB,$3C18,$03E7,$0000,$82E0,$00C0,$813C
		dc.w	$0000,$0001,$0007,$0000,$0000,$F000,$7000,$F000
		dc.w	$0000,$41F7,$0E08,$3000,$0000,$8F44,$7084,$0002
		dc.w	$0000,$01FF,$0600,$0000,$0000,$F828,$07FC,$0018
		dc.w	$0000,$0B40,$07FF,$007F,$0000,$0C36,$F3CF,$FFFF
		dc.w	$0000,$207F,$EF80,$4000,$0000,$FFF2,$000C,$000E
		dc.w	$0000,$1FCC,$7FF3,$0000,$0000,$0F80,$F07E,$000C
		dc.w	$0000,$000A,$0007,$0000,$0000,$7800,$7000,$F800
		dc.w	$0000,$7FCF,$7FF0,$0000,$0000,$FE16,$01FC,$000E
		dc.w	$0000,$03FF,$0000,$0000,$0000,$FC06,$03FA,$000E
		dc.w	$0000,$23C7,$1C00,$03FF,$0000,$0044,$0244,$01B8
		dc.w	$0000,$0004,$0003,$0000,$0000,$B000,$7000,$F000
		dc.w	$0000,$0100,$6800,$1600,$0000,$0008,$000E,$0004
		dc.w	$0000,$0000,$0000,$0000,$0000,$0020,$01FC,$001C
		dc.w	$0000,$1FF8,$06FF,$00FF,$0000,$38EE,$C30F,$FFFF
		dc.w	$0000,$9000,$7000,$2000,$0000,$0008,$00F6,$000E
		dc.w	$0000,$1700,$7600,$0800,$0000,$0082,$007C,$000E
		dc.w	$0000,$0014,$000E,$0001,$0000,$1000,$E000,$F000
		dc.w	$0000,$7700,$7600,$0800,$0000,$0090,$007E,$000E
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$00EE,$001E
		dc.w	$0000,$21E0,$1C0E,$03FE,$0000,$0468,$006C,$0390
		dc.w	$0000,$0006,$0001,$0000,$0000,$B000,$7000,$F000
		dc.w	$0000,$0300,$7800,$0700,$0000,$0012,$001C,$0008
		dc.w	$0000,$0000,$0000,$0000,$0000,$0084,$00F8,$001C
		dc.w	$0000,$2D81,$1E7E,$0000,$0000,$E386,$1C7F,$0007
		dc.w	$0000,$9800,$6800,$3000,$0000,$000C,$0072,$000E
		dc.w	$0000,$3000,$7000,$0E00,$0000,$0042,$007C,$000E
		dc.w	$0000,$003C,$001D,$0003,$0000,$2000,$C000,$E000
		dc.w	$0000,$3000,$7000,$0E00,$0000,$0042,$007C,$000E
		dc.w	$0000,$0000,$0000,$0000,$0000,$0042,$007C,$000E
		dc.w	$0000,$0198,$1E64,$01FC,$0000,$147C,$0C78,$0380
		dc.w	$0000,$0006,$0001,$0000,$0000,$9000,$7000,$F000
		dc.w	$0000,$0C00,$7300,$0F00,$0000,$0032,$002C,$0018
		dc.w	$0000,$0000,$0000,$0000,$0000,$01CC,$01F0,$001C
		dc.w	$0000,$5E7D,$3FFE,$0000,$0000,$F3C6,$0C3F,$0007
		dc.w	$0000,$0C00,$7400,$1800,$0000,$00CE,$00F0,$000E
		dc.w	$0000,$0D00,$7000,$0E00,$0000,$00E6,$0078,$000E
		dc.w	$0000,$0050,$003B,$0007,$0000,$4000,$8000,$C000
		dc.w	$0000,$0D00,$7000,$0E00,$0000,$00E6,$0078,$000E
		dc.w	$0000,$0000,$0000,$0000,$0000,$00E6,$00F8,$000E
		dc.w	$0000,$1000,$0FFF,$00FF,$0000,$07E0,$F8F8,$FF00
		dc.w	$0000,$0004,$0003,$0000,$0000,$C000,$3000,$F000
		dc.w	$0000,$08E3,$77FF,$0FFF,$0000,$E360,$FC1C,$FFF0
		dc.w	$0000,$1387,$307F,$0FFF,$0000,$FDFC,$F1E0,$FE1C
		dc.w	$0000,$FB86,$0F87,$0078,$0000,$FBE6,$041B,$0007
		dc.w	$0000,$441D,$78FE,$0FFF,$0000,$F3FE,$03F2,$FC0C
		dc.w	$0000,$0FC3,$703F,$0FFF,$0000,$CEFC,$F8F2,$FF0C
		dc.w	$0000,$0080,$007F,$0007,$0000,$0000,$8000,$8000
		dc.w	$0000,$0FC3,$703F,$0FFF,$0000,$CEFC,$F8F2,$FF0C
		dc.w	$0000,$19C3,$083F,$07FF,$0000,$FEFE,$F8F2,$FF0C
		dc.w	$0000,$103F,$0FBF,$007F,$0000,$E688,$F9F0,$FE00
		dc.w	$0000,$0001,$0007,$0000,$0000,$7000,$0000,$F000
		dc.w	$0000,$4FC0,$37FF,$0FFF,$0000,$8644,$F83C,$FFE0
		dc.w	$0000,$1B01,$78FF,$07FF,$0000,$98EC,$E0C0,$FF38
		dc.w	$0000,$0000,$0000,$0000,$0000,$0032,$000B,$0007
		dc.w	$0000,$21B0,$7C7F,$0FFF,$0000,$F8FE,$00E0,$FF1C
		dc.w	$0000,$4F80,$387F,$07FF,$0000,$8C76,$F060,$FF9C
		dc.w	$0000,$0108,$00F7,$000F,$0000,$0000,$0000,$0000
		dc.w	$0000,$4F80,$387F,$07FF,$0000,$8C76,$F060,$FF9C
		dc.w	$0000,$2D80,$1C7F,$03FF,$0000,$CC76,$F060,$FF9C
		dc.w	$0000,$0DEF,$0207,$001F,$0000,$F010,$FFE0,$F800
		dc.w	$0000,$0006,$0006,$0001,$0000,$3000,$3000,$C000
		dc.w	$0000,$6700,$17FF,$0FFF,$0000,$1C88,$E07C,$FFE0
		dc.w	$0000,$0100,$78FF,$07FF,$0000,$1880,$E080,$FF78
		dc.w	$0000,$0000,$0000,$0000,$0000,$000B,$0007,$0003
		dc.w	$0000,$74B0,$3C7F,$07FF,$0000,$FE04,$0004,$FFF8
		dc.w	$0000,$0380,$3C7F,$03FF,$0000,$0C40,$F044,$FFB8
		dc.w	$0000,$000E,$03E0,$001E,$0000,$0000,$0000,$0000
		dc.w	$0000,$0380,$3C7F,$03FF,$0000,$0C40,$F044,$FFB8
		dc.w	$0000,$0080,$3C7F,$03FF,$0000,$0C40,$F040,$FFBC
		dc.w	$0000,$07FC,$0003,$0000,$0000,$7F20,$80C0,$0000
		dc.w	$0000,$0008,$0003,$0004,$0000,$8800,$6000,$1000
		dc.w	$0000,$7FFF,$0000,$0000,$0000,$105C,$EFF8,$0040
		dc.w	$0000,$41FE,$3E01,$0000,$0000,$00E8,$FFE0,$0010
		dc.w	$0000,$0000,$0000,$0000,$0000,$0007,$0003,$0003
		dc.w	$0000,$3C3C,$3BC3,$0400,$0000,$1FCC,$FFC8,$0030
		dc.w	$0000,$20FF,$1F00,$0000,$0000,$7F74,$80F8,$0000
		dc.w	$0000,$0430,$03F0,$000C,$0000,$0000,$0000,$0000
		dc.w	$0000,$20FF,$1F00,$0000,$0000,$7F74,$80F8,$0000
		dc.w	$0000,$20FF,$1F00,$0000,$0000,$0074,$FFF0,$0008
		dc.w	$0000,$03FE,$0003,$0000,$0000,$F7C0,$0800,$0000
		dc.w	$0000,$0023,$000C,$0010,$0000,$E200,$1800,$0400
		dc.w	$0000,$7FFF,$0000,$0000,$0000,$9878,$67B8,$0040
		dc.w	$0000,$21FF,$1E00,$0000,$0000,$8030,$7FE0,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0007,$0001,$0003
		dc.w	$0000,$0C7F,$0B80,$3400,$0000,$8FF8,$7FF0,$0000
		dc.w	$0000,$10FE,$0F01,$0000,$0000,$0F08,$F0F0,$0000
		dc.w	$0000,$19C0,$07C0,$003E,$0000,$0000,$0000,$0000
		dc.w	$0000,$10FE,$0F01,$0000,$0000,$0F08,$F0F0,$0000
		dc.w	$0000,$10FF,$0F00,$0000,$0000,$C018,$3FF0,$0000
		dc.w	$0000,$00F0,$000F,$0000,$0000,$3F00,$C000,$0000
		dc.w	$0000,$000E,$0031,$0040,$0000,$3800,$C600,$0100
		dc.w	$0000,$7FFF,$0000,$0000,$0000,$FC60,$03A0,$0058
		dc.w	$0000,$0BFF,$0400,$0000,$0000,$F840,$0780,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0001,$0001,$0003
		dc.w	$0000,$05FF,$2200,$1C00,$0000,$F1E0,$0FC0,$0000
		dc.w	$0000,$05FF,$0200,$0000,$0000,$07A0,$F840,$0000
		dc.w	$0000,$26FF,$1E01,$01FE,$0000,$0000,$0000,$0000
		dc.w	$0000,$05FF,$0200,$0000,$0000,$07A0,$F840,$0000
		dc.w	$0000,$05FF,$0200,$0000,$0000,$FC20,$03C0,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0700,$0088,$0070
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0003,$0001,$0001
		dc.w	$0000,$2B00,$0400,$1800,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0168,$00C0,$0030
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0003,$0001,$0001
		dc.w	$0000,$0A00,$0400,$1800,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$00A0,$0040,$0030
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0001,$0000,$0001
		dc.w	$0000,$0A00,$0400,$1800,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$00A0,$0040,$0030
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0001,$0000
		dc.w	$0000,$0C00,$1000,$0800,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0020,$0050,$0020
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$1C00,$0000,$0800,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0070,$0000,$0020
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0800,$0000,$0800,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0020,$0000,$0020
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0800,$0800,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0020,$0000,$0020
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$1FF0
		dc.w	$1FF0,$06E3,$05E3,$03E7,$0000,$7006,$BFFE,$CFFE
		dc.w	$0000,$0030,$3FF0,$7FF8,$0000,$2F10,$181F,$7E0F
		dc.w	$0000,$0400,$F87F,$FCFF,$0000,$7307,$F3FF,$F7FF
		dc.w	$0000,$EC68,$9C70,$7C7C,$0000,$0039,$00FF,$01FF
		dc.w	$0000,$82F2,$81F8,$C7F1,$0000,$2366,$E1A7,$E3CF
		dc.w	$0000,$0E00,$FC00,$FE00,$0000,$1CD8,$7F86,$FFCF
		dc.w	$0000,$0B00,$0D00,$1E00,$0000,$1374,$1FF1,$3FF3
		dc.w	$0000,$6620,$FE0E,$FF1E,$0000,$080E,$0FFE,$07FE
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$2108
		dc.w	$2108,$0002,$0142,$00E1,$0000,$C3DA,$0424,$8202
		dc.w	$0000,$1F70,$2888,$0018,$0000,$1403,$3404,$0C02
		dc.w	$0000,$CF1E,$3631,$0600,$0000,$C7BC,$305B,$1601
		dc.w	$0000,$1038,$2800,$0818,$0000,$007B,$0084,$0040
		dc.w	$0000,$10DC,$C31C,$4C38,$0000,$A04B,$4104,$60C8
		dc.w	$0000,$6800,$B600,$0200,$0000,$3F61,$404E,$20E2
		dc.w	$0000,$1600,$0800,$0600,$0000,$3F51,$00A0,$6010
		dc.w	$0000,$7D02,$0112,$838E,$0000,$03DA,$0624,$0002
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0001,$0001,$0000,$0000,$4124
		dc.w	$4124,$01E3,$0126,$00E1,$0000,$0788,$848E,$8370
		dc.w	$0000,$2A68,$3E78,$0988,$0000,$4E07,$2E04,$1603
		dc.w	$0000,$063C,$893C,$7313,$0000,$6072,$53C5,$8438
		dc.w	$0000,$2000,$3838,$0818,$0000,$00D1,$0091,$006E
		dc.w	$0000,$90FC,$570C,$080C,$0000,$1185,$E14B,$70C0
		dc.w	$0000,$F600,$9A00,$6200,$0000,$7BA4,$4C63,$2021
		dc.w	$0000,$A000,$1400,$0C00,$0000,$0001,$A001,$4000
		dc.w	$0000,$0018,$C3BE,$C083,$0000,$0012,$0008,$0006
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$9552
		dc.w	$9552,$00C3,$0020,$01F7,$0000,$8200,$8100,$8700
		dc.w	$0000,$0000,$0800,$3808,$0000,$3A02,$6201,$1607
		dc.w	$0000,$0680,$0118,$0138,$0000,$0420,$0010,$0070
		dc.w	$0000,$0828,$0818,$3818,$0000,$00C0,$0020,$00E0
		dc.w	$0000,$1412,$1406,$480C,$0000,$59C0,$7840,$F8C0
		dc.w	$0000,$C000,$2000,$E000,$0000,$60A2,$1041,$7020
		dc.w	$0000,$3800,$F800,$D800,$0000,$6000,$E000,$0001
		dc.w	$0000,$8295,$C309,$C0B3,$0000,$0016,$0002,$000C
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0001,$0001,$0000,$0000,$4D74
		dc.w	$4D74,$00FB,$003E,$01D5,$0000,$8384,$81FC,$87FE
		dc.w	$0000,$1078,$0878,$3878,$0000,$4703,$7301,$3307
		dc.w	$0000,$011C,$021F,$01BF,$0000,$2030,$F010,$F070
		dc.w	$0000,$1EF8,$0FF8,$3FD8,$0000,$0074,$003F,$00FF
		dc.w	$0000,$9002,$D00C,$CC06,$0000,$D1C0,$7C40,$ECC0
		dc.w	$0000,$6000,$2000,$E000,$0000,$3A60,$1C11,$7FE0
		dc.w	$0000,$7000,$B001,$7000,$0000,$7271,$6FE0,$1FE1
		dc.w	$0000,$EBA7,$F271,$FD91,$0000,$0020,$000C,$8018
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0002,$0002,$0000,$0000,$0552
		dc.w	$0552,$01F7,$0132,$009D,$0000,$877C,$8482,$8202
		dc.w	$0000,$3018,$3830,$0818,$0000,$2507,$2105,$E303
		dc.w	$0000,$0233,$022C,$0180,$0000,$C470,$1450,$3030
		dc.w	$0000,$3938,$36D8,$0018,$0000,$00CF,$00B0,$0040
		dc.w	$0000,$1406,$5008,$CC06,$0000,$E5C0,$F840,$66C0
		dc.w	$0000,$E000,$A000,$6000,$0000,$6770,$58D0,$2030
		dc.w	$0000,$6000,$E000,$2001,$0000,$3ED1,$0131,$0010
		dc.w	$0000,$6C72,$F350,$8031,$0000,$8080,$8050,$8030
		dc.w	$0000,$8000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0004,$0004,$0000,$0000,$7D01
		dc.w	$7D01,$00BD,$0118,$00AD,$0000,$822C,$8530,$83C2
		dc.w	$0000,$9010,$B808,$0838,$0000,$2202,$6505,$E183
		dc.w	$0000,$0602,$0233,$019C,$0000,$7030,$9050,$1430
		dc.w	$0000,$1138,$3918,$0ED8,$0000,$0041,$0086,$0078
		dc.w	$0000,$CC18,$5008,$4C06,$0000,$EEC0,$E340,$60C0
		dc.w	$0000,$6000,$A000,$6000,$0000,$2040,$5030,$3010
		dc.w	$0000,$6001,$E000,$2000,$0000,$0040,$8031,$0010
		dc.w	$0000,$8087,$C078,$C03E,$0000,$C080,$40A0,$C060
		dc.w	$0000,$0000,$8000,$8000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0100
		dc.w	$0100,$01BD,$0008,$0099,$0000,$0701,$8100,$8301
		dc.w	$0000,$2800,$9879,$0838,$0000,$3887,$4781,$8083
		dc.w	$0000,$00B0,$0918,$0618,$0000,$0460,$0810,$0830
		dc.w	$0000,$2028,$1818,$0818,$0000,$00C0,$0020,$0060
		dc.w	$0000,$040E,$1A2C,$0410,$0000,$07C0,$E040,$60C0
		dc.w	$0000,$E000,$2000,$6000,$0000,$6060,$1030,$3010
		dc.w	$0000,$E000,$6000,$2000,$0000,$0060,$C031,$8010
		dc.w	$0000,$0018,$C0A7,$C040,$0000,$4021,$4140,$C0E1
		dc.w	$0000,$0000,$8000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0108,$0099,$0000,$8304,$05F9,$83FE
		dc.w	$0000,$9C33,$BFD8,$0FF8,$0000,$C043,$8185,$00C3
		dc.w	$0000,$8C18,$F33F,$FC1F,$0000,$5010,$8840,$F030
		dc.w	$0000,$1038,$3800,$0838,$0000,$0000,$00A0,$0060
		dc.w	$0000,$03D0,$1FEC,$03F0,$0000,$C340,$A000,$60C0
		dc.w	$0000,$2000,$8000,$6000,$0000,$30A0,$4F20,$3FD0
		dc.w	$0000,$6000,$C000,$2000,$0000,$32A1,$DD21,$7FD0
		dc.w	$0000,$81E1,$4040,$C000,$0000,$8104,$43F9,$40FE
		dc.w	$0000,$8000,$8000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$E5CE
		dc.w	$E5CE,$0291,$0110,$004A,$0000,$4711,$80EF,$0400
		dc.w	$0000,$90D0,$0F3B,$3018,$0000,$C301,$4080,$0046
		dc.w	$0000,$1E79,$E006,$0020,$0000,$9828,$7810,$1040
		dc.w	$0000,$0020,$1810,$2008,$0000,$0140,$0090,$0020
		dc.w	$0000,$0F71,$0088,$0000,$0000,$4081,$8100,$2040
		dc.w	$0000,$4000,$8000,$2000,$0000,$AE80,$1F61,$C000
		dc.w	$0000,$C800,$2000,$1000,$0000,$5C95,$2362,$C000
		dc.w	$0000,$2080,$C361,$2000,$0000,$C6D9,$07E7,$2000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$9529
		dc.w	$9529,$0342,$00E7,$0400,$0000,$CD38,$0326,$38C1
		dc.w	$0000,$0973,$398C,$4618,$0000,$43CD,$E723,$0018
		dc.w	$0000,$3C7A,$201B,$C084,$0000,$D858,$28A0,$1104
		dc.w	$0000,$2828,$5C74,$8000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$2000,$4000,$8000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0004,$0002,$0001
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$E5CE
		dc.w	$E5CE,$0000,$0000,$0000,$0000,$0002,$0000,$0001
		dc.w	$0000,$0018,$0008,$0008,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$1000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$4000,$8000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0002,$0000,$0001
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$9508
		dc.w	$9508,$0000,$0000,$0000,$0000,$0000,$0001,$0000
		dc.w	$0000,$0008,$0008,$0008,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$1000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0001,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$9508
		dc.w	$9508,$0000,$0000,$0000,$0FFF,$0000,$0000,$0000
		dc.w	$FFFF,$0008,$0000,$0008,$FFF7,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$C000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$8108
		even
fontpal	ds.w	2
l00be	ds.w	2
l00bf	ds.w	2
l00c0	ds.w	2
l00c1	ds.w	2
l00c2	ds.w	2
l00c3	ds.w	2
l00c4	ds.w	258
picture	dc.b	0,0
l00c6	dc.b	$00,$00,$FF,$7C
l00c7	dc.b	$F3,$88,$FC,$00
l00c8	dc.b	$3D,$88,$DE,$90
l00c9	dc.b	$FF,$A8,$FF,$30
l00ca	dc.b	$F9,$98,$0E,$DA
l00cb	dc.b	$FB,$A8,$3C,$30
l00cc	dc.b	$FD,$40,$0E,$50
l00cd	dc.b	$FF,$63,$02,$88
l00ce		dc.w	$03E0,$1010,$0C00,$FFFF,$1FFF,$2000,$0000,$FFFF
		dc.w	$FF3F,$00F0,$00C0,$FFFF,$CBF8,$3CF8,$3407,$FFFF
		dc.w	$00FF,$0000,$FF00,$FFFF,$FFFF,$0000,$0000,$FFFF
		dc.w	$807F,$0000,$7F80,$FFFF,$FE07,$0000,$01F8,$FFFF
		dc.w	$E103,$1F03,$1EFC,$FFFF,$8400,$7C00,$7BFF,$FFFF
		dc.w	$0000,$0000,$FFFF,$FFFF,$0180,$0187,$FE7F,$FFFF
		dc.w	$FFFF,$8000,$0000,$FFFF,$F800,$0000,$07FF,$FFFF
		dc.w	$0000,$0000,$FFFF,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$05F8,$1E3F,$FA07,$FFFF,$8FFD,$FFFE,$7002,$FFFF
		dc.w	$FFFF,$01FF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
		dc.w	$01E0,$1010,$0E00,$FFFF,$1FFF,$2000,$0000,$FFFF
		dc.w	$FE7C,$01C0,$0183,$FFFF,$17F0,$79F0,$E80F,$FFFF
		dc.w	$00FF,$0000,$FF00,$FFFF,$FFFE,$0000,$0001,$FFFF
		dc.w	$07FF,$0000,$F800,$FFFF,$FE1F,$0000,$01E0,$FFFF
		dc.w	$C60F,$3E0C,$39F0,$FFFF,$8800,$7800,$77FF,$FFFF
		dc.w	$0000,$0000,$FFFF,$FFFF,$0E01,$0E0F,$F1FE,$FFFF
		dc.w	$FFFF,$8000,$0000,$FFFF,$FF00,$0000,$00FF,$FFFF
		dc.w	$0000,$0000,$FFFF,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$09F7,$1E7F,$F608,$FFFF,$0FF3,$FFFC,$F00C,$FFFF
		dc.w	$FFFF,$07FF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
		dc.w	$03A0,$1010,$0C40,$FFFF,$1E9F,$2000,$0160,$FFFF
		dc.w	$FC80,$0381,$037F,$FFFF,$2FE0,$F3E0,$D01F,$FFFF
		dc.w	$00FF,$0000,$FF00,$FFFF,$FFFF,$0000,$0000,$FFFF
		dc.w	$0FFF,$0000,$F000,$FFFF,$FC3F,$0000,$03C0,$FFFF
		dc.w	$083E,$F831,$F7C1,$FFFF,$1000,$F000,$EFFF,$FFFF
		dc.w	$0000,$0000,$FFFF,$FFFF,$7003,$700E,$8FFC,$FFFF
		dc.w	$FFFF,$8000,$0000,$FFFF,$FE00,$0000,$01FF,$FFFF
		dc.w	$0000,$0000,$FFFF,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$0BFF,$3CFB,$F400,$FFFF,$3C0F,$DFF0,$C3F0,$FFFF
		dc.w	$FFFF,$1FFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
		dc.w	$0000,$1000,$0FC0,$FFFF,$1C1F,$2000,$03E0,$FFFF
		dc.w	$F900,$0703,$06FF,$FFFF,$5FC0,$E7C0,$A03F,$FFFF
		dc.w	$00FF,$0000,$FF00,$FFFF,$FFFF,$0000,$0000,$FFFF
		dc.w	$81FF,$0000,$7E00,$FFFF,$E07E,$0001,$1F81,$FFFF
		dc.w	$3078,$F047,$CF87,$FFFF,$6000,$E000,$9FFF,$FFFF
		dc.w	$0003,$0003,$FFFC,$FFFF,$8007,$801D,$7FF8,$FFFF
		dc.w	$3FFF,$0000,$C000,$FFFF,$FE00,$0000,$01FF,$FFFF
		dc.w	$0000,$0000,$FFFF,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$13EE,$7DF7,$EC11,$FFFF,$F81F,$1FE0,$07E0,$FFFF
		dc.w	$FFFF,$3FFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
		dc.w	$0000,$1000,$0F80,$FFFF,$0C0F,$4000,$33F0,$FFFF
		dc.w	$3900,$0707,$C6FF,$FFFF,$DF80,$AF80,$207F,$FFFF
		dc.w	$007F,$0000,$FF80,$FFFF,$FFFF,$0000,$0000,$FFFF
		dc.w	$C0FF,$0000,$3F00,$FFFF,$F0FC,$0003,$0F03,$FFFF
		dc.w	$41F0,$C18F,$BE0F,$FFFF,$8000,$8000,$7FFF,$FFFF
		dc.w	$000F,$000C,$FFF0,$FFFF,$E007,$001D,$1FF8,$FFFF
		dc.w	$0FFF,$0000,$F000,$FFFF,$FF00,$0000,$00FF,$FFFF
		dc.w	$0000,$0000,$FFFF,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$279C,$79EF,$D863,$FFFF,$E01F,$3FE0,$1FE0,$FFFF
		dc.w	$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
		dc.w	$0000,$1000,$0F80,$FFFF,$0000,$4000,$3FFF,$FFFF
		dc.w	$1201,$0E0F,$EDFE,$FFFF,$BF00,$DF00,$40FF,$FFFF
		dc.w	$007F,$0000,$FF80,$FFFF,$FFFF,$0000,$0000,$FFFF
		dc.w	$80FF,$0000,$7F00,$FFFF,$E0F8,$0007,$1F07,$FFFF
		dc.w	$83C3,$823F,$7C3C,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$1FFF,$0000,$FFFF,$E000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$7FFF,$8000,$7FFF
		dc.w	$0000,$1000,$0F80,$FFFF,$0000,$4000,$3FFF,$FFFF
		dc.w	$6403,$1C1F,$9BFC,$FFFF,$7E00,$9E00,$81FF,$FFFF
		dc.w	$007F,$0000,$FF80,$FFFF,$FFFF,$0000,$0000,$FFFF
		dc.w	$C07D,$0000,$3F82,$FFFF,$41F3,$000F,$BE0C,$FFFF
		dc.w	$0784,$047C,$F87B,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$1000,$0000,$FFFF,$E000,$0000,$0000,$FFFF,$0000
		dc.w	$0000,$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000
		dc.w	$0000,$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000
		dc.w	$0000,$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000
		dc.w	$0000,$0000,$FFFF,$0000,$FFFF,$7FFF,$8000,$7FFF
		dc.w	$0000,$1000,$0F80,$FFFF,$0180,$4000,$3E7F,$FFFF
		dc.w	$4407,$3C1E,$83F8,$C7FF,$7C00,$BC00,$83FF,$FFFF
		dc.w	$007F,$0000,$FF80,$FFFF,$871F,$78E0,$0000,$871F
		dc.w	$0000,$CE38,$31C7,$31C7,$03A4,$045C,$F81B,$FBBF
		dc.w	$0F18,$08F8,$F0E7,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$37FF,$27FF,$D800,$E000,$FFFF,$FFFF,$0000,$0000
		dc.w	$FFFF,$FFFF,$0000,$0000,$FFFF,$FFFF,$0000,$0000
		dc.w	$FFFF,$FFFF,$0000,$0000,$FFFF,$FFFF,$0000,$0000
		dc.w	$FFFF,$FFFF,$0000,$0000,$FFFF,$FFFF,$0000,$0000
		dc.w	$FFFE,$FFFE,$0001,$0000,$FFFF,$7FFF,$8000,$7FFF
		dc.w	$0000,$1000,$0F80,$FFFF,$3183,$4000,$0E7C,$FFFF
		dc.w	$800E,$7C3D,$33F1,$B3FF,$F800,$7800,$07FF,$FFFF
		dc.w	$007F,$0000,$FF80,$FFFF,$BECE,$4131,$0000,$BECE
		dc.w	$0000,$904C,$6FB3,$6FB3,$0380,$047F,$F830,$FBB0
		dc.w	$1E20,$11E0,$E1DF,$FFFF,$0001,$0001,$FFFE,$FFFF
		dc.w	$F400,$C400,$1BFF,$E000,$0000,$0000,$FFFF,$0000
		dc.w	$0000,$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000
		dc.w	$0000,$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000
		dc.w	$0000,$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000
		dc.w	$0002,$0002,$FFFD,$0000,$FFFF,$7FFF,$8000,$7FFF
		dc.w	$0000,$1000,$0F80,$FFFF,$7FD7,$8000,$0028,$FFFF
		dc.w	$881F,$7C7C,$23E0,$ABFF,$F800,$F800,$07FF,$FFFF
		dc.w	$00FF,$0000,$FF00,$FFFF,$86AC,$7953,$0000,$86AC
		dc.w	$E000,$1E54,$01AB,$E1AB,$1810,$07F2,$E02D,$F83D
		dc.w	$3CC0,$23C0,$C33F,$FFFF,$000F,$000E,$FFF0,$FFFF
		dc.w	$F5FF,$0400,$1BFF,$E000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$FFFF,$7FFF,$8000,$7FFF
		dc.w	$0180,$1000,$0E00,$FFFF,$7FFF,$0000,$0000,$FFFF
		dc.w	$901C,$74FB,$0B82,$9B9E,$7000,$F618,$09E7,$79E7
		dc.w	$0079,$6186,$9E00,$9E79,$FA69,$0596,$0000,$FA69
		dc.w	$EC00,$1164,$029B,$EE9B,$3A21,$05E5,$C19A,$FBBB
		dc.w	$F900,$C700,$06FF,$FFFF,$007F,$0070,$FF80,$FFFF
		dc.w	$F5FF,$0400,$1BFF,$E000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$FFFE,$7FFF,$8001,$7FFF
		dc.w	$0700,$0000,$1800,$FFFF,$7FFF,$0000,$0000,$FFFF
		dc.w	$801A,$78F5,$4784,$C79E,$7000,$F618,$09E7,$79E7
		dc.w	$0079,$6186,$9E00,$9E79,$871B,$78E4,$0000,$871B
		dc.w	$F000,$0E38,$01C7,$F1C7,$7800,$07CF,$83B0,$FBB0
		dc.w	$F200,$8E00,$0DFF,$FFFF,$0187,$0180,$FE78,$FFFF
		dc.w	$F5FF,$0400,$1BFF,$E000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$FFFD,$7FFE,$8002,$7FFF
		dc.w	$0300,$1000,$0C00,$FFFF,$7FFF,$0000,$0000,$FFFF
		dc.w	$207B,$E1F5,$DF84,$FFFF,$E000,$E000,$1FFF,$FFFF
		dc.w	$01FF,$0000,$FE00,$FFFF,$FFFF,$0000,$0000,$FFFF
		dc.w	$8000,$0000,$7FFF,$FFFF,$F884,$0787,$077B,$FFFF
		dc.w	$EC00,$9C00,$13FF,$FFFF,$0207,$0200,$FDF8,$FFFF
		dc.w	$F5FF,$0400,$1BFF,$E000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$FFFB,$7FFD,$8004,$7FFF
		dc.w	$0300,$1000,$0C00,$FFFF,$7FFF,$0000,$0000,$FFFF
		dc.w	$0014,$FDEB,$C208,$C21C,$4000,$CF7C,$3083,$7083
		dc.w	$01FF,$0000,$FE00,$FFFF,$860C,$79F3,$0000,$860C
		dc.w	$0001,$C97C,$3682,$3683,$1009,$EF8F,$0876,$187F
		dc.w	$3000,$F000,$CFFF,$FFFF,$1C01,$1C00,$E3FE,$FFFF
		dc.w	$F5FF,$0400,$1BFF,$E000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$FFF7,$7FFA,$8008,$7FFF
		dc.w	$0000,$1000,$0F00,$FFFF,$7FFF,$0000,$0000,$FFFF
		dc.w	$20E3,$E3DF,$9E08,$BEEB,$8000,$D040,$2FBF,$AFBF
		dc.w	$00FF,$0000,$FF00,$FFFF,$BAFA,$4504,$0001,$BAFB
		dc.w	$0002,$0A11,$F5EC,$F5EE,$E212,$1E5F,$09AD,$EBBF
		dc.w	$4000,$C000,$BFFF,$FFFF,$6000,$6000,$9FFF,$FFFF
		dc.w	$75FF,$0400,$9BFF,$E000,$F7FF,$0800,$FFFF,$0800
		dc.w	$FFFE,$0001,$FFFF,$0001,$1C70,$E38F,$FFFF,$E38F
		dc.w	$C31B,$3CE4,$FFFF,$3CE4,$A086,$5F79,$FFFF,$5F79
		dc.w	$EFFF,$1000,$FFFF,$1000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$FFEF,$7FF4,$8010,$7FFF
		dc.w	$0700,$1000,$0800,$FFFF,$FFFE,$0001,$0001,$FFFF
		dc.w	$4008,$FFF7,$8610,$C618,$0000,$D078,$2F87,$2F87
		dc.w	$00FF,$0000,$FF00,$FFFF,$BA00,$45E3,$001C,$BA1C
		dc.w	$0006,$8C11,$73E8,$73EE,$C064,$3FFF,$281B,$E87F
		dc.w	$8000,$8000,$7FFF,$FFFF,$8000,$8000,$7FFF,$FFFF
		dc.w	$15FF,$0400,$FBFF,$E000,$E7FF,$1800,$FFFF,$1800
		dc.w	$FFFE,$0001,$FFFF,$0001,$EEEF,$1110,$FFFF,$1110
		dc.w	$BEEB,$4114,$FFFF,$4114,$AFBA,$5045,$FFFF,$5045
		dc.w	$EFFF,$1000,$FFFF,$1000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$FFDF,$7FE8,$8020,$7FFF
		dc.w	$0E00,$1000,$0000,$FFFF,$FFFE,$0001,$0001,$FFFF
		dc.w	$40CB,$C7BF,$BA30,$FAFB,$8000,$D040,$2FBF,$AFBF
		dc.w	$0079,$6186,$9E00,$9E79,$BAE0,$4500,$001F,$BAFF
		dc.w	$0006,$4A11,$B5E8,$B5EE,$8BC9,$7FFF,$6036,$EBFF
		dc.w	$0003,$0003,$FFFC,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$15FF,$0400,$FBFF,$E000,$F7FF,$0800,$FFFF,$0800
		dc.w	$FFFE,$0001,$FFFF,$0001,$EEF1,$110E,$FFFF,$110E
		dc.w	$BEEB,$4114,$FFFF,$4114,$A187,$5E78,$FFFF,$5E78
		dc.w	$5FFF,$A000,$FFFF,$A000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$FFBF,$7FD0,$8040,$7FFF
		dc.w	$0E00,$1000,$0000,$FFFF,$FFFC,$0003,$0003,$FFFF
		dc.w	$808B,$FFFF,$0670,$86FB,$A000,$4F7C,$1083,$B083
		dc.w	$0079,$6186,$9E00,$9E79,$8600,$79F7,$0008,$8608
		dc.w	$000F,$8910,$76E0,$76EF,$1B96,$FFFE,$0069,$1BFF
		dc.w	$007C,$007C,$FF83,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$15FF,$0400,$FBFF,$E000,$F79E,$0861,$FFFF,$0861
		dc.w	$79E6,$8619,$FFFF,$8619,$EEFE,$1101,$FFFF,$1101
		dc.w	$BEED,$4112,$FFFF,$4112,$6FAF,$9050,$FFFF,$9050
		dc.w	$BFFF,$4000,$FFFF,$4000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$FF7F,$7FA3,$8080,$7FFF
		dc.w	$0601,$0800,$0000,$FFFF,$FFFC,$0003,$0003,$FFFF
		dc.w	$839F,$9F7F,$7C60,$FFFF,$F080,$0000,$0F7F,$FFFF
		dc.w	$00FF,$0000,$FF00,$FFFF,$FFF0,$0000,$000F,$FFFF
		dc.w	$001E,$0001,$FFE1,$FFFF,$3E38,$FFF8,$C1C7,$FFFF
		dc.w	$0FF0,$0FF0,$F00F,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$15FF,$0400,$FBFF,$E000,$F79E,$0861,$FFFF,$0861
		dc.w	$79E6,$8619,$FFFF,$8619,$1C61,$E39E,$FFFF,$E39E
		dc.w	$C31E,$3CE1,$FFFF,$3CE1,$E0B3,$1F4C,$FFFF,$1F4C
		dc.w	$BFFF,$4000,$FFFF,$4000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$FEFF,$7F2D,$8100,$7FFF
		dc.w	$0601,$0800,$0000,$FFFF,$FFFC,$0003,$0003,$FFFF
		dc.w	$831E,$9FFE,$7CE1,$FFFF,$7FC0,$0000,$803F,$FFFF
		dc.w	$00FF,$0000,$FF00,$FFFF,$F800,$0000,$07FF,$FFFF
		dc.w	$003C,$0003,$FFC3,$FFFF,$7C78,$FFF8,$8387,$FFFF
		dc.w	$3FC0,$3FC0,$C03F,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$15FF,$0400,$FBFF,$E000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$FCFF,$7F76,$8300,$7FFF
		dc.w	$0601,$0800,$0000,$FFFF,$FFFC,$0003,$0003,$FFFF
		dc.w	$871E,$9EFE,$78E1,$FFFF,$7FF0,$0000,$800F,$FFFF
		dc.w	$00FF,$0000,$FF00,$FFFF,$F800,$0000,$07FF,$FFFF
		dc.w	$0078,$0007,$FF87,$FFFF,$F8F3,$FFF3,$070C,$FFFF
		dc.w	$FF00,$FF00,$00FF,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$15FF,$0400,$FBFF,$E000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$F9FF,$7E99,$8600,$7FFF
		dc.w	$0401,$0800,$0000,$FFFF,$FFF9,$0007,$0006,$FFFF
		dc.w	$C73E,$3EFE,$38C1,$FFFF,$3FF8,$0000,$C007,$FFFF
		dc.w	$00FF,$0000,$FF00,$FFFF,$F800,$0000,$07FF,$FFFF
		dc.w	$00F0,$000F,$FF0F,$FFFF,$F1FF,$FFFF,$0E00,$FFFF
		dc.w	$FE00,$FE00,$01FF,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$15FF,$0400,$FBFF,$E000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$F9FF,$7F66,$8600,$7FFF
		dc.w	$0403,$0800,$0000,$FFFF,$FFF9,$0007,$0006,$FFFF
		dc.w	$CE3C,$3DFC,$31C3,$FFFF,$3FFC,$0000,$C003,$FFFF
		dc.w	$007F,$0000,$FF80,$FFFF,$E000,$0000,$1FFF,$FFFF
		dc.w	$01E1,$001F,$FE1E,$FFFF,$E3FF,$FFFF,$1C00,$FFFF
		dc.w	$F800,$F800,$07FF,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$15FF,$0400,$FBFF,$E000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$F6FF,$7B9C,$8900,$7FFF
		dc.w	$0403,$0800,$0000,$FFFF,$FFF9,$0007,$0006,$FFFF
		dc.w	$9E7C,$6DFC,$6183,$FFFF,$3FFF,$0000,$C000,$FFFF
		dc.w	$007F,$0000,$FF80,$FFFF,$8000,$0000,$7FFF,$FFFF
		dc.w	$03C3,$003F,$FC3C,$FFFF,$C7FF,$FFFF,$3800,$FFFF
		dc.w	$E000,$E000,$1FFF,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$15FF,$0400,$FBFF,$E000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$F5FF,$0F28,$8A00,$7FFF
		dc.w	$0403,$0800,$0000,$FFFF,$F3F3,$000E,$0C0C,$FFFF
		dc.w	$9E7C,$6DFC,$6183,$FFFF,$07FF,$0000,$F800,$FFFF
		dc.w	$C03F,$0000,$3FC0,$FFFF,$C000,$0000,$3FFF,$FFFF
		dc.w	$0787,$007F,$F878,$FFFF,$9FFF,$FFFF,$6000,$FFFF
		dc.w	$8000,$8000,$7FFF,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$15FF,$0400,$FBFF,$E000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$A9FF,$1ED3,$D600,$7FFF
		dc.w	$0001,$0800,$0002,$FFFF,$07F3,$000E,$F80C,$FFFF
		dc.w	$BC78,$5BF8,$4387,$FFFF,$063F,$0000,$F9C0,$FFFF
		dc.w	$C00F,$0000,$3FF0,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$078F,$007F,$F870,$FFFF,$3FFF,$FFFF,$C000,$FFFF
		dc.w	$0000,$0000,$FFFF,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$15FF,$0400,$FBFF,$E000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$83FF,$1D3C,$FC00,$7FFF
		dc.w	$0000,$0800,$0003,$FFFF,$03F3,$000E,$FC0C,$FFFF
		dc.w	$BCF8,$5BF8,$4307,$FFFF,$001F,$0000,$FFE0,$FFFF
		dc.w	$C000,$0000,$3FFF,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$0F1E,$00FF,$F0E1,$FFFF,$FFFC,$FFFC,$0003,$FFFF
		dc.w	$0000,$0000,$FFFF,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$15FF,$0400,$FBFF,$E000,$87FF,$7800,$FFFF,$7800
		dc.w	$FFFF,$0000,$FFFF,$0000,$1BAE,$E451,$FFFF,$E451
		dc.w	$C6EC,$3913,$FFFF,$3913,$71BB,$8E44,$FFFF,$8E44
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$87FF,$3E32,$F800,$7FFF
		dc.w	$0000,$0800,$0007,$FFFF,$7FF3,$000E,$800C,$FFFF
		dc.w	$3CF8,$DBF8,$C307,$FFFF,$7807,$0000,$87F8,$FFFF
		dc.w	$8000,$0000,$7FFF,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$1E7D,$01BF,$E182,$FFFF,$FFFC,$FFFC,$0003,$FFFF
		dc.w	$0000,$0000,$FFFF,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$15FF,$0400,$FBFF,$E000,$FBFF,$0400,$FFFF,$0400
		dc.w	$FFFE,$0001,$FFFF,$0001,$ED75,$128A,$FFFF,$128A
		dc.w	$BA6E,$4591,$FFFF,$4591,$EE9B,$1164,$FFFF,$1164
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$BFFF,$39C1,$C000,$7FFF
		dc.w	$0007,$0800,$0000,$FFFF,$FFE7,$001C,$0018,$FFFF
		dc.w	$7CFB,$B3F0,$8304,$FFFF,$F803,$0000,$07FC,$FFFF
		dc.w	$F000,$0000,$0FFF,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$3CFB,$033F,$C304,$FFFF,$FFE0,$FFE0,$001F,$FFFF
		dc.w	$0000,$0000,$FFFF,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$15FF,$0400,$FBFF,$E000,$C7FF,$3800,$FFFF,$3800
		dc.w	$FFFE,$0001,$FFFF,$0001,$EEFB,$1104,$FFFF,$1104
		dc.w	$BAAE,$4551,$FFFF,$4551,$E0AB,$1F54,$FFFF,$1F54
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$87FF,$3E9F,$F800,$7FFF
		dc.w	$0007,$0800,$0000,$FFFF,$FFE7,$001C,$0018,$FFFF
		dc.w	$7CFF,$B3F0,$8300,$FFFF,$FF01,$0000,$00FE,$FFFF
		dc.w	$F800,$0000,$07FF,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$38F7,$077F,$C708,$FFFF,$FF80,$FF80,$007F,$FFFF
		dc.w	$0000,$0000,$FFFF,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$15FF,$0400,$FBFF,$E000,$BF9E,$4061,$FFFF,$4061
		dc.w	$79E6,$8619,$FFFF,$8619,$ED75,$128A,$FFFF,$128A
		dc.w	$BACE,$4531,$FFFF,$4531,$EEB3,$114C,$FFFF,$114C
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$9FE3,$78FC,$E01C,$7FFF
		dc.w	$0007,$0800,$0000,$FFFF,$BFE7,$001C,$4018,$FFFF
		dc.w	$7DFF,$B3F0,$8200,$FFFF,$FF83,$0000,$007C,$FFFF
		dc.w	$F800,$0000,$07FF,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$79EF,$06FF,$8610,$FFFF,$FF00,$FF00,$00FF,$FFFF
		dc.w	$0000,$0000,$FFFF,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$15FF,$0400,$FBFF,$E000,$839E,$7C61,$FFFF,$7C61
		dc.w	$79E7,$8618,$FFFF,$8618,$1BAE,$E451,$FFFF,$E451
		dc.w	$C6EC,$3913,$FFFF,$3913,$6EBB,$9144,$FFFF,$9144
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$EF1C,$7FE0,$90E3,$7FFF
		dc.w	$000E,$0800,$0001,$FFFF,$7FE6,$001D,$8019,$FFFF
		dc.w	$79FF,$B7F0,$8600,$FFFF,$FFC0,$0000,$003F,$FFFF
		dc.w	$F800,$0000,$07FF,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$73DF,$8DFF,$8C20,$FFFF,$FC00,$FC00,$03FF,$FFFF
		dc.w	$0000,$0000,$FFFF,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$15FF,$0400,$FBFF,$E000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$B0E3,$7F03,$CF1C,$7FFF
		dc.w	$0000,$0800,$000F,$FFFF,$FFE6,$001D,$0019,$FFFF
		dc.w	$F9FF,$77F0,$0600,$FFFF,$FFF8,$0000,$0007,$FFFF
		dc.w	$F000,$0000,$0FFF,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$73BF,$8DFF,$8C40,$FFFF,$F800,$F800,$07FF,$FFFF
		dc.w	$0000,$0000,$FFFF,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$15FF,$0400,$FBFF,$E000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$C31F,$7C1F,$BCE0,$7FFF
		dc.w	$0000,$0800,$000F,$FFFF,$FFCE,$0039,$0031,$FFFF
		dc.w	$F9FF,$67E0,$0600,$FFFF,$FFFC,$0000,$0003,$FFFF
		dc.w	$7000,$0000,$8FFF,$FFFF,$0000,$0001,$FFFF,$FFFF
		dc.w	$7FBF,$83FF,$8040,$FFFF,$F000,$F000,$0FFF,$FFFF
		dc.w	$0000,$0000,$FFFF,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$15FF,$0400,$FBFF,$E000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$9CFF,$60FF,$E300,$7FFF
		dc.w	$0000,$0400,$000F,$FFFF,$FFCE,$0039,$0031,$FFFF
		dc.w	$F9FF,$67E0,$0600,$FFFF,$FFFC,$0000,$0003,$FFFF
		dc.w	$0000,$0000,$FFFF,$FFFF,$0000,$0103,$FFFF,$FFFF
		dc.w	$7FFF,$837F,$8000,$FFFF,$E000,$E000,$1FFF,$FFFF
		dc.w	$0000,$0000,$FFFF,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$35FF,$0400,$DBFF,$E000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$E7FF,$07FF,$9800,$7FFF
		dc.w	$000D,$0400,$0012,$FFFF,$FCCE,$0039,$0331,$FFFF
		dc.w	$F9FF,$67E0,$0600,$FFFF,$FFFE,$0000,$0001,$FFFF
		dc.w	$0000,$0000,$FFFF,$FFFF,$0100,$0303,$FEFF,$FFFF
		dc.w	$7FFF,$86FF,$8000,$FFFF,$C000,$C000,$3FFF,$FFFF
		dc.w	$0000,$0000,$FFFF,$FFFF,$007F,$0000,$FF80,$FFFF
		dc.w	$F5FF,$0400,$1BFF,$E000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$9FFF,$1FFF,$E000,$7FFF
		dc.w	$001E,$0400,$0001,$FFFF,$FCCE,$003D,$0331,$FFFF
		dc.w	$F3FF,$6FE0,$0C00,$FFFF,$FFFF,$0000,$0000,$FFFF
		dc.w	$C000,$0000,$3FFF,$FFFF,$0100,$0707,$FEFF,$FFFF
		dc.w	$FFFF,$0EFF,$0000,$FFFF,$8000,$8000,$7FFF,$FFFF
		dc.w	$0000,$0000,$FFFF,$FFFF,$00FF,$0000,$FF00,$FFFF
		dc.w	$F5FF,$0400,$1BFF,$E000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$FFFF,$7FFE,$8000,$7FFF
		dc.w	$001F,$0400,$0000,$FFFF,$FE4E,$003F,$01B1,$FFFF
		dc.w	$F3FF,$6FE0,$0C00,$FFFF,$FFFF,$0000,$0000,$FFFF
		dc.w	$C000,$0000,$3FFF,$FFFF,$0300,$0F07,$FCFF,$FFFF
		dc.w	$FFFF,$0DFF,$0000,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$0000,$0000,$FFFF,$FFFF,$01FF,$0000,$FE00,$FFFF
		dc.w	$F5FF,$0400,$1BFF,$E000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$FFFF,$7FFC,$8000,$7FFF
		dc.w	$001F,$0400,$0000,$FFFF,$E84F,$003F,$17B0,$FFFF
		dc.w	$F3FF,$EFE0,$0C00,$FFFF,$FFFF,$0000,$0000,$FFFF
		dc.w	$8000,$0000,$7FFF,$FFFF,$0601,$1E06,$F9FE,$FFFF
		dc.w	$FFFE,$1BFE,$0001,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$0000,$0000,$FFFF,$FFFF,$03FF,$0000,$FC00,$FFFF
		dc.w	$F5FF,$0400,$1BFF,$E000,$87FF,$7800,$FFFF,$7800
		dc.w	$FF83,$007C,$FFFF,$007C,$787F,$8780,$FFFF,$8780
		dc.w	$860C,$79F3,$FFFF,$79F3,$2083,$DF7C,$FFFF,$DF7C
		dc.w	$FC30,$03CF,$FFFF,$03CF,$8608,$79F7,$FFFF,$79F7
		dc.w	$2EFA,$D102,$FFFD,$D100,$FFFD,$7FF0,$8002,$7FFF
		dc.w	$001F,$0400,$0000,$FFFF,$800F,$003F,$7FF0,$FFFF
		dc.w	$F3FF,$EFE0,$0C00,$FFFF,$FFFF,$0000,$0000,$FFFF
		dc.w	$8000,$0000,$7FFF,$FFFF,$0601,$1E0F,$F9FE,$FFFF
		dc.w	$FFFC,$9BFC,$0003,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$0000,$0000,$FFFF,$FFFF,$00FF,$0000,$FF00,$FFFF
		dc.w	$F5FF,$0400,$1BFF,$E000,$FBFF,$0400,$FFFF,$0400
		dc.w	$FFEF,$0010,$FFFF,$0010,$7BBF,$8440,$FFFF,$8440
		dc.w	$BAFB,$4504,$FFFF,$4504,$EFEF,$1010,$FFFF,$1010
		dc.w	$FBEF,$0410,$FFFF,$0410,$BAFB,$4504,$FFFF,$4504
		dc.w	$E6FA,$1902,$FFFD,$1900,$FFFD,$7FE0,$8002,$7FFF
		dc.w	$003F,$0400,$0000,$FFFF,$C00F,$003F,$3FF0,$FFFF
		dc.w	$F3FF,$EFE0,$0C00,$FFFF,$FFFF,$0000,$0000,$FFFF
		dc.w	$8000,$0000,$7FFF,$FFFF,$0C07,$3C1F,$F3F8,$FFFF
		dc.w	$DFFC,$17FC,$2003,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$0000,$0000,$FFFF,$FFFF,$007F,$0000,$FF80,$FFFF
		dc.w	$F5FF,$0400,$1BFF,$E000,$C7FF,$3800,$FFFF,$3800
		dc.w	$FFEF,$0010,$FFFF,$0010,$787F,$8780,$FFFF,$8780
		dc.w	$861C,$79E3,$FFFF,$79E3,$61EF,$9E10,$FFFF,$9E10
		dc.w	$FC6F,$0390,$FFFF,$0390,$8618,$79E7,$FFFF,$79E7
		dc.w	$6AFA,$9502,$FFFD,$9500,$FFFD,$7FC0,$8002,$7FFF
		dc.w	$003F,$0400,$0000,$FFFF,$C007,$000F,$3FF8,$FFFF
		dc.w	$F3FF,$EFE0,$0C00,$FFFF,$FFFF,$0000,$0000,$FFFF
		dc.w	$8000,$0000,$7FFF,$FFFF,$0C0E,$3C1F,$F3F1,$FFFF
		dc.w	$DFF8,$0FF8,$2007,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$0000,$0000,$FFFF,$FFFF,$007F,$0000,$FF80,$FFFF
		dc.w	$F5FF,$0400,$1BFF,$E000,$FB9E,$0461,$FFFF,$0461
		dc.w	$79EF,$8610,$FFFF,$8610,$7BBF,$8440,$FFFF,$8440
		dc.w	$AEFF,$5100,$FFFF,$5100,$AFEF,$5010,$FFFF,$5010
		dc.w	$FFAF,$0050,$FFFF,$0050,$AEFB,$5104,$FFFF,$5104
		dc.w	$ECFA,$1302,$FFFD,$1300,$FFFD,$7F80,$8002,$7FFF
		dc.w	$003F,$0400,$0000,$FFFF,$E003,$0007,$1FFC,$FFFF
		dc.w	$F3FF,$EFE0,$0C00,$FFFF,$FFFF,$0000,$0000,$FFFF
		dc.w	$C000,$0000,$3FFF,$FFFF,$181C,$783F,$E7E3,$FFFF
		dc.w	$BFF8,$1FF8,$4007,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$0000,$0000,$FFFF,$FFFF,$00FF,$0000,$FF00,$FFFF
		dc.w	$F5FF,$0400,$1BFF,$E000,$879E,$7861,$FFFF,$7861
		dc.w	$79EF,$8610,$FFFF,$8610,$087F,$F780,$FFFF,$F780
		dc.w	$B208,$4DF7,$FFFF,$4DF7,$60EF,$9F10,$FFFF,$9F10
		dc.w	$F870,$078F,$FFFF,$078F,$B208,$4DF7,$FFFF,$4DF7
		dc.w	$2EFA,$D102,$FFFD,$D100,$FFFD,$7E00,$8002,$7FFF
		dc.w	$003F,$0400,$0000,$FFFF,$F301,$0007,$0CFE,$FFFF
		dc.w	$F3FF,$EFE0,$0C00,$FFFF,$FFFF,$0000,$0000,$FFFF
		dc.w	$C000,$0000,$3FFF,$FFFF,$1838,$787F,$E7C7,$FFFF
		dc.w	$BFF0,$1FF0,$400F,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$0000,$0000,$FFFF,$FFFF,$01FF,$0000,$FE00,$FFFF
		dc.w	$F5FF,$0400,$1BFF,$E000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$FCFD,$7C00,$8302,$7FFF
		dc.w	$003F,$0400,$0000,$FFFF,$FF00,$0007,$00FF,$FFFF
		dc.w	$F3FC,$EFE0,$0C03,$FFFF,$FFFF,$0000,$0000,$FFFF
		dc.w	$C000,$0000,$3FFF,$FFFF,$3070,$F07F,$CF8F,$FFFF
		dc.w	$7FF0,$3FF0,$800F,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$0000,$0000,$FFFF,$FFFF,$03FF,$0000,$FC00,$FFFF
		dc.w	$F5FF,$0400,$1BFF,$E000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$F87B,$7800,$8784,$7FFF
		dc.w	$001F,$0400,$0000,$FFFF,$FFC0,$0007,$003F,$FFFF
		dc.w	$73FC,$EFE0,$8C03,$FFFF,$FFFF,$0000,$0000,$FFFF
		dc.w	$C000,$0000,$3FFF,$FFFF,$30E0,$F0FF,$CF1F,$FFFF
		dc.w	$7FE0,$3FE0,$801F,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$0000,$0000,$FFFF,$FFFF,$07FF,$0000,$F800,$FFFF
		dc.w	$F5FF,$0400,$1BFF,$E000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$F833,$7000,$87CC,$7FFF
		dc.w	$0007,$021C,$0018,$FFFF,$FFC3,$0007,$003C,$FFFF
		dc.w	$F3FC,$EFE0,$0C03,$FFFF,$FFFF,$0000,$0000,$FFFF
		dc.w	$8000,$0001,$7FFF,$FFFF,$70C0,$F0FE,$8F3F,$FFFF
		dc.w	$FF60,$7F60,$009F,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$0000,$0000,$FFFF,$FFFF,$07FF,$0000,$F800,$FFFF
		dc.w	$F5FF,$0400,$1BFF,$E000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$F803,$6000,$87FC,$7FFF
		dc.w	$0007,$021E,$0018,$FFFF,$EFC0,$0007,$103F,$FFFF
		dc.w	$F3E4,$EFE0,$0C1B,$FFFF,$FFFF,$0000,$0000,$FFFF
		dc.w	$8000,$0001,$7FFF,$FFFF,$6180,$E1FE,$9E7F,$FFFF
		dc.w	$FE40,$7E40,$01BF,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$0000,$0000,$FFFF,$FFFF,$07FF,$0000,$F800,$FFFF
		dc.w	$F5FF,$0400,$1BFF,$E000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$FC02,$4000,$83FD,$7FFF
		dc.w	$0003,$021E,$001C,$FFFF,$C7C0,$000F,$383F,$FFFF
		dc.w	$F3E0,$EFE0,$0C1F,$FFFF,$3FFF,$0000,$C000,$FFFF
		dc.w	$8000,$0003,$7FFF,$FFFF,$E103,$E1FE,$1EFC,$FFFF
		dc.w	$F840,$F840,$07BF,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$0007,$0000,$FFF8,$FFFF,$07FF,$0000,$F800,$FFFF
		dc.w	$F5FF,$0400,$1BFF,$E000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$FC02,$0000,$83FD,$7FFF
		dc.w	$0007,$021E,$0018,$FFFF,$C7C4,$000F,$383B,$FFFF
		dc.w	$73E0,$EFE0,$8C1F,$FFFF,$1FFF,$0000,$E000,$FFFF
		dc.w	$8000,$0003,$7FFF,$FFFF,$E203,$E3FE,$1DFC,$FFFF
		dc.w	$E840,$E840,$17BF,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$0007,$0000,$FFF8,$FFFF,$87FF,$0000,$7800,$FFFF
		dc.w	$F5FF,$0400,$1BFF,$E000,$E7FF,$1800,$FFFF,$1800
		dc.w	$FFC7,$0038,$FFFF,$0038,$1C71,$E38E,$FFFF,$E38E
		dc.w	$C7F8,$3807,$FFFF,$3807,$2E83,$D17C,$FFFF,$D17C
		dc.w	$1871,$E78E,$FFFF,$E78E,$C77F,$3880,$FFFF,$3880
		dc.w	$FDFA,$0202,$FFFD,$0200,$F804,$0000,$87FB,$7FFF
		dc.w	$0007,$021F,$0018,$FFFF,$83C3,$000F,$7C3C,$FFFF
		dc.w	$F3E0,$EFE0,$0C1F,$FFFF,$FFFF,$0000,$0000,$FFFF
		dc.w	$8000,$0003,$7FFF,$FFFF,$C407,$C7FD,$3BF8,$FFFF
		dc.w	$C080,$C080,$3F7F,$FFFF,$1800,$0000,$E7FF,$FFFF
		dc.w	$0003,$0000,$FFFC,$FFFF,$DFFF,$0000,$2000,$FFFF
		dc.w	$F5FF,$0400,$1BFF,$E000,$D7FF,$2800,$FFFF,$2800
		dc.w	$FFBE,$0041,$FFFF,$0041,$EB2C,$14D3,$FFFF,$14D3
		dc.w	$B3FE,$4C01,$FFFF,$4C01,$EEEE,$1111,$FFFF,$1111
		dc.w	$EBBB,$1444,$FFFF,$1444,$BB7F,$4480,$FFFF,$4480
		dc.w	$F9FA,$0602,$FFFD,$0600,$FC04,$0000,$83FB,$7FFF
		dc.w	$0007,$020F,$0008,$FFFF,$0303,$001F,$FCFC,$FFFF
		dc.w	$F3F1,$EFF0,$0C0E,$FFFF,$FFFF,$0000,$0000,$FFFF
		dc.w	$8001,$0007,$7FFE,$FFFF,$C407,$C7FD,$3BF8,$FFFF
		dc.w	$8080,$8080,$7F7F,$FFFF,$2000,$4000,$DFFF,$FFFF
		dc.w	$0001,$0000,$FFFE,$FFFF,$FFFF,$0000,$0000,$FFFF
		dc.w	$F5FF,$0400,$1BFF,$E000,$B7FF,$4800,$FFFF,$4800
		dc.w	$FF87,$0078,$FFFF,$0078,$1AAA,$E555,$FFFF,$E555
		dc.w	$ABFE,$5401,$FFFF,$5401,$EEEE,$1111,$FFFF,$1111
		dc.w	$E87B,$1784,$FFFF,$1784,$837F,$7C80,$FFFF,$7C80
		dc.w	$FDFA,$0202,$FFFD,$0200,$8F84,$0000,$F07B,$7FFF
		dc.w	$0003,$020F,$000C,$FFFF,$0003,$00FF,$FFFC,$FFFF
		dc.w	$F3F1,$EFF0,$0C0E,$FFFF,$FFFF,$0000,$0000,$FFFF
		dc.w	$8001,$0007,$7FFE,$FFFF,$F80F,$DFFB,$07F0,$FFFF
		dc.w	$0100,$0101,$FEFF,$FFFF,$5800,$9800,$A7FF,$FFFF
		dc.w	$0001,$0000,$FFFE,$FFFF,$FFFF,$0000,$0000,$FFFF
		dc.w	$15FF,$0400,$FBFF,$E000,$839E,$7C61,$FFFF,$7C61
		dc.w	$79BA,$8645,$FFFF,$8645,$E9A6,$1659,$FFFF,$1659
		dc.w	$9BFE,$6401,$FFFF,$6401,$EEEE,$1111,$FFFF,$1111
		dc.w	$EAFB,$1504,$FFFF,$1504,$BB7F,$4480,$FFFF,$4480
		dc.w	$FDFA,$0202,$FFFD,$0200,$C1E4,$0000,$FE1B,$7FFF
		dc.w	$0003,$020F,$000C,$FFFF,$8019,$81FF,$7FE6,$FFFF
		dc.w	$FBF1,$F7F0,$040E,$FFFF,$FFFE,$0000,$0001,$FFFF
		dc.w	$0001,$0007,$FFFE,$FFFF,$F00F,$DFFB,$0FF0,$FFFF
		dc.w	$0000,$03C7,$FFFF,$FFFF,$9800,$3800,$67FF,$FFFF
		dc.w	$003F,$0000,$FFC0,$FFFF,$FFFC,$0000,$0003,$FFFF
		dc.w	$15FF,$0400,$FBFF,$E000,$F79E,$0861,$FFFF,$0861
		dc.w	$79C7,$8638,$FFFF,$8638,$1C71,$E38E,$FFFF,$E38E
		dc.w	$C7FE,$3801,$FFFF,$3801,$F0EF,$0F10,$FFFF,$0F10
		dc.w	$1B31,$E4CE,$FFFF,$E4CE,$BB0F,$44F0,$FFFF,$44F0
		dc.w	$FDFA,$0202,$FFFD,$0200,$E004,$0000,$DFFB,$7FFF
		dc.w	$0003,$020F,$000C,$FFFF,$801D,$83FF,$7FE2,$FFFF
		dc.w	$F9F0,$F7F0,$060F,$FFFF,$7FFC,$0000,$8003,$FFFF
		dc.w	$0003,$000F,$FFFC,$FFFF,$F01F,$9FF7,$0FE0,$FFFF
		dc.w	$0019,$07FE,$FFE6,$FFFF,$3800,$7800,$C7FF,$FFFF
		dc.w	$03FF,$0000,$FC00,$FFFF,$FFFE,$0000,$0001,$FFFF
		dc.w	$15FF,$0400,$FBFF,$E000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$E0E4,$0000,$DF1B,$7FFF
		dc.w	$000B,$020F,$0004,$FFFF,$803F,$87FF,$7FC0,$FFFF
		dc.w	$F9F0,$F7F0,$060F,$FFFF,$7FF8,$0000,$8007,$FFFF
		dc.w	$0003,$000F,$FFFC,$FFFF,$E01E,$BFFE,$1FE1,$FFFF
		dc.w	$01E2,$1E3C,$FE1D,$FFFF,$7000,$B000,$8FFF,$FFFF
		dc.w	$03FF,$0000,$FC00,$FFFF,$FFFE,$0000,$0001,$FFFF
		dc.w	$15FF,$0400,$FBFF,$E000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$F0F6,$0000,$CF09,$7FFF
		dc.w	$0205,$0707,$0002,$FFFF,$803F,$8FFF,$7FC0,$FFFF
		dc.w	$F9F8,$F7F8,$0607,$FFFF,$7FF8,$0000,$8007,$FFFF
		dc.w	$0003,$000F,$FFFC,$FFFF,$E03F,$3FFF,$1FC0,$FFFF
		dc.w	$07C4,$38F9,$F83B,$FFFF,$B000,$3000,$4FFF,$FFFF
		dc.w	$07FF,$0000,$F800,$FFFF,$FFFF,$0000,$0003,$FFFF
		dc.w	$F5FF,$0400,$FBFF,$E000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$F07A,$0000,$CF85,$7FFF
		dc.w	$0205,$070F,$0002,$FFFF,$C03F,$DFFF,$3FC0,$FFFF
		dc.w	$FDF8,$FBF8,$0207,$FFFF,$3FF8,$0000,$C007,$FFFF
		dc.w	$0003,$000F,$FFFC,$FFFF,$C07E,$7FFE,$3F81,$FFFF
		dc.w	$07C9,$7FF2,$F836,$FFFF,$7000,$7000,$8FFF,$FFFF
		dc.w	$07FF,$0000,$F800,$FFFF,$FFF8,$0000,$003F,$FFFF
		dc.w	$15FF,$0400,$FBFF,$E000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$D072,$0000,$EF8D,$7FFF
		dc.w	$0205,$070F,$0002,$FFFF,$E07F,$FFFF,$1F80,$FFFF
		dc.w	$FDF8,$FBF8,$0207,$FFFF,$3FFC,$0000,$C003,$FFFF
		dc.w	$0007,$001E,$FFF8,$FFFF,$C07F,$7FFF,$3F80,$FFFF
		dc.w	$F912,$FFE4,$06ED,$FFFF,$F000,$F060,$0FFF,$FFFF
		dc.w	$07FF,$0000,$F800,$FFFF,$FFE7,$0007,$00F8,$FFFF
		dc.w	$D5FF,$C400,$3BFF,$E000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFA,$0002,$FFFD,$0000,$C067,$0003,$FF98,$7FFF
		dc.w	$0206,$070F,$0001,$FFFF,$E07F,$EFFF,$1F80,$FFFF
		dc.w	$FDF8,$FBF8,$0207,$FFFF,$1FF8,$0000,$E007,$FFFF
		dc.w	$0007,$001E,$FFF8,$FFFF,$80FE,$FFFF,$7F01,$FFFF
		dc.w	$7E31,$87C1,$81CE,$FFFF,$F030,$F0F0,$0FCF,$FFFF
		dc.w	$01FF,$0000,$FE00,$FFFF,$FF98,$0018,$07E0,$FFFF
		dc.w	$1400,$0400,$FBFF,$E000,$0000,$0000,$FFFF,$0000
		dc.w	$0000,$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000
		dc.w	$0000,$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000
		dc.w	$0000,$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000
		dc.w	$0002,$0002,$FFFD,$0000,$C06F,$0007,$FF90,$7FFF
		dc.w	$0206,$070F,$0001,$FFFF,$E07F,$E7FF,$1F80,$FFFF
		dc.w	$FDFC,$FBFC,$0203,$FFFF,$1FF8,$0000,$E007,$FFFF
		dc.w	$0006,$001D,$FFF9,$FFFF,$80FC,$FFFF,$7F03,$FFFF
		dc.w	$3E6F,$CB8F,$C190,$FFFF,$F038,$F8F8,$0FC7,$FFFF
		dc.w	$01FF,$0000,$FE00,$FFFF,$FF60,$0060,$1F81,$FFFF
		dc.w	$17FF,$07FF,$F800,$E000,$FFFF,$FFFF,$0000,$0000
		dc.w	$FFFF,$FFFF,$0000,$0000,$FFFF,$FFFF,$0000,$0000
		dc.w	$FFFF,$FFFF,$0000,$0000,$FFFF,$FFFF,$0000,$0000
		dc.w	$FFFF,$FFFF,$0000,$0000,$FFFF,$FFFF,$0000,$0000
		dc.w	$FFFE,$FFFE,$0001,$0000,$C04F,$000F,$FFB0,$7FFF
		dc.w	$0607,$0F0F,$0000,$FFFF,$EEFF,$ED7F,$1100,$FFFF
		dc.w	$FCFC,$FBFC,$0303,$FFFF,$1FFF,$007F,$E000,$FFFF
		dc.w	$FE06,$FE1D,$01F9,$FFFF,$81F8,$FFFF,$7E07,$FFFF
		dc.w	$7CEF,$970F,$8310,$FFFF,$C03A,$F3BA,$3FC5,$FFFF
		dc.w	$1FFF,$0000,$E000,$FFFF,$FC80,$0080,$7F07,$FFFF
		dc.w	$1000,$0000,$FFFF,$E000,$0000,$0000,$FFFF,$0000
		dc.w	$0000,$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000
		dc.w	$0000,$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000
		dc.w	$0000,$0000,$FFFF,$0000,$0000,$0000,$FFFF,$0000
		dc.w	$0000,$0000,$FFFF,$0000,$E08F,$000F,$DF70,$7FFF
		dc.w	$0603,$0F07,$0000,$FFFF,$EEFF,$EDFF,$1100,$FFFF
		dc.w	$FCFC,$FBFC,$0303,$FFFF,$1FFF,$0FFF,$E000,$FFFF
		dc.w	$FFE5,$FFFF,$001A,$FFFF,$01F0,$FFFF,$FE0F,$FFFF
		dc.w	$F9C7,$6E07,$0638,$FFFF,$A03F,$C3BF,$5FC0,$FFFF
		dc.w	$1FFF,$0000,$E001,$FFFF,$F300,$0300,$FC0F,$FFFF
		dc.w	$1FFF,$0000,$FFFF,$E000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$FFFF,$0000,$FFFF,$0000
		dc.w	$FFFF,$0000,$FFFF,$0000,$E089,$0009,$DF76,$7FFF
		dc.w	$0603,$0F07,$0000,$FFFF,$EEFF,$EDFF,$1100,$FFFF
		dc.w	$FEFE,$FDFE,$0101,$FFFF,$7FF8,$7F80,$8007,$FFFF
		dc.w	$1FE5,$1FFF,$E01A,$FFFF,$03E1,$FFFE,$FC1E,$FFFF
		dc.w	$F3C7,$9C07,$0C38,$FFFF,$5B3F,$9FBF,$A4C0,$FFFF
		dc.w	$9FFF,$8000,$6003,$FFFF,$CC00,$0C00,$F01F,$FFFF
		dc.w	$0A00,$3203,$FDFF,$FFFF,$002C,$004F,$FFD3,$FFFF
		dc.w	$0C33,$BFE3,$F3CC,$FFFF,$FFC6,$FC46,$0039,$FFFF
		dc.w	$FB20,$F8C0,$04DF,$FFFF,$FC00,$0005,$03FF,$FFFF
		dc.w	$401E,$8F01,$BFE1,$FFFF,$001F,$FF1F,$FFE0,$FFFF
		dc.w	$48FF,$48E0,$B703,$FFFF,$E088,$0008,$DF77,$FFFF
		dc.w	$0603,$0F07,$0000,$FFFF,$FEFF,$FDFF,$0100,$FFFF
		dc.w	$FEFF,$FDFF,$0100,$FFFF,$FFF8,$FC00,$0007,$FFFF
		dc.w	$03CD,$03FF,$FC32,$FFFF,$03C7,$FFF9,$FC38,$FFFF
		dc.w	$678C,$B80F,$9873,$FFFF,$DFBF,$1BBF,$2040,$FFFF
		dc.w	$BFFF,$8000,$400F,$FFFF,$3000,$3000,$C07F,$FFFF
		dc.w	$1600,$660F,$F9FF,$FFFF,$801C,$006F,$FFE3,$FFFF
		dc.w	$08CF,$3FCF,$F730,$FFFF,$FFE4,$FE24,$001B,$FFFF
		dc.w	$7DA0,$7C40,$825F,$FFFF,$0E00,$000B,$F1FF,$FFFF
		dc.w	$80E0,$3C1F,$7F1F,$FFFF,$001E,$F01E,$FFE1,$FFFF
		dc.w	$2C3F,$2C20,$D3C0,$FFFF,$C088,$0008,$3F77,$FFFF
		dc.w	$0603,$0F07,$0000,$FFFF,$FEFF,$FDFF,$0100,$FFFF
		dc.w	$FEFF,$FDFF,$0100,$FFFF,$FFF8,$F000,$0007,$FFFF
		dc.w	$00CE,$00FB,$FF31,$FFFF,$07CE,$FFF7,$F831,$FFFF
		dc.w	$4F19,$F01E,$B0E6,$FFFF,$BFBC,$3FBC,$4043,$FFFF
		dc.w	$1FFC,$0000,$E01F,$FFFF,$C000,$C000,$00FF,$FFFF
		dc.w	$2403,$C43C,$FBFF,$FFFF,$0016,$0026,$FFE9,$FFFF
		dc.w	$1340,$DFF8,$ECBF,$FFFF,$F832,$FFD2,$07CD,$FFFF
		dc.w	$3ED0,$3E20,$C12F,$FFFF,$0001,$0016,$FFFE,$FFFF
		dc.w	$0300,$70FF,$FCFF,$FFFF,$003E,$803E,$FFC1,$FFFF
		dc.w	$1C3F,$1C20,$E3C0,$FFFF,$C108,$0008,$3EF7,$FFFF
		dc.w	$0603,$0F07,$0000,$FFFF,$FEFF,$FDFF,$0100,$FFFF
		dc.w	$FE7F,$FDFF,$0180,$FFFF,$CFF8,$C000,$3007,$FFFF
		dc.w	$000A,$003F,$FFF5,$FFFF,$0798,$FFEF,$F867,$FFFF
		dc.w	$CE12,$F01C,$31ED,$FFFF,$7FF8,$7FE0,$801F,$FFFF
		dc.w	$1FFB,$0003,$E07C,$FFFF,$0000,$0001,$01FF,$FFFF
		dc.w	$5808,$98F0,$E7FF,$FFFF,$0016,$0027,$FFE9,$FFFF
		dc.w	$1C80,$DFF8,$E37F,$FFFF,$701B,$7FEB,$8FE4,$FFFF
		dc.w	$3F68,$3F10,$C097,$FFFF,$0004,$0028,$FFFB,$FFFF
		dc.w	$0C03,$C3FF,$F3FC,$FFFF,$F83E,$F83E,$07C1,$FFFF
		dc.w	$0FAF,$0FA0,$F050,$FFFF,$8610,$0610,$79EF,$FFFF
		dc.w	$0601,$0F03,$0000,$FFFF,$FEFF,$FDFF,$0100,$FFFF
		dc.w	$FF7F,$FEFF,$0080,$FFFF,$87FC,$8000,$7803,$FFFF
		dc.w	$001A,$002F,$FFE5,$FFFF,$0F31,$FFDF,$F0CE,$FFFF
		dc.w	$9C24,$E038,$63DB,$FFFF,$FF0C,$FF00,$00FF,$FFFF
		dc.w	$0FF6,$0006,$F0F8,$FFFF,$0200,$0003,$01FF,$FFFF
		dc.w	$BE33,$3FC3,$C1FC,$FFFF,$C004,$C037,$3FFB,$FFFF
		dc.w	$1103,$FFF3,$EEFC,$FFFF,$E03D,$FFE5,$1FC2,$FFFF
		dc.w	$2F88,$2F90,$D077,$FFFF,$0028,$0051,$FFD7,$FFFF
		dc.w	$100F,$0FFF,$EFF0,$FFFF,$F01F,$F01F,$0FE0,$FFFF
		dc.w	$07EF,$07E0,$F810,$FFFF,$0590,$0590,$FA6F,$FFFF
		dc.w	$0601,$0F03,$0000,$FFFF,$FEFF,$FFFF,$0100,$FFFF
		dc.w	$FF7F,$FEFF,$0080,$FFFF,$87FE,$8000,$7801,$FFFF
		dc.w	$001C,$002F,$FFE3,$FFFF,$0F63,$FFBF,$F09C,$FFFF
		dc.w	$3849,$C071,$C7B6,$FFFF,$FF0E,$FF00,$00FF,$FFFF
		dc.w	$1FEC,$000C,$E1F0,$FFFF,$0600,$0003,$01FF,$FFFF
		dc.w	$BC43,$3FA4,$C3FF,$FFFF,$C000,$C01B,$3FFF,$FFFF
		dc.w	$3207,$DFF7,$CDF8,$FFFF,$C07F,$3FB7,$3F80,$FFFF
		dc.w	$97E4,$97E8,$681B,$FFFF,$0050,$00A2,$FFAF,$FFFF
		dc.w	$601F,$1FE0,$9FE0,$FFFF,$F01F,$001F,$0FE0,$FFFF
		dc.w	$87E8,$87E0,$7817,$FFFF,$0FE0,$08E0,$F01F,$FFFF
		dc.w	$0E01,$1F03,$0000,$FFFF,$FEFF,$FFFF,$0100,$FFFF
		dc.w	$FF7F,$FEFF,$0080,$FFFF,$C7FC,$C000,$3803,$FFFF
		dc.w	$001C,$006F,$FFE3,$FFFF,$0ECE,$FF7F,$F131,$FFFF
		dc.w	$7093,$80E3,$8F6C,$FFFF,$FF06,$FF00,$00FF,$FFFF
		dc.w	$0F90,$0010,$F3E0,$FFFF,$0FC9,$0006,$0037,$FFFF
		dc.w	$1887,$3F18,$E7FF,$FFFF,$E000,$E01B,$1FFF,$FFFF
		dc.w	$741F,$9FFC,$8BE0,$FFFF,$81B2,$7E32,$7E4D,$FFFF
		dc.w	$79F2,$79F4,$860D,$FFFF,$00A2,$0144,$FF5D,$FFFF
		dc.w	$8000,$7FFF,$7FFF,$FFFF,$001B,$F01B,$FFE4,$FFFF
		dc.w	$87E0,$87E0,$781F,$FFFF,$1BC0,$1840,$E43F,$FFFF
		dc.w	$0E01,$1F03,$0000,$FFFF,$FEFF,$FFFF,$0100,$FFFF
		dc.w	$FFBF,$FF7F,$0040,$FFFF,$C3FC,$C000,$3C03,$FFFF
		dc.w	$001C,$006F,$FFE3,$FFFF,$0C9C,$FFFF,$F363,$FFFF
		dc.w	$F127,$01C7,$0ED8,$FFFF,$FE04,$FE00,$01FF,$FFFF
		dc.w	$0F60,$0060,$FF80,$FFFF,$3FD1,$000E,$002F,$FFFF
		dc.w	$3107,$7E39,$CFFE,$FFFF,$E000,$E01B,$1FFF,$FFFF
		dc.w	$7818,$9FF8,$87E7,$FFFF,$0271,$FC71,$FD8E,$FFFF
		dc.w	$48F9,$48FA,$B706,$FFFF,$0144,$028B,$FEBB,$FFFF
		dc.w	$0000,$FFFE,$FFFF,$FFFF,$0008,$0008,$FFF7,$FFFF
		dc.w	$03E0,$03E0,$FC1F,$FFFF,$1BA0,$3820,$E45F,$FFFF
		dc.w	$0E01,$1F03,$0000,$FFFF,$FEFF,$FFFF,$0100,$FFFF
		dc.w	$FFBF,$FF7F,$0040,$FFFF,$E3FC,$E000,$1C03,$FFFF
		dc.w	$003C,$004F,$FFC3,$FFFF,$1579,$FFFE,$EA86,$FFFF
		dc.w	$C24F,$338F,$3DB0,$FFFF,$EC04,$EC00,$13FF,$FFFF
		dc.w	$1E80,$0080,$FF00,$FFFF,$7FF2,$000C,$000F,$FFFF
		dc.w	$720B,$FC73,$8FFC,$FFFF,$E000,$E00B,$1FFF,$FFFF
		dc.w	$701E,$97F1,$8FE1,$FFFF,$05F1,$F9F1,$FA0E,$FFFF
		dc.w	$CFFC,$CFFD,$3003,$FFFF,$8280,$053F,$7D7F,$FFFF
		dc.w	$0002,$FFFA,$FFFD,$FFFF,$0008,$0008,$FFF7,$FFFF
		dc.w	$80E0,$80E0,$7F1F,$FFFF,$2BA1,$4821,$D45E,$FFFF
		dc.w	$0E01,$1F03,$0000,$FFFF,$FFFF,$FF7F,$0000,$FFFF
		dc.w	$FFBF,$FF7F,$0040,$FFFF,$E3FC,$E000,$1C03,$FFFF
		dc.w	$003C,$004F,$FFC3,$FFFF,$16F1,$FFFE,$E90E,$FFFF
		dc.w	$84DF,$771F,$7B20,$FFFF,$8404,$8400,$7BFF,$FFFF
		dc.w	$3908,$0108,$FE00,$FFFF,$FFE5,$0019,$001E,$FFFF
		dc.w	$6417,$F8E7,$9FF8,$FFFF,$E000,$E10B,$1FFF,$FFFF
		dc.w	$603C,$B7E3,$9FC3,$FFFF,$0B71,$F370,$F48E,$FFFF
		dc.w	$B84E,$B84E,$47B1,$FFFF,$6507,$EA78,$9AF8,$FFFF
		dc.w	$F7F9,$0801,$0806,$FFFF,$FE04,$FE04,$01FB,$FFFF
		dc.w	$C370,$C370,$3C8F,$FFFF,$24BB,$443B,$DB44,$FFFF
		dc.w	$0E00,$1F01,$0000,$FFFF,$FFFF,$FF7F,$0000,$FFFF
		dc.w	$FF9F,$FF7F,$0060,$FFFF,$F1FF,$F000,$0E00,$FFFF
		dc.w	$0038,$004F,$FFC7,$FFFF,$29E2,$FFFD,$D61D,$FFFF
		dc.w	$C99F,$6E1F,$1660,$FFFF,$80FC,$8000,$7FFF,$FFFF
		dc.w	$7611,$0610,$F800,$FFFF,$FFE4,$0019,$001F,$FFFF
		dc.w	$C42F,$F9CF,$3BF0,$FFFF,$E180,$6283,$1E7F,$FFFF
		dc.w	$E0F8,$3447,$1F07,$FFFF,$1731,$E730,$E8CE,$FFFF
		dc.w	$D046,$5046,$2FB9,$FFFF,$B20F,$B480,$4DF0,$FFFF
		dc.w	$FF03,$0003,$00FC,$FFFF,$FF86,$E006,$0079,$FFFF
		dc.w	$63F0,$63F0,$9C0F,$FFFF,$223F,$423F,$DDC0,$FFFF
		dc.w	$0600,$0F01,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
		dc.w	$FFDF,$FFBF,$0020,$FFFF,$F9FE,$F800,$0601,$FFFF
		dc.w	$0038,$004F,$FFC7,$FFFF,$2BE3,$FFFC,$D40C,$FFFF
		dc.w	$3333,$FC33,$04CC,$FFFF,$0DE0,$0000,$FFFF,$FFFF
		dc.w	$E863,$0860,$F000,$FFFF,$FFC4,$0039,$003F,$FFFF
		dc.w	$C85F,$F39C,$3FE0,$FFFF,$E380,$2D83,$1C7F,$FFFF
		dc.w	$E0B0,$038F,$1F4F,$FFFF,$2F23,$CF20,$D0DC,$FFFF
		dc.w	$D830,$5831,$27CF,$FFFF,$3C00,$B900,$C3FF,$FFFF
		dc.w	$D307,$0307,$2CF8,$FFFF,$FFC3,$8003,$003C,$FFFF
		dc.w	$03F0,$03F0,$FC0F,$FFFF,$36BF,$46BF,$C940,$FFFF
		dc.w	$0600,$0F01,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
		dc.w	$FFDF,$FFBF,$0020,$FFFF,$F8FE,$F800,$0701,$FFFF
		dc.w	$0038,$004F,$FFC7,$FFFF,$2B83,$FFEC,$D410,$FFFF
		dc.w	$1370,$EC70,$808F,$FFFF,$FBC1,$0400,$FFFF,$FFFF
		dc.w	$D0C3,$10C0,$E004,$FFFF,$FC49,$0033,$03BE,$FFFF
		dc.w	$88BF,$F330,$7FC0,$FFFF,$E781,$7B82,$187E,$FFFF
		dc.w	$C3E0,$57FF,$3C1F,$FFFF,$5F23,$9F20,$A0DC,$FFFF
		dc.w	$EE3D,$2E3E,$11C2,$FFFF,$DE07,$1E07,$21F8,$FFFF
		dc.w	$8387,$8387,$7C78,$FFFF,$E101,$1C01,$1EFE,$FFFF
		dc.w	$1CF0,$00F0,$E30F,$FFFF,$CFBF,$2FBF,$3040,$FFFF
		dc.w	$0700,$0F80,$0000,$FFFF,$7FFF,$FFFF,$0000,$FFFF
		dc.w	$FFEF,$FFDF,$0010,$FFFF,$FCFC,$FC00,$0303,$FFFF
		dc.w	$0038,$004F,$FFC7,$FFFF,$4B8F,$FF9F,$9460,$FFFF
		dc.w	$2070,$DC70,$838F,$FFFF,$99E3,$6600,$FFFF,$FFFF
		dc.w	$A181,$21C0,$C00E,$FFFF,$F809,$0033,$07FE,$FFFF
		dc.w	$9076,$E768,$7F89,$FFFF,$8FC1,$F7C2,$703E,$FFFF
		dc.w	$8F01,$FE3E,$70FE,$FFFF,$BF67,$3F60,$4098,$FFFF
		dc.w	$F37B,$137C,$0C84,$FFFF,$EF87,$0F87,$1078,$FFFF
		dc.w	$F3EF,$F3EF,$0C10,$FFFF,$8201,$FC01,$71FE,$FFFF
		dc.w	$13B8,$0C38,$EC47,$FFFF,$CE5B,$2E1B,$31A4,$FFFF
		dc.w	$0700,$0F80,$0000,$FFFF,$3FFF,$7FFF,$0000,$FFFF
		dc.w	$FFEF,$FFDF,$0010,$FFFF,$FEF8,$FE00,$0107,$FFFF
		dc.w	$0038,$004F,$FFC7,$FFFF,$48B0,$FEFF,$9101,$FFFF
		dc.w	$41FC,$FDFC,$0203,$FFFF,$90F7,$6F00,$FFFF,$FFFF
		dc.w	$4300,$4380,$801F,$FFFF,$7017,$0067,$8FF8,$FFFF
		dc.w	$11E7,$E7DF,$FE18,$FFFF,$3FC1,$CFC3,$C03E,$FFFF
		dc.w	$9703,$FE7D,$68FC,$FFFF,$F3E3,$F3E0,$0C1C,$FFFF
		dc.w	$F326,$1338,$0CD9,$FFFF,$6FC3,$0FC3,$903C,$FFFF
		dc.w	$F70E,$F70F,$08F1,$FFFF,$07C0,$F800,$C03F,$FFFF
		dc.w	$08B9,$0738,$F746,$FFFF,$AE63,$4E03,$519C,$FFFF
		dc.w	$0700,$0F80,$0000,$FFFF,$0FFF,$3FFF,$0000,$FFFF
		dc.w	$FFF7,$FFEF,$0008,$FFFF,$FFF8,$FF00,$0007,$FFFF
		dc.w	$0038,$004F,$FFC3,$FFFF,$4281,$EBDB,$1424,$FFFF
		dc.w	$12BE,$FDFE,$4001,$FFFF,$128E,$2D00,$FFFF,$FFFF
		dc.w	$8400,$8700,$003F,$FFFF,$7017,$0067,$8FF8,$FFFF
		dc.w	$21FA,$CFFB,$FE05,$FFFF,$7FE1,$BFE3,$801E,$FFFF
		dc.w	$2287,$FEFB,$DD78,$FFFF,$C263,$C260,$3D9C,$FFFF
		dc.w	$F80E,$6830,$07F1,$FFFF,$0FF1,$0FF1,$F00E,$FFFF
		dc.w	$4430,$443F,$BBCF,$FFFF,$2F0C,$F00C,$00F3,$FFFF
		dc.w	$C84D,$C78C,$37B2,$FFFF,$4FB1,$8F81,$B04E,$FFFF
		dc.w	$0300,$0780,$0000,$FFFF,$07FF,$0FFF,$0000,$FFFF
		dc.w	$FFF7,$FFEF,$0008,$FFFF,$FFF8,$FF80,$0007,$FFFF
		dc.w	$0030,$004D,$FFC3,$FFFF,$0155,$D7F5,$280A,$FFFF
		dc.w	$B4A7,$CBFD,$0000,$FFFF,$971D,$A801,$7FFE,$FFFF
		dc.w	$087C,$0C00,$007F,$FFFF,$6196,$0067,$9FF9,$FFFF
		dc.w	$6364,$8FC7,$FC9B,$FFFF,$DFE3,$7FE3,$201C,$FFFF
		dc.w	$4308,$FFF3,$BCF7,$FFFF,$8061,$0060,$7F9E,$FFFF
		dc.w	$FC0C,$E430,$03F3,$FFFF,$2CF8,$2CF8,$D307,$FFFF
		dc.w	$78C2,$78FF,$873C,$FFFF,$1E0E,$E00E,$01F1,$FFFF
		dc.w	$F02F,$CFCC,$0FD0,$FFFF,$5FB9,$9F81,$A046,$FFFF
		dc.w	$0300,$0780,$0000,$FFFF,$03FF,$07FF,$0000,$FFFF
		dc.w	$FFFF,$FFE7,$0000,$FFFF,$FFF8,$FFC0,$0007,$FFFF
		dc.w	$0028,$007E,$FF81,$FFFF,$48A0,$E9EF,$3610,$FFFF
		dc.w	$215B,$BEF7,$4000,$FFFF,$903D,$9001,$6FFE,$FFFF
		dc.w	$10F6,$1800,$00FF,$FFFF,$0716,$00E7,$FFE9,$FFFF
		dc.w	$42C9,$9F8E,$FD36,$FFFF,$BFF1,$DFF1,$400E,$FFFF
		dc.w	$E211,$9FE6,$1DEE,$FFFF,$0067,$00A0,$FF98,$FFFF
		dc.w	$FC18,$F460,$03E7,$FFFF,$7E3C,$783C,$81C3,$FFFF
		dc.w	$0F04,$0FFF,$F0F8,$FFFF,$1E1C,$C01C,$21E3,$FFFF
		dc.w	$302C,$2FC5,$CFD3,$FFFF,$3F73,$BF43,$C08C,$FFFF
		dc.w	$0300,$0780,$0000,$FFFF,$01FF,$03FF,$0000,$FFFF
		dc.w	$FFFB,$FFF7,$0004,$FFFF,$FFF0,$FFE0,$000F,$FFFF
		dc.w	$0058,$00FE,$FF03,$FFFF,$81D0,$ADFF,$5200,$FFFF
		dc.w	$2942,$BC9F,$4220,$FFFF,$B07A,$A802,$47FC,$FFFF
		dc.w	$03E8,$1008,$20F7,$FFFF,$1F14,$00E7,$FFEB,$FFFF
		dc.w	$C793,$1C9D,$FA6C,$FFFF,$7FF8,$BFF8,$8007,$FFFF
		dc.w	$FC22,$87CC,$03DD,$FFFF,$00BF,$0721,$FF40,$FFFF
		dc.w	$FE18,$F260,$01E7,$FFFF,$37DF,$381F,$C820,$FFFF
		dc.w	$0C00,$0FFF,$F3E0,$FFFF,$0020,$8020,$7FDF,$FFFF
		dc.w	$D85D,$079E,$27A2,$FFFF,$7F87,$7F87,$8078,$FFFF
		dc.w	$0380,$07C0,$0000,$FFFF,$01FF,$03FF,$0000,$FFFF
		dc.w	$FFFF,$FFFB,$0000,$FFFF,$FFF0,$FFF0,$000F,$FFFF
		dc.w	$0C24,$0FFD,$F002,$FFFF,$D140,$DBBF,$2680,$FFFF
		dc.w	$E2A1,$DF7B,$0004,$FFFF,$4A74,$DA04,$25F8,$FFFF
		dc.w	$27FF,$2000,$407F,$FFFF,$FF14,$00E7,$FFEB,$FFFF
		dc.w	$8686,$3C9B,$F979,$FFFF,$FFF8,$7F78,$0007,$FFFF
		dc.w	$9C44,$8798,$63BB,$FFFF,$017F,$3E63,$FE80,$FFFF
		dc.w	$FF18,$F960,$00E7,$FFFF,$EFDF,$F01F,$1020,$FFFF
		dc.w	$F800,$FFFF,$0790,$FFFF,$0002,$0001,$FFFD,$FFFF
		dc.w	$4E7A,$81FC,$B185,$FFFF,$743B,$7403,$8BC4,$FFFF
		dc.w	$0380,$07C0,$0000,$FFFF,$01FF,$03FF,$0000,$FFFF
		dc.w	$FFFD,$FFFB,$0002,$FFFF,$FFF8,$FFF8,$0007,$FFFF
		dc.w	$12BA,$32FA,$CD05,$FFFF,$02E4,$E7AF,$1912,$FFFF
		dc.w	$7310,$CE95,$006A,$FFFF,$15E8,$7F08,$80F0,$FFFF
		dc.w	$4A60,$4000,$859F,$FFFF,$7F29,$00CE,$FFD7,$FFFF
		dc.w	$892D,$3936,$F6D2,$FFFF,$BFFC,$F93C,$4003,$FFFF
		dc.w	$9884,$8F18,$677B,$FFFF,$02FF,$FCF3,$FD00,$FFFF
		dc.w	$FF78,$F980,$0087,$FFFF,$DFCE,$E00E,$2031,$FFFF
		dc.w	$F010,$FFFE,$0E61,$FFFF,$000C,$C003,$FFF3,$FFFF
		dc.w	$67D4,$81E8,$982B,$FFFF,$1B18,$7800,$E4E7,$FFFF
		dc.w	$0380,$07C0,$0000,$FFFF,$00FF,$01FF,$0000,$FFFF
		dc.w	$FFFE,$FFFD,$0001,$FFFF,$FFFC,$FFFC,$0003,$FFFF
		dc.w	$2411,$2F5D,$D0A2,$FFFF,$10BD,$9F2A,$6640,$FFFF
		dc.w	$AFC0,$56EA,$0015,$FFFF,$1FD0,$DE10,$21E1,$FFFF
		dc.w	$8190,$820F,$1EF0,$FFFF,$3F29,$00CE,$37D7,$FFFF
		dc.w	$89DB,$39ED,$F624,$FFFF,$73FE,$BD7E,$8C01,$FFFF
		dc.w	$8904,$8E59,$76FB,$FFFF,$05FF,$F9F7,$FA00,$FFFF
		dc.w	$FF70,$F800,$008F,$FFFF,$A4DE,$C01E,$5B21,$FFFF
		dc.w	$6060,$7FFF,$9D83,$FFFF,$1810,$C00F,$A7EF,$FFFF
		dc.w	$2F09,$C3F1,$D0F6,$FFFF,$7AD0,$98D0,$852F,$FFFF
		dc.w	$0780,$0FC0,$0000,$FFFF,$00FF,$01FF,$0000,$FFFF
		dc.w	$FFFF,$FFFF,$0000,$FFFF,$FFFE,$FFFE,$0001,$FFFF
		dc.w	$105A,$3FFF,$C000,$FFFF,$20BD,$6F3A,$9C40,$FFFF
		dc.w	$6FA9,$D379,$0006,$FFFF,$A7A1,$BC21,$43C2,$FFFF
		dc.w	$21B0,$0604,$1EF8,$FFFF,$3F29,$00CE,$3FD7,$FFFF
		dc.w	$0DF6,$7D9B,$F209,$FFFF,$E1FE,$3EFE,$1E01,$FFFF
		dc.w	$5708,$59D3,$A8F7,$FFFF,$0A7F,$F27F,$F580,$FFFF
		dc.w	$FF30,$FC00,$00CF,$FFFF,$4030,$8030,$BFCF,$FFFF
		dc.w	$81C1,$BFFF,$7A0E,$FFFF,$8788,$D807,$3877,$FFFF
		dc.w	$27E6,$C617,$D819,$FFFF,$F0F8,$40F8,$0F07,$FFFF
		dc.w	$0780,$0FC0,$0000,$FFFF,$00FF,$01FF,$0000,$FFFF
		dc.w	$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
		dc.w	$0981,$147F,$E244,$FFFF,$42BE,$DCFD,$2900,$FFFF
		dc.w	$71C9,$CBEF,$0410,$FFFF,$8742,$E842,$1784,$FFFF
		dc.w	$5178,$0602,$2EFC,$FFFF,$3F11,$94DE,$2BEF,$FFFF
		dc.w	$0EED,$7AB6,$F112,$FFFF,$E1F0,$FEFF,$1E0F,$FFFF
		dc.w	$5650,$5B87,$A9AF,$FFFF,$167F,$E67F,$E980,$FFFF
		dc.w	$FF30,$FE00,$00CF,$FFFF,$86C0,$06C6,$793D,$FFFF
		dc.w	$8183,$FFFB,$7A1C,$FFFF,$9024,$CFC3,$2FDB,$FFFF
		dc.w	$3FC5,$CE26,$C03A,$FFFF,$E35D,$835D,$1CA2,$FFFF
		dc.w	$0700,$0F40,$0080,$FFFF,$007F,$00FF,$0000,$FFFF
		dc.w	$FFFF,$FFFF,$0000,$FFFF,$FFFE,$FFFE,$0001,$FFFF
		dc.w	$1891,$1F7F,$E066,$FFFF,$0A59,$F5DE,$A020,$FFFF
		dc.w	$73EC,$CD92,$0801,$FFFF,$0E84,$9084,$6708,$FFFF
		dc.w	$A0F4,$7806,$5FF8,$FFFF,$0313,$C1DC,$3EEF,$FFFF
		dc.w	$0EDB,$7AED,$F124,$FFFF,$8141,$BE7F,$7EBE,$FFFF
		dc.w	$5460,$59AF,$AB9F,$FFFF,$2FFF,$CFFF,$D000,$FFFF
		dc.w	$FF30,$FF00,$00CF,$FFFF,$0FA0,$0E3C,$F05B,$FFFF
		dc.w	$0307,$FDF7,$F478,$FFFF,$1063,$CF83,$2F9C,$FFFF
		dc.w	$FF8D,$FE4E,$0072,$FFFF,$9FEF,$1FCF,$6010,$FFFF
		dc.w	$0700,$0F40,$0080,$FFFF,$007F,$00FF,$0000,$FFFF
		dc.w	$DFFF,$DFFF,$2000,$FFFF,$FFDC,$FFDC,$0023,$FFFF
		dc.w	$D084,$DF9F,$2060,$FFFF,$0581,$FF2A,$2054,$FFFF
		dc.w	$702E,$CFDD,$07C0,$FFFF,$DD09,$2108,$0E10,$FFFF
		dc.w	$CDE8,$F00C,$33F0,$FFFF,$0013,$C0DC,$3FED,$FFFF
		dc.w	$4F3E,$7BDF,$B0C1,$FFFF,$8103,$BE7F,$7EFC,$FFFF
		dc.w	$F460,$B9BF,$0B9F,$FFFF,$5F3F,$9F3F,$A0C0,$FFFF
		dc.w	$FF80,$FF80,$007F,$FFFF,$1FC0,$1E3D,$E033,$FFFF
		dc.w	$061D,$FBE1,$E8E2,$FFFF,$0C77,$E386,$1388,$FFFF
		dc.w	$F843,$088C,$07BC,$FFFF,$7F6D,$7F01,$8092,$FFFF
		dc.w	$0600,$0E40,$0180,$FFFF,$0047,$00C7,$0038,$FFFF
		dc.w	$81FF,$81FF,$7E00,$FFFF,$FF81,$FF81,$007E,$FFFF
		dc.w	$FFD2,$F477,$0008,$FFFF,$0E48,$F3DA,$A025,$FFFF
		dc.w	$48F6,$F7EF,$0700,$FFFF,$FA12,$8210,$1C21,$FFFF
		dc.w	$EBE8,$100C,$17F0,$FFFF,$002B,$C0C4,$3FD5,$FFFF
		dc.w	$4EFD,$7BBF,$B102,$FFFF,$02E3,$3CFF,$FD1C,$FFFF
		dc.w	$FC20,$D9BF,$03DF,$FFFF,$BE0F,$3E0F,$41F0,$FFFF
		dc.w	$E200,$E200,$1DFF,$FFFF,$7B86,$3879,$8461,$FFFF
		dc.w	$0C39,$F7C1,$D1C6,$FFFF,$87FF,$F03E,$7800,$FFFF
		dc.w	$8848,$0890,$77B7,$FFFF,$FF7B,$3F03,$0084,$FFFF
		dc.w	$0000,$0820,$07C0,$FFFF,$0003,$0043,$003C,$FFFF
		dc.w	$00FF,$00FF,$FF00,$FFFF,$FE10,$FE00,$01FF,$FFFF
		dc.w	$3BAA,$3C7F,$C001,$FFFF,$8820,$77FF,$2000,$FFFF
		dc.w	$0EF6,$F3E9,$0100,$FFFF,$F427,$6421,$1840,$FFFF
		dc.w	$D7E8,$200C,$2FF0,$FFFF,$182B,$C0C4,$3FD5,$FFFF
		dc.w	$7C79,$7FFF,$8386,$FFFF,$041F,$78FF,$FBE0,$FFFF
		dc.w	$E441,$E5BE,$1BBE,$FFFF,$3E07,$7E07,$C1F8,$FFFF
		dc.w	$0301,$0300,$FCFE,$FFFF,$E104,$00FB,$1EE3,$FFFF
		dc.w	$187C,$EF9F,$A383,$FFFF,$03FE,$FBC6,$FC01,$FFFF
		dc.w	$2883,$2870,$D77C,$FFFF,$7E33,$7E23,$81CC,$FFFF
		dc.w	$0000,$0420,$03C0,$FFFF,$003D,$0041,$003E,$FFFF
		dc.w	$B87E,$807E,$7F81,$FFFF,$081E,$0000,$FFFF,$FFFF
		dc.w	$5980,$1E7F,$A067,$FFFF,$C712,$AFFF,$1000,$FFFF
		dc.w	$5440,$F1FF,$0BB6,$FFFF,$E84F,$C840,$3080,$FFFF
		dc.w	$0F90,$6018,$FFE0,$FFFF,$3C2B,$C0C4,$3FD5,$FFFF
		dc.w	$587A,$7FF6,$A785,$FFFF,$081F,$71EF,$F7E0,$FFFF
		dc.w	$B242,$B3FC,$4DBD,$FFFF,$3E06,$FE06,$C1F9,$FFFF
		dc.w	$0C40,$0C00,$F3BF,$FFFF,$C604,$01FB,$39C3,$FFFF
		dc.w	$90E5,$7F79,$271A,$FFFF,$84C3,$F803,$47FC,$FFFF
		dc.w	$443C,$4440,$BBC3,$FFFF,$F839,$FFE1,$07C6,$FFFF
		dc.w	$0000,$0420,$03C0,$FFFF,$002F,$0050,$003F,$FFFF
		dc.w	$3D9F,$001F,$FFE0,$FFFF,$3F38,$0007,$FFFF,$FFFF
		dc.w	$3119,$DEFF,$E062,$FFFF,$C4B9,$AC3F,$13C0,$FFFF
		dc.w	$4140,$DABF,$24B6,$FFFF,$D04C,$1040,$6183,$FFFF
		dc.w	$2D10,$C018,$DFE0,$FFFF,$3C2B,$C0C4,$3FD5,$FFFF
		dc.w	$8824,$FFB8,$77DB,$FFFF,$1033,$67C3,$EFCC,$FFFF
		dc.w	$0244,$03F9,$FDBB,$FFFF,$3A02,$FA02,$C5FD,$FFFF
		dc.w	$11E0,$1000,$EE1F,$FFFF,$5C01,$01FE,$A3D6,$FFFF
		dc.w	$2138,$FE47,$4EC7,$FFFF,$C1C2,$F802,$07FD,$FFFF
		dc.w	$2431,$24C1,$DBCE,$FFFF,$C3D8,$FC10,$3C27,$FFFF
		dc.w	$0000,$0420,$03C0,$FFFF,$000F,$0030,$001F,$FFFF
		dc.w	$0F87,$0007,$FFF8,$FFFF,$7BFC,$0403,$FFFF,$FFFF
		dc.w	$7A67,$9FFF,$E000,$FFFF,$85EC,$EC0F,$13F0,$FFFF
		dc.w	$6AA0,$FF5F,$0015,$FFFF,$D093,$1090,$610C,$FFFF
		dc.w	$3B20,$C030,$DFC0,$FFFF,$022A,$40C4,$3DD5,$FFFF
		dc.w	$8802,$FF3A,$77FD,$FFFF,$0001,$7F81,$FFFE,$FFFF
		dc.w	$83C8,$82F3,$7C37,$FFFF,$3381,$F381,$CC7E,$FFFF
		dc.w	$0BF3,$0800,$F40C,$FFFF,$F001,$03FE,$0FA6,$FFFF
		dc.w	$0207,$FCF8,$5DF8,$FFFF,$C086,$F806,$07F9,$FFFF
		dc.w	$1461,$1481,$EB9E,$FFFF,$9F08,$E008,$60F7,$FFFF
		dc.w	$0000,$0420,$03C0,$FFFF,$0006,$0038,$001F,$FFFF
		dc.w	$0C7A,$0382,$FFFD,$FFFF,$F0F2,$0F01,$FFFF,$FFFF
		dc.w	$FB90,$3FFD,$8002,$FFFF,$19F7,$D807,$27F8,$FFFF
		dc.w	$7425,$D79A,$0850,$FFFF,$A131,$2130,$C20E,$FFFF
		dc.w	$FA20,$0030,$3FC0,$FFFF,$078E,$8070,$3871,$FFFF
		dc.w	$9002,$FE3A,$6FFD,$FFFF,$0080,$7F00,$FF7F,$FFFF
		dc.w	$C0D6,$C061,$3F29,$FFFF,$6189,$E189,$9E76,$FFFF
		dc.w	$490C,$06E0,$B6F3,$FFFF,$6002,$03FD,$9FAC,$FFFF
		dc.w	$0439,$FBC1,$BBC6,$FFFF,$0106,$F806,$07F9,$FFFF
		dc.w	$1460,$1481,$EB9F,$FFFF,$001F,$8018,$FFE0,$FFF8
		dc.w	$0000,$0410,$03E0,$FFFF,$0005,$003A,$001F,$FFFF
		dc.w	$3C1C,$03E0,$FFFB,$FFFF,$2000,$1FF8,$FFFF,$FFFF
		dc.w	$FA40,$3E5F,$01A0,$FFFF,$1FFF,$FF9F,$0060,$FFFF
		dc.w	$7EA1,$C35E,$0011,$FFFF,$4222,$4263,$841C,$FFFF
		dc.w	$7620,$0030,$FFC0,$FFFF,$3B86,$0078,$0479,$FFFF
		dc.w	$9002,$FE3A,$6FFD,$FFFF,$0140,$FE00,$FEBF,$FFFF
		dc.w	$0067,$0020,$FF98,$FFFF,$4016,$C016,$BFE9,$FFFF
		dc.w	$1108,$0600,$EEF7,$FFFF,$1002,$27FD,$EF4C,$FFFF
		dc.w	$08C7,$F707,$B738,$FFFF,$19CF,$F80F,$0770,$FFFF
		dc.w	$0A40,$0A8F,$F5BF,$FFFF,$023F,$FC38,$FDC0,$FFF8
		dc.w	$0000,$0410,$03E0,$FFFF,$0000,$001F,$000F,$FFFF
		dc.w	$F606,$11F8,$EFFD,$FFFF,$7FE0,$001E,$FFFF,$FFFF
		dc.w	$5E01,$1F7D,$E082,$FFFF,$9AE7,$DFE7,$2018,$FFFF
		dc.w	$7DF9,$C006,$0201,$FFFF,$4255,$427F,$8400,$FFFF
		dc.w	$6340,$0061,$FF80,$FFFF,$1388,$107B,$2C74,$FFFF
		dc.w	$1184,$EE34,$4E7B,$FFFF,$03C0,$FC00,$FC3F,$FFFF
		dc.w	$0077,$0010,$FF88,$FFFF,$05E3,$0000,$FA1C,$FFFF
		dc.w	$D034,$2108,$2FCB,$FFFF,$1004,$67FB,$EF59,$FFFF
		dc.w	$1F1F,$E01F,$60E0,$FFFF,$E1EF,$F80F,$0730,$FFFF
		dc.w	$8200,$829F,$7DFF,$FFFF,$FF3F,$003C,$00C0,$FFFC
		dc.w	$0008,$020C,$01F0,$FFFF,$0000,$001F,$000F,$FFFF
		dc.w	$DB87,$1878,$E7FE,$FFFF,$7FE0,$001F,$B0BF,$FFFF
		dc.w	$8F3B,$0FBF,$F040,$FFFF,$9C1B,$DFE3,$201C,$FFFF
		dc.w	$423A,$C004,$3DC3,$FFFF,$84CA,$84FE,$0801,$FFFF
		dc.w	$E340,$0061,$FF80,$FFFF,$0D40,$0155,$32AA,$FFFF
		dc.w	$17C4,$EA24,$403B,$FFFF,$06C0,$F800,$F93F,$FFFF
		dc.w	$01F0,$3800,$FE0F,$FFFF,$07C7,$0000,$F838,$FFFF
		dc.w	$8044,$6038,$7FBB,$FFFF,$210C,$4EF3,$DE91,$FFFF
		dc.w	$7060,$8FFF,$0F9F,$FFFF,$00EC,$FF0C,$FF93,$FFFF
		dc.w	$C017,$C028,$3FE8,$FFFF,$DC2F,$002C,$23D0,$FFFC
		dc.w	$0004,$0206,$01F8,$FFFF,$000D,$0012,$000F,$FFFF
		dc.w	$1CFE,$1C00,$E379,$FFFF,$30BC,$0003,$CF5F,$FFFF
		dc.w	$BFFF,$3FFF,$C000,$FFFF,$180D,$DFD1,$202E,$FFFF
		dc.w	$6406,$C404,$1BFB,$FFFF,$8410,$84FE,$0801,$FFFF
		dc.w	$C140,$0061,$FF80,$FFFF,$1CAA,$16EB,$2114,$FFFF
		dc.w	$D1CC,$F66D,$0833,$FFFF,$0E00,$F000,$F1FF,$FFFF
		dc.w	$00FE,$C000,$FF01,$FFFF,$39DE,$0021,$C621,$FFFF
		dc.w	$0042,$803C,$FFBD,$FFFF,$2209,$4DF7,$DD12,$FFFF
		dc.w	$C00F,$3FF0,$3FF0,$FFFF,$FFE8,$0108,$0097,$FFFF
		dc.w	$7000,$707F,$8FFF,$FFFF,$059F,$E118,$FAE0,$FFF8
		dc.w	$000A,$0203,$01FC,$FFFF,$0002,$000C,$0007,$FFFF
		dc.w	$EF78,$EF00,$10C7,$FFFF,$001F,$0000,$FFE3,$FFFF
		dc.w	$BFFF,$7FFF,$8000,$FFFF,$803D,$DF85,$207A,$FFFF
		dc.w	$633D,$C339,$1CC6,$FFFF,$0949,$09FC,$1003,$FFFF
		dc.w	$C080,$00C3,$FF00,$FFFF,$1A41,$137F,$2480,$FFFF
		dc.w	$2A44,$FBE4,$041B,$FFFF,$0C03,$F000,$F3FC,$FFFF
		dc.w	$C07D,$0000,$3F82,$FFFF,$F81E,$00C0,$07E1,$FFFF
		dc.w	$02B0,$0040,$FD4F,$FFFF,$3202,$DDFD,$CD08,$FFFF
		dc.w	$0070,$FF80,$7F8F,$FFFF,$01F8,$0118,$FE87,$FFFF
		dc.w	$2840,$283F,$D7BF,$FFFF,$06FF,$F898,$F960,$FFF8
		dc.w	$0029,$0221,$01DE,$FFFF,$0002,$C00C,$0007,$FFFF
		dc.w	$7F00,$7F00,$80FF,$FFFF,$0303,$0000,$FFFC,$FFFF
		dc.w	$FFFF,$3FFF,$0000,$FFFF,$9EBB,$9E88,$6177,$FFFF
		dc.w	$F6FD,$C0F1,$090E,$FFFF,$0991,$09FC,$1003,$FFFF
		dc.w	$8080,$00C3,$FF00,$FFFF,$2D32,$ADFA,$1205,$FFFF
		dc.w	$A418,$EEA0,$1147,$FFFF,$0440,$4001,$FBBF,$FFFF
		dc.w	$B782,$0000,$487D,$FFFF,$7604,$8100,$89FB,$FFFF
		dc.w	$2082,$007C,$DF7D,$FFFF,$3832,$FDCD,$C700,$FFFF
		dc.w	$A380,$C000,$1C7F,$FFFF,$7ACC,$7B0C,$84B3,$FFFF
		dc.w	$40DF,$4020,$BF20,$FFFF,$E3FF,$1FF0,$1C00,$FFF0
		dc.w	$007C,$0170,$008F,$FFFF,$0001,$600E,$8007,$FFFF
		dc.w	$3F00,$3F00,$C0FF,$FFFF,$0F80,$0000,$FFFF,$FFFF
		dc.w	$3FEC,$7FEC,$8013,$FFFF,$5CF7,$5CF0,$A30D,$FFFF
		dc.w	$31FA,$C0F2,$0E0C,$FFFF,$126B,$13FC,$2003,$FFFF
		dc.w	$8080,$00C3,$FF00,$FFFF,$3B08,$8FBD,$0042,$FFFF
		dc.w	$D4EE,$DFF0,$2001,$FFFF,$01E1,$001A,$FE1E,$FFFF
		dc.w	$E000,$01E0,$1FFF,$FFFF,$7C06,$8200,$83F9,$FFFF
		dc.w	$0003,$00FC,$FFFC,$FFFF,$FE31,$3FCF,$00CC,$FFFF
		dc.w	$4003,$C003,$3FFC,$FFFF,$F9C2,$FE02,$01BD,$FFFF
		dc.w	$81FF,$8000,$7E00,$FFFF,$0FDC,$F1C3,$F023,$FFE3
		dc.w	$00FE,$01F8,$0007,$FFFF,$4000,$6007,$8003,$FFFF
		dc.w	$9E5E,$1E00,$E1A1,$FFFF,$FE02,$0002,$FF9D,$FFFF
		dc.w	$3DCC,$7DC0,$823F,$FFFF,$5E68,$5867,$A197,$FFFF
		dc.w	$9BFA,$13E2,$E41C,$FFFF,$11A7,$13FC,$2003,$FFFF
		dc.w	$0100,$0183,$FE00,$FFFF,$2CC2,$87D7,$1028,$FFFF
		dc.w	$8913,$FBDC,$0424,$FFFF,$C19E,$0060,$3E61,$FFFF
		dc.w	$81E0,$0011,$7E1F,$FFFF,$FFB4,$0008,$004B,$FFFF
		dc.w	$923F,$001C,$6DC0,$FFFF,$F88A,$7F8F,$0070,$FFFF
		dc.w	$801F,$881C,$7FE3,$FFFF,$F1EC,$7E0C,$8113,$FFFF
		dc.w	$03E6,$0000,$FC19,$FFFF,$0FE8,$10E7,$F017,$FFF7
		dc.w	$00FE,$01F8,$0007,$FFFF,$4002,$6005,$8003,$FFFF
		dc.w	$71E0,$801E,$FE7F,$FFFF,$BE43,$40A3,$FFCC,$FFFF
		dc.w	$9C1C,$BC10,$43EF,$FFFF,$5F50,$584F,$A0AF,$FFFF
		dc.w	$FFFA,$7FE2,$801C,$FFFF,$208F,$21FC,$4603,$FFFF
		dc.w	$0100,$0183,$FE00,$FFFF,$0920,$8FFA,$3005,$FFFF
		dc.w	$5128,$F537,$0AC7,$FFFF,$40E7,$8000,$BF18,$FFFF
		dc.w	$0E11,$000E,$F1EE,$FFFF,$E03B,$07C4,$1FC4,$FFFF
		dc.w	$53C3,$201E,$AC20,$FFFF,$6004,$7FC7,$8038,$FFFF
		dc.w	$427C,$CC78,$3D87,$FFFF,$7960,$0E80,$F19F,$FFFF
		dc.w	$07F8,$01F8,$F807,$FFFF,$3678,$0067,$C987,$FFE7
		dc.w	$00FE,$01F8,$0007,$FFFF,$4002,$6005,$8003,$FFFF
		dc.w	$8901,$70FE,$FFFF,$FFFF,$0C47,$F0B7,$FFC0,$FFFF
		dc.w	$CE10,$CE10,$31EF,$FFFF,$19A1,$189E,$E65F,$FFFF
		dc.w	$FFF4,$FFC4,$0038,$FFFF,$2117,$21FC,$4603,$FFFF
		dc.w	$1500,$0187,$FE00,$FFFF,$0DA1,$81DD,$3212,$FFFF
		dc.w	$8104,$7B6B,$0493,$FFFF,$6001,$8000,$9FFE,$FFFF
		dc.w	$9C7F,$0000,$6380,$FFFF,$C007,$0038,$3FF8,$FFFF
		dc.w	$E3A0,$1CFE,$1C01,$FFFF,$6008,$7FBF,$8070,$FFFF
		dc.w	$0F3E,$D038,$30C7,$FFFF,$2F10,$20E0,$DFFF,$FFFF
		dc.w	$3E01,$03FE,$C1FE,$CFFF,$F038,$0027,$0FC7,$FFE7
		dc.w	$00FE,$01F8,$0007,$FFFF,$4001,$6003,$8000,$FFFF
		dc.w	$FE83,$004C,$F1FF,$FFFF,$90C7,$0136,$FF40,$FFFF
		dc.w	$EE75,$4E77,$1188,$FFFF,$00DB,$0025,$FFA6,$FFFF
		dc.w	$FF74,$FF44,$00B8,$FFFF,$20B3,$20BC,$4743,$FFFF
		dc.w	$3A00,$0306,$FC00,$FFFF,$09C3,$023E,$3438,$FFFF
		dc.w	$ADBC,$6C03,$1243,$FFFF,$6000,$8000,$9FFF,$FFFF
		dc.w	$46EE,$0000,$B911,$FFFF,$000F,$0010,$FFF0,$FFFF
		dc.w	$FD00,$03FE,$0201,$FFFF,$1819,$2F1F,$C0E0,$FFFF
		dc.w	$5C3F,$F33E,$03C1,$FFFF,$333F,$30C0,$CCC0,$FFC0
		dc.w	$E1F8,$0607,$1E07,$1FFF,$3E7D,$C673,$C182,$FFF3
		dc.w	$00FE,$01F8,$0007,$FFFF,$4000,$6002,$8001,$FFFF
		dc.w	$2060,$1E03,$DFFF,$FFFF,$31C4,$C237,$FEC3,$FFFF
		dc.w	$5D92,$9C1B,$A3E4,$FFFF,$8099,$C069,$3F66,$FFFF
		dc.w	$1828,$1808,$E7F0,$FFFF,$463B,$4038,$81C7,$FFFF
		dc.w	$6400,$0706,$F800,$FFFF,$33FB,$0026,$0C00,$FFFF
		dc.w	$92E3,$7E00,$011C,$FFFF,$C000,$0000,$3FFF,$FFFF
		dc.w	$1B80,$0000,$E47F,$FFFF,$1200,$0001,$EDFF,$FFFF
		dc.w	$7F10,$81FF,$8000,$FFFF,$2182,$D587,$DA7C,$FFFF
		dc.w	$00DE,$3F58,$FF27,$FFFF,$32FF,$3100,$CF00,$FF00
		dc.w	$C63C,$1803,$3FFF,$3FFF,$0BFC,$F3F3,$F403,$FFF3
		dc.w	$00FF,$01F8,$0007,$FFFF,$0000,$2002,$C001,$FFFF
		dc.w	$0780,$FFBF,$F87F,$FFFF,$51C6,$A237,$FEC1,$FFFF
		dc.w	$71EB,$B03F,$8FC0,$FFFF,$28B0,$3C50,$C34F,$FFFF
		dc.w	$0428,$0108,$FFF0,$FFFF,$4927,$4600,$86DF,$FFFF
		dc.w	$D800,$1C06,$E000,$FFFF,$01D1,$017E,$1E00,$FFFF
		dc.w	$A0F0,$7380,$0C0F,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$040E,$0000,$FBF1,$FFFF,$0F00,$0000,$F0FF,$FFFF
		dc.w	$0636,$7FF9,$F801,$FFFF,$2068,$DF83,$DA16,$FFFF
		dc.w	$03F8,$1CE0,$FC1F,$FFFF,$43FF,$4000,$BE00,$FE00
		dc.w	$F683,$0080,$0F7C,$FFFF,$05FC,$F9F3,$FA03,$FFF3
		dc.w	$00FF,$01FC,$0003,$FFFF,$0001,$2003,$C000,$FFFF
		dc.w	$FFFF,$07C0,$F83F,$FFFF,$F3C2,$043B,$BDC1,$FFFF
		dc.w	$EC55,$60FF,$9F00,$FFFF,$2372,$7EB0,$808F,$FFFF
		dc.w	$6E68,$1188,$F7F1,$FFFF,$91F7,$8E00,$1FEF,$FFFF
		dc.w	$2000,$3806,$C000,$FFFF,$0181,$01F6,$1E08,$FFFF
		dc.w	$2A7E,$AF00,$5081,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$0000,$001C,$FFFF,$FFFF,$0E01,$0000,$F1FE,$FFFF
		dc.w	$080A,$0FF5,$F0C1,$FFFF,$C278,$3D87,$3980,$FFFF
		dc.w	$1FE7,$83C7,$6018,$FFFF,$87EF,$8010,$7870,$F871
		dc.w	$E0C0,$00C0,$1F3F,$FFFF,$90FC,$68E3,$6F03,$FFE3
		dc.w	$007F,$00FC,$0003,$FFFF,$2000,$3001,$C000,$FFFF
		dc.w	$FBFF,$03F8,$0400,$FFFF,$9BC3,$043B,$6DC0,$FFFF
		dc.w	$ECE8,$E07B,$1F84,$FFFF,$DDCF,$FF40,$00BE,$FFFF
		dc.w	$F2D0,$0C10,$0FE1,$FFFF,$9B2E,$84D0,$0FF7,$FFFF
		dc.w	$C000,$E006,$0000,$FFFF,$1F04,$1EBF,$0040,$FFFF
		dc.w	$82E7,$EE18,$1118,$FFFF,$8480,$0000,$7B7F,$FFFF
		dc.w	$031E,$0001,$FCE1,$FFFF,$1C01,$0000,$E3FE,$FFFF
		dc.w	$9500,$1FFF,$624E,$FFFF,$7FC0,$FFB8,$0007,$FFFF
		dc.w	$1FE7,$CC07,$2018,$FFFF,$CFDF,$4020,$B060,$F063
		dc.w	$07DC,$07C0,$F823,$FFFF,$79FC,$0583,$9603,$FF83
		dc.w	$007F,$00FC,$0003,$FFFF,$2000,$3001,$C000,$FFFF
		dc.w	$1BF8,$13F8,$E407,$FFFF,$03C1,$043D,$FDC0,$FFFF
		dc.w	$F1A1,$F1EB,$0E14,$FFFF,$1527,$FF00,$003C,$FFFF
		dc.w	$06A1,$F821,$F9C2,$FFFF,$9F75,$8089,$0FEE,$FFFF
		dc.w	$0000,$C002,$0000,$FFFF,$1848,$19DB,$0624,$FFFF
		dc.w	$D1E1,$FE1E,$001E,$FFFF,$C743,$0080,$383C,$FFFF
		dc.w	$C0F1,$000E,$3F0E,$FFFF,$C1B1,$0000,$3E4E,$FFFF
		dc.w	$4681,$3FFF,$B834,$FFFF,$F802,$FFC3,$003C,$FFFF
		dc.w	$00E3,$E002,$1F1D,$FFFF,$FF7C,$0000,$C0C3,$C0C7
		dc.w	$17E8,$07E0,$F817,$FFFF,$0EFF,$00C0,$F900,$FFC0
		dc.w	$00BF,$01BC,$0043,$FFFF,$2000,$3001,$C000,$FFFF
		dc.w	$3FFC,$3FFC,$C003,$FFFF,$03C1,$043D,$FDC0,$FFFF
		dc.w	$F6C0,$F0CD,$0F32,$FFFF,$0A9E,$BF01,$40D9,$FFFF
		dc.w	$03A1,$FC21,$FDC2,$FFFF,$BD42,$82BB,$0FFC,$FFFF
		dc.w	$0000,$0000,$0000,$FFFF,$1F20,$1D77,$008E,$FFFF
		dc.w	$AB40,$BFBF,$40BF,$FFFF,$C2C0,$0181,$3C3F,$FFFF
		dc.w	$1D31,$C0C0,$E2CE,$FFFF,$07F8,$0000,$F807,$FFFF
		dc.w	$0860,$5EFF,$F190,$FFFF,$E03C,$FC3F,$03C0,$FFFF
		dc.w	$0F5F,$E010,$10A0,$FFF0,$FF19,$0020,$00E7,$00E7
		dc.w	$F3E8,$03E7,$FC17,$FFFF,$C77B,$0044,$3C84,$FFC4
		dc.w	$009F,$019C,$0063,$FFFF,$2000,$3001,$C000,$FFFF
		dc.w	$FFFC,$FFFC,$0003,$FFFF,$03C0,$0422,$FDC8,$FFF7
		dc.w	$16E0,$10FE,$4F01,$BFFF,$DD58,$E247,$0197,$FFFF
		dc.w	$01A1,$FE21,$FFC2,$FFFF,$3384,$0C7E,$2DF8,$FFFF
		dc.w	$0000,$0000,$0000,$FFFF,$1F02,$1CAB,$005C,$FFFF
		dc.w	$8061,$FB9E,$379E,$FFFF,$88BD,$01C0,$7602,$FFFF
		dc.w	$C758,$38A0,$38A7,$FFFF,$0754,$03F0,$F80B,$FFFF
		dc.w	$08FF,$1DFF,$F300,$FFFF,$0FF8,$0FFF,$F000,$FFFF
		dc.w	$F76F,$C07C,$0880,$FFFC,$C3FF,$3C00,$3C07,$3C07
		dc.w	$3C08,$2007,$DFF7,$FFFF,$C3B3,$03AC,$3C4C,$FFEC
		dc.w	$004F,$00CC,$0033,$FFFF,$2000,$3000,$C000,$FFFF
		dc.w	$7FFE,$FFFE,$0001,$FFFF,$0100,$0011,$5544,$BBBB
		dc.w	$0010,$003F,$2480,$DB7F,$5A9A,$6485,$8315,$FFFF
		dc.w	$0743,$F843,$F984,$FFFF,$13D8,$0C24,$3D30,$FFFF
		dc.w	$0000,$0001,$0000,$FFFF,$1990,$1827,$0648,$FFFF
		dc.w	$C3FF,$BC00,$3C00,$FFFF,$BEB8,$01C0,$4007,$FFFF
		dc.w	$70EC,$0F10,$8F13,$FFFF,$0414,$07F0,$F80B,$FFFF
		dc.w	$60FC,$93FC,$9F03,$FFFF,$FFE1,$FFFF,$0000,$FFFF
		dc.w	$F902,$F1FE,$0601,$FFFF,$C1FE,$3E00,$3E33,$3E33
		dc.w	$CE05,$C002,$3FFA,$FFFF,$E1F1,$21EE,$1E0E,$FFEE
		dc.w	$0027,$0064,$001B,$FFFF,$2000,$3000,$C000,$FFFF
		dc.w	$7FFF,$FFFF,$0000,$FFFF,$0880,$0808,$A2A2,$DDDD
		dc.w	$0002,$0006,$2490,$DB6F,$468F,$F880,$070C,$FFFF
		dc.w	$FF42,$4042,$0384,$FFFF,$03F8,$0800,$3FF8,$FFFF
		dc.w	$0006,$0000,$0007,$FFFF,$1CC0,$9C3F,$033E,$FFFF
		dc.w	$0C7F,$8380,$7380,$FFFF,$FD7B,$03E0,$0004,$FFFF
		dc.w	$8F89,$0000,$7076,$FFFF,$7831,$1FF0,$800E,$FFFF
		dc.w	$9182,$6F82,$6E7D,$FFFF,$3BC1,$3BFF,$C400,$FFFF
		dc.w	$FE0D,$FDFD,$0002,$FDFF,$B3B6,$8C48,$4C7B,$CC7B
		dc.w	$9406,$8001,$7FF9,$FFFF,$8CE1,$709E,$771E,$FF9E
		dc.w	$0013,$0030,$000F,$FFFF,$2000,$3000,$C000,$FFFF
		dc.w	$2FE1,$6FE1,$1014,$FFFB,$0840,$0804,$A351,$DCEE
		dc.w	$0000,$0004,$1251,$EDAE,$2D27,$7130,$0E07,$FFFF
		dc.w	$AE82,$F082,$030C,$FFFF,$1338,$1700,$68F8,$FFFF
		dc.w	$000D,$0001,$000E,$FFFF,$0668,$8607,$0196,$FFFF
		dc.w	$FE27,$81D0,$7DC8,$FFFF,$FA9F,$02B0,$0540,$FFFF
		dc.w	$C30F,$0000,$3CF0,$FFFF,$E038,$3FF8,$0007,$FFFF
		dc.w	$C100,$1F00,$3EFF,$FFFF,$0003,$01F8,$FE04,$FFFF
		dc.w	$CEE5,$03FD,$3002,$F3FF,$CF67,$C098,$30FB,$F0FB
		dc.w	$3046,$0001,$FFB9,$FFFF,$18E3,$E09C,$EF1C,$FF9C
		dc.w	$0009,$0018,$0007,$FFFF,$9000,$1800,$E000,$FFFF
		dc.w	$0000,$4000,$3F55,$FFBB,$0000,$0004,$B391,$CC6E
		dc.w	$0000,$4000,$1249,$EDB6,$6A25,$7237,$0C40,$FFFF
		dc.w	$4E82,$F082,$030C,$FFFF,$1238,$37A0,$0848,$FFFF
		dc.w	$008D,$00C1,$000E,$FFFF,$0210,$8707,$00EE,$FFFF
		dc.w	$F791,$9D74,$000A,$FFFF,$FC0D,$0682,$0172,$FFFF
		dc.w	$438D,$8002,$BC72,$FFFF,$FF78,$FF80,$0007,$FFFF
		dc.w	$C238,$0438,$3DC7,$FFFF,$010A,$3BFA,$C405,$FFFF
		dc.w	$7F9E,$639E,$8061,$E3FF,$27EF,$2010,$D93D,$F9FD
		dc.w	$C07C,$0003,$FF83,$FFFF,$3BFF,$C300,$DC00,$FF00
		dc.w	$0006,$000E,$0001,$FFFF,$9000,$1800,$E000,$FFFF
		dc.w	$0000,$0000,$3AAA,$FDDD,$3380,$0000,$B399,$CC66
		dc.w	$0000,$0002,$3248,$CDB7,$04A2,$0437,$A8C0,$5FFF
		dc.w	$B682,$F882,$070C,$FFFF,$3180,$3FE0,$0010,$FFFF
		dc.w	$028D,$00C1,$030E,$FFFF,$020A,$83C5,$0034,$FFFF
		dc.w	$AAAE,$DBFF,$0400,$FFFF,$788E,$05F1,$8201,$FFFF
		dc.w	$6060,$800F,$9F9E,$FFFF,$1878,$F880,$0707,$FFFF
		dc.w	$02FF,$E5FF,$FC00,$FFFF,$853E,$FDFE,$0201,$FFFF
		dc.w	$EE46,$3206,$11F9,$33FF,$270F,$2000,$D8FC,$F8FC
		dc.w	$F67C,$3003,$C983,$FFFF,$73F7,$8008,$BC08,$FC08
		dc.w	$0002,$2006,$2001,$DFFF,$2000,$3000,$C000,$FFFF
		dc.w	$0000,$0000,$12AA,$EDDD,$73C8,$0048,$73B3,$8C04
		dc.w	$0000,$0002,$7648,$89B7,$0445,$0467,$A880,$5FFF
		dc.w	$0E94,$F886,$0718,$FFFF,$1A40,$3FC0,$0030,$FFFF
		dc.w	$068D,$00C1,$070E,$FFFF,$0254,$83F3,$0008,$FFFF
		dc.w	$D421,$B77B,$0884,$FFFF,$BAA7,$CFE8,$0010,$FFFF
		dc.w	$30D8,$C007,$CF26,$FFFF,$1D71,$FF80,$000E,$FFFF
		dc.w	$ADBF,$43BF,$5040,$FFFF,$973F,$FDFE,$0000,$FFFE
		dc.w	$6DF1,$9431,$93CE,$B7FF,$3781,$3002,$C87E,$F87E
		dc.w	$E7F0,$200F,$180F,$3FFF,$6325,$80DA,$FCDA,$FCDA
		dc.w	$4800,$4003,$4800,$B7FF,$E000,$F000,$0001,$FFFE
		dc.w	$0006,$0000,$0926,$F6D9,$007E,$73C8,$73B7,$8C00
		dc.w	$7000,$0002,$76C8,$8937,$4485,$04C7,$D000,$6FFF
		dc.w	$5514,$F906,$0618,$FFFF,$24C0,$3FE0,$0010,$FFFF
		dc.w	$1E80,$00C3,$1F0C,$FFFF,$01F9,$81FB,$0004,$FFFF
		dc.w	$C1A2,$B5FE,$0A01,$FFFF,$234D,$9BEA,$4412,$FFFF
		dc.w	$B77C,$4807,$4880,$FFFF,$38A5,$EFC0,$001A,$FFFF
		dc.w	$F581,$078F,$0870,$FFFF,$2FFF,$FEFC,$0000,$FFFC
		dc.w	$ADD1,$5411,$53EE,$77FF,$57C9,$1002,$E83E,$F83E
		dc.w	$CF31,$00CE,$30CE,$3FFF,$4644,$81BB,$F9BB,$F9BB
		dc.w	$0000,$C800,$C900,$36FF,$0000,$C000,$0008,$FFF7
		dc.w	$8900,$006E,$896E,$7691,$F7CB,$F7FC,$F7B7,$0800
		dc.w	$1400,$6802,$7ED8,$8127,$4086,$00C7,$D100,$6FFF
		dc.w	$ED14,$3906,$0618,$FFFF,$3200,$3F80,$0070,$FFFF
		dc.w	$3E80,$00CF,$3F00,$FFFF,$009D,$80BF,$0040,$FFFF
		dc.w	$9445,$FF6F,$0090,$FFFF,$3887,$C6F8,$0100,$FFFF
		dc.w	$0609,$F80F,$F9F0,$FFFF,$B903,$CF40,$00BC,$FFFF
		dc.w	$C3C0,$07DF,$3820,$FFFF,$EDDF,$FE20,$0020,$FFE0
		dc.w	$AE59,$5419,$53E6,$77FF,$6FF3,$080C,$F01C,$F81C
		dc.w	$CE00,$01FF,$31FF,$3FFF,$F444,$33BB,$4BBB,$FBBB
		dc.w	$D900,$1800,$D94A,$26B5,$0004,$0000,$4444,$BBBB
		dc.w	$03FE,$DBFE,$DB6E,$2401,$01F9,$F7FF,$FF76,$0000
		dc.w	$17C0,$F900,$EED9,$0026,$4004,$0082,$D101,$6EFF
		dc.w	$5D14,$2106,$8E18,$FFFF,$2810,$3200,$05E0,$FFFF
		dc.w	$7C81,$00CD,$7F02,$FFFF,$0005,$8017,$0068,$FFFF
		dc.w	$0242,$F7FF,$0800,$FFFF,$B416,$8FF9,$4000,$FFFF
		dc.w	$E207,$1C06,$1DF8,$FFFF,$CE03,$3F00,$00FC,$FFFF
		dc.w	$4F81,$0FFF,$B000,$FFFF,$F03D,$FEC2,$01C2,$FFC2
		dc.w	$B9B6,$49BE,$4641,$4FFF,$EFFB,$8804,$700C,$FA0C
		dc.w	$DE00,$01FF,$27FF,$3FFF,$BE85,$B17A,$417A,$F17A
		dc.w	$4140,$7A00,$BB49,$04B6,$0020,$0006,$2226,$DDD9
		dc.w	$DB91,$DBFF,$DB6E,$2400,$00FF,$EEFF,$FFEE,$0000
		dc.w	$D278,$FFC0,$EDB9,$0006,$0000,$4080,$9143,$2EBF
		dc.w	$1D14,$4106,$AE18,$FFFF,$1520,$0A00,$20C0,$FFFF
		dc.w	$F801,$0301,$FC06,$FFFF,$0011,$8023,$004C,$FFFF
		dc.w	$A391,$F77F,$0824,$FFFF,$EAAD,$1FFB,$0000,$FFFF
		dc.w	$4A43,$F460,$059C,$FFFF,$F400,$0FF0,$000F,$FFFF
		dc.w	$6307,$03FF,$9C00,$FFFF,$F8FD,$FD02,$0302,$FF02
		dc.w	$FDE2,$0DFE,$0201,$0FFF,$1FFF,$1800,$E000,$FA00
		dc.w	$EC7C,$0382,$1B83,$1FFF,$8F86,$0078,$F079,$F079
		dc.w	$FE09,$8E40,$7649,$01B6,$220F,$002F,$222E,$DDD0
		dc.w	$24BF,$FFD1,$DB6E,$0000,$EC17,$02FF,$FFED,$0000
		dc.w	$FF43,$FFF8,$DBBB,$0004,$B000,$4003,$B340,$0CBF
		dc.w	$AD14,$6106,$1E18,$FFFF,$1381,$0C00,$2061,$FFFF
		dc.w	$F005,$0401,$F806,$FFFF,$000D,$8003,$0070,$FFFF
		dc.w	$5D80,$FD7F,$023F,$FFFF,$F086,$1A9D,$0560,$FFFF
		dc.w	$BCA2,$C0E7,$0318,$FFFF,$F800,$1FFE,$0001,$FFFF
		dc.w	$401F,$07FF,$B800,$FFFF,$F88E,$FB00,$0771,$FF71
		dc.w	$FFE2,$1FFE,$0001,$1FFF,$3F9F,$3800,$C060,$FA60
		dc.w	$FFCF,$0001,$0878,$0FFF,$1EEE,$0110,$E111,$E111
		dc.w	$50C0,$5ED9,$AED9,$0126,$00E1,$66EF,$66EE,$9910
		dc.w	$2FFF,$F511,$DAEE,$0000,$FDE2,$103F,$EFDD,$0000
		dc.w	$FFE8,$FFFF,$BB77,$0000,$3000,$C001,$7748,$08B7
		dc.w	$DD2C,$A10E,$0E30,$FFFF,$2803,$0400,$13E3,$FFFF
		dc.w	$C00D,$0801,$F00E,$FFFF,$002D,$8003,$0010,$FFFF
		dc.w	$F7C2,$BE7D,$003D,$FFFF,$F00B,$338D,$0C70,$FFFF
		dc.w	$F655,$0AFF,$0100,$FFFF,$4000,$BFFF,$0000,$FFFF
		dc.w	$00FF,$FCFF,$0300,$FFFF,$F10C,$F200,$0EF3,$FEF3
		dc.w	$FF80,$1F80,$007F,$1FFF,$3F8F,$3800,$C070,$FA70
		dc.w	$FFE6,$0002,$0FFD,$0FFF,$747D,$4B80,$8B83,$CB83
		dc.w	$BE3B,$93BB,$EDBB,$0044,$6E01,$6EEF,$6EEE,$9110
		dc.w	$FE00,$2612,$D9ED,$0000,$07FF,$2224,$DDDB,$0000
		dc.w	$5FF0,$FFFE,$B76F,$0000,$0C00,$F100,$EECA,$0035
		dc.w	$1D2C,$E10E,$0E30,$FFFF,$2B03,$0400,$10C3,$FFFF
		dc.w	$800D,$3201,$C00E,$FFFF,$0029,$803B,$0004,$FFFF
		dc.w	$FBBB,$0444,$0004,$FFFF,$F12E,$13B3,$0C40,$FFFF
		dc.w	$4AEE,$9FBF,$2000,$FFFF,$A260,$FFFF,$0000,$FFFF
		dc.w	$FDE7,$FDFF,$0200,$FFFF,$C70C,$C000,$38F3,$FEF3
		dc.w	$AFE6,$1F80,$5019,$5FFF,$7FA7,$7060,$8018,$F078
		dc.w	$FF8A,$008A,$0775,$07FF,$647D,$5B80,$9B83,$DB83
		dc.w	$5780,$64FB,$FB7B,$0004,$0EEF,$6001,$6EEE,$9110
		dc.w	$2200,$2612,$D9ED,$0000,$00FF,$2444,$DBBB,$0000
		dc.w	$EBFC,$9FFD,$76EF,$0000,$0580,$D800,$FFCA,$0035
		dc.w	$DA2C,$E20E,$1C30,$FFFF,$1007,$1200,$2DC7,$FFFF
		dc.w	$000D,$4601,$800E,$FFFF,$0009,$803F,$0000,$FFFF
		dc.w	$FB5D,$16A7,$0000,$FFFF,$B8C2,$6DDF,$0220,$FFFF
		dc.w	$945F,$76FF,$0900,$FFFF,$5E73,$FFFF,$0000,$FFFF
		dc.w	$FEE0,$FEFF,$0100,$FFFF,$B69C,$C000,$0963,$FD63
		dc.w	$AFFE,$1600,$5001,$57F7,$FF87,$A040,$003F,$A07F
		dc.w	$FC0C,$000C,$03F3,$03FF,$E47D,$9B80,$1B83,$9B83
		dc.w	$65FF,$7184,$FE7B,$0000,$F111,$9111,$6EEE,$0000
		dc.w	$7709,$7FAD,$8052,$0000,$2003,$6448,$9BB7,$0000
		dc.w	$F9FB,$97FB,$6EDF,$0000,$A180,$BA00,$FFBA,$0045
		dc.w	$7A2C,$620E,$1C30,$FFFF,$0D06,$0F00,$3087,$FFFF
		dc.w	$000D,$9C01,$000E,$FFFF,$0009,$8017,$0020,$FFFF
		dc.w	$FD6E,$32BF,$0000,$FFFF,$D452,$EEFB,$0104,$FFFF
		dc.w	$93B9,$B8F9,$4406,$FFFF,$EEFC,$FFFC,$0003,$FFFF
		dc.w	$7F90,$7FFF,$8000,$FFFF,$1E7F,$E000,$0180,$FD80
		dc.w	$EEFF,$1000,$1100,$11E1,$FFFF,$0020,$001F,$003F
		dc.w	$FD1C,$011C,$02E3,$03FF,$F45D,$8BA0,$0BA3,$8BA3
		dc.w	$724E,$744C,$FFB3,$0000,$8177,$81FF,$7E00,$0000
		dc.w	$7777,$FC80,$037F,$0000,$F400,$9C49,$63B6,$0000
		dc.w	$7F3B,$12FB,$EDDF,$0000,$7060,$7700,$FFF6,$0009
		dc.w	$3A2C,$220E,$5C30,$BFFF,$1C0C,$1E01,$218E,$FFFF
		dc.w	$081D,$2C01,$101E,$FFFF,$0021,$802F,$0010,$FFFF
		dc.w	$F668,$3FA5,$0012,$FFFF,$8AB0,$BFF2,$400D,$FFFF
		dc.w	$2FD6,$79F0,$8009,$FFFF,$FFE3,$FFE3,$001C,$FFFF
		dc.w	$E701,$E7FE,$1800,$FFFF,$0C3F,$F000,$03C0,$FBC0
		dc.w	$FBFF,$7400,$0400,$7460,$FF87,$78A0,$005F,$78FF
		dc.w	$7C1F,$001F,$83E0,$83FF,$FC99,$0360,$0367,$0367
		dc.w	$A8A1,$AA08,$FFFF,$0000,$D82A,$057F,$FE80,$0000
		dc.w	$AA80,$F52B,$0AFF,$0000,$1E40,$62C9,$FD36,$0000
		dc.w	$0FCB,$227F,$DDB7,$0000,$0C28,$EEC0,$1FFE,$0001
		dc.w	$1A2C,$020E,$5C30,$BFFF,$0498,$0682,$391C,$FFFF
		dc.w	$281D,$4C01,$301E,$FFFF,$0000,$801F,$0020,$FFFF
		dc.w	$EB88,$5EFA,$0005,$FFFF,$0741,$7FF6,$8008,$FFFF
		dc.w	$9566,$3FF0,$4009,$FFFF,$F983,$F983,$067C,$FFFF
		dc.w	$9E01,$9FF1,$600E,$FFFF,$FC7F,$0000,$0380,$8380
		dc.w	$F3FF,$F401,$0C00,$FC41,$878E,$8480,$787F,$FCFF
		dc.w	$7E3F,$803F,$01C0,$81FF,$F399,$0C60,$0C67,$0C67
		dc.w	$DC00,$DDDD,$FFFF,$0000,$10DD,$CAFF,$FD00,$0000
		dc.w	$D700,$2ADC,$DDFF,$0000,$83A2,$A937,$FEC8,$0000
		dc.w	$03E8,$249F,$DB76,$0000,$2D0C,$DDD0,$EFFC,$0003
		dc.w	$022C,$020E,$D430,$2FFF,$1C10,$1E04,$2118,$FFFF
		dc.w	$681D,$8C01,$701E,$FFFF,$0028,$802F,$0010,$FFFF
		dc.w	$525C,$BFFF,$0000,$FFFF,$3FA1,$C0ED,$3F12,$FFFF
		dc.w	$4AEB,$D7F8,$2004,$FFFF,$0400,$0400,$FBFF,$FFFF
		dc.w	$7811,$7FFF,$8000,$FFFF,$FF9F,$C041,$0060,$C061
		dc.w	$037F,$0487,$FC80,$FC87,$07C9,$04C8,$F837,$FCFF
		dc.w	$FF7F,$0072,$C080,$C0F2,$F39B,$0C60,$0C67,$0C67
		dc.w	$DDDC,$DDDD,$FFFF,$0000,$51DD,$A3FE,$DC01,$0000
		dc.w	$B099,$6DDD,$DFFF,$0000,$9877,$DD01,$FFFE,$0000
		dc.w	$007C,$4493,$BB6D,$0000,$3389,$87B2,$F3FF,$0800
		dc.w	$822C,$020E,$D430,$2FFF,$3020,$3209,$0D30,$FFFF
		dc.w	$D09D,$18C1,$E01E,$FFFF,$0010,$801D,$0022,$FFFF
		dc.w	$90A3,$DFBC,$2043,$FFFF,$FF8E,$003F,$FFC0,$FFFF
		dc.w	$BDFC,$E3FC,$0003,$FFFF,$0381,$0381,$FC7E,$FFFF
		dc.w	$E0F9,$FF0E,$0000,$FFFF,$9E4F,$8180,$61B0,$E1F1
		dc.w	$FFF1,$0011,$000E,$F81F,$2FFC,$2E7C,$D003,$FE7F
		dc.w	$3FFF,$0000,$C000,$C000,$9D1B,$62E0,$62E7,$62E7
		dc.w	$AE82,$AEA8,$FBFF,$0000,$8AAA,$5FF5,$A00A,$0000
		dc.w	$52AA,$FAAA,$AFFF,$0000,$AA80,$AAAA,$FFFF,$0000
		dc.w	$A01D,$2922,$D6DD,$0000,$F860,$0777,$FCFF,$0000
		dc.w	$822C,$020E,$B430,$4FFF,$3801,$3A12,$0521,$FFFF
		dc.w	$D09A,$18C3,$E01C,$FFFF,$0010,$0010,$002F,$FFFF
		dc.w	$2BCF,$FFF0,$000F,$FFFF,$FFBD,$0037,$FFC0,$FFFF
		dc.w	$7DFE,$FFFE,$0001,$FFFF,$61FF,$01FF,$9E00,$FFFF
		dc.w	$07E4,$F80C,$0013,$FFFF,$037B,$0084,$FC84,$FCFD
		dc.w	$FFE8,$0008,$3017,$F01F,$EFFF,$EE7F,$1000,$FE7F
		dc.w	$DFFF,$C000,$2000,$E000,$0710,$F8E0,$F8EF,$F8EF
		dc.w	$7C07,$7F70,$F7FF,$0000,$377E,$BFC9,$4037,$0000
		dc.w	$A666,$F777,$7FFF,$0000,$6658,$775D,$FFFF,$0000
		dc.w	$180E,$5924,$E6DB,$0000,$0C6C,$F3EE,$0F7F,$0000
		dc.w	$422C,$020E,$6430,$9FFF,$2003,$2424,$1A43,$FFFF
		dc.w	$D09A,$18C3,$E11C,$FFFF,$0008,$000C,$0013,$FFFF
		dc.w	$1A3F,$3FC0,$C03F,$FFFF,$FF66,$007F,$FF80,$FFFF
		dc.w	$7E78,$FFF8,$0007,$FFFF,$01FC,$01FF,$FE00,$FFFF
		dc.w	$1F06,$E00E,$00F1,$FFFF,$2507,$25F8,$DAF8,$FFF8
		dc.w	$FFFC,$007C,$E003,$E07F,$BFFE,$B006,$4001,$F007
		dc.w	$FFFD,$0002,$0002,$0002,$07F0,$F800,$F80F,$F80F
		dc.w	$7894,$7FE8,$F777,$0000,$377C,$BF8B,$4077,$0000
		dc.w	$9916,$EE67,$77FF,$0000,$6AC8,$6AEA,$FFFF,$0000
		dc.w	$C883,$EAAA,$F555,$0000,$911C,$6EDD,$F1BF,$0200
		dc.w	$422C,$820E,$C830,$37FF,$3A07,$7E48,$7807,$87FF
		dc.w	$D09A,$18C3,$E11C,$FFFF,$0012,$001A,$0005,$FFFF
		dc.w	$90FF,$FF00,$00FF,$FFFF,$00C6,$00FF,$FF00,$FFFF
		dc.w	$77B4,$F7F4,$080B,$FFFF,$00C0,$00FF,$FF00,$FFFF
		dc.w	$0032,$803E,$7FC1,$FFFF,$1DFF,$1D00,$E200,$FF00
		dc.w	$FF2F,$007F,$0080,$E0FF,$1F5F,$00A0,$E0A0,$E0E0
		dc.w	$FFFF,$0000,$0000,$0000,$07C0,$F830,$F83F,$F83F
		dc.w	$D760,$FDD5,$2AAA,$0000,$AA7F,$FF55,$00AA,$0000
		dc.w	$D60A,$7CAA,$ABFF,$0000,$A956,$AD57,$FFFF,$0000
		dc.w	$0002,$5449,$FFB6,$0000,$0003,$FBBB,$101F,$0CC0
		dc.w	$022C,$820E,$8830,$77FF,$3F38,$3FC0,$0FFF,$F000
		dc.w	$E09A,$08C3,$F11C,$FFFF,$0009,$000F,$0010,$FFFF
		dc.w	$83F8,$FC00,$03FF,$FFFF,$7F83,$7FFF,$8000,$FFFF
		dc.w	$B3FD,$F3FF,$0C00,$FFFF,$01F0,$01FF,$FE00,$FFFF
		dc.w	$3033,$B03F,$4FC0,$FFFF,$0EEF,$0E90,$F110,$FF9C
		dc.w	$FF58,$03C0,$0027,$43FF,$7EEF,$0110,$8110,$81F0
		dc.w	$FFE1,$001E,$001E,$001E,$8D81,$7270,$727F,$727F
		dc.w	$27C1,$FA23,$DDDC,$0000,$DC7B,$FE22,$01DD,$0000
		dc.w	$BB89,$225D,$DDFF,$0000,$9A10,$DDBA,$FFFF,$0000
		dc.w	$302F,$BBB8,$FFC7,$0000,$E010,$1CD6,$E00F,$0760
		dc.w	$222C,$420E,$F830,$07FF,$3400,$3C0F,$0010,$FFF0
		dc.w	$011A,$C443,$399C,$0FFF,$0000,$000F,$0010,$FFFF
		dc.w	$0007,$F807,$07F8,$FFFF,$8080,$80FC,$0003,$FFFF
		dc.w	$63F3,$63FF,$9C00,$FFFF,$378C,$378F,$C870,$FFFF
		dc.w	$1C0E,$FC0E,$03F1,$FFFF,$ED67,$ED58,$1298,$FFDC
		dc.w	$FC8F,$0EC0,$0130,$0FFF,$FEEF,$0110,$0110,$01F0
		dc.w	$E780,$187F,$187F,$187F,$78D3,$8720,$872F,$872F
		dc.w	$FFC1,$2223,$DDDC,$0000,$DC3B,$FE22,$01DD,$0000
		dc.w	$BB89,$221D,$DDFF,$0000,$83FF,$DE2A,$FDD5,$0000
		dc.w	$75C0,$A08F,$DF70,$0000,$0008,$E66D,$6007,$1BB0
		dc.w	$C02C,$E00E,$F430,$0BFF,$3408,$3C0B,$0014,$FFF8
		dc.w	$019A,$3C02,$C1DC,$0DFF,$0004,$0017,$0008,$FFFF
		dc.w	$1FF8,$FFF8,$0000,$FFFF,$0000,$007C,$0003,$FFFF
		dc.w	$0307,$03FF,$FC00,$FFFF,$B8C2,$B843,$473C,$FFFF
		dc.w	$385F,$F814,$07A0,$FFFF,$FB77,$1F48,$0088,$FFCC
		dc.w	$F466,$1A63,$0199,$1FFF,$FF5F,$00A0,$00A0,$00F0
		dc.w	$8700,$78FF,$78FF,$78FF,$3073,$CF80,$CF8F,$CF8F
		dc.w	$140A,$155F,$EAA0,$0000,$A808,$FD55,$02AA,$0000
		dc.w	$00EA,$554A,$AABF,$0000,$9751,$BD51,$EAAE,$0000
		dc.w	$F107,$5118,$AEE7,$0000,$8080,$7337,$8183,$1C58
		dc.w	$482C,$C00E,$ED30,$12FF,$3410,$3C18,$0020,$FFFF
		dc.w	$00DA,$8E02,$71DC,$02FF,$0002,$001A,$0005,$BFFF
		dc.w	$3800,$F800,$0000,$FFFF,$0006,$0078,$0001,$FFFF
		dc.w	$01C9,$01FF,$FE00,$FFFF,$F05F,$F01F,$0FA0,$FFFF
		dc.w	$407F,$C023,$3F80,$FFFF,$DCBB,$DFA4,$2044,$FFE5
		dc.w	$EA39,$2638,$11C6,$3FFE,$FFF7,$0008,$0008,$0008
		dc.w	$0600,$F9FF,$F9FF,$F9FF,$1033,$EFC0,$EFCF,$EFCF
		dc.w	$F837,$F8BF,$0740,$0000,$7000,$F888,$0777,$0000
		dc.w	$0066,$8897,$777F,$0000,$3E74,$48FE,$F701,$0000
		dc.w	$1559,$9FFE,$600F,$0000,$E268,$1993,$E2E9,$0C04
		dc.w	$282F,$3007,$FD3F,$02F0,$FE20,$FEB8,$FE40,$01FF
		dc.w	$001A,$7F02,$00DC,$9C1F,$0001,$4015,$400A,$1FFF
		dc.w	$4000,$C000,$0000,$FFFF,$0007,$0038,$0000,$FFFF
		dc.w	$00DE,$00DF,$FF20,$FFFF,$7F30,$FF10,$00CF,$FFFF
		dc.w	$DFE3,$C063,$201C,$FFFF,$FEB9,$FFA6,$0046,$FFE7
		dc.w	$9DF7,$03F4,$6008,$7FFC,$FFFE,$0001,$0001,$8001
		dc.w	$0600,$F9FF,$F9FF,$F9FF,$10F9,$EF00,$EF07,$EF07
		dc.w	$0737,$FFBF,$0040,$0000,$7407,$FC8F,$0370,$0000
		dc.w	$7066,$F897,$077F,$0000,$682B,$08FF,$F700,$0000
		dc.w	$ABB0,$FFFF,$0001,$0000,$4134,$AECB,$E376,$1400
		dc.w	$302C,$F00E,$F930,$06FF,$1E67,$007F,$1F86,$E000
		dc.w	$800A,$F8F2,$870C,$207F,$0000,$2013,$600C,$0FFF
		dc.w	$0000,$8000,$0000,$FFFF,$0007,$0038,$0000,$FFFF
		dc.w	$7986,$0187,$8678,$FFFF,$34D3,$FC13,$032C,$FFFF
		dc.w	$E3FD,$C1FD,$1C02,$FFFF,$FE5E,$FFD9,$0021,$FFF9
		dc.w	$FB7B,$6308,$0484,$7FFC,$FF7F,$0080,$0180,$C180
		dc.w	$2630,$D9CF,$D9CF,$D9FF,$1F0E,$E0F0,$E0F1,$E0F1
		dc.w	$C0AA,$FFFF,$0000,$0000,$A00A,$FD5F,$02A0,$0000
		dc.w	$A8D1,$FD7B,$02AE,$0000,$C09D,$15FF,$EA00,$0000
		dc.w	$5D5E,$FFF1,$000E,$0000,$019A,$C665,$43BA,$3800
		dc.w	$020C,$C40E,$FEA0,$015F,$0873,$087F,$0073,$FFC0
		dc.w	$C003,$F4FB,$4B05,$10BE,$0000,$101C,$3000,$83FF
		dc.w	$0000,$0000,$0000,$FFFF,$0006,$0008,$0001,$FFFF
		dc.w	$7003,$001B,$8FE4,$FFFF,$13F5,$FEFF,$0000,$FFFF
		dc.w	$C4DF,$80DF,$3B20,$FFFF,$FF27,$FFE4,$0018,$FFFC
		dc.w	$E6EB,$660C,$1914,$7FFD,$FF3B,$00C4,$03C4,$C3C4
		dc.w	$FC79,$0386,$0386,$03FE,$FC07,$03F8,$03F8,$03F8
		dc.w	$DC1D,$7FFF,$8000,$0000,$C5DD,$FFFF,$0000,$0000
		dc.w	$D8E3,$FA3E,$05DD,$0000,$81CA,$23FF,$DC00,$0000
		dc.w	$EAF3,$FFFC,$001F,$0000,$80C2,$633D,$81DB,$3C00
		dc.w	$0A0C,$BC0E,$7EA0,$015F,$091B,$093F,$011B,$FEC0
		dc.w	$E000,$F3F8,$6C06,$01C8,$8000,$8C18,$9C00,$41FF
		dc.w	$0000,$0000,$0000,$FFFF,$0000,$0000,$0007,$FFFF
		dc.w	$8001,$02BF,$7D40,$FFFF,$00B2,$FF3F,$0040,$FFFF
		dc.w	$0446,$E047,$1BB8,$FFFF,$7F91,$FFF2,$000C,$FFFE
		dc.w	$FF03,$3F04,$00FC,$3FFD,$7F38,$80C7,$83C7,$C3C7
		dc.w	$FC7D,$0382,$0382,$03FA,$FC03,$03FC,$03FC,$C3FC
		dc.w	$C01D,$23FF,$DC00,$0000,$C5DD,$FFFF,$0000,$0000
		dc.w	$D1FF,$F222,$0DDD,$0000,$1DD7,$3FFF,$C000,$0000
		dc.w	$5740,$FFFF,$0003,$0000,$C241,$399A,$C2C1,$1C2C
		dc.w	$090C,$DA0E,$BFA0,$005F,$049B,$04BB,$049F,$FB40
		dc.w	$E000,$F3E8,$6C17,$02E0,$0000,$0210,$4E00,$207F
		dc.w	$0000,$0000,$0000,$FFFF,$0000,$0000,$000F,$FFFF
		dc.w	$F808,$39BF,$0640,$FFFF,$435B,$FF1F,$00A0,$FFFF
		dc.w	$380C,$FC0F,$03F0,$FFFF,$378F,$F7FF,$0800,$FFFF
		dc.w	$FE02,$FE05,$01FD,$FFFD,$7C38,$83C7,$87C7,$87C7
		dc.w	$F1FF,$0F00,$0000,$0FF9,$C400,$3BFF,$3BFF,$FBFF
		dc.w	$FFC8,$23FF,$DC00,$0000,$A2AA,$FFFF,$0000,$0000
		dc.w	$A0A8,$F555,$0AAA,$0000,$2AAA,$7FFF,$8000,$0000
		dc.w	$BAAC,$FFD3,$003C,$0000,$4300,$9CCD,$C340,$2436
		dc.w	$054C,$D60E,$BF60,$009F,$12D8,$12DB,$12FF,$ED00
		dc.w	$000C,$6FCC,$F037,$0344,$0000,$0180,$A780,$103F
		dc.w	$0000,$0000,$0000,$FFFF,$0001,$0000,$000E,$FFFF
		dc.w	$F818,$39FB,$0604,$FFFF,$695F,$FF1C,$00A3,$FFFF
		dc.w	$9C0C,$1E0F,$E1F0,$FFFF,$065F,$C672,$3980,$FFFF
		dc.w	$A5E7,$45D8,$1A18,$7FF8,$7C38,$83C7,$87C7,$87C7
		dc.w	$61FF,$9FC0,$8000,$9FF9,$C200,$3DFF,$3DFF,$FDFF
		dc.w	$3E50,$E27F,$DD80,$0000,$6577,$FFFF,$0000,$0000
		dc.w	$4071,$C889,$3776,$0000,$7775,$FFFF,$0000,$0000
		dc.w	$C0C3,$EAFC,$150F,$0000,$0180,$E64D,$4380,$3836
		dc.w	$1448,$3E88,$0FE8,$C017,$4A40,$4A5B,$4AFF,$B500
		dc.w	$007A,$6F7E,$F0C3,$0542,$E000,$E040,$FFC0,$001F
		dc.w	$0000,$0300,$0000,$FFFF,$0000,$0000,$0007,$FFFF
		dc.w	$0262,$07E3,$F81C,$FFFF,$36FF,$FE70,$010F,$FFFF
		dc.w	$AC0C,$2E0F,$C1F0,$FFFF,$823F,$E263,$1D80,$FFFF
		dc.w	$535F,$A320,$8CA0,$BFE0,$B458,$4BA7,$4BA7,$4BA7
		dc.w	$431F,$BF00,$80E0,$BFFB,$C359,$3CA6,$3CA6,$FCA6
		dc.w	$3F8C,$822F,$FDD0,$0000,$6577,$FFFF,$0000,$0000
		dc.w	$4003,$C88B,$3774,$0000,$7772,$FFFF,$0000,$0000
		dc.w	$8EC0,$D1FF,$2E73,$0000,$84C0,$7336,$85C0,$181B
		dc.w	$0152,$AF92,$1DF2,$400D,$AB40,$AB6B,$BFFF,$4000
		dc.w	$0166,$AF7F,$F9A4,$0324,$8000,$FF20,$F8E0,$000F
		dc.w	$0080,$00F8,$3F00,$FFFF,$0006,$0006,$0001,$FFFF
		dc.w	$48DD,$4FC5,$B022,$FFFF,$0FFE,$FF00,$00FF,$FFFF
		dc.w	$1649,$1707,$C0B0,$FFFF,$9F3F,$E0FF,$0000,$FFFF
		dc.w	$0EBF,$F640,$E140,$FFC0,$FFFF,$0000,$0000,$0000
		dc.w	$3B0F,$FF00,$00F0,$FFF3,$C3FF,$3C00,$3C00,$FC00
		dc.w	$3BE5,$0027,$7FD8,$8000,$A6AA,$FFFF,$0000,$0000
		dc.w	$A80A,$FD5F,$02A0,$0000,$AAA1,$FFFF,$0000,$0000
		dc.w	$3470,$9E8F,$757C,$0000,$0640,$99B6,$86C0,$681B
		dc.w	$0035,$F7B5,$0BFF,$4000,$AA00,$AB6D,$FFFF,$0000
		dc.w	$0956,$A7FE,$F855,$0254,$8280,$FA80,$FFF0,$0083
		dc.w	$3F38,$003C,$F1C0,$FFFF,$0007,$0007,$0000,$FFFF
		dc.w	$F811,$FF83,$006C,$FFFF,$BFFC,$F800,$07FF,$FFFF
		dc.w	$23F9,$2307,$8000,$FFFF,$8F3F,$F0FE,$0000,$FFFF
		dc.w	$DCBF,$2C40,$0340,$FFC0,$FFFE,$0001,$0000,$0001
		dc.w	$3E0F,$EE00,$01F0,$FFF3,$C1FF,$3E00,$3E00,$FE00
		dc.w	$0BFC,$0044,$0FBB,$F000,$02DD,$7FFF,$8000,$0000
		dc.w	$DC1D,$FE3F,$01C0,$0000,$DDD1,$FFFF,$0000,$0000
		dc.w	$2ACC,$7DB3,$AA4F,$0000,$0100,$EEDB,$0740,$702D
		dc.w	$0000,$686D,$17FF,$8000,$0000,$AB6D,$FFFF,$0000
		dc.w	$20AC,$89FD,$F6AB,$00A8,$4460,$767C,$FFFD,$0063
		dc.w	$7FCC,$000E,$FEF0,$FFFF,$0000,$0007,$0007,$FFFF
		dc.w	$0000,$FFFF,$FFFF,$FFFF,$7FF0,$8000,$FF3F,$FFFF
		dc.w	$4000,$43FF,$03FF,$FFFF,$0000,$FFFF,$FFFF,$FFFF
		dc.w	$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF
		dc.w	$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF
		dc.w	$03BF,$0004,$07FB,$F800,$20DD,$7FFF,$8000,$0000
		dc.w	$DDDD,$FFFF,$0000,$0000,$DDD0,$FFFF,$0000,$0000
		dc.w	$5983,$BEFC,$5D73,$0000,$0080,$7F6D,$0980,$9036
		dc.w	$1E21,$BF26,$0EFB,$CE20,$8401,$79B4,$AFFF,$0000
		dc.w	$A3AC,$57FC,$AAAB,$02A8,$2818,$AD62,$FFCA,$0009
		dc.w	$FF0C,$000E,$FFF0,$FFFF,$0000,$C007,$0007,$FFFF
		dc.w	$0003,$FFFC,$FFFF,$FFFF,$FFE0,$0000,$F07C,$FFFF
		dc.w	$8000,$83FF,$03FF,$FFFF,$0000,$FFFF,$FFFF,$FFFF
		dc.w	$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF
		dc.w	$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF,$FFFF
		dc.w	$01BB,$0000,$01FF,$FE00,$952A,$9FFF,$6400,$0400
		dc.w	$AAAA,$FFFF,$0000,$0000,$AAA0,$FFFF,$0000,$0000
		dc.w	$EAF0,$3D8F,$EA7C,$0000,$0C00,$93B5,$0E80,$E05A
		dc.w	$09FC,$BDFC,$03FF,$C1FC,$A9B5,$940A,$EFF5,$8000
		dc.w	$42A8,$EDFA,$5207,$4000,$0011,$9B64,$FFD1,$0014
		dc.w	$7E18,$001C,$7FE1,$FFFF,$0C07,$4000,$8C00,$FFFF
		dc.w	$FFFF,$0000,$000F,$FFFF,$FFE3,$0003,$87F8,$FFFF
		dc.w	$07FF,$0000,$0000,$FFFF,$FFFF,$0000,$0000,$FFFF
		dc.w	$FFFF,$0000,$0000,$FFFF,$FFFF,$0000,$0000,$FFFF
		dc.w	$FFFF,$0000,$0000,$FFFF,$FFFF,$0000,$0000,$FFFF
		dc.w	$003B,$0000,$003F,$FFC0,$46A3,$0FFF,$F200,$0200
		dc.w	$7777,$FFFF,$0000,$0000,$7770,$FFFF,$0000,$0000
		dc.w	$560E,$B8F0,$570E,$0001,$2200,$DDDB,$3300,$406C
		dc.w	$1803,$FD57,$12AB,$1003,$9DAA,$925F,$FDAA,$900A
		dc.w	$AAA8,$AEF9,$FB07,$0000,$0446,$443A,$BBC2,$0006
		dc.w	$8871,$0078,$BF83,$7FFF,$1E07,$4000,$8600,$FFFF
		dc.w	$FFFF,$0000,$003F,$FFFF,$FFC6,$0004,$07F2,$FFFF
		dc.w	$0FFF,$0000,$0000,$FFFF,$FFFF,$0000,$0000,$FFFF
		dc.w	$FFFF,$0000,$0000,$FFFF,$FFFF,$0000,$0000,$FFFF
		dc.w	$FFFF,$0000,$0000,$FFFF,$FFFF,$0000,$0000,$FFFF
		dc.w	$000B,$0000,$000F,$FFF0,$6918,$0BFF,$F500,$0100
		dc.w	$7777,$FFFF,$0000,$0000,$7770,$FFFF,$0000,$0000
		dc.w	$3080,$45FF,$BA70,$0003,$1800,$676E,$1C01,$81B0
		dc.w	$0C28,$7EAA,$8955,$0800,$0A55,$FFF5,$0A5F,$0A40
		dc.w	$405D,$551D,$FFE2,$0000,$7F85,$FF9F,$7061,$0001
		dc.w	$41E3,$41F0,$1E07,$3FFF,$3C07,$0100,$2600,$FFFF
		dc.w	$FC1F,$0000,$0018,$FFFF,$FE06,$0004,$1FF2,$FFFF
		dc.w	$0FFF,$0000,$0000,$FFFF,$FFFF,$0000,$0000,$FFFF
		dc.w	$FFFF,$0000,$0000,$FFFF,$FFFF,$0000,$0000,$FFFF
		dc.w	$FFFF,$0000,$0000,$FFFF,$FFFF,$0000,$0000,$FFFF
		dc.w	$0001,$0000,$0001,$FFFE,$79C2,$0BFF,$F5C0,$01C0
		dc.w	$AAAA,$7FFF,$8000,$0000,$AAA0,$FFFF,$0000,$0000
		dc.w	$8180,$AAFF,$557C,$0000,$4400,$B9B6,$6409,$82C0
		dc.w	$0C78,$9EAA,$6955,$0800,$4055,$EAD5,$157F,$0000
		dc.w	$407E,$557E,$FF91,$0010,$8FF0,$EFF2,$3F0D,$0000
		dc.w	$A3C6,$A3E0,$A00F,$BFFF,$7A03,$0308,$0C00,$FFFF
		dc.w	$F80F,$0000,$000C,$FFFF,$FF0C,$0008,$3FE4,$FFFF
		dc.w	$3FFF,$0000,$3FFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
		dc.w	$FFFF,$0000,$FFFF,$FFFF,$FFC7,$0038,$FFBF,$FFFF
		dc.w	$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
		dc.w	$0000,$0880,$0000,$FFFF,$39E1,$0FFA,$35E5,$C1E0
		dc.w	$5DDD,$7FFF,$8000,$0000,$DDCC,$FEFF,$DD04,$0004
		dc.w	$408C,$D1F0,$2E0C,$0003,$3000,$CEE9,$3816,$0300
		dc.w	$04BE,$BD55,$46AA,$0400,$AAAA,$52AA,$AFFF,$0000
		dc.w	$AF75,$879F,$F87F,$0015,$0378,$CF79,$BFE6,$0000
		dc.w	$400C,$5800,$B81E,$07FF,$F403,$0608,$8800,$FFFF
		dc.w	$800F,$0000,$000F,$FFFF,$DC2C,$0028,$7FC4,$FFFF
		dc.w	$3FFF,$0000,$3FFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
		dc.w	$FFFF,$0000,$FFFF,$FFFF,$FF81,$007E,$FFFF,$FFFF
		dc.w	$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
		dc.w	$0000,$50C0,$0000,$FFFF,$3FD1,$79EE,$3FF5,$B9C0
		dc.w	$5DDF,$7FFD,$8007,$0000,$BAD4,$DF7F,$FD84,$0004
		dc.w	$0170,$EB8F,$1470,$0003,$0800,$739A,$4865,$8500
		dc.w	$06BE,$6F55,$94AA,$0400,$82AA,$6AAA,$BFFF,$0000
		dc.w	$BFCA,$9C7F,$E7FF,$044A,$8074,$EE75,$DFFE,$8000
		dc.w	$A719,$AA00,$5F1D,$00FF,$E800,$0E08,$3000,$FFFF
		dc.w	$0006,$0000,$0007,$FFFF,$00D8,$00D0,$FF08,$FFFF
		dc.w	$7FFF,$0000,$7FFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
		dc.w	$FFFF,$0000,$FFFF,$FFFF,$FF1E,$00ED,$FFF3,$FFFF
		dc.w	$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
		dc.w	$0000,$8000,$0000,$FFFF,$3FC6,$FFB9,$3FCE,$3F80
		dc.w	$ABBF,$7FAE,$807F,$0000,$77BE,$AB7F,$FE86,$0006
		dc.w	$33B0,$F7C3,$083C,$0000,$6000,$99A6,$7059,$8600
		dc.w	$0254,$9EAB,$6355,$0200,$1554,$D555,$7FFF,$0000
		dc.w	$6E6E,$73FF,$8FFE,$026E,$543F,$FEBF,$55FF,$543F
		dc.w	$02C3,$9C40,$7EC3,$003F,$9000,$1E08,$E000,$FFFF
		dc.w	$0003,$0000,$0003,$FFFF,$0330,$0330,$FC00,$FFFF
		dc.w	$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
		dc.w	$FFFF,$0000,$FFFF,$FFFF,$FF65,$0084,$FFFB,$FFFF
		dc.w	$7FFF,$8000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
		dc.w	$0001,$0440,$0001,$FFFF,$3C95,$FD69,$3FB6,$3C00
		dc.w	$776E,$FF77,$00FF,$0000,$EED7,$77BF,$FF47,$0007
		dc.w	$1500,$FFF8,$0004,$0003,$1000,$EB69,$1096,$0400
		dc.w	$0B54,$AFAB,$5255,$0200,$9551,$D555,$7FFE,$0000
		dc.w	$C9BC,$D7FF,$2FFC,$01BC,$817F,$D583,$2B7F,$0103
		dc.w	$E5C7,$BB40,$A7E7,$A01F,$6000,$7C08,$8000,$FFFF
		dc.w	$0002,$0000,$0003,$FFFF,$8CC1,$0CC0,$F001,$FFFF
		dc.w	$FFFF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
		dc.w	$FFFF,$0000,$FFFF,$FFFF,$FEC4,$014C,$FFBB,$FFFF
		dc.w	$3FFF,$4000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
		dc.w	$0002,$0921,$0003,$FFFF,$8023,$6DCB,$9E74,$8000
		dc.w	$75EE,$FF77,$03FF,$0000,$EEEF,$77BF,$FF4F,$000F
		dc.w	$C520,$FFC7,$C138,$C100,$0000,$1E9A,$0165,$E000
		dc.w	$022B,$6F55,$92AA,$0200,$42A4,$EAAF,$BFF0,$0000
		dc.w	$30FE,$8FFF,$73FE,$00FE,$31AB,$A4F8,$5FAF,$00A8
		dc.w	$08CD,$F721,$C0EE,$001F,$8000,$F808,$0000,$FFFF
		dc.w	$0007,$0000,$0007,$FFFF,$0780,$0780,$E003,$FFFF
		dc.w	$03FF,$0000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
		dc.w	$FFFF,$0000,$FFFF,$FFFF,$FF04,$00FC,$FCFB,$FFFF
		dc.w	$9FFF,$6000,$FFFF,$FFFF,$FFFF,$0000,$FFFF,$FFFF
		dc.w	$0004,$2043,$0007,$FFFF,$838A,$7C5F,$F3A0,$8000
		dc.w	$89DD,$D6AA,$2FFF,$0000,$DD7F,$ABFF,$FE0F,$000F
		dc.w	$FAB0,$FFC1,$FABE,$FA81,$0000,$E9A6,$0659,$1000
		dc.w	$0283,$9FD5,$622A,$0200,$4070,$EADE,$BFA1,$0000
		dc.w	$0007,$7E07,$9C07,$0007,$15D5,$FF57,$0AAD,$0005
		dc.w	$810E,$3EC7,$F028,$001F,$0000,$F018,$0000,$FFFF
		dc.w	$001E,$0000,$001F,$FFFF,$1807,$1807,$8000,$FFFF
		dc.w	$BC00,$FC00,$03FF,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$0000,$0000,$FFFF,$FFFF,$00EA,$0716,$FF1D,$FFFF
		dc.w	$4000,$2000,$FFFF,$FFFF,$0000,$0000,$FFFF,$FFFF
		dc.w	$0008,$6007,$000F,$FFFE,$0C1D,$12BF,$ED40,$0000
		dc.w	$987B,$A5DD,$5FFF,$0000,$23B3,$DEFF,$FD10,$0010
		dc.w	$7FC0,$7FFF,$FFC0,$7FC0,$0090,$DA69,$0596,$E000
		dc.w	$1B51,$BFFA,$4205,$0200,$558C,$A0FD,$5F02,$0000
		dc.w	$6400,$BA00,$6600,$00F8,$0002,$0002,$0005,$0000
		dc.w	$7208,$CC26,$7C08,$40DF,$0000,$0018,$0000,$FFFF
		dc.w	$0078,$0000,$007F,$FFFF,$7000,$7001,$000E,$FFFF
		dc.w	$20FF,$D3FF,$1C00,$FFFF,$F3FF,$FFFF,$0000,$FFFF
		dc.w	$FFFF,$FFFF,$0000,$FFFF,$E3F1,$F80F,$1C0C,$FFFF
		dc.w	$2FFF,$1FFF,$F000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
		dc.w	$0008,$1304,$000F,$FFFC,$602C,$91BE,$EE41,$0000
		dc.w	$1C00,$21DD,$DFFF,$0000,$7D53,$A7FF,$D810,$0010
		dc.w	$35F8,$77E7,$8DFF,$05E0,$01FA,$FE9A,$0165,$0000
		dc.w	$1751,$7FFA,$8205,$0200,$5E31,$AAFC,$5503,$0000
		dc.w	$9800,$FC00,$B800,$01FF,$0000,$0000,$0000,$FFF8
		dc.w	$4100,$7200,$8E00,$007F,$0007,$0018,$0007,$FFFF
		dc.w	$03C0,$0038,$03C0,$FFFF,$E01F,$E018,$0000,$FFF9
		dc.w	$FF00,$C300,$00FF,$E7FF,$1000,$3E00,$C1FF,$FFFF
		dc.w	$3FFF,$3FFF,$C000,$FFFF,$C439,$E007,$3BC4,$FFFF
		dc.w	$6FFF,$1FFF,$F000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
		dc.w	$0010,$010F,$001F,$FFFC,$87B2,$4E7F,$B180,$0000
		dc.w	$2A80,$502A,$AFFF,$0000,$CAC0,$5FC4,$A003,$0038
		dc.w	$6EB0,$EEFF,$19B0,$08B0,$03A7,$91FF,$8E59,$6000
		dc.w	$86A8,$DFFD,$6202,$0200,$0BD9,$5FFA,$A305,$0300
		dc.w	$5403,$EC00,$DC03,$01FF,$8000,$0000,$8000,$FFFF
		dc.w	$1700,$1800,$0700,$007F,$000F,$0010,$000F,$FFFF
		dc.w	$FFFF,$003F,$FFC0,$FFFF,$0037,$003C,$0008,$FFFD
		dc.w	$DF75,$A28A,$208A,$E78A,$FFC3,$3C70,$000C,$7E7C
		dc.w	$4000,$8000,$BFFF,$BFFF,$0808,$4007,$F7F6,$FFFF
		dc.w	$FFFF,$9FFF,$6000,$FFFF,$FFFF,$FFFF,$0000,$FFFF
		dc.w	$0022,$011D,$003E,$FFFE,$4F8C,$F23F,$0DC0,$0000
		dc.w	$3776,$8880,$777F,$0000,$3700,$BF80,$4001,$007E
		dc.w	$659C,$EDBF,$135F,$011C,$0FF7,$F3F7,$0D9E,$0000
		dc.w	$EDEA,$FFFF,$5540,$0540,$AEE2,$FFF1,$0C0E,$0C00
		dc.w	$281F,$D001,$E81E,$03FF,$C000,$8000,$4000,$FFFF
		dc.w	$0000,$0000,$0000,$E0FF,$000C,$0030,$000F,$FFFF
		dc.w	$FC30,$0030,$FC00,$FFFF,$0077,$006C,$0008,$FFED
		dc.w	$DF75,$A2AA,$208A,$E7AA,$FDD7,$1AE8,$0208,$3FF8
		dc.w	$6BFF,$9400,$9400,$9400,$880C,$4012,$77F3,$7FFF
		dc.w	$EFFF,$A3FF,$5C00,$FFFF,$E495,$E495,$1B6A,$FFFF
		dc.w	$0046,$3138,$007F,$FFFF,$4F98,$E1FC,$1E03,$0000
		dc.w	$0080,$55D5,$AA2A,$0000,$A800,$FE00,$0000,$01FF
		dc.w	$0CAF,$9DBF,$624F,$000F,$D7E5,$EFE5,$D97F,$C000
		dc.w	$F6D5,$FFFF,$96D5,$06D5,$5F65,$FFEB,$5017,$5000
		dc.w	$70FF,$8802,$72FD,$05FF,$AC00,$6000,$8C00,$FFFF
		dc.w	$0000,$0000,$0000,$FFFF,$0001,$0061,$001E,$FFFF
		dc.w	$01C0,$01F0,$F000,$FFFF,$0077,$004C,$0008,$FFCD
		dc.w	$DE75,$A1FA,$218A,$E3FA,$BDD7,$5AE8,$4208,$7FF8
		dc.w	$7BFF,$8400,$8400,$8400,$91D8,$4026,$6E27,$7FFF
		dc.w	$460D,$400D,$B9F2,$F9FF,$2000,$3FFF,$C000,$FFFF
		dc.w	$004D,$6231,$007E,$FFFF,$27A1,$F23A,$0DC5,$8000
		dc.w	$85DD,$27FF,$D800,$0000,$D000,$F000,$0000,$0FFF
		dc.w	$0CA1,$1DBF,$2241,$C001,$7FD9,$9FD9,$767F,$0000
		dc.w	$E25F,$FFFF,$6252,$0252,$FF09,$FF46,$48BB,$4800
		dc.w	$807F,$409C,$8063,$0FFF,$4380,$E800,$0780,$FFFF
		dc.w	$0000,$0000,$0000,$FFFF,$001F,$007F,$0000,$FFFF
		dc.w	$0600,$07C0,$0000,$FFFF,$00F6,$00C9,$0009,$FFC9
		dc.w	$DF07,$2288,$20F8,$E7FB,$BB96,$55A9,$4449,$7FF9
		dc.w	$EBFB,$5404,$1404,$F424,$BE05,$400B,$41FE,$7FFF
		dc.w	$2740,$20B7,$D8B8,$F8BF,$0000,$FFFF,$0000,$FFFF
		dc.w	$009A,$E063,$00FC,$FFFF,$1383,$3A31,$05CF,$C001
		dc.w	$FAAA,$FFFF,$F800,$F800,$8000,$8000,$0000,$7FFF
		dc.w	$01A1,$13BE,$0C41,$E000,$3B91,$3F97,$E5FE,$0000
		dc.w	$DBFF,$FFFF,$4091,$0091,$F854,$FC2E,$23DC,$2000
		dc.w	$4880,$2CFF,$4000,$1FFF,$82E0,$C400,$03E0,$FFFF
		dc.w	$0000,$0000,$0000,$FFFF,$0000,$0020,$0000,$FFFF
		dc.w	$1800,$1E00,$0000,$FFFF,$01F9,$0246,$0200,$FE4F
		dc.w	$DEF6,$2108,$2109,$230F,$6E97,$95A8,$9148,$9FF9
		dc.w	$E9DB,$D624,$1604,$F6B4,$F008,$0007,$0FF7,$7FFF
		dc.w	$C369,$C093,$3C94,$FC97,$6EB2,$FFFF,$0000,$FFFF
		dc.w	$0144,$2486,$01F8,$FFFF,$0C20,$1F7C,$0080,$E003
		dc.w	$FF74,$FFFF,$FF00,$FF03,$7C00,$8000,$7C00,$FFFF
		dc.w	$0042,$027C,$018F,$FC00,$C746,$DF62,$F9FD,$0000
		dc.w	$1376,$FFFF,$8000,$0000,$E1AA,$F275,$0DEE,$0000
		dc.w	$0000,$1E00,$0000,$9FFF,$0218,$0800,$07F8,$FFFF
		dc.w	$0000,$0000,$0000,$FFFF,$0003,$0023,$0000,$FFFF
		dc.w	$E000,$F800,$0000,$FFFF,$01F8,$0607,$0600,$FE0F
		dc.w	$DFFC,$2004,$2003,$A00F,$7EB7,$8D08,$8148,$9FE9
		dc.w	$E969,$D6B6,$1606,$F7FE,$1018,$E007,$EFE7,$FFFF
		dc.w	$016D,$C091,$FE92,$FF93,$A005,$E007,$0000,$FFFF
		dc.w	$0098,$491C,$01E0,$FFFF,$1304,$0FF0,$100C,$F003
		dc.w	$6380,$7F80,$6380,$E3FF,$1FF0,$E000,$1FF0,$FFFF
		dc.w	$1C6C,$0070,$1C3F,$FFA0,$800E,$1656,$FFF9,$0000
		dc.w	$6377,$FFFF,$0000,$0000,$0E91,$9178,$6EF1,$0000
		dc.w	$0060,$807F,$0780,$7FFF,$0A0C,$9800,$07FC,$FFFF
		dc.w	$0000,$0000,$0000,$FFFF,$001F,$003F,$0000,$FFFF
		dc.w	$8000,$E000,$0000,$FFFF,$09F0,$060F,$0600,$F61F
		dc.w	$DF7C,$2005,$2083,$A1CF,$FEB5,$0D0A,$014A,$1FEB
		dc.w	$FAFA,$E5B5,$0405,$F7FD,$3830,$C00F,$C7CF,$FFFF
		dc.w	$00FD,$FE01,$FF02,$FFFB,$C000,$C000,$0000,$FFFF
		dc.w	$0320,$D038,$03C0,$FFFF,$72C6,$0FE9,$7816,$F800
		dc.w	$70C0,$7FC0,$7000,$F03F,$00FF,$1F00,$00FF,$FFFF
		dc.w	$FE1F,$0024,$FE3B,$FFC0,$2518,$4089,$FFF6,$0000
		dc.w	$5BB0,$FFF8,$0007,$0000,$7548,$8BB4,$7778,$0000
		dc.w	$01CF,$000F,$01F0,$7FFF,$94C2,$F000,$0FFE,$FFFF
		dc.w	$0000,$0000,$0000,$FFFF,$0000,$001F,$0000,$FFFF
		dc.w	$0000,$8000,$0000,$FFFF,$0DD0,$322F,$3220,$F23F
		dc.w	$5E5C,$A025,$21A3,$E3EF,$FEB5,$090A,$014A,$1DEB
		dc.w	$FFF8,$E1B7,$0007,$F3FF,$1FF8,$E007,$E007,$FFFF
		dc.w	$000C,$FFF0,$FFF2,$FFFF,$6800,$7800,$0000,$FFFF
		dc.w	$0441,$4070,$0781,$FFFF,$8143,$7FE5,$FC1A,$FC00
		dc.w	$3840,$3FC0,$3800,$F83F,$0000,$00FF,$0000,$FFFF
		dc.w	$085F,$F87D,$0062,$E780,$D979,$801B,$7FE4,$0000
		dc.w	$8603,$E444,$1BBB,$0000,$AA84,$5DC2,$BB84,$0001
		dc.w	$00F0,$0000,$00FF,$FFFF,$E1CF,$E000,$1FFF,$FFFF
		dc.w	$8000,$0000,$8000,$FFFF,$0000,$0004,$0000,$FFFF
		dc.w	$0000,$0000,$0000,$FFFF,$5DD0,$A22F,$A220,$A23F
		dc.w	$3E5E,$C027,$01A1,$E3EF,$FF15,$00AA,$00EA,$08EA
		dc.w	$FDF4,$42AB,$020B,$E3FB,$220C,$C1F3,$DDF3,$FFFF
		dc.w	$040C,$FBF0,$FBF0,$FFFF,$0C80,$0F80,$0000,$FFFF
		dc.w	$0882,$00E1,$0F03,$FFFF,$00A1,$FFF6,$FE09,$FE00
		dc.w	$0FE0,$8020,$EFC0,$7FDF,$0000,$0000,$0000,$FFFF
		dc.w	$10B2,$38B2,$00CD,$C700,$7D78,$697F,$9680,$0000
		dc.w	$1FDB,$8425,$1BDB,$4000,$D4C4,$EE22,$DCC4,$0011
		dc.w	$01F8,$0000,$01FF,$FFFF,$C030,$0030,$FFCF,$FFFF
		dc.w	$6000,$0000,$E000,$FFFF,$0000,$0000,$0000,$FFFF
		dc.w	$0001,$0006,$0006,$FFFE,$DDD0,$222F,$2220,$223F
		dc.w	$3F56,$C12B,$00A9,$E3EB,$FFBF,$0840,$0040,$1C40
		dc.w	$FEFB,$0104,$0104,$4117,$0C0F,$E3F0,$F3F0,$FFFF
		dc.w	$FC1D,$03E1,$03E2,$FFFF,$0060,$87E0,$0000,$FFFF
		dc.w	$088C,$00E3,$0F0F,$FFFF,$0F46,$F0E9,$FF16,$FF00
		dc.w	$C020,$4000,$87F0,$3FFF,$0000,$0000,$0000,$FFFF
		dc.w	$3956,$7F76,$1989,$9800,$9AC0,$9AF8,$6500,$0007
		dc.w	$2E55,$1DEE,$3BDD,$8000,$D220,$EF10,$DE20,$000B
		dc.w	$07F0,$0000,$07FF,$FFFF,$50C7,$00E0,$FF1F,$FFFF
		dc.w	$BE00,$0000,$EE00,$FFFF,$0000,$0000,$0000,$FFFF
		dc.w	$0009,$0016,$0016,$FFF6,$DDD2,$222F,$2220,$223F
		dc.w	$1FD0,$E1AF,$002F,$F3EF,$FFBB,$1844,$0044,$3C44
		dc.w	$BEFF,$4100,$4100,$4107,$E10F,$1EF0,$1EF0,$FFFF
		dc.w	$F8F9,$0701,$0706,$FFFF,$01B0,$81F0,$0000,$FFFF
		dc.w	$1108,$01C7,$1E0F,$FFFF,$3F1B,$C0FC,$FF03,$FF80
		dc.w	$61C8,$83C8,$6032,$1FFF,$0000,$0000,$0000,$FFFF
		dc.w	$1CB9,$3EF9,$1F06,$DC00,$0000,$FFC0,$0000,$003F
		dc.w	$2D75,$1CEE,$39DD,$8000,$E120,$F080,$E120,$001F
		dc.w	$0FE0,$0000,$0FFF,$FFFF,$951C,$01C0,$FE3C,$FFFF
		dc.w	$AF80,$2000,$C180,$FFFF,$0000,$0000,$0000,$FFFF
		dc.w	$0159,$00A6,$00A6,$FEA6,$5DD4,$A22F,$A220,$A23F
		dc.w	$1FD5,$E32A,$002A,$F7AA,$FFBF,$1840,$0040,$3C40
		dc.w	$FEFC,$0100,$0103,$010F,$0EF8,$0000,$F107,$FFFF
		dc.w	$3FC3,$C003,$C03C,$FFFF,$01C7,$81C7,$0000,$FFFF
		dc.w	$1113,$A1CC,$1E1F,$FFFF,$EC08,$0FBF,$F000,$FFC0
		dc.w	$B032,$D1FA,$2001,$0FFD,$0000,$0000,$FF80,$FFFF
		dc.w	$0B58,$1DCB,$0E34,$E800,$1C00,$0000,$FFFF,$FFFF
		dc.w	$18AC,$0866,$D0CC,$E600,$6100,$1080,$6100,$067F
		dc.w	$0F81,$0080,$3F7F,$FFFF,$2220,$0300,$FC60,$FFFF
		dc.w	$BFE0,$A800,$1400,$FFFF,$0000,$0000,$0000,$FFFF
		dc.w	$037B,$0484,$0484,$FCA6,$75D8,$8A27,$8A20,$AA2F
		dc.w	$1FF7,$F308,$0008,$FF88,$FF00,$08FF,$00FF,$1DFF
		dc.w	$7EFB,$810B,$8104,$E10F,$F007,$F007,$0FF8,$FFFF
		dc.w	$000E,$000F,$FFF0,$FFFF,$012E,$032E,$0000,$FFFF
		dc.w	$221D,$4387,$3C18,$FFFF,$3004,$FE0D,$0002,$FFF0
		dc.w	$D833,$307B,$C800,$07FC,$0F01,$0001,$FFFF,$FFFF
		dc.w	$0620,$0B0C,$ECF3,$F003,$FFEF,$1FEF,$E010,$FFFF
		dc.w	$9EC4,$080A,$96C4,$E721,$27F8,$11F8,$2600,$8FFF
		dc.w	$0F06,$7F00,$00FF,$FFFF,$4201,$0301,$FC40,$FFFF
		dc.w	$7FF8,$C000,$3E48,$FFFF,$0000,$0000,$0000,$FFFF
		dc.w	$0B7B,$0484,$0484,$F4A6,$75D8,$8A27,$8A20,$AA2F
		dc.w	$0FD7,$F128,$0028,$FBA8,$DFF8,$2007,$2007,$2BFF
		dc.w	$3FF0,$C007,$C008,$F00F,$0FF8,$FFFF,$0000,$FFFF
		dc.w	$FFF8,$FFFE,$0000,$FFFF,$0640,$0F40,$0000,$FFFF
		dc.w	$222A,$438F,$3C30,$FFFF,$0002,$F006,$0001,$FFF8
		dc.w	$7E01,$A831,$5600,$01FE,$FFFC,$8501,$7FFF,$7FFC
		dc.w	$7DE3,$8630,$F9CF,$600F,$F1FE,$01FE,$1E01,$FFFF
		dc.w	$10F4,$7042,$6EB4,$8F39,$0C0F,$6007,$4C78,$9FFF
		dc.w	$83D9,$8FC0,$003F,$FFFF,$8442,$0603,$F8C0,$FFFF
		dc.w	$223C,$6000,$1FEC,$FFFF,$0000,$0000,$0000,$FFFF
		dc.w	$1A7B,$0584,$0584,$E5A6,$01DA,$0027,$1E20,$FE2F
		dc.w	$0FD7,$F828,$0028,$FD28,$5DE0,$A01F,$A21F,$A3FF
		dc.w	$3826,$C066,$C000,$FFFF,$0000,$1FFE,$01FC,$FFFF
		dc.w	$5A00,$7FF8,$0000,$FFFF,$1B70,$1FF0,$0000,$FFFF
		dc.w	$4424,$870D,$7832,$FFFF,$0000,$F103,$00F0,$FFFC
		dc.w	$FF81,$D483,$2B00,$007E,$B0A0,$8F60,$7DFF,$70BC
		dc.w	$F707,$CC07,$F3F8,$C07F,$FFF4,$FFC4,$003B,$FFFF
		dc.w	$ECE7,$ED8A,$116D,$1E71,$C001,$4000,$8007,$BFFF
		dc.w	$F0F3,$0300,$F0FF,$FFFF,$3880,$3C00,$C080,$FFFF
		dc.w	$221F,$6000,$1FFF,$FFFF,$0000,$0000,$0000,$FFFF
		dc.w	$3A78,$0584,$0584,$C5A7,$00DB,$0027,$0720,$FF2F
		dc.w	$8ED7,$F928,$0128,$FD28,$5C3F,$A200,$A1C0,$A3FF
		dc.w	$C401,$0113,$3800,$FFFF,$403D,$C7CE,$07C2,$FFFF
		dc.w	$1413,$1E93,$0000,$FFFF,$0408,$0C08,$0000,$FFFF
		dc.w	$444B,$8718,$7867,$FFFF,$E098,$1603,$E1F8,$FFFC
		dc.w	$37C0,$5B00,$A4C0,$003F,$C202,$CBC3,$3FBF,$323E
		dc.w	$6E00,$8800,$F600,$01FF,$0070,$0000,$007F,$FFFF
		dc.w	$431D,$031C,$FCE3,$FCE3,$F800,$8000,$7F80,$FFFF
		dc.w	$1C1E,$0078,$FC07,$FFFF,$C000,$F800,$0180,$FFFF
		dc.w	$7222,$C000,$3FFE,$FFFF,$A000,$A000,$4000,$FFFF
		dc.w	$3A78,$C580,$C580,$C5A7,$00C8,$0037,$0730,$FF3F
		dc.w	$0ED6,$FD28,$0128,$FF29,$0200,$1200,$007F,$FFFF
		dc.w	$0408,$0008,$F800,$FFFF,$43FF,$CF31,$0000,$FFFF
		dc.w	$8800,$0C40,$0000,$FFFF,$0410,$0610,$0000,$FFFF
		dc.w	$489C,$8E20,$70DF,$FFFF,$01F8,$1803,$E7F8,$FFFC
		dc.w	$CFA0,$2486,$DB60,$001F,$0240,$00EF,$3FDF,$F040
		dc.w	$D800,$0000,$F800,$07FF,$01F8,$0000,$03FF,$FFFF
		dc.w	$9F1C,$0000,$E1FF,$FFFF,$0600,$0600,$F9F8,$FFFF
		dc.w	$0385,$0019,$0F86,$FFFF,$8002,$E01F,$0300,$FFFF
		dc.w	$BE42,$8000,$7FFE,$FFFF,$B000,$B007,$4007,$FFFF
		dc.w	$3800,$C7F0,$C600,$C7FF,$01FF,$01FF,$0600,$FFFF
		dc.w	$C802,$C803,$0000,$FFFF,$0980,$0980,$000F,$FFFF
		dc.w	$F884,$00CC,$0000,$FFFF,$20FF,$73FE,$0000,$FFFF
		dc.w	$8C04,$0E0C,$0000,$FFFF,$0A90,$0FF8,$0000,$FFFF
		dc.w	$8883,$0E43,$F0BC,$FFFF,$00F1,$CC03,$33F8,$FFFC
		dc.w	$D082,$2450,$DFB3,$000F,$8380,$807F,$03FF,$FC00
		dc.w	$E000,$0000,$E000,$1FFF,$10F7,$0000,$1FCF,$FFFF
		dc.w	$FCFC,$0000,$83FF,$FFFF,$01F7,$01F0,$FE0F,$FFFF
		dc.w	$0060,$0007,$01E0,$FFFF,$0405,$CC0D,$0002,$FFFF
		dc.w	$1FC4,$0000,$FFFC,$FFFF,$9000,$F00F,$000F,$FFFF
		dc.w	$2000,$DFF0,$C000,$DFFF,$037F,$037F,$0400,$FFFF
		dc.w	$F001,$F401,$0000,$FFFF,$0010,$0870,$0000,$FFFF
		dc.w	$004A,$00CE,$0000,$FFFF,$0006,$00F8,$0000,$FFFF
		dc.w	$1248,$1FCC,$0000,$FFFF,$2E0C,$7E3C,$0000,$FFFF
		dc.w	$9100,$1C7F,$E180,$FFFF,$1811,$860B,$79F0,$FFFC
		dc.w	$2102,$D368,$2EDB,$0007,$80E3,$8000,$00FF,$FF00
		dc.w	$0000,$8000,$8001,$7FFF,$31FF,$0000,$FF00,$FFFF
		dc.w	$E0E8,$0000,$7FFF,$FFFF,$E021,$0020,$FFDF,$FFFF
		dc.w	$F018,$0000,$F078,$FFFF,$0802,$9806,$0001,$FFFF
		dc.w	$7398,$7001,$8FF8,$FFFF,$0800,$981F,$001F,$FFFF
		dc.w	$01C0,$FFE0,$C000,$FFFF,$06FE,$06FE,$0001,$FFFF
		dc.w	$F801,$FB01,$0000,$FFFF,$8028,$843C,$0000,$FFFF
		dc.w	$8084,$8186,$0000,$FFFF,$0000,$1000,$0000,$FFFF
		dc.w	$1811,$7871,$0000,$FFFF,$5000,$F800,$0000,$FFFF
		dc.w	$9103,$1CFF,$E100,$FFFF,$2000,$8101,$60F0,$FFFE
		dc.w	$0488,$2BB4,$D76D,$0003,$8000,$8000,$0000,$FFFF
		dc.w	$0002,$0000,$003F,$FFFF,$37FE,$0000,$FE7B,$FFFF
		dc.w	$001E,$0000,$FFFF,$FFFF,$3FFE,$001E,$FFE1,$FFFF
		dc.w	$FE07,$0000,$FE0F,$FFFF,$0002,$200E,$0001,$FFFF
		dc.w	$9041,$F043,$0FA0,$FFFF,$0800,$9C3F,$0000,$FFFF
		dc.w	$0FC0,$FFC0,$0000,$FFFF,$04FC,$07FD,$0002,$FFFF
		dc.w	$6E80,$EE81,$1000,$FFFF,$8414,$841C,$0000,$FFFF
		dc.w	$1001,$3201,$0000,$FFFF,$A000,$E001,$0000,$FFFF
		dc.w	$4030,$C039,$0000,$FFFF,$A001,$F001,$0000,$FFFF
		dc.w	$20C0,$38C3,$C03C,$FFFF,$4040,$00E0,$C000,$FFFF
		dc.w	$0A04,$D9C8,$2FB5,$0803,$8000,$8000,$0000,$FFFF
		dc.w	$001F,$0000,$03FF,$FFFF,$FFFF,$0000,$F7FF,$FFFF
		dc.w	$0003,$0000,$FC03,$FFFF,$1FC4,$0004,$FFFB,$FFFF
		dc.w	$4780,$0780,$F801,$FFFF,$C001,$0003,$C000,$FFFF
		dc.w	$8B82,$FB87,$0440,$FFFF,$0000,$343F,$0000,$FFFF
		dc.w	$0E00,$FE00,$0000,$FFFF,$0C3F,$0F3F,$00C0,$FFFF
		dc.w	$0E01,$6E81,$9000,$FFFF,$0840,$C870,$0000,$FFFF
		dc.w	$2000,$3000,$0000,$FFFF,$40A0,$60E0,$0000,$FFFF
		dc.w	$0048,$1C7C,$0000,$FFFF,$D000,$F800,$0000,$FFFF
		dc.w	$2130,$393C,$C0C3,$FFFF,$0000,$0000,$8000,$FFFF
		dc.w	$41C5,$4061,$33DC,$8C43,$8000,$8000,$0000,$FFFF
		dc.w	$7E7F,$0000,$7FC0,$FFFF,$FE00,$0000,$3FFC,$FFFF
		dc.w	$0000,$0000,$0000,$FFFF,$0FD8,$0018,$0FE7,$FFFF
		dc.w	$2180,$2180,$DE60,$FFFF,$3800,$5803,$2700,$FFFF
		dc.w	$0682,$FF8B,$0044,$FFFF,$0000,$7C3F,$0000,$FFFF
		dc.w	$0000,$FC00,$0000,$FFFF,$19DE,$1FDE,$0021,$FFFF
		dc.w	$F700,$FF41,$0000,$FFFF,$90A2,$98E2,$0000,$FFFF
		dc.w	$0000,$0400,$0000,$FFFF,$2044,$3064,$0000,$FFFF
		dc.w	$A580,$F7E0,$0000,$FFFF,$2000,$3C00,$0000,$FFFF
		dc.w	$00CF,$F0FF,$0300,$FFFF,$0000,$0008,$0000,$FFFF
		dc.w	$50C1,$6061,$33DA,$8C47,$0010,$0000,$001F,$FFFF
		dc.w	$00FF,$0000,$FFC0,$FFFF,$EF00,$0000,$7FC0,$FFFF
		dc.w	$0000,$0000,$0000,$FFFF,$018D,$000D,$01F2,$FFFF
		dc.w	$FF3C,$FF3C,$00C0,$FFFF,$041F,$1C00,$03FF,$FFFF
		dc.w	$F804,$078E,$F840,$FFFF,$0000,$6400,$0000,$FFFF
		dc.w	$0000,$0000,$0000,$FFFF,$3248,$3FC8,$0037,$FFFF
		dc.w	$4F41,$7F43,$8000,$FFFF,$0840,$1CE0,$0000,$FFFF
		dc.w	$0000,$0C00,$0000,$FFFF,$5000,$7000,$0000,$FFFF
		dc.w	$4224,$6336,$0000,$FFFF,$0E00,$1E00,$0000,$FFFF
		dc.w	$0304,$E31C,$0CE0,$FFFF,$0008,$001E,$0000,$FFFF
		dc.w	$3133,$20EB,$1198,$CE07,$0000,$0000,$07FF,$FFFF
		dc.w	$5DF4,$0000,$FFFF,$FFFF,$0000,$0000,$FC00,$FFFF
		dc.w	$0000,$0000,$0000,$FFFF,$0010,$0000,$007F,$FFFF
		dc.w	$F1F7,$F1F7,$0E08,$FFFF,$0066,$07E0,$001F,$FFFF
		dc.w	$0780,$0042,$FF80,$FFFF,$0000,$6400,$0000,$FFFF
		dc.w	$0000,$0000,$0000,$FFFF,$6062,$7FE2,$001D,$FFFF
		dc.w	$8B00,$FB40,$0400,$FFFF,$8237,$867F,$0000,$FFFF
		dc.w	$0C00,$0C08,$0000,$FFFF,$0200,$8201,$0000,$FFFF
		dc.w	$A202,$FE06,$0000,$FFFF,$04A0,$0FA0,$0000,$FFFF
		dc.w	$0C10,$8C18,$13C0,$FFFF,$000E,$003E,$0000,$FFFF
		dc.w	$0153,$60C3,$51B0,$8E0F,$0006,$0000,$7FFF,$FFFF
		dc.w	$0820,$0000,$8FFF,$FFFF,$0000,$0000,$C000,$FFFF
		dc.w	$0000,$0000,$000F,$FFFF,$0008,$0000,$E00F,$FFFF
		dc.w	$1379,$1379,$EC86,$FFFF,$807B,$83FB,$4004,$FFFF
		dc.w	$0078,$0000,$FFF8,$FFFF,$0000,$2E00,$0000,$FFFF
		dc.w	$0000,$0000,$0000,$FFFF,$8443,$FFC3,$003C,$FFFF
		dc.w	$7D44,$FD46,$0200,$FFFF,$000A,$000F,$0000,$FFFF
		dc.w	$9002,$FC12,$0000,$FFFF,$0400,$060E,$0000,$FFFF
		dc.w	$00A0,$01E0,$0000,$FFFF,$0B17,$0FB7,$0000,$FFFF
		dc.w	$1C48,$0048,$7F80,$FFFF,$001E,$003E,$0000,$FFFF
		dc.w	$1063,$1053,$61A0,$8E0F,$0000,$0000,$7FF0,$FFFF
		dc.w	$0000,$0000,$0FFC,$FFFF,$0000,$0000,$0000,$FFFF
		dc.w	$000E,$0000,$01FF,$FFFF,$C000,$C000,$380F,$FFFF
		dc.w	$1CFE,$1FFF,$E000,$FFFF,$00C3,$CFC3,$303C,$FFFF
		dc.w	$FE06,$8000,$7FFE,$FFFF,$0000,$0100,$0000,$FFFF
		dc.w	$0001,$0001,$0000,$FFFF,$837C,$F3FF,$0C00,$FFFF
		dc.w	$9F42,$9F4E,$6000,$FFFF,$2000,$3000,$0000,$FFFF
		dc.w	$6C04,$FC16,$0000,$FFFF,$0020,$0070,$0000,$FFFF
		dc.w	$0018,$0038,$0000,$FFFF,$0480,$0F86,$0000,$FFFF
		dc.w	$6580,$1980,$FE00,$FFFF,$0004,$0024,$0000,$FFFF
		dc.w	$04C3,$09E3,$2700,$D01F,$0000,$0000,$0000,$FFFF
		dc.w	$0100,$0000,$3F00,$FFFF,$0000,$0000,$0000,$FFFF
		dc.w	$0003,$0003,$1FFC,$FFFF,$F1C0,$F1C0,$0E3F,$FFFF
		dc.w	$3465,$3FFF,$C000,$FFFF,$C781,$FF80,$007F,$FFFF
		dc.w	$F0E3,$0002,$FFFD,$FFFF,$C000,$0180,$C000,$FFFF
		dc.w	$0001,$0001,$0000,$FFFF,$0181,$E1FF,$1E00,$FFFF
		dc.w	$9E08,$9E08,$6000,$FFFF,$0000,$2000,$0000,$FFFF
		dc.w	$5002,$7816,$0000,$FFFF,$00C0,$00F0,$0000,$FFFF
		dc.w	$0020,$0030,$0000,$FFFF,$0560,$07E0,$0000,$FFFF
		dc.w	$C380,$3C00,$FFFF,$FFFF,$00F1,$0001,$C080,$FFFF
		dc.w	$0103,$06AB,$0300,$F87F,$0000,$0000,$0007,$FFFF
		dc.w	$0000,$0000,$E000,$FFFF,$0000,$0000,$0000,$FFFF
		dc.w	$03FF,$0000,$3FFF,$FFFF,$F9D0,$79D1,$862E,$FFFF
		dc.w	$3FF7,$3FFF,$C000,$FFFF,$BFC0,$FFC0,$003F,$FFFF
		dc.w	$0FF6,$0007,$FCF8,$FFFF,$2000,$81C0,$7800,$FFFF
		dc.w	$0002,$0003,$0000,$FFFF,$0741,$E7FF,$1800,$FFFF
		dc.w	$2600,$3E00,$C000,$FFFF,$0000,$0200,$0000,$FFFF
		dc.w	$0000,$0002,$0000,$FFFF,$8010,$C01E,$0000,$FFFF
		dc.w	$01AC,$01FE,$0000,$FFFF,$0190,$01F0,$0000,$FFFF
		dc.w	$0000,$0000,$FFF0,$FFFF,$0FFF,$0000,$0800,$FFFF
		dc.w	$C001,$030B,$3000,$FCFF,$0000,$0000,$007C,$FFFF
		dc.w	$0000,$0000,$0000,$FFFF,$0000,$0000,$0000,$FFFF
		dc.w	$0E7F,$0000,$3FFF,$FFFF,$E117,$011F,$FEE0,$FFFF
		dc.w	$722C,$FFEF,$0010,$FFFF,$F8FB,$F8FB,$0704,$FFFF
		dc.w	$3FF9,$0001,$FC3E,$FFFF,$B000,$B8E0,$4700,$FFFF
		dc.w	$000C,$000F,$0000,$FFFF,$3A81,$FFFF,$0000,$FFFF
		dc.w	$7E01,$7E07,$8000,$FFFF,$0100,$0180,$0000,$FFFF
		dc.w	$0000,$0008,$0000,$FFFF,$0003,$0003,$0000,$FFFF
		dc.w	$5552,$FFF6,$0000,$FFFF,$0068,$0078,$0000,$FFFF
		dc.w	$FF83,$FF9C,$0060,$FFFF,$FFFC,$0000,$001F,$FFFF
		dc.w	$F801,$F81B,$0400,$FFFF,$0000,$0000,$0000,$FFFF
		dc.w	$0000,$0000,$0000,$FFFF,$0000,$0000,$0000,$FFFF
		dc.w	$02E6,$0000,$1FFF,$FFFF,$03DE,$03FF,$FC00,$FFFF
		dc.w	$2C10,$FFFF,$0000,$FFFF,$2E1C,$EE1C,$11E3,$FFFF
		dc.w	$0FC0,$0000,$FC3F,$FFFF,$20F8,$33F8,$C000,$FFFF
		dc.w	$0010,$001F,$0000,$FFFF,$15E6,$FDFF,$0200,$FFFF
		dc.w	$6202,$6203,$9C00,$FFFF,$0084,$0186,$0000,$FFFF
		dc.w	$0000,$0000,$0000,$FFFF,$C000,$E000,$0000,$FFFF
		dc.w	$2A80,$7EC0,$0000,$FFFF,$0018,$0038,$0000,$FFFF
		dc.w	$001F,$0FE0,$0018,$FFFF,$FFF3,$0003,$E1FC,$FFFF
		dc.w	$0219,$FE3F,$0100,$FFFF,$0000,$8000,$0000,$FFFF
		dc.w	$0000,$0000,$0000,$FFFF,$0000,$0000,$0000,$FFFF
		dc.w	$0000,$0000,$07FF,$FFFF,$DE18,$1EFF,$E100,$FFFF
		dc.w	$1390,$FBFF,$0400,$FFFF,$601A,$FE1A,$01E5,$FFFF
		dc.w	$1FF0,$0000,$FFFF,$FFFF,$9004,$1CFC,$E000,$FFFF
		dc.w	$0010,$001F,$0000,$FFFF,$043E,$FC3E,$03C1,$FFFF
		dc.w	$0F02,$0F02,$F000,$FFFF,$8006,$8006,$0000,$FFFF
		dc.w	$0000,$0002,$0000,$FFFF,$2000,$6000,$0000,$FFFF
		dc.w	$0C50,$3CF0,$0000,$FFFF,$0010,$0018,$0000,$FFFF
		dc.w	$0FFF,$1000,$0FFF,$FFFF,$800C,$000F,$FFF0,$FFFF
		dc.w	$0191,$03BB,$0000,$FFFF,$0000,$8000,$0000,$FFFF
		dc.w	$0000,$0000,$0000,$FFFF,$0000,$0000,$0000,$FFFF
		dc.w	$0070,$0000,$01FF,$FFFF,$7970,$79FF,$8600,$FFFF
		dc.w	$147A,$FCFE,$0301,$FFFF,$E0FD,$FFFD,$0002,$FFFF
		dc.w	$887A,$8000,$7FFF,$FFFF,$9822,$1C76,$E000,$FFFF
		dc.w	$0020,$003F,$0000,$FFFF,$062F,$BE2F,$41D0,$FFFF
		dc.w	$9980,$DF80,$2000,$FFFF,$0000,$0008,$0000,$FFFF
		dc.w	$2000,$3002,$0000,$FFFF,$4000,$4000,$0000,$FFFF
		dc.w	$1020,$1C60,$0000,$FFFF,$0010,$0030,$0000,$FFFF
		dc.w	$1FFF,$67F1,$180E,$FFFF,$FFF0,$FFFC,$0000,$FFFF
		dc.w	$0081,$0193,$0000,$FFFF,$0000,$8000,$0000,$FFFF
		dc.w	$0000,$0000,$0000,$FFFF,$0000,$0000,$0000,$FFFF
		dc.w	$0067,$0001,$00FE,$FFFF,$F9F0,$FFFF,$0000,$FFFF
		dc.w	$0C9E,$FCFE,$0301,$FFFF,$D822,$FFFE,$0001,$FFFF
		dc.w	$C3BF,$C380,$3C7F,$FFFF,$0C11,$0E33,$F000,$FFFF
		dc.w	$0040,$007F,$0000,$FFFF,$3630,$BE7F,$4180,$FFFF
		dc.w	$47E0,$FFE0,$0000,$FFFF,$0000,$2000,$0000,$FFFF
		dc.w	$1800,$3800,$0000,$FFFF,$0000,$0000,$0000,$FFFF
		dc.w	$0500,$3F00,$0000,$FFFF,$00A0,$00E0,$0000,$FFFF
		dc.w	$7C00,$87FF,$7800,$FFFF,$0000,$FFFF,$0000,$FFFF
		dc.w	$0080,$F193,$0000,$FFFF,$0000,$8000,$0000,$FFFF
		dc.w	$0000,$0000,$0000,$FFFF,$0000,$0000,$0000,$FFFF
		dc.w	$000F,$0000,$003F,$FFFF,$F3AC,$7FBF,$8040,$FFFF
		dc.w	$1EE3,$FFFF,$0000,$FFFF,$0021,$FFFF,$0000,$FFFF
		dc.w	$FC07,$FC00,$03FF,$FFFF,$0408,$0619,$F800,$FFFF
		dc.w	$8080,$80FF,$0000,$FFFF,$CC01,$CCFF,$3300,$FFFF
		dc.w	$C650,$FE50,$01A0,$FFFF,$0000,$0040,$0000,$FFFF
		dc.w	$0201,$0F09,$0000,$FFFF,$0000,$8000,$0000,$FFFF
		dc.w	$2080,$F180,$0000,$FFFF,$0300,$0380,$0000,$FFFF
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000

buffer	ds.w	1024
save_usp	ds.w	2
file1	dc.b	'DISC.PRG',0,0
file2	dc.b	'OXXONIAN.PRG',0,0
file3	dc.b	'RESET.PRG',0,0
file4	dc.b	'TIT1.PRG',0,0
file5	dc.b	0,0
file6	ds.w	1024
screen	ds.w	2
zuend	end
