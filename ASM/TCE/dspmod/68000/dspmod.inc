
				offset

SampPtr:		ds.l 1			;aktuelle SamplePos
SampEnd:		ds.l 1			;Ende
RepStart:		ds.l 1
RepLen:			ds.l 1
SampPtrFrac:	ds.l 1
SampPer:		ds.w 1
SampVol:		ds.w 1
SampMainVol:	ds.w 1
SampPos:		ds.w 1
SizeOfSamp_:

				text
				