#ifndef	INCLUDED_EXCEPT_H
#define	INCLUDED_EXCEPT_H

/* ###################################################################################
#  INCLUDES
################################################################################### */

#include	<GODLIB\BASE\BASE.H>


/* ###################################################################################
#  ENUMS
################################################################################### */



/* ###################################################################################
#  STRUCTS
################################################################################### */



/* ###################################################################################
#  PROTOTYPES
################################################################################### */

void	Except_Init( void );
void	Except_DeInit( void );

void	Except_Crash( void );


/* ################################################################################ */

#endif	/* INCLUDED_EXCEPT_H */