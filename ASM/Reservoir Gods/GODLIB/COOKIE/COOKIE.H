#ifndef	INCLUDED_COOKIE_H
#define	INCLUDED_COOKIE_H

/* ###################################################################################
#  INCLUDES
################################################################################### */

#include	<GODLIB\BASE\BASE.H>


/* ###################################################################################
#  DEFINES
################################################################################### */

#define	dCOOKIEJAR_BASE	0x5A0L


/* ###################################################################################
#  STRUCTS
################################################################################### */

typedef struct
{
	U32	Cookie;
	U32	Value;
} sCookie;


/* ###################################################################################
#  PROTOTYPES
################################################################################### */

U8			CookieJar_Exists( void );
U8			CookieJar_CookieExists( const U32 aCookie );
sCookie *	CookieJar_GetpCookie(   const U32 aCookie );
U32			CookieJar_GetCookieValue(    const U32 aCookie );
void		CookieJar_SetCookieValue(    const U32 aCookie, const U32 aValue );


/* ################################################################################ */

#endif	/* INCLUDED_COOKIE_H */