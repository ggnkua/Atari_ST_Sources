#ifndef	INCLUDED_DEBUG_H
#define	INCLUDED_DEBUG_H

/* ###################################################################################
#  INCLUDES
################################################################################### */

#include	<GODLIB\BASE\BASE.H>

/* ###################################################################################
#  DEFINES
################################################################################### */

#ifdef	dDEBUG

#define	Debug_Action( aAction )	aAction

#else

#define	Debug_Action( aAction )

#endif


/* ################################################################################ */

#endif	/*	INCLUDED_DEBUG_H	*/