#ifndef	INCLUDED_SCREENGRAB_H
#define	INCLUDED_SCREENGRAB_H

/* ###################################################################################
#  INCLUDES
################################################################################### */

#include	<GODLIB\BASE\BASE.H>



/* ###################################################################################
#  DEFINES
################################################################################### */


/* ###################################################################################
#  STRUCTS
################################################################################### */


/* ###################################################################################
#  PROTOTYPES
################################################################################### */

void	ScreenGrab_Init( void );
void	ScreenGrab_DeInit( void );

void	ScreenGrab_Enable( void );
void	ScreenGrab_Disable( void );

void	ScreenGrab_SetKeyIndex( const U8 aIndex );
void	ScreenGrab_SetDirectory( const char * apDirectory );


/* ################################################################################ */

#endif	/*	INCLUDED_SCREENGRAB_H */