#ifndef	INCLUDED_GOD_H
#define	INCLUDED_GOD_H

/* ###################################################################################
#  INCLUDES
################################################################################### */

#include	<GODLIB\BASE\BASE.H>

#include	<GODLIB\PICTYPES\CANVAS.H>


/* ###################################################################################
#  STRUCTS
################################################################################### */

typedef	struct
{
	U16	ID;
	U16	Width;
	U16	Height;
} sGodHeader;


typedef struct
{
	sGodHeader	Header;
	U16			Pixels[ 1 ];
} sGod;


/* ###################################################################################
#  PROTOTYPES
################################################################################### */

sGod *		God_FromCanvas( sCanvas * apCanvas );
sCanvas *	God_ToCanvas( sGod * apGod );


/* ################################################################################ */

#endif	/*	INCLUDED_GOD_H */