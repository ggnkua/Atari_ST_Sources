#ifndef	INCLUDED_IMG_H
#define	INCLUDED_IMG_H

/* ###################################################################################
#  INCLUDES
################################################################################### */

#include	<GODLIB\BASE\BASE.H>


/* ###################################################################################
#  STRUCTS
################################################################################### */

typedef	struct
{
	U16	Version;
	U16	HeaderLength;
	U16	PlaneCount;
	U16	PatternLength;
	U16	PixelWidth;
	U16	PixelHeight;
	U16	Width;
	U16	Height;
} sImgHeader;


/* ################################################################################ */

#endif	/*	INCLUDED_IMG_H */