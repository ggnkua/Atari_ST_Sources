#ifndef	INCLUDED_MAC_H
#define	INCLUDED_MAC_H

/* ###################################################################################
#  INCLUDES
################################################################################### */

#include	<GODLIB\BASE\BASE.H>


/* ###################################################################################
#  STRUCTS
################################################################################### */

typedef	struct
{
	U32	Version;
} sMacHeader;


typedef	struct
{
	U8	Brush[ 38 ][ 8 ];
} sMacBrushes;


/* ################################################################################ */

#endif	/*	INCLUDED_MAC_H */