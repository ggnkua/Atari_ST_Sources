#ifndef	INCLUDED_ANI_H
#define	INCLUDED_ANI_H

/* ###################################################################################
#  INCLUDES
################################################################################### */

#include	<GODLIB\BASE\BASE.H>


/* ###################################################################################
#  DEFINES
################################################################################### */

#define	dANI_MAGIC	0xBABEEBEA


/* ###################################################################################
#  STRUCTS
################################################################################### */

typedef struct
{
	U32	Magic;
	U16	Width;
	U16	Height;
	U16	Size;
	U16	X;
	U16	Y;
	U16	FrameCount;
	U16	AnimSpeed;
	U32	Reserved;
} sAniHeader;



/* ################################################################################ */

#endif	/*	INCLUDED_ANI_H */