#ifndef	INCLUDED_RGB_H
#define	INCLUDED_RGB_H

/* ###################################################################################
#  INCLUDES
################################################################################### */

#include	<GODLIB\BASE\BASE.H>


/* ###################################################################################
#  STRUCTS
################################################################################### */

typedef	struct
{
	U16	Resolution
	U16	Palette0[ 16 ];
	U16	RedPlane[ 16000 ];
	U16	Palette1[ 16 ];
	U16	GreenPlane[ 16000 ];
	U16	Palette2[ 16 ];
	U16	BluePlane[ 16000 ];
} sRgb;


/* ################################################################################ */

#endif	/*	INCLUDED_RGB_H */