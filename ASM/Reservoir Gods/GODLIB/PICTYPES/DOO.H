#ifndef	INCLUDED_DOO_H
#define	INCLUDED_DOO_H

/* ###################################################################################
#  INCLUDES
################################################################################### */

#include	<GODLIB\BASE\BASE.H>


/* ###################################################################################
#  STRUCTS
################################################################################### */

typedef	struct
{
	U16	Pixels[ 16000 ];
} sDoo;


/* ################################################################################ */

#endif	/*	INCLUDED_DOO_H */