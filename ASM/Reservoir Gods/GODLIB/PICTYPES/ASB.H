#ifndef	INCLUDED_ASB_H
#define	INCLUDED_ASB_H

/* ###################################################################################
#  INCLUDES
################################################################################### */

#include	<GODLIB\BASE\BASE.H>


/* ###################################################################################
#  STRUCTS
################################################################################### */

typedef	struct
{
	U16	FrameCount;
	U16	Reserved;
	U16	Width;
	U16	Height;
	U16	Palette[ 16 ];
} sAsbHeader;


typedef	struct
{
	U16	Width;
	U16	Height;
	U16	Reserved;
	U16	Pixels[ 1 ];
} sAsbFrame;


/* ################################################################################ */

#endif	/*	INCLUDED_ASB_H */