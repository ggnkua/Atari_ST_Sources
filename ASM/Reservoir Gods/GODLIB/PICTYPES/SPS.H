#ifndef	INCLUDED_SPS_H
#define	INCLUDED_SPS_H

/* ###################################################################################
#  INCLUDES
################################################################################### */

#include	<GODLIB\BASE\BASE.H>


/* ###################################################################################
#  STRUCTS
################################################################################### */

typedef	struct
{
	U16	ID;
	U16	Reserved;
	U32	DataLength;
	U32	ColourLength;
} sSpsHeader;


/* ################################################################################ */

#endif	/*	INCLUDED_SPS_H */