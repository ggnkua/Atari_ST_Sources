#ifndef	INCLUDED_FLM_H
#define	INCLUDED_FLM_H

/* ###################################################################################
#  INCLUDES
################################################################################### */

#include	<GODLIB\BASE\BASE.H>


/* ###################################################################################
#  DEFINES
################################################################################### */

#define	dFLM_MAGIC	0x27182818


/* ###################################################################################
#  STRUCTS
################################################################################### */

typedef	struct
{
	U16	FrameCount;
	U16	Palette[ 16 ];
	U16	Speed;
	U16	Direction;
	U16	EndAction;
	U16	Width;
	U16	Height;
	U16	VersionMajor;
	U16	VersionMinor;
	U32	Magic;
	U32	Reserved[ 3 ];
} sFlmHeader;


/* ################################################################################ */

#endif	/*	INCLUDED_FLM_H */