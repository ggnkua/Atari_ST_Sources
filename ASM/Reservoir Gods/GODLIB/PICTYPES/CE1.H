#ifndef	INCLUDED_CE1_H
#define	INCLUDED_CE1_H

/* ###################################################################################
#  INCLUDES
################################################################################### */

#include	<GODLIB\BASE\BASE.H>


/* ###################################################################################
#  DEFINES
################################################################################### */

#define	dCE1_MAGIC	0x45594553


/* ###################################################################################
#  STRUCTS
################################################################################### */

typedef	struct
{
	U32	ID;
	U32	Resolution;
	U16	Reserved[ 8 ];
} sCe1Header;


typedef struct
{
	U8	RedPlane[ 64000 ];
	U8	GreenPlane[ 64000 ];
	U8	BluePlane[ 64000 ];
} sCe1Data;


typedef struct
{
	U16	Pixel[ 64000 ];
} sCe2Data;


/* ################################################################################ */

#endif	/*	INCLUDED_CE1_H */