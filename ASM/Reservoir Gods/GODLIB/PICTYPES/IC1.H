#ifndef	INCLUDED_IC1_H
#define	INCLUDED_IC1_H

/* ###################################################################################
#  INCLUDES
################################################################################### */

#include	<GODLIB\BASE\BASE.H>


/* ###################################################################################
#  DEFINES
################################################################################### */

#define	dIC1_MAGIC	mSTRING_TO_U32( 'I', 'M', 'D', 'C' )


/* ###################################################################################
#  STRUCTS
################################################################################### */

typedef	struct
{
	U32	ID;
	U16	Resolution;
	U16	Palette[ 16 ];
	U16	Date;
	U16	Time;
	U8	FileName[ 8 ];
	U16	DataLength;
	U32	RegistrationNumber;
	U8	Reserved[ 8 ];
	U8	CompressedFlag;
} sIc1Header;


/* ################################################################################ */

#endif	/*	INCLUDED_IC1_H */