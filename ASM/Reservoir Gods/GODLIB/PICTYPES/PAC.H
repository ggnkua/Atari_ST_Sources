#ifndef	INCLUDED_PAC_H
#define	INCLUDED_PAC_H

/* ###################################################################################
#  INCLUDES
################################################################################### */

#include	<GODLIB\BASE\BASE.H>


/* ###################################################################################
#  DEFINES
################################################################################### */

#define	dPAC_ORIENTATION_HORIZONTAL	mSTRING_TO_U32( 'p', 'm', '8', '5' )
#define	dPAC_ORIENTATION_VERTICAL	mSTRING_TO_U32( 'p', 'm', '8', '6' )


/* ###################################################################################
#  STRUCTS
################################################################################### */

typedef	struct
{
	U32	Orientaiton;
	U8	ID;
	U8	PackByte;
	U8	SpecialByte;
} sPacHeader;


/* ################################################################################ */

#endif	/*	INCLUDED_PAC_H */