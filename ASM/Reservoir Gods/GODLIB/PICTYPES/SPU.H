#ifndef	INCLUDED_SPU_H
#define	INCLUDED_SPU_H

/* ###################################################################################
#  INCLUDES
################################################################################### */

#include	<GODLIB\BASE\BASE.H>


/* ###################################################################################
#  STRUCTS
################################################################################### */

typedef	struct
{
	U16	Pixels[ 16000 ];
	U16	Palettes[ 199 ][ 3 ][ 16 ];
} sSpu;


/* ################################################################################ */

#endif	/*	INCLUDED_SPU_H */