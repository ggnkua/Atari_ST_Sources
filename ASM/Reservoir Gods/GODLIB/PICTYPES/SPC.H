#ifndef	INCLUDED_SPC_H
#define	INCLUDED_SPC_H

/* ###################################################################################
#  INCLUDES
################################################################################### */

#include	<GODLIB\BASE\BASE.H>


/* ###################################################################################
#  STRUCTS
################################################################################### */

typedef	struct
{
	U16	ID;
	U16	Reserved;
	U32	DataLength;
	U32	ColourLength;
} sSpcHeader;


/* ################################################################################ */

#endif	/*	INCLUDED_SPC_H */