#ifndef	INCLUDED_ART_H
#define	INCLUDED_ART_H

/* ###################################################################################
#  INCLUDES
################################################################################### */

#include	<GODLIB\BASE\BASE.H>

#include	<GODLIB\PICTYPES\CANVAS.H>
#include	<GODLIB\PICTYPES\CANVASIC.H>


/* ###################################################################################
#  STRUCTS
################################################################################### */

typedef	struct
{
	U16	Pixels[ 16000 ];
	U16	Palettes[ 16 ][ 16 ];
} sArt;


/* ###################################################################################
#  PROTOTYPES
################################################################################### */

sArt *		Art_FromCanvas( sCanvas * apCanvas, uCanvasPixel * apPalette );
sCanvas *	Art_ToCanvas( sArt * apArt );


/* ################################################################################ */

#endif	/*	INCLUDED_ART_H */