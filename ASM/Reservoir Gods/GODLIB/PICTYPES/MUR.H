#ifndef	INCLUDED_MUR_H
#define	INCLUDED_MUR_H

/* ###################################################################################
#  INCLUDES
################################################################################### */

#include	<GODLIB\BASE\BASE.H>


/* ###################################################################################
#  STRUCTS
################################################################################### */

typedef	struct
{
	U16	Pixels[ 16000 ];
} sMur;


/* ################################################################################ */

#endif	/*	INCLUDED_MUR_H */