#ifndef	INCLUDED_RANDOM_H
#define	INCLUDED_RANDOM_H

/* ###################################################################################
#  INCLUDES
################################################################################### */

#include	<GODLIB\BASE\BASE.H>


/* ###################################################################################
#  PROTOTYPES
################################################################################### */

void		Random_Init( void );
void		Random_DeInit( void );
void		Random_Update( void );

U16			Random_GetClamped( U16 aMax );
U32			Random_Get( void );


/* ################################################################################ */

#endif	/*	INCLUDED_RANDOM_H	*/