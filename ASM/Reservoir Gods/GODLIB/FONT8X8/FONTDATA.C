#include	<GODLIB\BASE\BASE.H>

U8 gFont8x8[12544] =
{
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x18,0x18,0x18,0x18,0x18,0x00,0x18,0x00,
0x66,0x66,0x66,0x00,0x00,0x00,0x00,0x00,
0x00,0x6C,0xFE,0x6C,0x6C,0xFE,0x6C,0x00,
0x18,0x3E,0x60,0x3C,0x06,0x7C,0x18,0x00,
0x00,0x66,0x6C,0x18,0x30,0x66,0x46,0x00,
0x38,0x6C,0x38,0x70,0xDE,0xCC,0x76,0x00,
0x18,0x18,0x18,0x00,0x00,0x00,0x00,0x00,
0x0E,0x1C,0x18,0x18,0x18,0x1C,0x0E,0x00,
0x70,0x38,0x18,0x18,0x18,0x38,0x70,0x00,
0x00,0x66,0x3C,0xFF,0x3C,0x66,0x00,0x00,
0x00,0x18,0x18,0x7E,0x18,0x18,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x30,0x30,0x60,
0x00,0x00,0x00,0x7E,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x18,0x18,0x00,
0x02,0x06,0x0C,0x18,0x30,0x60,0x40,0x00,
0x3C,0x66,0x6E,0x76,0x66,0x66,0x3C,0x00,
0x18,0x38,0x18,0x18,0x18,0x18,0x7E,0x00,
0x3C,0x66,0x06,0x0C,0x18,0x30,0x7E,0x00,
0x7E,0x0C,0x18,0x0C,0x06,0x66,0x3C,0x00,
0x0C,0x1C,0x3C,0x6C,0x7E,0x0C,0x0C,0x00,
0x7E,0x60,0x7C,0x06,0x06,0x66,0x3C,0x00,
0x3C,0x60,0x60,0x7C,0x66,0x66,0x3C,0x00,
0x7E,0x06,0x0C,0x18,0x30,0x30,0x30,0x00,
0x3C,0x66,0x66,0x3C,0x66,0x66,0x3C,0x00,
0x3C,0x66,0x66,0x3E,0x06,0x0C,0x38,0x00,
0x00,0x18,0x18,0x00,0x18,0x18,0x00,0x00,
0x00,0x18,0x18,0x00,0x18,0x18,0x30,0x00,
0x06,0x0C,0x18,0x30,0x18,0x0C,0x06,0x00,
0x00,0x00,0x7E,0x00,0x00,0x7E,0x00,0x00,
0x60,0x30,0x18,0x0C,0x18,0x30,0x60,0x00,
0x3C,0x66,0x06,0x0C,0x18,0x00,0x18,0x00,
0x3C,0x66,0x6E,0x6A,0x6E,0x60,0x3E,0x00,
0x18,0x3C,0x66,0x66,0x7E,0x66,0x66,0x00,
0x7C,0x66,0x66,0x7C,0x66,0x66,0x7C,0x00,
0x3C,0x66,0x60,0x60,0x60,0x66,0x3C,0x00,
0x78,0x6C,0x66,0x66,0x66,0x6C,0x78,0x00,
0x7E,0x60,0x60,0x7C,0x60,0x60,0x7E,0x00,
0x7E,0x60,0x60,0x7C,0x60,0x60,0x60,0x00,
0x3E,0x60,0x60,0x6E,0x66,0x66,0x3E,0x00,
0x66,0x66,0x66,0x7E,0x66,0x66,0x66,0x00,
0x3C,0x18,0x18,0x18,0x18,0x18,0x3C,0x00,
0x06,0x06,0x06,0x06,0x06,0x66,0x3C,0x00,
0x66,0x6C,0x78,0x70,0x78,0x6C,0x66,0x00,
0x60,0x60,0x60,0x60,0x60,0x60,0x7E,0x00,
0xC6,0xEE,0xFE,0xD6,0xC6,0xC6,0xC6,0x00,
0x66,0x76,0x7E,0x7E,0x6E,0x66,0x66,0x00,
0x3C,0x66,0x66,0x66,0x66,0x66,0x3C,0x00,
0x7C,0x66,0x66,0x7C,0x60,0x60,0x60,0x00,
0x3C,0x66,0x66,0x66,0x76,0x6C,0x36,0x00,
0x7C,0x66,0x66,0x7C,0x6C,0x66,0x66,0x00,
0x3C,0x66,0x60,0x3C,0x06,0x66,0x3C,0x00,
0x7E,0x18,0x18,0x18,0x18,0x18,0x18,0x00,
0x66,0x66,0x66,0x66,0x66,0x66,0x3E,0x00,
0x66,0x66,0x66,0x66,0x66,0x3C,0x18,0x00,
0xC6,0xC6,0xC6,0xD6,0xFE,0xEE,0xC6,0x00,
0x66,0x66,0x3C,0x18,0x3C,0x66,0x66,0x00,
0x66,0x66,0x66,0x3C,0x18,0x18,0x18,0x00,
0x7E,0x06,0x0C,0x18,0x30,0x60,0x7E,0x00,
0x1E,0x18,0x18,0x18,0x18,0x18,0x1E,0x00,
0x40,0x60,0x30,0x18,0x0C,0x06,0x02,0x00,
0x78,0x18,0x18,0x18,0x18,0x18,0x78,0x00,
0x10,0x38,0x6C,0xC6,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0xFE,0x00,
0x00,0xC0,0x60,0x30,0x00,0x00,0x00,0x00,
0x00,0x00,0x3C,0x06,0x3E,0x66,0x3E,0x00,
0x60,0x60,0x7C,0x66,0x66,0x66,0x7C,0x00,
0x00,0x00,0x3C,0x60,0x60,0x60,0x3C,0x00,
0x06,0x06,0x3E,0x66,0x66,0x66,0x3E,0x00,
0x00,0x00,0x3C,0x66,0x7E,0x60,0x3C,0x00,
0x1C,0x30,0x7C,0x30,0x30,0x30,0x30,0x00,
0x00,0x00,0x3E,0x66,0x66,0x3E,0x06,0x7C,
0x60,0x60,0x7C,0x66,0x66,0x66,0x66,0x00,
0x18,0x00,0x38,0x18,0x18,0x18,0x3C,0x00,
0x18,0x00,0x18,0x18,0x18,0x18,0x18,0x70,
0x60,0x60,0x66,0x6C,0x78,0x6C,0x66,0x00,
0x38,0x18,0x18,0x18,0x18,0x18,0x3C,0x00,
0x00,0x00,0xEC,0xFE,0xD6,0xC6,0xC6,0x00,
0x00,0x00,0x7C,0x66,0x66,0x66,0x66,0x00,
0x00,0x00,0x3C,0x66,0x66,0x66,0x3C,0x00,
0x00,0x00,0x7C,0x66,0x66,0x66,0x7C,0x60,
0x00,0x00,0x3E,0x66,0x66,0x66,0x3E,0x06,
0x00,0x00,0x7C,0x66,0x60,0x60,0x60,0x00,
0x00,0x00,0x3E,0x60,0x3C,0x06,0x7C,0x00,
0x00,0x18,0x7E,0x18,0x18,0x18,0x0E,0x00,
0x00,0x00,0x66,0x66,0x66,0x66,0x3E,0x00,
0x00,0x00,0x66,0x66,0x66,0x3C,0x18,0x00,
0x00,0x00,0xC6,0xC6,0xD6,0x7C,0x6C,0x00,
0x00,0x00,0x66,0x3C,0x18,0x3C,0x66,0x00,
0x00,0x00,0x66,0x66,0x66,0x3E,0x06,0x7C,
0x00,0x00,0x7E,0x0C,0x18,0x30,0x7E,0x00,
0x0E,0x18,0x18,0x30,0x18,0x18,0x0E,0x00,
0x18,0x18,0x18,0x18,0x18,0x18,0x18,0x18,
0x70,0x18,0x18,0x0C,0x18,0x18,0x70,0x00,
0x00,0x60,0xF2,0x9E,0x0C,0x00,0x00,0x00,
0x00,0x18,0x18,0x34,0x34,0x62,0x7E,0x00,
0x00,0x3C,0x66,0x60,0x66,0x3C,0x08,0x38,
0x66,0x00,0x00,0x66,0x66,0x66,0x3E,0x00,
0x0C,0x18,0x00,0x3C,0x7E,0x60,0x3C,0x00,
0x18,0x66,0x00,0x3C,0x06,0x7E,0x3E,0x00,
0x66,0x00,0x3C,0x06,0x3E,0x66,0x3E,0x00,
0x30,0x18,0x00,0x3C,0x06,0x7E,0x3E,0x00,
0x18,0x18,0x00,0x3C,0x06,0x7E,0x3E,0x00,
0x00,0x00,0x3C,0x60,0x60,0x3C,0x08,0x18,
0x18,0x66,0x00,0x3C,0x7E,0x60,0x3C,0x00,
0x66,0x00,0x3C,0x66,0x7E,0x60,0x3C,0x00,
0x30,0x18,0x00,0x3C,0x7E,0x60,0x3C,0x00,
0x66,0x00,0x00,0x38,0x18,0x18,0x3C,0x00,
0x18,0x66,0x00,0x38,0x18,0x18,0x3C,0x00,
0x60,0x30,0x00,0x38,0x18,0x18,0x3C,0x00,
0x66,0x00,0x18,0x3C,0x66,0x7E,0x66,0x00,
0x18,0x00,0x18,0x3C,0x66,0x7E,0x66,0x00,
0x0C,0x18,0x7E,0x60,0x7C,0x60,0x7E,0x00,
0x00,0x00,0x7E,0x1B,0x7F,0xD8,0x7E,0x00,
0x3F,0x78,0xD8,0xDE,0xF8,0xD8,0xDF,0x00,
0x18,0x66,0x00,0x3C,0x66,0x66,0x3C,0x00,
0x66,0x00,0x00,0x3C,0x66,0x66,0x3C,0x00,
0x30,0x18,0x00,0x3C,0x66,0x66,0x3C,0x00,
0x18,0x66,0x00,0x66,0x66,0x66,0x3E,0x00,
0x30,0x18,0x00,0x66,0x66,0x66,0x3E,0x00,
0x66,0x00,0x66,0x66,0x66,0x3E,0x06,0x7C,
0x66,0x00,0x3C,0x66,0x66,0x66,0x3C,0x00,
0x66,0x00,0x66,0x66,0x66,0x66,0x3E,0x00,
0x18,0x18,0x3C,0x60,0x60,0x3C,0x18,0x18,
0x1C,0x3A,0x30,0x7C,0x30,0x30,0x7E,0x00,
0x66,0x66,0x3C,0x18,0x3C,0x18,0x18,0x00,
0x1C,0x36,0x66,0x7C,0x66,0x66,0x7C,0x60,
0x1E,0x30,0x7C,0x30,0x30,0x30,0x60,0x00,
0x0C,0x18,0x00,0x3C,0x06,0x7E,0x3E,0x00,
0x0C,0x18,0x00,0x38,0x18,0x18,0x3C,0x00,
0x0C,0x18,0x00,0x3C,0x66,0x66,0x3C,0x00,
0x0C,0x18,0x00,0x66,0x66,0x66,0x3E,0x00,
0x34,0x58,0x00,0x7C,0x66,0x66,0x66,0x00,
0x34,0x58,0x00,0x66,0x76,0x6E,0x66,0x00,
0x00,0x3C,0x06,0x3E,0x66,0x3E,0x00,0x3C,
0x00,0x3C,0x66,0x66,0x66,0x3C,0x00,0x3C,
0x00,0x18,0x00,0x18,0x30,0x60,0x66,0x3C,
0x00,0x00,0x00,0x3E,0x30,0x30,0x30,0x00,
0x00,0x00,0x00,0x7C,0x0C,0x0C,0x0C,0x00,
0xC6,0xCC,0xD8,0x36,0x6B,0xC3,0x86,0x0F,
0xC6,0xCC,0xD8,0x36,0x6E,0xD6,0x9F,0x06,
0x00,0x18,0x00,0x18,0x18,0x18,0x18,0x18,
0x1B,0x36,0x6C,0xD8,0x6C,0x36,0x1B,0x00,
0xD8,0x6C,0x36,0x1B,0x36,0x6C,0xD8,0x00,
0x34,0x58,0x00,0x3C,0x06,0x7E,0x3E,0x00,
0x34,0x58,0x00,0x3C,0x66,0x66,0x3C,0x00,
0x02,0x3C,0x66,0x6E,0x76,0x66,0x3C,0x40,
0x00,0x02,0x3C,0x6E,0x76,0x66,0x3C,0x40,
0x00,0x00,0x7E,0xDB,0xDF,0xD8,0x7E,0x00,
0x7F,0xD8,0xD8,0xDE,0xD8,0xD8,0x7F,0x00,
0x30,0x18,0x00,0x18,0x3C,0x66,0x7E,0x66,
0x34,0x58,0x00,0x18,0x3C,0x66,0x7E,0x66,
0x34,0x58,0x3C,0x66,0x66,0x66,0x66,0x3C,
0x66,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x0C,0x18,0x30,0x00,0x00,0x00,0x00,0x00,
0x00,0x10,0x38,0x10,0x10,0x10,0x00,0x00,
0x7A,0xCA,0xCA,0xCA,0x7A,0x0A,0x0A,0x0A,
0x7E,0xC3,0xBD,0xB1,0xB1,0xBD,0xC3,0x7E,
0x7E,0xC3,0xBD,0xA5,0xB9,0xAD,0xC3,0x7E,
0xF1,0x5B,0x5F,0x55,0x51,0x00,0x00,0x00,
0x66,0x00,0xE6,0x66,0x66,0xF6,0x06,0x1C,
0xF6,0x66,0x66,0x66,0x66,0xF6,0x06,0x1C,
0x00,0x66,0x76,0x3C,0x6E,0x66,0x00,0x00,
0x00,0x7C,0x0C,0x0C,0x0C,0x7E,0x00,0x00,
0x00,0x1E,0x06,0x0E,0x1E,0x36,0x00,0x00,
0x00,0x7E,0x0C,0x0C,0x0C,0x0C,0x00,0x00,
0x00,0x7C,0x06,0x66,0x66,0x66,0x00,0x00,
0x00,0x1C,0x0C,0x0C,0x0C,0x0C,0x00,0x00,
0x00,0x1E,0x0C,0x06,0x06,0x06,0x00,0x00,
0x00,0x7E,0x36,0x36,0x36,0x36,0x00,0x00,
0x60,0x6E,0x66,0x66,0x66,0x7E,0x00,0x00,
0x00,0x3C,0x0C,0x0C,0x00,0x00,0x00,0x00,
0x00,0x3E,0x06,0x06,0x06,0x3E,0x00,0x00,
0x60,0x7E,0x06,0x06,0x06,0x0E,0x00,0x00,
0x00,0x6C,0x3E,0x66,0x66,0x6E,0x00,0x00,
0x00,0x1C,0x0C,0x0C,0x0C,0x3C,0x00,0x00,
0x00,0x3E,0x36,0x36,0x36,0x1C,0x00,0x00,
0x00,0x36,0x36,0x36,0x36,0x7E,0x00,0x00,
0x00,0x7E,0x66,0x76,0x06,0x7E,0x00,0x00,
0x00,0x66,0x66,0x3C,0x0E,0x7E,0x00,0x00,
0x00,0x3E,0x06,0x36,0x36,0x34,0x30,0x00,
0x00,0x78,0x0C,0x0C,0x0C,0x0C,0x00,0x00,
0x00,0xD6,0xD6,0xD6,0xD6,0xFE,0x00,0x00,
0x00,0x7C,0x6C,0x6C,0x6C,0xEC,0x00,0x00,
0x00,0x1C,0x0C,0x0C,0x0C,0x0C,0x0C,0x00,
0x00,0x3E,0x06,0x06,0x06,0x06,0x06,0x00,
0x00,0xFE,0x66,0x66,0x66,0x7E,0x00,0x00,
0x00,0x7E,0x66,0x76,0x06,0x06,0x06,0x00,
0x00,0x36,0x36,0x1C,0x0C,0x0C,0x0C,0x00,
0x0E,0x1B,0x3C,0x66,0x66,0x3C,0xD8,0x70,
0x00,0x10,0x38,0x6C,0xC6,0x82,0x00,0x00,
0x66,0xF7,0x99,0x99,0xEF,0x66,0x00,0x00,
0x00,0x00,0x76,0xDC,0xC8,0xDC,0x76,0x00,
0x1C,0x36,0x66,0x7C,0x66,0x66,0x7C,0x60,
0x00,0xFE,0x66,0x62,0x60,0x60,0x60,0xF8,
0x00,0x00,0xFE,0x6C,0x6C,0x6C,0x6C,0x48,
0xFE,0x66,0x30,0x18,0x30,0x66,0xFE,0x00,
0x00,0x1E,0x38,0x6C,0x6C,0x6C,0x38,0x00,
0x00,0x00,0x6C,0x6C,0x6C,0x6C,0x7F,0xC0,
0x00,0x00,0x7E,0x18,0x18,0x18,0x18,0x10,
0x3C,0x18,0x3C,0x66,0x66,0x3C,0x18,0x3C,
0x00,0x3C,0x66,0x7E,0x66,0x66,0x3C,0x00,
0x00,0x3C,0x66,0x66,0x66,0x24,0x66,0x00,
0x1C,0x36,0x78,0xDC,0xCC,0xEC,0x78,0x00,
0x0C,0x18,0x38,0x54,0x54,0x38,0x30,0x60,
0x00,0x10,0x7C,0xD6,0xD6,0xD6,0x7C,0x10,
0x3E,0x70,0x60,0x7E,0x60,0x70,0x3E,0x00,
0x3C,0x66,0x66,0x66,0x66,0x66,0x66,0x00,
0x00,0x7E,0x00,0x7E,0x00,0x7E,0x00,0x00,
0x18,0x18,0x7E,0x18,0x18,0x00,0x7E,0x00,
0x30,0x18,0x0C,0x18,0x30,0x00,0x7E,0x00,
0x0C,0x18,0x30,0x18,0x0C,0x00,0x7E,0x00,
0x00,0x0E,0x1B,0x1B,0x18,0x18,0x18,0x18,
0x18,0x18,0x18,0x18,0xD8,0xD8,0x70,0x00,
0x18,0x18,0x00,0x7E,0x00,0x18,0x18,0x00,
0x00,0x32,0x4C,0x00,0x32,0x4C,0x00,0x00,
0x38,0x6C,0x38,0x00,0x00,0x00,0x00,0x00,
0x38,0x7C,0x38,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x18,0x18,0x00,0x00,
0x00,0x00,0x0F,0x18,0xD8,0x70,0x30,0x00,
0x38,0x6C,0x6C,0x6C,0x6C,0x00,0x00,0x00,
0x38,0x6C,0x18,0x30,0x7C,0x00,0x00,0x00,
0x78,0x0C,0x38,0x0C,0x78,0x00,0x00,0x00,
0x00,0xFE,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xFF,
0x18,0x18,0x18,0x18,0x18,0x00,0x18,0xFF,
0x66,0x66,0x66,0x00,0x00,0x00,0x00,0xFF,
0x00,0x6C,0xFE,0x6C,0x6C,0xFE,0x6C,0xFF,
0x18,0x3E,0x60,0x3C,0x06,0x7C,0x18,0xFF,
0x00,0x66,0x6C,0x18,0x30,0x66,0x46,0xFF,
0x38,0x6C,0x38,0x70,0xDE,0xCC,0x76,0xFF,
0x18,0x18,0x18,0x00,0x00,0x00,0x00,0xFF,
0x0E,0x1C,0x18,0x18,0x18,0x1C,0x0E,0xFF,
0x70,0x38,0x18,0x18,0x18,0x38,0x70,0xFF,
0x00,0x66,0x3C,0xFF,0x3C,0x66,0x00,0xFF,
0x00,0x18,0x18,0x7E,0x18,0x18,0x00,0xFF,
0x00,0x00,0x00,0x00,0x00,0x30,0x30,0xFF,
0x00,0x00,0x00,0x7E,0x00,0x00,0x00,0xFF,
0x00,0x00,0x00,0x00,0x00,0x18,0x18,0xFF,
0x02,0x06,0x0C,0x18,0x30,0x60,0x40,0xFF,
0x3C,0x66,0x6E,0x76,0x66,0x66,0x3C,0xFF,
0x18,0x38,0x18,0x18,0x18,0x18,0x7E,0xFF,
0x3C,0x66,0x06,0x0C,0x18,0x30,0x7E,0xFF,
0x7E,0x0C,0x18,0x0C,0x06,0x66,0x3C,0xFF,
0x0C,0x1C,0x3C,0x6C,0x7E,0x0C,0x0C,0xFF,
0x7E,0x60,0x7C,0x06,0x06,0x66,0x3C,0xFF,
0x3C,0x60,0x60,0x7C,0x66,0x66,0x3C,0xFF,
0x7E,0x06,0x0C,0x18,0x30,0x30,0x30,0xFF,
0x3C,0x66,0x66,0x3C,0x66,0x66,0x3C,0xFF,
0x3C,0x66,0x66,0x3E,0x06,0x0C,0x38,0xFF,
0x00,0x18,0x18,0x00,0x18,0x18,0x00,0xFF,
0x00,0x18,0x18,0x00,0x18,0x18,0x30,0xFF,
0x06,0x0C,0x18,0x30,0x18,0x0C,0x06,0xFF,
0x00,0x00,0x7E,0x00,0x00,0x7E,0x00,0xFF,
0x60,0x30,0x18,0x0C,0x18,0x30,0x60,0xFF,
0x3C,0x66,0x06,0x0C,0x18,0x00,0x18,0xFF,
0x3C,0x66,0x6E,0x6A,0x6E,0x60,0x3E,0xFF,
0x18,0x3C,0x66,0x66,0x7E,0x66,0x66,0xFF,
0x7C,0x66,0x66,0x7C,0x66,0x66,0x7C,0xFF,
0x3C,0x66,0x60,0x60,0x60,0x66,0x3C,0xFF,
0x78,0x6C,0x66,0x66,0x66,0x6C,0x78,0xFF,
0x7E,0x60,0x60,0x7C,0x60,0x60,0x7E,0xFF,
0x7E,0x60,0x60,0x7C,0x60,0x60,0x60,0xFF,
0x3E,0x60,0x60,0x6E,0x66,0x66,0x3E,0xFF,
0x66,0x66,0x66,0x7E,0x66,0x66,0x66,0xFF,
0x3C,0x18,0x18,0x18,0x18,0x18,0x3C,0xFF,
0x06,0x06,0x06,0x06,0x06,0x66,0x3C,0xFF,
0x66,0x6C,0x78,0x70,0x78,0x6C,0x66,0xFF,
0x60,0x60,0x60,0x60,0x60,0x60,0x7E,0xFF,
0xC6,0xEE,0xFE,0xD6,0xC6,0xC6,0xC6,0xFF,
0x66,0x76,0x7E,0x7E,0x6E,0x66,0x66,0xFF,
0x3C,0x66,0x66,0x66,0x66,0x66,0x3C,0xFF,
0x7C,0x66,0x66,0x7C,0x60,0x60,0x60,0xFF,
0x3C,0x66,0x66,0x66,0x76,0x6C,0x36,0xFF,
0x7C,0x66,0x66,0x7C,0x6C,0x66,0x66,0xFF,
0x3C,0x66,0x60,0x3C,0x06,0x66,0x3C,0xFF,
0x7E,0x18,0x18,0x18,0x18,0x18,0x18,0xFF,
0x66,0x66,0x66,0x66,0x66,0x66,0x3E,0xFF,
0x66,0x66,0x66,0x66,0x66,0x3C,0x18,0xFF,
0xC6,0xC6,0xC6,0xD6,0xFE,0xEE,0xC6,0xFF,
0x66,0x66,0x3C,0x18,0x3C,0x66,0x66,0xFF,
0x66,0x66,0x66,0x3C,0x18,0x18,0x18,0xFF,
0x7E,0x06,0x0C,0x18,0x30,0x60,0x7E,0xFF,
0x1E,0x18,0x18,0x18,0x18,0x18,0x1E,0xFF,
0x40,0x60,0x30,0x18,0x0C,0x06,0x02,0xFF,
0x78,0x18,0x18,0x18,0x18,0x18,0x78,0xFF,
0x10,0x38,0x6C,0xC6,0x00,0x00,0x00,0xFF,
0x00,0x00,0x00,0x00,0x00,0x00,0xFE,0xFF,
0x00,0xC0,0x60,0x30,0x00,0x00,0x00,0xFF,
0x00,0x00,0x3C,0x06,0x3E,0x66,0x3E,0xFF,
0x60,0x60,0x7C,0x66,0x66,0x66,0x7C,0xFF,
0x00,0x00,0x3C,0x60,0x60,0x60,0x3C,0xFF,
0x06,0x06,0x3E,0x66,0x66,0x66,0x3E,0xFF,
0x00,0x00,0x3C,0x66,0x7E,0x60,0x3C,0xFF,
0x1C,0x30,0x7C,0x30,0x30,0x30,0x30,0xFF,
0x00,0x00,0x3E,0x66,0x66,0x3E,0x06,0xFF,
0x60,0x60,0x7C,0x66,0x66,0x66,0x66,0xFF,
0x18,0x00,0x38,0x18,0x18,0x18,0x3C,0xFF,
0x18,0x00,0x18,0x18,0x18,0x18,0x18,0xFF,
0x60,0x60,0x66,0x6C,0x78,0x6C,0x66,0xFF,
0x38,0x18,0x18,0x18,0x18,0x18,0x3C,0xFF,
0x00,0x00,0xEC,0xFE,0xD6,0xC6,0xC6,0xFF,
0x00,0x00,0x7C,0x66,0x66,0x66,0x66,0xFF,
0x00,0x00,0x3C,0x66,0x66,0x66,0x3C,0xFF,
0x00,0x00,0x7C,0x66,0x66,0x66,0x7C,0xFF,
0x00,0x00,0x3E,0x66,0x66,0x66,0x3E,0xFF,
0x00,0x00,0x7C,0x66,0x60,0x60,0x60,0xFF,
0x00,0x00,0x3E,0x60,0x3C,0x06,0x7C,0xFF,
0x00,0x18,0x7E,0x18,0x18,0x18,0x0E,0xFF,
0x00,0x00,0x66,0x66,0x66,0x66,0x3E,0xFF,
0x00,0x00,0x66,0x66,0x66,0x3C,0x18,0xFF,
0x00,0x00,0xC6,0xC6,0xD6,0x7C,0x6C,0xFF,
0x00,0x00,0x66,0x3C,0x18,0x3C,0x66,0xFF,
0x00,0x00,0x66,0x66,0x66,0x3E,0x06,0xFF,
0x00,0x00,0x7E,0x0C,0x18,0x30,0x7E,0xFF,
0x0E,0x18,0x18,0x30,0x18,0x18,0x0E,0xFF,
0x18,0x18,0x18,0x18,0x18,0x18,0x18,0xFF,
0x70,0x18,0x18,0x0C,0x18,0x18,0x70,0xFF,
0x00,0x60,0xF2,0x9E,0x0C,0x00,0x00,0xFF,
0x00,0x18,0x18,0x34,0x34,0x62,0x7E,0xFF,
0x00,0x3C,0x66,0x60,0x66,0x3C,0x08,0xFF,
0x66,0x00,0x00,0x66,0x66,0x66,0x3E,0xFF,
0x0C,0x18,0x00,0x3C,0x7E,0x60,0x3C,0xFF,
0x18,0x66,0x00,0x3C,0x06,0x7E,0x3E,0xFF,
0x66,0x00,0x3C,0x06,0x3E,0x66,0x3E,0xFF,
0x30,0x18,0x00,0x3C,0x06,0x7E,0x3E,0xFF,
0x18,0x18,0x00,0x3C,0x06,0x7E,0x3E,0xFF,
0x00,0x00,0x3C,0x60,0x60,0x3C,0x08,0xFF,
0x18,0x66,0x00,0x3C,0x7E,0x60,0x3C,0xFF,
0x66,0x00,0x3C,0x66,0x7E,0x60,0x3C,0xFF,
0x30,0x18,0x00,0x3C,0x7E,0x60,0x3C,0xFF,
0x66,0x00,0x00,0x38,0x18,0x18,0x3C,0xFF,
0x18,0x66,0x00,0x38,0x18,0x18,0x3C,0xFF,
0x60,0x30,0x00,0x38,0x18,0x18,0x3C,0xFF,
0x66,0x00,0x18,0x3C,0x66,0x7E,0x66,0xFF,
0x18,0x00,0x18,0x3C,0x66,0x7E,0x66,0xFF,
0x0C,0x18,0x7E,0x60,0x7C,0x60,0x7E,0xFF,
0x00,0x00,0x7E,0x1B,0x7F,0xD8,0x7E,0xFF,
0x3F,0x78,0xD8,0xDE,0xF8,0xD8,0xDF,0xFF,
0x18,0x66,0x00,0x3C,0x66,0x66,0x3C,0xFF,
0x66,0x00,0x00,0x3C,0x66,0x66,0x3C,0xFF,
0x30,0x18,0x00,0x3C,0x66,0x66,0x3C,0xFF,
0x18,0x66,0x00,0x66,0x66,0x66,0x3E,0xFF,
0x30,0x18,0x00,0x66,0x66,0x66,0x3E,0xFF,
0x66,0x00,0x66,0x66,0x66,0x3E,0x06,0xFF,
0x66,0x00,0x3C,0x66,0x66,0x66,0x3C,0xFF,
0x66,0x00,0x66,0x66,0x66,0x66,0x3E,0xFF,
0x18,0x18,0x3C,0x60,0x60,0x3C,0x18,0xFF,
0x1C,0x3A,0x30,0x7C,0x30,0x30,0x7E,0xFF,
0x66,0x66,0x3C,0x18,0x3C,0x18,0x18,0xFF,
0x1C,0x36,0x66,0x7C,0x66,0x66,0x7C,0xFF,
0x1E,0x30,0x7C,0x30,0x30,0x30,0x60,0xFF,
0x0C,0x18,0x00,0x3C,0x06,0x7E,0x3E,0xFF,
0x0C,0x18,0x00,0x38,0x18,0x18,0x3C,0xFF,
0x0C,0x18,0x00,0x3C,0x66,0x66,0x3C,0xFF,
0x0C,0x18,0x00,0x66,0x66,0x66,0x3E,0xFF,
0x34,0x58,0x00,0x7C,0x66,0x66,0x66,0xFF,
0x34,0x58,0x00,0x66,0x76,0x6E,0x66,0xFF,
0x00,0x3C,0x06,0x3E,0x66,0x3E,0x00,0xFF,
0x00,0x3C,0x66,0x66,0x66,0x3C,0x00,0xFF,
0x00,0x18,0x00,0x18,0x30,0x60,0x66,0xFF,
0x00,0x00,0x00,0x3E,0x30,0x30,0x30,0xFF,
0x00,0x00,0x00,0x7C,0x0C,0x0C,0x0C,0xFF,
0xC6,0xCC,0xD8,0x36,0x6B,0xC3,0x86,0xFF,
0xC6,0xCC,0xD8,0x36,0x6E,0xD6,0x9F,0xFF,
0x00,0x18,0x00,0x18,0x18,0x18,0x18,0xFF,
0x1B,0x36,0x6C,0xD8,0x6C,0x36,0x1B,0xFF,
0xD8,0x6C,0x36,0x1B,0x36,0x6C,0xD8,0xFF,
0x34,0x58,0x00,0x3C,0x06,0x7E,0x3E,0xFF,
0x34,0x58,0x00,0x3C,0x66,0x66,0x3C,0xFF,
0x02,0x3C,0x66,0x6E,0x76,0x66,0x3C,0xFF,
0x00,0x02,0x3C,0x6E,0x76,0x66,0x3C,0xFF,
0x00,0x00,0x7E,0xDB,0xDF,0xD8,0x7E,0xFF,
0x7F,0xD8,0xD8,0xDE,0xD8,0xD8,0x7F,0xFF,
0x30,0x18,0x00,0x18,0x3C,0x66,0x7E,0xFF,
0x34,0x58,0x00,0x18,0x3C,0x66,0x7E,0xFF,
0x34,0x58,0x3C,0x66,0x66,0x66,0x66,0xFF,
0x66,0x00,0x00,0x00,0x00,0x00,0x00,0xFF,
0x0C,0x18,0x30,0x00,0x00,0x00,0x00,0xFF,
0x00,0x10,0x38,0x10,0x10,0x10,0x00,0xFF,
0x7A,0xCA,0xCA,0xCA,0x7A,0x0A,0x0A,0xFF,
0x7E,0xC3,0xBD,0xB1,0xB1,0xBD,0xC3,0xFF,
0x7E,0xC3,0xBD,0xA5,0xB9,0xAD,0xC3,0xFF,
0xF1,0x5B,0x5F,0x55,0x51,0x00,0x00,0xFF,
0x66,0x00,0xE6,0x66,0x66,0xF6,0x06,0xFF,
0xF6,0x66,0x66,0x66,0x66,0xF6,0x06,0xFF,
0x00,0x66,0x76,0x3C,0x6E,0x66,0x00,0xFF,
0x00,0x7C,0x0C,0x0C,0x0C,0x7E,0x00,0xFF,
0x00,0x1E,0x06,0x0E,0x1E,0x36,0x00,0xFF,
0x00,0x7E,0x0C,0x0C,0x0C,0x0C,0x00,0xFF,
0x00,0x7C,0x06,0x66,0x66,0x66,0x00,0xFF,
0x00,0x1C,0x0C,0x0C,0x0C,0x0C,0x00,0xFF,
0x00,0x1E,0x0C,0x06,0x06,0x06,0x00,0xFF,
0x00,0x7E,0x36,0x36,0x36,0x36,0x00,0xFF,
0x60,0x6E,0x66,0x66,0x66,0x7E,0x00,0xFF,
0x00,0x3C,0x0C,0x0C,0x00,0x00,0x00,0xFF,
0x00,0x3E,0x06,0x06,0x06,0x3E,0x00,0xFF,
0x60,0x7E,0x06,0x06,0x06,0x0E,0x00,0xFF,
0x00,0x6C,0x3E,0x66,0x66,0x6E,0x00,0xFF,
0x00,0x1C,0x0C,0x0C,0x0C,0x3C,0x00,0xFF,
0x00,0x3E,0x36,0x36,0x36,0x1C,0x00,0xFF,
0x00,0x36,0x36,0x36,0x36,0x7E,0x00,0xFF,
0x00,0x7E,0x66,0x76,0x06,0x7E,0x00,0xFF,
0x00,0x66,0x66,0x3C,0x0E,0x7E,0x00,0xFF,
0x00,0x3E,0x06,0x36,0x36,0x34,0x30,0xFF,
0x00,0x78,0x0C,0x0C,0x0C,0x0C,0x00,0xFF,
0x00,0xD6,0xD6,0xD6,0xD6,0xFE,0x00,0xFF,
0x00,0x7C,0x6C,0x6C,0x6C,0xEC,0x00,0xFF,
0x00,0x1C,0x0C,0x0C,0x0C,0x0C,0x0C,0xFF,
0x00,0x3E,0x06,0x06,0x06,0x06,0x06,0xFF,
0x00,0xFE,0x66,0x66,0x66,0x7E,0x00,0xFF,
0x00,0x7E,0x66,0x76,0x06,0x06,0x06,0xFF,
0x00,0x36,0x36,0x1C,0x0C,0x0C,0x0C,0xFF,
0x0E,0x1B,0x3C,0x66,0x66,0x3C,0xD8,0xFF,
0x00,0x10,0x38,0x6C,0xC6,0x82,0x00,0xFF,
0x66,0xF7,0x99,0x99,0xEF,0x66,0x00,0xFF,
0x00,0x00,0x76,0xDC,0xC8,0xDC,0x76,0xFF,
0x1C,0x36,0x66,0x7C,0x66,0x66,0x7C,0xFF,
0x00,0xFE,0x66,0x62,0x60,0x60,0x60,0xFF,
0x00,0x00,0xFE,0x6C,0x6C,0x6C,0x6C,0xFF,
0xFE,0x66,0x30,0x18,0x30,0x66,0xFE,0xFF,
0x00,0x1E,0x38,0x6C,0x6C,0x6C,0x38,0xFF,
0x00,0x00,0x6C,0x6C,0x6C,0x6C,0x7F,0xFF,
0x00,0x00,0x7E,0x18,0x18,0x18,0x18,0xFF,
0x3C,0x18,0x3C,0x66,0x66,0x3C,0x18,0xFF,
0x00,0x3C,0x66,0x7E,0x66,0x66,0x3C,0xFF,
0x00,0x3C,0x66,0x66,0x66,0x24,0x66,0xFF,
0x1C,0x36,0x78,0xDC,0xCC,0xEC,0x78,0xFF,
0x0C,0x18,0x38,0x54,0x54,0x38,0x30,0xFF,
0x00,0x10,0x7C,0xD6,0xD6,0xD6,0x7C,0xFF,
0x3E,0x70,0x60,0x7E,0x60,0x70,0x3E,0xFF,
0x3C,0x66,0x66,0x66,0x66,0x66,0x66,0xFF,
0x00,0x7E,0x00,0x7E,0x00,0x7E,0x00,0xFF,
0x18,0x18,0x7E,0x18,0x18,0x00,0x7E,0xFF,
0x30,0x18,0x0C,0x18,0x30,0x00,0x7E,0xFF,
0x0C,0x18,0x30,0x18,0x0C,0x00,0x7E,0xFF,
0x00,0x0E,0x1B,0x1B,0x18,0x18,0x18,0xFF,
0x18,0x18,0x18,0x18,0xD8,0xD8,0x70,0xFF,
0x18,0x18,0x00,0x7E,0x00,0x18,0x18,0xFF,
0x00,0x32,0x4C,0x00,0x32,0x4C,0x00,0xFF,
0x38,0x6C,0x38,0x00,0x00,0x00,0x00,0xFF,
0x38,0x7C,0x38,0x00,0x00,0x00,0x00,0xFF,
0x00,0x00,0x00,0x00,0x18,0x18,0x00,0xFF,
0x00,0x00,0x0F,0x18,0xD8,0x70,0x30,0xFF,
0x38,0x6C,0x6C,0x6C,0x6C,0x00,0x00,0xFF,
0x38,0x6C,0x18,0x30,0x7C,0x00,0x00,0xFF,
0x78,0x0C,0x38,0x0C,0x78,0x00,0x00,0xFF,
0x00,0xFE,0x00,0x00,0x00,0x00,0x00,0xFF,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x06,0x0C,0x0C,0x18,0x18,0x00,0x30,0x00,
0x19,0x33,0x33,0x00,0x00,0x00,0x00,0x00,
0x00,0x36,0x7F,0x6C,0x6C,0xFC,0xD8,0x00,
0x06,0x1F,0x30,0x3C,0x06,0xF8,0x30,0x00,
0x00,0x33,0x36,0x18,0x30,0xCC,0x8C,0x00,
0x0E,0x36,0x1C,0x70,0xDE,0x98,0xEC,0x00,
0x06,0x0C,0x0C,0x00,0x00,0x00,0x00,0x00,
0x03,0x0E,0x0C,0x18,0x18,0x38,0x1C,0x00,
0x1C,0x1C,0x0C,0x18,0x18,0x70,0xE0,0x00,
0x00,0x33,0x1E,0xFF,0x3C,0xCC,0x00,0x00,
0x00,0x0C,0x0C,0x7E,0x18,0x30,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x60,0x60,0x80,
0x00,0x00,0x00,0x7E,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x30,0x30,0x00,
0x00,0x03,0x06,0x18,0x30,0xC0,0x80,0x00,
0x0F,0x33,0x37,0x76,0x66,0xCC,0x78,0x00,
0x06,0x1C,0x0C,0x18,0x18,0x30,0xFC,0x00,
0x0F,0x33,0x03,0x0C,0x18,0x60,0xFC,0x00,
0x1F,0x06,0x0C,0x0C,0x06,0xCC,0x78,0x00,
0x03,0x0E,0x1E,0x6C,0x7E,0x18,0x18,0x00,
0x1F,0x30,0x3E,0x06,0x06,0xCC,0x78,0x00,
0x0F,0x30,0x30,0x7C,0x66,0xCC,0x78,0x00,
0x1F,0x03,0x06,0x18,0x30,0x60,0x60,0x00,
0x0F,0x33,0x33,0x3C,0x66,0xCC,0x78,0x00,
0x0F,0x33,0x33,0x3E,0x06,0x18,0x70,0x00,
0x00,0x0C,0x0C,0x00,0x18,0x30,0x00,0x00,
0x00,0x0C,0x0C,0x00,0x18,0x30,0x60,0x00,
0x01,0x06,0x0C,0x30,0x18,0x18,0x0C,0x00,
0x00,0x00,0x3F,0x00,0x00,0xFC,0x00,0x00,
0x18,0x18,0x0C,0x0C,0x18,0x60,0xC0,0x00,
0x0F,0x33,0x03,0x0C,0x18,0x00,0x30,0x00,
0x0F,0x33,0x37,0x6A,0x6E,0xC0,0x7C,0x00,
0x06,0x1E,0x33,0x66,0x7E,0xCC,0xCC,0x00,
0x1F,0x33,0x33,0x7C,0x66,0xCC,0xF8,0x00,
0x0F,0x33,0x30,0x60,0x60,0xCC,0x78,0x00,
0x1E,0x36,0x33,0x66,0x66,0xD8,0xF0,0x00,
0x1F,0x30,0x30,0x7C,0x60,0xC0,0xFC,0x00,
0x1F,0x30,0x30,0x7C,0x60,0xC0,0xC0,0x00,
0x0F,0x30,0x30,0x6E,0x66,0xCC,0x7C,0x00,
0x19,0x33,0x33,0x7E,0x66,0xCC,0xCC,0x00,
0x0F,0x0C,0x0C,0x18,0x18,0x30,0x78,0x00,
0x01,0x03,0x03,0x06,0x06,0xCC,0x78,0x00,
0x19,0x36,0x3C,0x70,0x78,0xD8,0xCC,0x00,
0x18,0x30,0x30,0x60,0x60,0xC0,0xFC,0x00,
0x31,0x77,0x7F,0xD6,0xC6,0x8C,0x8C,0x00,
0x19,0x3B,0x3F,0x7E,0x6E,0xCC,0xCC,0x00,
0x0F,0x33,0x33,0x66,0x66,0xCC,0x78,0x00,
0x1F,0x33,0x33,0x7C,0x60,0xC0,0xC0,0x00,
0x0F,0x33,0x33,0x66,0x76,0xD8,0x6C,0x00,
0x1F,0x33,0x33,0x7C,0x6C,0xCC,0xCC,0x00,
0x0F,0x33,0x30,0x3C,0x06,0xCC,0x78,0x00,
0x1F,0x0C,0x0C,0x18,0x18,0x30,0x30,0x00,
0x19,0x33,0x33,0x66,0x66,0xCC,0x7C,0x00,
0x19,0x33,0x33,0x66,0x66,0x78,0x30,0x00,
0x31,0x63,0x63,0xD6,0xFE,0xDC,0x8C,0x00,
0x19,0x33,0x1E,0x18,0x3C,0xCC,0xCC,0x00,
0x19,0x33,0x33,0x3C,0x18,0x30,0x30,0x00,
0x1F,0x03,0x06,0x18,0x30,0xC0,0xFC,0x00,
0x07,0x0C,0x0C,0x18,0x18,0x30,0x3C,0x00,
0x10,0x30,0x18,0x18,0x0C,0x0C,0x04,0x00,
0x1E,0x0C,0x0C,0x18,0x18,0x30,0xF0,0x00,
0x04,0x1C,0x36,0xC6,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0xFC,0x00,
0x00,0x60,0x30,0x30,0x00,0x00,0x00,0x00,
0x00,0x00,0x1E,0x06,0x3E,0xCC,0x7C,0x00,
0x18,0x30,0x3E,0x66,0x66,0xCC,0xF8,0x00,
0x00,0x00,0x1E,0x60,0x60,0xC0,0x78,0x00,
0x01,0x03,0x1F,0x66,0x66,0xCC,0x7C,0x00,
0x00,0x00,0x1E,0x66,0x7E,0xC0,0x78,0x00,
0x07,0x18,0x3E,0x30,0x30,0x60,0x60,0x00,
0x00,0x00,0x1F,0x66,0x66,0x7C,0x0C,0xF0,
0x18,0x30,0x3E,0x66,0x66,0xCC,0xCC,0x00,
0x06,0x00,0x1C,0x18,0x18,0x30,0x78,0x00,
0x06,0x00,0x0C,0x18,0x18,0x30,0x30,0xC0,
0x18,0x30,0x33,0x6C,0x78,0xD8,0xCC,0x00,
0x0E,0x0C,0x0C,0x18,0x18,0x30,0x78,0x00,
0x00,0x00,0x76,0xFE,0xD6,0x8C,0x8C,0x00,
0x00,0x00,0x3E,0x66,0x66,0xCC,0xCC,0x00,
0x00,0x00,0x1E,0x66,0x66,0xCC,0x78,0x00,
0x00,0x00,0x3E,0x66,0x66,0xCC,0xF8,0x80,
0x00,0x00,0x1F,0x66,0x66,0xCC,0x7C,0x18,
0x00,0x00,0x3E,0x66,0x60,0xC0,0xC0,0x00,
0x00,0x00,0x1F,0x60,0x3C,0x0C,0xF8,0x00,
0x00,0x0C,0x3F,0x18,0x18,0x30,0x1C,0x00,
0x00,0x00,0x33,0x66,0x66,0xCC,0x7C,0x00,
0x00,0x00,0x33,0x66,0x66,0x78,0x30,0x00,
0x00,0x00,0x63,0xC6,0xD6,0xF8,0xD8,0x00,
0x00,0x00,0x33,0x3C,0x18,0x78,0xCC,0x00,
0x00,0x00,0x33,0x66,0x66,0x7C,0x0C,0xF0,
0x00,0x00,0x3F,0x0C,0x18,0x60,0xFC,0x00,
0x03,0x0C,0x0C,0x30,0x18,0x30,0x1C,0x00,
0x06,0x0C,0x0C,0x18,0x18,0x30,0x30,0x60,
0x1C,0x0C,0x0C,0x0C,0x18,0x30,0xE0,0x00,
0x00,0x30,0x79,0x9E,0x0C,0x00,0x00,0x00,
0x00,0x0C,0x0C,0x34,0x34,0xC4,0xFC,0x00,
0x00,0x1E,0x33,0x60,0x66,0x78,0x10,0xE0,
0x19,0x00,0x00,0x66,0x66,0xCC,0x7C,0x00,
0x03,0x0C,0x00,0x3C,0x7E,0xC0,0x78,0x00,
0x06,0x33,0x00,0x3C,0x06,0xFC,0x7C,0x00,
0x19,0x00,0x1E,0x06,0x3E,0xCC,0x7C,0x00,
0x0C,0x0C,0x00,0x3C,0x06,0xFC,0x7C,0x00,
0x06,0x0C,0x00,0x3C,0x06,0xFC,0x7C,0x00,
0x00,0x00,0x1E,0x60,0x60,0x78,0x10,0x60,
0x06,0x33,0x00,0x3C,0x7E,0xC0,0x78,0x00,
0x19,0x00,0x1E,0x66,0x7E,0xC0,0x78,0x00,
0x0C,0x0C,0x00,0x3C,0x7E,0xC0,0x78,0x00,
0x19,0x00,0x00,0x38,0x18,0x30,0x78,0x00,
0x06,0x33,0x00,0x38,0x18,0x30,0x78,0x00,
0x18,0x18,0x00,0x38,0x18,0x30,0x78,0x00,
0x19,0x00,0x0C,0x3C,0x66,0xFC,0xCC,0x00,
0x06,0x00,0x0C,0x3C,0x66,0xFC,0xCC,0x00,
0x03,0x0C,0x3F,0x60,0x7C,0xC0,0xFC,0x00,
0x00,0x00,0x3F,0x1B,0x7F,0xB0,0xFC,0x00,
0x0F,0x3C,0x6C,0xDE,0xF8,0xB0,0xBE,0x00,
0x06,0x33,0x00,0x3C,0x66,0xCC,0x78,0x00,
0x19,0x00,0x00,0x3C,0x66,0xCC,0x78,0x00,
0x0C,0x0C,0x00,0x3C,0x66,0xCC,0x78,0x00,
0x06,0x33,0x00,0x66,0x66,0xCC,0x7C,0x00,
0x0C,0x0C,0x00,0x66,0x66,0xCC,0x7C,0x00,
0x19,0x00,0x33,0x66,0x66,0x7C,0x0C,0xF0,
0x19,0x00,0x1E,0x66,0x66,0xCC,0x78,0x00,
0x19,0x00,0x33,0x66,0x66,0xCC,0x7C,0x00,
0x06,0x0C,0x1E,0x60,0x60,0x78,0x30,0x60,
0x07,0x1D,0x18,0x7C,0x30,0x60,0xFC,0x00,
0x19,0x33,0x1E,0x18,0x3C,0x30,0x30,0x00,
0x07,0x1B,0x33,0x7C,0x66,0xCC,0xF8,0x80,
0x07,0x18,0x3E,0x30,0x30,0x60,0xC0,0x00,
0x03,0x0C,0x00,0x3C,0x06,0xFC,0x7C,0x00,
0x03,0x0C,0x00,0x38,0x18,0x30,0x78,0x00,
0x03,0x0C,0x00,0x3C,0x66,0xCC,0x78,0x00,
0x03,0x0C,0x00,0x66,0x66,0xCC,0x7C,0x00,
0x0D,0x2C,0x00,0x7C,0x66,0xCC,0xCC,0x00,
0x0D,0x2C,0x00,0x66,0x76,0xDC,0xCC,0x00,
0x00,0x1E,0x03,0x3E,0x66,0x7C,0x00,0xF0,
0x00,0x1E,0x33,0x66,0x66,0x78,0x00,0xF0,
0x00,0x0C,0x00,0x18,0x30,0xC0,0xCC,0xF0,
0x00,0x00,0x00,0x3E,0x30,0x60,0x60,0x00,
0x00,0x00,0x00,0x7C,0x0C,0x18,0x18,0x00,
0x31,0x66,0x6C,0x36,0x6B,0x86,0x0C,0x3C,
0x31,0x66,0x6C,0x36,0x6E,0xAC,0x3E,0x18,
0x00,0x0C,0x00,0x18,0x18,0x30,0x30,0x60,
0x06,0x1B,0x36,0xD8,0x6C,0x6C,0x36,0x00,
0x36,0x36,0x1B,0x1B,0x36,0xD8,0xB0,0x00,
0x0D,0x2C,0x00,0x3C,0x06,0xFC,0x7C,0x00,
0x0D,0x2C,0x00,0x3C,0x66,0xCC,0x78,0x00,
0x00,0x1E,0x33,0x6E,0x76,0xCC,0x78,0x00,
0x00,0x01,0x1E,0x6E,0x76,0xCC,0x78,0x00,
0x00,0x00,0x3F,0xDB,0xDF,0xB0,0xFC,0x00,
0x1F,0x6C,0x6C,0xDE,0xD8,0xB0,0xFE,0x00,
0x0C,0x0C,0x00,0x18,0x3C,0xCC,0xFC,0x98,
0x0D,0x2C,0x00,0x18,0x3C,0xCC,0xFC,0x98,
0x0D,0x2C,0x1E,0x66,0x66,0xCC,0xCC,0xF0,
0x19,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x03,0x0C,0x18,0x00,0x00,0x00,0x00,0x00,
0x00,0x08,0x1C,0x10,0x10,0x20,0x00,0x00,
0x1E,0x65,0x65,0xCA,0x7A,0x14,0x14,0x28,
0x1F,0x61,0x5E,0xB1,0xB1,0x7A,0x86,0xF8,
0x1F,0x61,0x5E,0xA5,0xB9,0x5A,0x86,0xF8,
0x3C,0x2D,0x2F,0x55,0x51,0x00,0x00,0x00,
0x19,0x00,0x73,0x66,0x66,0xEC,0x0C,0x70,
0x3D,0x33,0x33,0x66,0x66,0xEC,0x0C,0x70,
0x00,0x33,0x3B,0x3C,0x6E,0xCC,0x00,0x00,
0x00,0x3E,0x06,0x0C,0x0C,0xFC,0x00,0x00,
0x00,0x0F,0x03,0x0E,0x1E,0x6C,0x00,0x00,
0x00,0x3F,0x06,0x0C,0x0C,0x18,0x00,0x00,
0x00,0x3E,0x03,0x66,0x66,0xCC,0x00,0x00,
0x00,0x0E,0x06,0x0C,0x0C,0x18,0x00,0x00,
0x00,0x0F,0x06,0x06,0x06,0x0C,0x00,0x00,
0x00,0x3F,0x1B,0x36,0x36,0x6C,0x00,0x00,
0x18,0x37,0x33,0x66,0x66,0xFC,0x00,0x00,
0x00,0x1E,0x06,0x0C,0x00,0x00,0x00,0x00,
0x00,0x1F,0x03,0x06,0x06,0x7C,0x00,0x00,
0x18,0x3F,0x03,0x06,0x06,0x1C,0x00,0x00,
0x00,0x36,0x1F,0x66,0x66,0xDC,0x00,0x00,
0x00,0x0E,0x06,0x0C,0x0C,0x78,0x00,0x00,
0x00,0x1F,0x1B,0x36,0x36,0x38,0x00,0x00,
0x00,0x1B,0x1B,0x36,0x36,0xFC,0x00,0x00,
0x00,0x3F,0x33,0x76,0x06,0xFC,0x00,0x00,
0x00,0x33,0x33,0x3C,0x0E,0xFC,0x00,0x00,
0x00,0x1F,0x03,0x36,0x36,0x68,0x60,0x00,
0x00,0x3C,0x06,0x0C,0x0C,0x18,0x00,0x00,
0x00,0x6B,0x6B,0xD6,0xD6,0xFC,0x00,0x00,
0x00,0x3E,0x36,0x6C,0x6C,0xD8,0x00,0x00,
0x00,0x0E,0x06,0x0C,0x0C,0x18,0x18,0x00,
0x00,0x1F,0x03,0x06,0x06,0x0C,0x0C,0x00,
0x00,0x7F,0x33,0x66,0x66,0xFC,0x00,0x00,
0x00,0x3F,0x33,0x76,0x06,0x0C,0x0C,0x00,
0x00,0x1B,0x1B,0x1C,0x0C,0x18,0x18,0x00,
0x03,0x0D,0x1E,0x66,0x66,0x78,0xB0,0xC0,
0x00,0x08,0x1C,0x6C,0xC6,0x04,0x00,0x00,
0x19,0x7B,0x4C,0x99,0xEF,0xCC,0x00,0x00,
0x00,0x00,0x3B,0xDC,0xC8,0xB8,0xEC,0x00,
0x07,0x1B,0x33,0x7C,0x66,0xCC,0xF8,0x80,
0x00,0x7F,0x33,0x62,0x60,0xC0,0xC0,0xE0,
0x00,0x00,0x7F,0x6C,0x6C,0xD8,0xD8,0x20,
0x3F,0x33,0x18,0x18,0x30,0xCC,0xFC,0x00,
0x00,0x0F,0x1C,0x6C,0x6C,0xD8,0x70,0x00,
0x00,0x00,0x36,0x6C,0x6C,0xD8,0xFE,0x00,
0x00,0x00,0x3F,0x18,0x18,0x30,0x30,0x40,
0x0F,0x0C,0x1E,0x66,0x66,0x78,0x30,0xF0,
0x00,0x1E,0x33,0x7E,0x66,0xCC,0x78,0x00,
0x00,0x1E,0x33,0x66,0x66,0x48,0xCC,0x00,
0x07,0x1B,0x3C,0xDC,0xCC,0xD8,0xF0,0x00,
0x03,0x0C,0x1C,0x54,0x54,0x70,0x60,0x80,
0x00,0x08,0x3E,0xD6,0xD6,0xAC,0xF8,0x40,
0x0F,0x38,0x30,0x7E,0x60,0xE0,0x7C,0x00,
0x0F,0x33,0x33,0x66,0x66,0xCC,0xCC,0x00,
0x00,0x3F,0x00,0x7E,0x00,0xFC,0x00,0x00,
0x06,0x0C,0x3F,0x18,0x18,0x00,0xFC,0x00,
0x0C,0x0C,0x06,0x18,0x30,0x00,0xFC,0x00,
0x03,0x0C,0x18,0x18,0x0C,0x00,0xFC,0x00,
0x00,0x07,0x0D,0x1B,0x18,0x30,0x30,0x60,
0x06,0x0C,0x0C,0x18,0xD8,0xB0,0xE0,0x00,
0x06,0x0C,0x00,0x7E,0x00,0x30,0x30,0x00,
0x00,0x19,0x26,0x00,0x32,0x98,0x00,0x00,
0x0E,0x36,0x1C,0x00,0x00,0x00,0x00,0x00,
0x0E,0x3E,0x1C,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x18,0x30,0x00,0x00,
0x00,0x00,0x07,0x18,0xD8,0xE0,0x60,0x00,
0x0E,0x36,0x36,0x6C,0x6C,0x00,0x00,0x00,
0x0E,0x36,0x0C,0x30,0x7C,0x00,0x00,0x00,
0x1E,0x06,0x1C,0x0C,0x78,0x00,0x00,0x00,
0x00,0x7F,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x08,0x10,0x08,0x10,0x08,0x00,0x08,0x00,
0x22,0x44,0x22,0x00,0x00,0x00,0x00,0x00,
0x00,0x44,0xAA,0x44,0x28,0x54,0x28,0x00,
0x08,0x14,0x20,0x14,0x02,0x54,0x08,0x00,
0x00,0x44,0x28,0x10,0x20,0x44,0x02,0x00,
0x28,0x44,0x28,0x50,0x8A,0x44,0x22,0x00,
0x08,0x10,0x08,0x00,0x00,0x00,0x00,0x00,
0x0A,0x14,0x08,0x10,0x08,0x14,0x0A,0x00,
0x20,0x10,0x08,0x10,0x08,0x10,0x20,0x00,
0x00,0x44,0x28,0x55,0x28,0x44,0x00,0x00,
0x00,0x10,0x08,0x54,0x08,0x10,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x10,0x20,0x40,
0x00,0x00,0x00,0x54,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x10,0x08,0x00,
0x02,0x04,0x08,0x10,0x20,0x40,0x00,0x00,
0x28,0x44,0x2A,0x54,0x22,0x44,0x28,0x00,
0x08,0x10,0x08,0x10,0x08,0x10,0x2A,0x00,
0x28,0x44,0x02,0x04,0x08,0x10,0x2A,0x00,
0x2A,0x04,0x08,0x04,0x02,0x44,0x28,0x00,
0x08,0x14,0x28,0x44,0x2A,0x04,0x08,0x00,
0x2A,0x40,0x28,0x04,0x02,0x44,0x28,0x00,
0x28,0x40,0x20,0x54,0x22,0x44,0x28,0x00,
0x2A,0x04,0x08,0x10,0x20,0x10,0x20,0x00,
0x28,0x44,0x22,0x14,0x22,0x44,0x28,0x00,
0x28,0x44,0x22,0x14,0x02,0x04,0x28,0x00,
0x00,0x10,0x08,0x00,0x08,0x10,0x00,0x00,
0x00,0x10,0x08,0x00,0x08,0x10,0x20,0x00,
0x02,0x04,0x08,0x10,0x08,0x04,0x02,0x00,
0x00,0x00,0x2A,0x00,0x00,0x54,0x00,0x00,
0x20,0x10,0x08,0x04,0x08,0x10,0x20,0x00,
0x28,0x44,0x02,0x04,0x08,0x00,0x08,0x00,
0x28,0x44,0x2A,0x40,0x2A,0x40,0x2A,0x00,
0x08,0x14,0x22,0x44,0x2A,0x44,0x22,0x00,
0x28,0x44,0x22,0x54,0x22,0x44,0x28,0x00,
0x28,0x44,0x20,0x40,0x20,0x44,0x28,0x00,
0x28,0x44,0x22,0x44,0x22,0x44,0x28,0x00,
0x2A,0x40,0x20,0x54,0x20,0x40,0x2A,0x00,
0x2A,0x40,0x20,0x54,0x20,0x40,0x20,0x00,
0x2A,0x40,0x20,0x44,0x22,0x44,0x2A,0x00,
0x22,0x44,0x22,0x54,0x22,0x44,0x22,0x00,
0x28,0x10,0x08,0x10,0x08,0x10,0x28,0x00,
0x02,0x04,0x02,0x04,0x02,0x44,0x28,0x00,
0x22,0x44,0x28,0x50,0x28,0x44,0x22,0x00,
0x20,0x40,0x20,0x40,0x20,0x40,0x2A,0x00,
0x82,0x44,0xAA,0x54,0x82,0x44,0x82,0x00,
0x22,0x54,0x2A,0x54,0x2A,0x44,0x22,0x00,
0x28,0x44,0x22,0x44,0x22,0x44,0x28,0x00,
0x28,0x44,0x22,0x54,0x20,0x40,0x20,0x00,
0x28,0x44,0x22,0x44,0x22,0x44,0x22,0x00,
0x28,0x44,0x22,0x54,0x28,0x44,0x22,0x00,
0x28,0x44,0x20,0x14,0x02,0x44,0x28,0x00,
0x2A,0x10,0x08,0x10,0x08,0x10,0x08,0x00,
0x22,0x44,0x22,0x44,0x22,0x44,0x2A,0x00,
0x22,0x44,0x22,0x44,0x22,0x14,0x08,0x00,
0x82,0x44,0x82,0x54,0xAA,0x44,0x82,0x00,
0x22,0x44,0x28,0x10,0x28,0x44,0x22,0x00,
0x22,0x44,0x22,0x14,0x08,0x10,0x08,0x00,
0x2A,0x04,0x08,0x10,0x20,0x40,0x2A,0x00,
0x0A,0x10,0x08,0x10,0x08,0x10,0x0A,0x00,
0x00,0x40,0x20,0x10,0x08,0x04,0x02,0x00,
0x28,0x10,0x08,0x10,0x08,0x10,0x28,0x00,
0x00,0x10,0x28,0x44,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0xAA,0x00,
0x00,0x40,0x20,0x10,0x00,0x00,0x00,0x00,
0x00,0x00,0x28,0x04,0x2A,0x44,0x2A,0x00,
0x20,0x40,0x28,0x44,0x22,0x44,0x28,0x00,
0x00,0x00,0x28,0x40,0x20,0x40,0x28,0x00,
0x02,0x04,0x2A,0x44,0x22,0x44,0x2A,0x00,
0x00,0x00,0x28,0x44,0x2A,0x40,0x28,0x00,
0x08,0x10,0x28,0x10,0x20,0x10,0x20,0x00,
0x00,0x00,0x2A,0x44,0x22,0x14,0x02,0x54,
0x20,0x40,0x28,0x44,0x22,0x44,0x22,0x00,
0x08,0x00,0x28,0x10,0x08,0x10,0x28,0x00,
0x08,0x00,0x08,0x10,0x08,0x10,0x08,0x50,
0x20,0x40,0x22,0x44,0x28,0x44,0x22,0x00,
0x28,0x10,0x08,0x10,0x08,0x10,0x28,0x00,
0x00,0x00,0xA8,0x54,0x82,0x44,0x82,0x00,
0x00,0x00,0x28,0x44,0x22,0x44,0x22,0x00,
0x00,0x00,0x28,0x44,0x22,0x44,0x28,0x00,
0x00,0x00,0x28,0x44,0x22,0x44,0x28,0x40,
0x00,0x00,0x2A,0x44,0x22,0x44,0x2A,0x04,
0x00,0x00,0x28,0x44,0x20,0x40,0x20,0x00,
0x00,0x00,0x2A,0x40,0x28,0x04,0x28,0x00,
0x00,0x10,0x2A,0x10,0x08,0x10,0x0A,0x00,
0x00,0x00,0x22,0x44,0x22,0x44,0x2A,0x00,
0x00,0x00,0x22,0x44,0x22,0x14,0x08,0x00,
0x00,0x00,0x82,0x44,0x82,0x54,0x28,0x00,
0x00,0x00,0x22,0x14,0x08,0x14,0x22,0x00,
0x00,0x00,0x22,0x44,0x22,0x14,0x02,0x54,
0x00,0x00,0x2A,0x04,0x08,0x10,0x2A,0x00,
0x0A,0x10,0x08,0x10,0x08,0x10,0x0A,0x00,
0x08,0x10,0x08,0x10,0x08,0x10,0x08,0x10,
0x20,0x10,0x08,0x04,0x08,0x10,0x20,0x00,
0x00,0x40,0xA2,0x14,0x08,0x00,0x00,0x00,
0x00,0x10,0x08,0x14,0x20,0x40,0x2A,0x00,
0x00,0x14,0x22,0x40,0x22,0x14,0x08,0x10,
0x22,0x00,0x00,0x44,0x22,0x44,0x2A,0x00,
0x08,0x10,0x00,0x14,0x2A,0x40,0x28,0x00,
0x08,0x44,0x00,0x14,0x02,0x54,0x2A,0x00,
0x22,0x00,0x28,0x04,0x2A,0x44,0x2A,0x00,
0x20,0x10,0x00,0x14,0x02,0x54,0x2A,0x00,
0x08,0x10,0x00,0x14,0x02,0x54,0x2A,0x00,
0x00,0x00,0x28,0x40,0x20,0x14,0x08,0x10,
0x08,0x44,0x00,0x14,0x2A,0x40,0x28,0x00,
0x22,0x00,0x28,0x44,0x2A,0x40,0x28,0x00,
0x20,0x10,0x00,0x14,0x2A,0x40,0x28,0x00,
0x22,0x00,0x00,0x10,0x08,0x10,0x28,0x00,
0x08,0x44,0x00,0x10,0x08,0x10,0x28,0x00,
0x20,0x10,0x00,0x10,0x08,0x10,0x28,0x00,
0x22,0x00,0x08,0x14,0x22,0x54,0x22,0x00,
0x08,0x00,0x08,0x14,0x22,0x54,0x22,0x00,
0x08,0x10,0x2A,0x40,0x28,0x40,0x2A,0x00,
0x00,0x00,0x2A,0x11,0x2A,0x50,0x2A,0x00,
0x2A,0x50,0x88,0x54,0xA8,0x50,0x8A,0x00,
0x08,0x44,0x00,0x14,0x22,0x44,0x28,0x00,
0x22,0x00,0x00,0x14,0x22,0x44,0x28,0x00,
0x20,0x10,0x00,0x14,0x22,0x44,0x28,0x00,
0x08,0x44,0x00,0x44,0x22,0x44,0x2A,0x00,
0x20,0x10,0x00,0x44,0x22,0x44,0x2A,0x00,
0x22,0x00,0x22,0x44,0x22,0x14,0x02,0x54,
0x22,0x00,0x28,0x44,0x22,0x44,0x28,0x00,
0x22,0x00,0x22,0x44,0x22,0x44,0x2A,0x00,
0x08,0x10,0x28,0x40,0x20,0x14,0x08,0x10,
0x08,0x10,0x20,0x54,0x20,0x10,0x2A,0x00,
0x22,0x44,0x28,0x10,0x28,0x10,0x08,0x00,
0x08,0x14,0x22,0x54,0x22,0x44,0x28,0x40,
0x0A,0x10,0x28,0x10,0x20,0x10,0x20,0x00,
0x08,0x10,0x00,0x14,0x02,0x54,0x2A,0x00,
0x08,0x10,0x00,0x10,0x08,0x10,0x28,0x00,
0x08,0x10,0x00,0x14,0x22,0x44,0x28,0x00,
0x08,0x10,0x00,0x44,0x22,0x44,0x2A,0x00,
0x20,0x50,0x00,0x54,0x22,0x44,0x22,0x00,
0x20,0x50,0x00,0x44,0x22,0x44,0x22,0x00,
0x00,0x14,0x02,0x14,0x22,0x14,0x00,0x14,
0x00,0x14,0x22,0x44,0x22,0x14,0x00,0x14,
0x00,0x10,0x00,0x10,0x20,0x40,0x22,0x14,
0x00,0x00,0x00,0x14,0x20,0x10,0x20,0x00,
0x00,0x00,0x00,0x54,0x08,0x04,0x08,0x00,
0x82,0x44,0x88,0x14,0x2A,0x41,0x82,0x05,
0x82,0x44,0x88,0x14,0x2A,0x54,0x8A,0x04,
0x00,0x10,0x00,0x10,0x08,0x10,0x08,0x10,
0x0A,0x14,0x28,0x50,0x28,0x14,0x0A,0x00,
0x88,0x44,0x22,0x11,0x22,0x44,0x88,0x00,
0x20,0x50,0x00,0x14,0x02,0x54,0x2A,0x00,
0x20,0x50,0x00,0x14,0x22,0x44,0x28,0x00,
0x02,0x14,0x22,0x44,0x22,0x44,0x28,0x40,
0x00,0x00,0x28,0x44,0x22,0x44,0x28,0x40,
0x00,0x00,0x2A,0x51,0x8A,0x50,0x2A,0x00,
0x2A,0x50,0x88,0x54,0x88,0x50,0x2A,0x00,
0x20,0x10,0x00,0x10,0x28,0x44,0x2A,0x44,
0x20,0x50,0x00,0x10,0x28,0x44,0x2A,0x44,
0x20,0x50,0x28,0x44,0x22,0x44,0x22,0x14,
0x22,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x08,0x10,0x20,0x00,0x00,0x00,0x00,0x00,
0x00,0x10,0x28,0x10,0x00,0x10,0x00,0x00,
0x2A,0x40,0x8A,0x40,0x2A,0x00,0x0A,0x00,
0x2A,0x41,0xA8,0x11,0xA0,0x15,0x82,0x54,
0x2A,0x41,0xA8,0x05,0xA8,0x05,0x82,0x54,
0xA0,0x51,0x0A,0x55,0x00,0x00,0x00,0x00,
0x22,0x00,0xA2,0x44,0x22,0x54,0x02,0x14,
0xA2,0x44,0x22,0x44,0x22,0x54,0x02,0x14,
0x00,0x44,0x22,0x14,0x2A,0x44,0x00,0x00,
0x00,0x54,0x08,0x04,0x08,0x54,0x00,0x00,
0x00,0x14,0x02,0x04,0x0A,0x14,0x00,0x00,
0x00,0x54,0x08,0x04,0x08,0x04,0x00,0x00,
0x00,0x54,0x02,0x44,0x22,0x44,0x00,0x00,
0x00,0x14,0x08,0x04,0x08,0x04,0x00,0x00,
0x00,0x14,0x08,0x04,0x02,0x04,0x00,0x00,
0x00,0x54,0x22,0x14,0x22,0x14,0x00,0x00,
0x20,0x44,0x22,0x44,0x22,0x54,0x00,0x00,
0x00,0x14,0x08,0x04,0x00,0x00,0x00,0x00,
0x00,0x14,0x02,0x04,0x02,0x14,0x00,0x00,
0x20,0x54,0x02,0x04,0x02,0x04,0x00,0x00,
0x00,0x44,0x2A,0x44,0x22,0x44,0x00,0x00,
0x00,0x14,0x08,0x04,0x08,0x14,0x00,0x00,
0x00,0x14,0x22,0x14,0x22,0x14,0x00,0x00,
0x00,0x14,0x22,0x14,0x22,0x54,0x00,0x00,
0x00,0x54,0x22,0x54,0x02,0x54,0x00,0x00,
0x00,0x44,0x22,0x14,0x0A,0x54,0x00,0x00,
0x00,0x14,0x02,0x14,0x22,0x14,0x20,0x00,
0x00,0x50,0x08,0x04,0x08,0x04,0x00,0x00,
0x00,0x54,0x82,0x54,0x82,0x54,0x00,0x00,
0x00,0x54,0x28,0x44,0x28,0x44,0x00,0x00,
0x00,0x14,0x08,0x04,0x08,0x04,0x08,0x00,
0x00,0x14,0x02,0x04,0x02,0x04,0x02,0x00,
0x00,0x54,0x22,0x44,0x22,0x54,0x00,0x00,
0x00,0x54,0x22,0x54,0x02,0x04,0x02,0x00,
0x00,0x14,0x22,0x14,0x08,0x04,0x08,0x00,
0x0A,0x11,0x28,0x44,0x22,0x14,0x88,0x50,
0x00,0x10,0x28,0x44,0x82,0x00,0x00,0x00,
0x22,0x55,0x88,0x11,0xAA,0x44,0x00,0x00,
0x00,0x00,0x22,0x54,0x88,0x54,0x22,0x00,
0x08,0x14,0x22,0x54,0x22,0x44,0x28,0x40,
0x00,0x54,0x22,0x40,0x20,0x40,0x20,0x50,
0x00,0x00,0xAA,0x44,0x28,0x44,0x28,0x40,
0xAA,0x44,0x20,0x10,0x20,0x44,0xAA,0x00,
0x00,0x14,0x28,0x44,0x28,0x44,0x28,0x00,
0x00,0x00,0x28,0x44,0x28,0x44,0x2A,0x40,
0x00,0x00,0x2A,0x10,0x08,0x10,0x08,0x10,
0x28,0x10,0x28,0x44,0x22,0x14,0x08,0x14,
0x00,0x14,0x22,0x54,0x22,0x44,0x28,0x00,
0x00,0x14,0x22,0x44,0x22,0x04,0x22,0x00,
0x08,0x14,0x28,0x54,0x88,0x44,0x28,0x00,
0x08,0x10,0x28,0x54,0x00,0x10,0x20,0x40,
0x00,0x10,0x28,0x54,0x82,0x54,0x28,0x10,
0x2A,0x50,0x20,0x54,0x20,0x50,0x2A,0x00,
0x28,0x44,0x22,0x44,0x22,0x44,0x22,0x00,
0x00,0x54,0x00,0x54,0x00,0x54,0x00,0x00,
0x08,0x10,0x2A,0x10,0x08,0x00,0x2A,0x00,
0x20,0x10,0x08,0x10,0x20,0x00,0x2A,0x00,
0x08,0x10,0x20,0x10,0x08,0x00,0x2A,0x00,
0x00,0x04,0x0A,0x11,0x08,0x10,0x08,0x10,
0x08,0x10,0x08,0x10,0x88,0x50,0x20,0x00,
0x08,0x10,0x00,0x54,0x00,0x10,0x08,0x00,
0x00,0x10,0x08,0x00,0x22,0x44,0x00,0x00,
0x28,0x44,0x28,0x00,0x00,0x00,0x00,0x00,
0x28,0x54,0x28,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x08,0x10,0x00,0x00,
0x00,0x00,0x0A,0x10,0x88,0x50,0x20,0x00,
0x28,0x44,0x28,0x44,0x28,0x00,0x00,0x00,
0x28,0x44,0x08,0x10,0x28,0x00,0x00,0x00,
0x28,0x04,0x28,0x04,0x28,0x00,0x00,0x00,
0x00,0x54,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x1C,0x1C,0x1C,0x1C,0x1C,0x00,0x1C,0x00,
0x77,0x77,0x77,0x00,0x00,0x00,0x00,0x00,
0x00,0x7E,0xFF,0x7E,0x7E,0xFF,0x7E,0x00,
0x1C,0x3F,0x70,0x3E,0x07,0x7E,0x1C,0x00,
0x00,0x77,0x7E,0x1C,0x38,0x77,0x67,0x00,
0x3C,0x7E,0x3C,0x78,0xFF,0xEE,0x7F,0x00,
0x1C,0x1C,0x1C,0x00,0x00,0x00,0x00,0x00,
0x0F,0x1E,0x1C,0x1C,0x1C,0x1E,0x0F,0x00,
0x78,0x3C,0x1C,0x1C,0x1C,0x3C,0x78,0x00,
0x00,0x77,0x3E,0xFF,0x3E,0x77,0x00,0x00,
0x00,0x1C,0x1C,0x7F,0x1C,0x1C,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x38,0x38,0x70,
0x00,0x00,0x00,0x7F,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x1C,0x1C,0x00,
0x03,0x07,0x0E,0x1C,0x38,0x70,0x60,0x00,
0x3E,0x77,0x7F,0x7F,0x77,0x77,0x3E,0x00,
0x1C,0x3C,0x1C,0x1C,0x1C,0x1C,0x7F,0x00,
0x3E,0x77,0x07,0x0E,0x1C,0x38,0x7F,0x00,
0x7F,0x0E,0x1C,0x0E,0x07,0x77,0x3E,0x00,
0x0E,0x1E,0x3E,0x7E,0x7F,0x0E,0x0E,0x00,
0x7F,0x70,0x7E,0x07,0x07,0x77,0x3E,0x00,
0x3E,0x70,0x70,0x7E,0x77,0x77,0x3E,0x00,
0x7F,0x07,0x0E,0x1C,0x38,0x38,0x38,0x00,
0x3E,0x77,0x77,0x3E,0x77,0x77,0x3E,0x00,
0x3E,0x77,0x77,0x3F,0x07,0x0E,0x3C,0x00,
0x00,0x1C,0x1C,0x00,0x1C,0x1C,0x00,0x00,
0x00,0x1C,0x1C,0x00,0x1C,0x1C,0x38,0x00,
0x07,0x0E,0x1C,0x38,0x1C,0x0E,0x07,0x00,
0x00,0x00,0x7F,0x00,0x00,0x7F,0x00,0x00,
0x70,0x38,0x1C,0x0E,0x1C,0x38,0x70,0x00,
0x3E,0x77,0x07,0x0E,0x1C,0x00,0x1C,0x00,
0x3E,0x77,0x7F,0x7F,0x7F,0x70,0x3F,0x00,
0x1C,0x3E,0x77,0x77,0x7F,0x77,0x77,0x00,
0x7E,0x77,0x77,0x7E,0x77,0x77,0x7E,0x00,
0x3E,0x77,0x70,0x70,0x70,0x77,0x3E,0x00,
0x7C,0x7E,0x77,0x77,0x77,0x7E,0x7C,0x00,
0x7F,0x70,0x70,0x7E,0x70,0x70,0x7F,0x00,
0x7F,0x70,0x70,0x7E,0x70,0x70,0x70,0x00,
0x3F,0x70,0x70,0x7F,0x77,0x77,0x3F,0x00,
0x77,0x77,0x77,0x7F,0x77,0x77,0x77,0x00,
0x3E,0x1C,0x1C,0x1C,0x1C,0x1C,0x3E,0x00,
0x07,0x07,0x07,0x07,0x07,0x77,0x3E,0x00,
0x77,0x7E,0x7C,0x78,0x7C,0x7E,0x77,0x00,
0x70,0x70,0x70,0x70,0x70,0x70,0x7F,0x00,
0xE7,0xFF,0xFF,0xFF,0xE7,0xE7,0xE7,0x00,
0x77,0x7F,0x7F,0x7F,0x7F,0x77,0x77,0x00,
0x3E,0x77,0x77,0x77,0x77,0x77,0x3E,0x00,
0x7E,0x77,0x77,0x7E,0x70,0x70,0x70,0x00,
0x3E,0x77,0x77,0x77,0x7F,0x7E,0x3F,0x00,
0x7E,0x77,0x77,0x7E,0x7E,0x77,0x77,0x00,
0x3E,0x77,0x70,0x3E,0x07,0x77,0x3E,0x00,
0x7F,0x1C,0x1C,0x1C,0x1C,0x1C,0x1C,0x00,
0x77,0x77,0x77,0x77,0x77,0x77,0x3F,0x00,
0x77,0x77,0x77,0x77,0x77,0x3E,0x1C,0x00,
0xE7,0xE7,0xE7,0xFF,0xFF,0xFF,0xE7,0x00,
0x77,0x77,0x3E,0x1C,0x3E,0x77,0x77,0x00,
0x77,0x77,0x77,0x3E,0x1C,0x1C,0x1C,0x00,
0x7F,0x07,0x0E,0x1C,0x38,0x70,0x7F,0x00,
0x1F,0x1C,0x1C,0x1C,0x1C,0x1C,0x1F,0x00,
0x60,0x70,0x38,0x1C,0x0E,0x07,0x03,0x00,
0x7C,0x1C,0x1C,0x1C,0x1C,0x1C,0x7C,0x00,
0x18,0x3C,0x7E,0xE7,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0xFF,0x00,
0x00,0xE0,0x70,0x38,0x00,0x00,0x00,0x00,
0x00,0x00,0x3E,0x07,0x3F,0x77,0x3F,0x00,
0x70,0x70,0x7E,0x77,0x77,0x77,0x7E,0x00,
0x00,0x00,0x3E,0x70,0x70,0x70,0x3E,0x00,
0x07,0x07,0x3F,0x77,0x77,0x77,0x3F,0x00,
0x00,0x00,0x3E,0x77,0x7F,0x70,0x3E,0x00,
0x1E,0x38,0x7E,0x38,0x38,0x38,0x38,0x00,
0x00,0x00,0x3F,0x77,0x77,0x3F,0x07,0x7E,
0x70,0x70,0x7E,0x77,0x77,0x77,0x77,0x00,
0x1C,0x00,0x3C,0x1C,0x1C,0x1C,0x3E,0x00,
0x1C,0x00,0x1C,0x1C,0x1C,0x1C,0x1C,0x78,
0x70,0x70,0x77,0x7E,0x7C,0x7E,0x77,0x00,
0x3C,0x1C,0x1C,0x1C,0x1C,0x1C,0x3E,0x00,
0x00,0x00,0xFE,0xFF,0xFF,0xE7,0xE7,0x00,
0x00,0x00,0x7E,0x77,0x77,0x77,0x77,0x00,
0x00,0x00,0x3E,0x77,0x77,0x77,0x3E,0x00,
0x00,0x00,0x7E,0x77,0x77,0x77,0x7E,0x70,
0x00,0x00,0x3F,0x77,0x77,0x77,0x3F,0x07,
0x00,0x00,0x7E,0x77,0x70,0x70,0x70,0x00,
0x00,0x00,0x3F,0x70,0x3E,0x07,0x7E,0x00,
0x00,0x1C,0x7F,0x1C,0x1C,0x1C,0x0F,0x00,
0x00,0x00,0x77,0x77,0x77,0x77,0x3F,0x00,
0x00,0x00,0x77,0x77,0x77,0x3E,0x1C,0x00,
0x00,0x00,0xE7,0xE7,0xFF,0x7E,0x7E,0x00,
0x00,0x00,0x77,0x3E,0x1C,0x3E,0x77,0x00,
0x00,0x00,0x77,0x77,0x77,0x3F,0x07,0x7E,
0x00,0x00,0x7F,0x0E,0x1C,0x38,0x7F,0x00,
0x0F,0x1C,0x1C,0x38,0x1C,0x1C,0x0F,0x00,
0x1C,0x1C,0x1C,0x1C,0x1C,0x1C,0x1C,0x1C,
0x78,0x1C,0x1C,0x0E,0x1C,0x1C,0x78,0x00,
0x00,0x70,0xFB,0xDF,0x0E,0x00,0x00,0x00,
0x00,0x1C,0x1C,0x3E,0x3E,0x73,0x7F,0x00,
0x00,0x3E,0x77,0x70,0x77,0x3E,0x0C,0x3C,
0x77,0x00,0x00,0x77,0x77,0x77,0x3F,0x00,
0x0E,0x1C,0x00,0x3E,0x7F,0x70,0x3E,0x00,
0x1C,0x77,0x00,0x3E,0x07,0x7F,0x3F,0x00,
0x77,0x00,0x3E,0x07,0x3F,0x77,0x3F,0x00,
0x38,0x1C,0x00,0x3E,0x07,0x7F,0x3F,0x00,
0x1C,0x1C,0x00,0x3E,0x07,0x7F,0x3F,0x00,
0x00,0x00,0x3E,0x70,0x70,0x3E,0x0C,0x1C,
0x1C,0x77,0x00,0x3E,0x7F,0x70,0x3E,0x00,
0x77,0x00,0x3E,0x77,0x7F,0x70,0x3E,0x00,
0x38,0x1C,0x00,0x3E,0x7F,0x70,0x3E,0x00,
0x77,0x00,0x00,0x3C,0x1C,0x1C,0x3E,0x00,
0x1C,0x77,0x00,0x3C,0x1C,0x1C,0x3E,0x00,
0x70,0x38,0x00,0x3C,0x1C,0x1C,0x3E,0x00,
0x77,0x00,0x1C,0x3E,0x77,0x7F,0x77,0x00,
0x1C,0x00,0x1C,0x3E,0x77,0x7F,0x77,0x00,
0x0E,0x1C,0x7F,0x70,0x7E,0x70,0x7F,0x00,
0x00,0x00,0x7F,0x1F,0x7F,0xFC,0x7F,0x00,
0x3F,0x7C,0xFC,0xFF,0xFC,0xFC,0xFF,0x00,
0x1C,0x77,0x00,0x3E,0x77,0x77,0x3E,0x00,
0x77,0x00,0x00,0x3E,0x77,0x77,0x3E,0x00,
0x38,0x1C,0x00,0x3E,0x77,0x77,0x3E,0x00,
0x1C,0x77,0x00,0x77,0x77,0x77,0x3F,0x00,
0x38,0x1C,0x00,0x77,0x77,0x77,0x3F,0x00,
0x77,0x00,0x77,0x77,0x77,0x3F,0x07,0x7E,
0x77,0x00,0x3E,0x77,0x77,0x77,0x3E,0x00,
0x77,0x00,0x77,0x77,0x77,0x77,0x3F,0x00,
0x1C,0x1C,0x3E,0x70,0x70,0x3E,0x1C,0x1C,
0x1E,0x3F,0x38,0x7E,0x38,0x38,0x7F,0x00,
0x77,0x77,0x3E,0x1C,0x3E,0x1C,0x1C,0x00,
0x1E,0x3F,0x77,0x7E,0x77,0x77,0x7E,0x70,
0x1F,0x38,0x7E,0x38,0x38,0x38,0x70,0x00,
0x0E,0x1C,0x00,0x3E,0x07,0x7F,0x3F,0x00,
0x0E,0x1C,0x00,0x3C,0x1C,0x1C,0x3E,0x00,
0x0E,0x1C,0x00,0x3E,0x77,0x77,0x3E,0x00,
0x0E,0x1C,0x00,0x77,0x77,0x77,0x3F,0x00,
0x3E,0x7C,0x00,0x7E,0x77,0x77,0x77,0x00,
0x3E,0x7C,0x00,0x77,0x7F,0x7F,0x77,0x00,
0x00,0x3E,0x07,0x3F,0x77,0x3F,0x00,0x3E,
0x00,0x3E,0x77,0x77,0x77,0x3E,0x00,0x3E,
0x00,0x1C,0x00,0x1C,0x38,0x70,0x77,0x3E,
0x00,0x00,0x00,0x3F,0x38,0x38,0x38,0x00,
0x00,0x00,0x00,0x7E,0x0E,0x0E,0x0E,0x00,
0xE7,0xEE,0xFC,0x3F,0x7F,0xE3,0xC7,0x0F,
0xE7,0xEE,0xFC,0x3F,0x7F,0xFF,0xDF,0x07,
0x00,0x1C,0x00,0x1C,0x1C,0x1C,0x1C,0x1C,
0x1F,0x3F,0x7E,0xFC,0x7E,0x3F,0x1F,0x00,
0xFC,0x7E,0x3F,0x1F,0x3F,0x7E,0xFC,0x00,
0x3E,0x7C,0x00,0x3E,0x07,0x7F,0x3F,0x00,
0x3E,0x7C,0x00,0x3E,0x77,0x77,0x3E,0x00,
0x03,0x3E,0x77,0x7F,0x7F,0x77,0x3E,0x60,
0x00,0x03,0x3E,0x7F,0x7F,0x77,0x3E,0x60,
0x00,0x00,0x7F,0xFF,0xFF,0xFC,0x7F,0x00,
0x7F,0xFC,0xFC,0xFF,0xFC,0xFC,0x7F,0x00,
0x38,0x1C,0x00,0x1C,0x3E,0x77,0x7F,0x77,
0x3E,0x7C,0x00,0x1C,0x3E,0x77,0x7F,0x77,
0x3E,0x7C,0x3E,0x77,0x77,0x77,0x77,0x3E,
0x77,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x0E,0x1C,0x38,0x00,0x00,0x00,0x00,0x00,
0x00,0x18,0x3C,0x18,0x18,0x18,0x00,0x00,
0x7F,0xEF,0xEF,0xEF,0x7F,0x0F,0x0F,0x0F,
0x7F,0xE3,0xFF,0xF9,0xF9,0xFF,0xE3,0x7F,
0x7F,0xE3,0xFF,0xF7,0xFD,0xFF,0xE3,0x7F,
0xF9,0x7F,0x7F,0x7F,0x79,0x00,0x00,0x00,
0x77,0x00,0xF7,0x77,0x77,0xFF,0x07,0x1E,
0xFF,0x77,0x77,0x77,0x77,0xFF,0x07,0x1E,
0x00,0x77,0x7F,0x3E,0x7F,0x77,0x00,0x00,
0x00,0x7E,0x0E,0x0E,0x0E,0x7F,0x00,0x00,
0x00,0x1F,0x07,0x0F,0x1F,0x3F,0x00,0x00,
0x00,0x7F,0x0E,0x0E,0x0E,0x0E,0x00,0x00,
0x00,0x7E,0x07,0x77,0x77,0x77,0x00,0x00,
0x00,0x1E,0x0E,0x0E,0x0E,0x0E,0x00,0x00,
0x00,0x1F,0x0E,0x07,0x07,0x07,0x00,0x00,
0x00,0x7F,0x3F,0x3F,0x3F,0x3F,0x00,0x00,
0x70,0x7F,0x77,0x77,0x77,0x7F,0x00,0x00,
0x00,0x3E,0x0E,0x0E,0x00,0x00,0x00,0x00,
0x00,0x3F,0x07,0x07,0x07,0x3F,0x00,0x00,
0x70,0x7F,0x07,0x07,0x07,0x0F,0x00,0x00,
0x00,0x7E,0x3F,0x77,0x77,0x7F,0x00,0x00,
0x00,0x1E,0x0E,0x0E,0x0E,0x3E,0x00,0x00,
0x00,0x3F,0x3F,0x3F,0x3F,0x1E,0x00,0x00,
0x00,0x3F,0x3F,0x3F,0x3F,0x7F,0x00,0x00,
0x00,0x7F,0x77,0x7F,0x07,0x7F,0x00,0x00,
0x00,0x77,0x77,0x3E,0x0F,0x7F,0x00,0x00,
0x00,0x3F,0x07,0x3F,0x3F,0x3E,0x38,0x00,
0x00,0x7C,0x0E,0x0E,0x0E,0x0E,0x00,0x00,
0x00,0xFF,0xFF,0xFF,0xFF,0xFF,0x00,0x00,
0x00,0x7E,0x7E,0x7E,0x7E,0xFE,0x00,0x00,
0x00,0x1E,0x0E,0x0E,0x0E,0x0E,0x0E,0x00,
0x00,0x3F,0x07,0x07,0x07,0x07,0x07,0x00,
0x00,0xFF,0x77,0x77,0x77,0x7F,0x00,0x00,
0x00,0x7F,0x77,0x7F,0x07,0x07,0x07,0x00,
0x00,0x3F,0x3F,0x1E,0x0E,0x0E,0x0E,0x00,
0x0F,0x1F,0x3E,0x77,0x77,0x3E,0xFC,0x78,
0x00,0x18,0x3C,0x7E,0xE7,0xC3,0x00,0x00,
0x77,0xFF,0xDD,0xDD,0xFF,0x77,0x00,0x00,
0x00,0x00,0x7F,0xFE,0xEC,0xFE,0x7F,0x00,
0x1E,0x3F,0x77,0x7E,0x77,0x77,0x7E,0x70,
0x00,0xFF,0x77,0x73,0x70,0x70,0x70,0xFC,
0x00,0x00,0xFF,0x7E,0x7E,0x7E,0x7E,0x6C,
0xFF,0x77,0x38,0x1C,0x38,0x77,0xFF,0x00,
0x00,0x1F,0x3C,0x7E,0x7E,0x7E,0x3C,0x00,
0x00,0x00,0x7E,0x7E,0x7E,0x7E,0x7F,0xE0,
0x00,0x00,0x7F,0x1C,0x1C,0x1C,0x1C,0x18,
0x3E,0x1C,0x3E,0x77,0x77,0x3E,0x1C,0x3E,
0x00,0x3E,0x77,0x7F,0x77,0x77,0x3E,0x00,
0x00,0x3E,0x77,0x77,0x77,0x36,0x77,0x00,
0x1E,0x3F,0x7C,0xFE,0xEE,0xFE,0x7C,0x00,
0x0E,0x1C,0x3C,0x7E,0x7E,0x3C,0x38,0x70,
0x00,0x18,0x7E,0xFF,0xFF,0xFF,0x7E,0x18,
0x3F,0x78,0x70,0x7F,0x70,0x78,0x3F,0x00,
0x3E,0x77,0x77,0x77,0x77,0x77,0x77,0x00,
0x00,0x7F,0x00,0x7F,0x00,0x7F,0x00,0x00,
0x1C,0x1C,0x7F,0x1C,0x1C,0x00,0x7F,0x00,
0x38,0x1C,0x0E,0x1C,0x38,0x00,0x7F,0x00,
0x0E,0x1C,0x38,0x1C,0x0E,0x00,0x7F,0x00,
0x00,0x0F,0x1F,0x1F,0x1C,0x1C,0x1C,0x1C,
0x1C,0x1C,0x1C,0x1C,0xFC,0xFC,0x78,0x00,
0x1C,0x1C,0x00,0x7F,0x00,0x1C,0x1C,0x00,
0x00,0x3B,0x6E,0x00,0x3B,0x6E,0x00,0x00,
0x3C,0x7E,0x3C,0x00,0x00,0x00,0x00,0x00,
0x3C,0x7E,0x3C,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x1C,0x1C,0x00,0x00,
0x00,0x00,0x0F,0x1C,0xFC,0x78,0x38,0x00,
0x3C,0x7E,0x7E,0x7E,0x7E,0x00,0x00,0x00,
0x3C,0x7E,0x1C,0x38,0x7E,0x00,0x00,0x00,
0x7C,0x0E,0x3C,0x0E,0x7C,0x00,0x00,0x00,
0x00,0xFF,0x00,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xFF,
0x1C,0x1C,0x1C,0x1C,0x1C,0x00,0x1C,0xFF,
0x77,0x77,0x77,0x00,0x00,0x00,0x00,0xFF,
0x00,0x7E,0xFF,0x7E,0x7E,0xFF,0x7E,0xFF,
0x1C,0x3F,0x70,0x3E,0x07,0x7E,0x1C,0xFF,
0x00,0x77,0x7E,0x1C,0x38,0x77,0x67,0xFF,
0x3C,0x7E,0x3C,0x78,0xFF,0xEE,0x7F,0xFF,
0x1C,0x1C,0x1C,0x00,0x00,0x00,0x00,0xFF,
0x0F,0x1E,0x1C,0x1C,0x1C,0x1E,0x0F,0xFF,
0x78,0x3C,0x1C,0x1C,0x1C,0x3C,0x78,0xFF,
0x00,0x77,0x3E,0xFF,0x3E,0x77,0x00,0xFF,
0x00,0x1C,0x1C,0x7F,0x1C,0x1C,0x00,0xFF,
0x00,0x00,0x00,0x00,0x00,0x38,0x38,0xFF,
0x00,0x00,0x00,0x7F,0x00,0x00,0x00,0xFF,
0x00,0x00,0x00,0x00,0x00,0x1C,0x1C,0xFF,
0x03,0x07,0x0E,0x1C,0x38,0x70,0x60,0xFF,
0x3E,0x77,0x7F,0x7F,0x77,0x77,0x3E,0xFF,
0x1C,0x3C,0x1C,0x1C,0x1C,0x1C,0x7F,0xFF,
0x3E,0x77,0x07,0x0E,0x1C,0x38,0x7F,0xFF,
0x7F,0x0E,0x1C,0x0E,0x07,0x77,0x3E,0xFF,
0x0E,0x1E,0x3E,0x7E,0x7F,0x0E,0x0E,0xFF,
0x7F,0x70,0x7E,0x07,0x07,0x77,0x3E,0xFF,
0x3E,0x70,0x70,0x7E,0x77,0x77,0x3E,0xFF,
0x7F,0x07,0x0E,0x1C,0x38,0x38,0x38,0xFF,
0x3E,0x77,0x77,0x3E,0x77,0x77,0x3E,0xFF,
0x3E,0x77,0x77,0x3F,0x07,0x0E,0x3C,0xFF,
0x00,0x1C,0x1C,0x00,0x1C,0x1C,0x00,0xFF,
0x00,0x1C,0x1C,0x00,0x1C,0x1C,0x38,0xFF,
0x07,0x0E,0x1C,0x38,0x1C,0x0E,0x07,0xFF,
0x00,0x00,0x7F,0x00,0x00,0x7F,0x00,0xFF,
0x70,0x38,0x1C,0x0E,0x1C,0x38,0x70,0xFF,
0x3E,0x77,0x07,0x0E,0x1C,0x00,0x1C,0xFF,
0x3E,0x77,0x7F,0x7F,0x7F,0x70,0x3F,0xFF,
0x1C,0x3E,0x77,0x77,0x7F,0x77,0x77,0xFF,
0x7E,0x77,0x77,0x7E,0x77,0x77,0x7E,0xFF,
0x3E,0x77,0x70,0x70,0x70,0x77,0x3E,0xFF,
0x7C,0x7E,0x77,0x77,0x77,0x7E,0x7C,0xFF,
0x7F,0x70,0x70,0x7E,0x70,0x70,0x7F,0xFF,
0x7F,0x70,0x70,0x7E,0x70,0x70,0x70,0xFF,
0x3F,0x70,0x70,0x7F,0x77,0x77,0x3F,0xFF,
0x77,0x77,0x77,0x7F,0x77,0x77,0x77,0xFF,
0x3E,0x1C,0x1C,0x1C,0x1C,0x1C,0x3E,0xFF,
0x07,0x07,0x07,0x07,0x07,0x77,0x3E,0xFF,
0x77,0x7E,0x7C,0x78,0x7C,0x7E,0x77,0xFF,
0x70,0x70,0x70,0x70,0x70,0x70,0x7F,0xFF,
0xE7,0xFF,0xFF,0xFF,0xE7,0xE7,0xE7,0xFF,
0x77,0x7F,0x7F,0x7F,0x7F,0x77,0x77,0xFF,
0x3E,0x77,0x77,0x77,0x77,0x77,0x3E,0xFF,
0x7E,0x77,0x77,0x7E,0x70,0x70,0x70,0xFF,
0x3E,0x77,0x77,0x77,0x7F,0x7E,0x3F,0xFF,
0x7E,0x77,0x77,0x7E,0x7E,0x77,0x77,0xFF,
0x3E,0x77,0x70,0x3E,0x07,0x77,0x3E,0xFF,
0x7F,0x1C,0x1C,0x1C,0x1C,0x1C,0x1C,0xFF,
0x77,0x77,0x77,0x77,0x77,0x77,0x3F,0xFF,
0x77,0x77,0x77,0x77,0x77,0x3E,0x1C,0xFF,
0xE7,0xE7,0xE7,0xFF,0xFF,0xFF,0xE7,0xFF,
0x77,0x77,0x3E,0x1C,0x3E,0x77,0x77,0xFF,
0x77,0x77,0x77,0x3E,0x1C,0x1C,0x1C,0xFF,
0x7F,0x07,0x0E,0x1C,0x38,0x70,0x7F,0xFF,
0x1F,0x1C,0x1C,0x1C,0x1C,0x1C,0x1F,0xFF,
0x60,0x70,0x38,0x1C,0x0E,0x07,0x03,0xFF,
0x7C,0x1C,0x1C,0x1C,0x1C,0x1C,0x7C,0xFF,
0x18,0x3C,0x7E,0xE7,0x00,0x00,0x00,0xFF,
0x00,0x00,0x00,0x00,0x00,0x00,0xFF,0xFF,
0x00,0xE0,0x70,0x38,0x00,0x00,0x00,0xFF,
0x00,0x00,0x3E,0x07,0x3F,0x77,0x3F,0xFF,
0x70,0x70,0x7E,0x77,0x77,0x77,0x7E,0xFF,
0x00,0x00,0x3E,0x70,0x70,0x70,0x3E,0xFF,
0x07,0x07,0x3F,0x77,0x77,0x77,0x3F,0xFF,
0x00,0x00,0x3E,0x77,0x7F,0x70,0x3E,0xFF,
0x1E,0x38,0x7E,0x38,0x38,0x38,0x38,0xFF,
0x00,0x00,0x3F,0x77,0x77,0x3F,0x07,0xFF,
0x70,0x70,0x7E,0x77,0x77,0x77,0x77,0xFF,
0x1C,0x00,0x3C,0x1C,0x1C,0x1C,0x3E,0xFF,
0x1C,0x00,0x1C,0x1C,0x1C,0x1C,0x1C,0xFF,
0x70,0x70,0x77,0x7E,0x7C,0x7E,0x77,0xFF,
0x3C,0x1C,0x1C,0x1C,0x1C,0x1C,0x3E,0xFF,
0x00,0x00,0xFE,0xFF,0xFF,0xE7,0xE7,0xFF,
0x00,0x00,0x7E,0x77,0x77,0x77,0x77,0xFF,
0x00,0x00,0x3E,0x77,0x77,0x77,0x3E,0xFF,
0x00,0x00,0x7E,0x77,0x77,0x77,0x7E,0xFF,
0x00,0x00,0x3F,0x77,0x77,0x77,0x3F,0xFF,
0x00,0x00,0x7E,0x77,0x70,0x70,0x70,0xFF,
0x00,0x00,0x3F,0x70,0x3E,0x07,0x7E,0xFF,
0x00,0x1C,0x7F,0x1C,0x1C,0x1C,0x0F,0xFF,
0x00,0x00,0x77,0x77,0x77,0x77,0x3F,0xFF,
0x00,0x00,0x77,0x77,0x77,0x3E,0x1C,0xFF,
0x00,0x00,0xE7,0xE7,0xFF,0x7E,0x7E,0xFF,
0x00,0x00,0x77,0x3E,0x1C,0x3E,0x77,0xFF,
0x00,0x00,0x77,0x77,0x77,0x3F,0x07,0xFF,
0x00,0x00,0x7F,0x0E,0x1C,0x38,0x7F,0xFF,
0x0F,0x1C,0x1C,0x38,0x1C,0x1C,0x0F,0xFF,
0x1C,0x1C,0x1C,0x1C,0x1C,0x1C,0x1C,0xFF,
0x78,0x1C,0x1C,0x0E,0x1C,0x1C,0x78,0xFF,
0x00,0x70,0xFB,0xDF,0x0E,0x00,0x00,0xFF,
0x00,0x1C,0x1C,0x3E,0x3E,0x73,0x7F,0xFF,
0x00,0x3E,0x77,0x70,0x77,0x3E,0x0C,0xFF,
0x77,0x00,0x00,0x77,0x77,0x77,0x3F,0xFF,
0x0E,0x1C,0x00,0x3E,0x7F,0x70,0x3E,0xFF,
0x1C,0x77,0x00,0x3E,0x07,0x7F,0x3F,0xFF,
0x77,0x00,0x3E,0x07,0x3F,0x77,0x3F,0xFF,
0x38,0x1C,0x00,0x3E,0x07,0x7F,0x3F,0xFF,
0x1C,0x1C,0x00,0x3E,0x07,0x7F,0x3F,0xFF,
0x00,0x00,0x3E,0x70,0x70,0x3E,0x0C,0xFF,
0x1C,0x77,0x00,0x3E,0x7F,0x70,0x3E,0xFF,
0x77,0x00,0x3E,0x77,0x7F,0x70,0x3E,0xFF,
0x38,0x1C,0x00,0x3E,0x7F,0x70,0x3E,0xFF,
0x77,0x00,0x00,0x3C,0x1C,0x1C,0x3E,0xFF,
0x1C,0x77,0x00,0x3C,0x1C,0x1C,0x3E,0xFF,
0x70,0x38,0x00,0x3C,0x1C,0x1C,0x3E,0xFF,
0x77,0x00,0x1C,0x3E,0x77,0x7F,0x77,0xFF,
0x1C,0x00,0x1C,0x3E,0x77,0x7F,0x77,0xFF,
0x0E,0x1C,0x7F,0x70,0x7E,0x70,0x7F,0xFF,
0x00,0x00,0x7F,0x1F,0x7F,0xFC,0x7F,0xFF,
0x3F,0x7C,0xFC,0xFF,0xFC,0xFC,0xFF,0xFF,
0x1C,0x77,0x00,0x3E,0x77,0x77,0x3E,0xFF,
0x77,0x00,0x00,0x3E,0x77,0x77,0x3E,0xFF,
0x38,0x1C,0x00,0x3E,0x77,0x77,0x3E,0xFF,
0x1C,0x77,0x00,0x77,0x77,0x77,0x3F,0xFF,
0x38,0x1C,0x00,0x77,0x77,0x77,0x3F,0xFF,
0x77,0x00,0x77,0x77,0x77,0x3F,0x07,0xFF,
0x77,0x00,0x3E,0x77,0x77,0x77,0x3E,0xFF,
0x77,0x00,0x77,0x77,0x77,0x77,0x3F,0xFF,
0x1C,0x1C,0x3E,0x70,0x70,0x3E,0x1C,0xFF,
0x1E,0x3F,0x38,0x7E,0x38,0x38,0x7F,0xFF,
0x77,0x77,0x3E,0x1C,0x3E,0x1C,0x1C,0xFF,
0x1E,0x3F,0x77,0x7E,0x77,0x77,0x7E,0xFF,
0x1F,0x38,0x7E,0x38,0x38,0x38,0x70,0xFF,
0x0E,0x1C,0x00,0x3E,0x07,0x7F,0x3F,0xFF,
0x0E,0x1C,0x00,0x3C,0x1C,0x1C,0x3E,0xFF,
0x0E,0x1C,0x00,0x3E,0x77,0x77,0x3E,0xFF,
0x0E,0x1C,0x00,0x77,0x77,0x77,0x3F,0xFF,
0x3E,0x7C,0x00,0x7E,0x77,0x77,0x77,0xFF,
0x3E,0x7C,0x00,0x77,0x7F,0x7F,0x77,0xFF,
0x00,0x3E,0x07,0x3F,0x77,0x3F,0x00,0xFF,
0x00,0x3E,0x77,0x77,0x77,0x3E,0x00,0xFF,
0x00,0x1C,0x00,0x1C,0x38,0x70,0x77,0xFF,
0x00,0x00,0x00,0x3F,0x38,0x38,0x38,0xFF,
0x00,0x00,0x00,0x7E,0x0E,0x0E,0x0E,0xFF,
0xE7,0xEE,0xFC,0x3F,0x7F,0xE3,0xC7,0xFF,
0xE7,0xEE,0xFC,0x3F,0x7F,0xFF,0xDF,0xFF,
0x00,0x1C,0x00,0x1C,0x1C,0x1C,0x1C,0xFF,
0x1F,0x3F,0x7E,0xFC,0x7E,0x3F,0x1F,0xFF,
0xFC,0x7E,0x3F,0x1F,0x3F,0x7E,0xFC,0xFF,
0x3E,0x7C,0x00,0x3E,0x07,0x7F,0x3F,0xFF,
0x3E,0x7C,0x00,0x3E,0x77,0x77,0x3E,0xFF,
0x03,0x3E,0x77,0x7F,0x7F,0x77,0x3E,0xFF,
0x00,0x03,0x3E,0x7F,0x7F,0x77,0x3E,0xFF,
0x00,0x00,0x7F,0xFF,0xFF,0xFC,0x7F,0xFF,
0x7F,0xFC,0xFC,0xFF,0xFC,0xFC,0x7F,0xFF,
0x38,0x1C,0x00,0x1C,0x3E,0x77,0x7F,0xFF,
0x3E,0x7C,0x00,0x1C,0x3E,0x77,0x7F,0xFF,
0x3E,0x7C,0x3E,0x77,0x77,0x77,0x77,0xFF,
0x77,0x00,0x00,0x00,0x00,0x00,0x00,0xFF,
0x0E,0x1C,0x38,0x00,0x00,0x00,0x00,0xFF,
0x00,0x18,0x3C,0x18,0x18,0x18,0x00,0xFF,
0x7F,0xEF,0xEF,0xEF,0x7F,0x0F,0x0F,0xFF,
0x7F,0xE3,0xFF,0xF9,0xF9,0xFF,0xE3,0xFF,
0x7F,0xE3,0xFF,0xF7,0xFD,0xFF,0xE3,0xFF,
0xF9,0x7F,0x7F,0x7F,0x79,0x00,0x00,0xFF,
0x77,0x00,0xF7,0x77,0x77,0xFF,0x07,0xFF,
0xFF,0x77,0x77,0x77,0x77,0xFF,0x07,0xFF,
0x00,0x77,0x7F,0x3E,0x7F,0x77,0x00,0xFF,
0x00,0x7E,0x0E,0x0E,0x0E,0x7F,0x00,0xFF,
0x00,0x1F,0x07,0x0F,0x1F,0x3F,0x00,0xFF,
0x00,0x7F,0x0E,0x0E,0x0E,0x0E,0x00,0xFF,
0x00,0x7E,0x07,0x77,0x77,0x77,0x00,0xFF,
0x00,0x1E,0x0E,0x0E,0x0E,0x0E,0x00,0xFF,
0x00,0x1F,0x0E,0x07,0x07,0x07,0x00,0xFF,
0x00,0x7F,0x3F,0x3F,0x3F,0x3F,0x00,0xFF,
0x70,0x7F,0x77,0x77,0x77,0x7F,0x00,0xFF,
0x00,0x3E,0x0E,0x0E,0x00,0x00,0x00,0xFF,
0x00,0x3F,0x07,0x07,0x07,0x3F,0x00,0xFF,
0x70,0x7F,0x07,0x07,0x07,0x0F,0x00,0xFF,
0x00,0x7E,0x3F,0x77,0x77,0x7F,0x00,0xFF,
0x00,0x1E,0x0E,0x0E,0x0E,0x3E,0x00,0xFF,
0x00,0x3F,0x3F,0x3F,0x3F,0x1E,0x00,0xFF,
0x00,0x3F,0x3F,0x3F,0x3F,0x7F,0x00,0xFF,
0x00,0x7F,0x77,0x7F,0x07,0x7F,0x00,0xFF,
0x00,0x77,0x77,0x3E,0x0F,0x7F,0x00,0xFF,
0x00,0x3F,0x07,0x3F,0x3F,0x3E,0x38,0xFF,
0x00,0x7C,0x0E,0x0E,0x0E,0x0E,0x00,0xFF,
0x00,0xFF,0xFF,0xFF,0xFF,0xFF,0x00,0xFF,
0x00,0x7E,0x7E,0x7E,0x7E,0xFE,0x00,0xFF,
0x00,0x1E,0x0E,0x0E,0x0E,0x0E,0x0E,0xFF,
0x00,0x3F,0x07,0x07,0x07,0x07,0x07,0xFF,
0x00,0xFF,0x77,0x77,0x77,0x7F,0x00,0xFF,
0x00,0x7F,0x77,0x7F,0x07,0x07,0x07,0xFF,
0x00,0x3F,0x3F,0x1E,0x0E,0x0E,0x0E,0xFF,
0x0F,0x1F,0x3E,0x77,0x77,0x3E,0xFC,0xFF,
0x00,0x18,0x3C,0x7E,0xE7,0xC3,0x00,0xFF,
0x77,0xFF,0xDD,0xDD,0xFF,0x77,0x00,0xFF,
0x00,0x00,0x7F,0xFE,0xEC,0xFE,0x7F,0xFF,
0x1E,0x3F,0x77,0x7E,0x77,0x77,0x7E,0xFF,
0x00,0xFF,0x77,0x73,0x70,0x70,0x70,0xFF,
0x00,0x00,0xFF,0x7E,0x7E,0x7E,0x7E,0xFF,
0xFF,0x77,0x38,0x1C,0x38,0x77,0xFF,0xFF,
0x00,0x1F,0x3C,0x7E,0x7E,0x7E,0x3C,0xFF,
0x00,0x00,0x7E,0x7E,0x7E,0x7E,0x7F,0xFF,
0x00,0x00,0x7F,0x1C,0x1C,0x1C,0x1C,0xFF,
0x3E,0x1C,0x3E,0x77,0x77,0x3E,0x1C,0xFF,
0x00,0x3E,0x77,0x7F,0x77,0x77,0x3E,0xFF,
0x00,0x3E,0x77,0x77,0x77,0x36,0x77,0xFF,
0x1E,0x3F,0x7C,0xFE,0xEE,0xFE,0x7C,0xFF,
0x0E,0x1C,0x3C,0x7E,0x7E,0x3C,0x38,0xFF,
0x00,0x18,0x7E,0xFF,0xFF,0xFF,0x7E,0xFF,
0x3F,0x78,0x70,0x7F,0x70,0x78,0x3F,0xFF,
0x3E,0x77,0x77,0x77,0x77,0x77,0x77,0xFF,
0x00,0x7F,0x00,0x7F,0x00,0x7F,0x00,0xFF,
0x1C,0x1C,0x7F,0x1C,0x1C,0x00,0x7F,0xFF,
0x38,0x1C,0x0E,0x1C,0x38,0x00,0x7F,0xFF,
0x0E,0x1C,0x38,0x1C,0x0E,0x00,0x7F,0xFF,
0x00,0x0F,0x1F,0x1F,0x1C,0x1C,0x1C,0xFF,
0x1C,0x1C,0x1C,0x1C,0xFC,0xFC,0x78,0xFF,
0x1C,0x1C,0x00,0x7F,0x00,0x1C,0x1C,0xFF,
0x00,0x3B,0x6E,0x00,0x3B,0x6E,0x00,0xFF,
0x3C,0x7E,0x3C,0x00,0x00,0x00,0x00,0xFF,
0x3C,0x7E,0x3C,0x00,0x00,0x00,0x00,0xFF,
0x00,0x00,0x00,0x00,0x1C,0x1C,0x00,0xFF,
0x00,0x00,0x0F,0x1C,0xFC,0x78,0x38,0xFF,
0x3C,0x7E,0x7E,0x7E,0x7E,0x00,0x00,0xFF,
0x3C,0x7E,0x1C,0x38,0x7E,0x00,0x00,0xFF,
0x7C,0x0E,0x3C,0x0E,0x7C,0x00,0x00,0xFF,
0x00,0xFF,0x00,0x00,0x00,0x00,0x00,0xFF,
0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x07,0x0E,0x0E,0x1C,0x1C,0x00,0x38,0x00,
0x1D,0x3B,0x3B,0x00,0x00,0x00,0x00,0x00,
0x00,0x3F,0x7F,0x7E,0x7E,0xFE,0xFC,0x00,
0x07,0x1F,0x38,0x3E,0x07,0xFC,0x38,0x00,
0x00,0x3B,0x3F,0x1C,0x38,0xEE,0xCE,0x00,
0x0F,0x3F,0x1E,0x78,0xFF,0xDC,0xFE,0x00,
0x07,0x0E,0x0E,0x00,0x00,0x00,0x00,0x00,
0x03,0x0F,0x0E,0x1C,0x1C,0x3C,0x1E,0x00,
0x1E,0x1E,0x0E,0x1C,0x1C,0x78,0xF0,0x00,
0x00,0x3B,0x1F,0xFF,0x3E,0xEE,0x00,0x00,
0x00,0x0E,0x0E,0x7F,0x1C,0x38,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x70,0x70,0xC0,
0x00,0x00,0x00,0x7F,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x38,0x38,0x00,
0x00,0x03,0x07,0x1C,0x38,0xE0,0xC0,0x00,
0x0F,0x3B,0x3F,0x7F,0x77,0xEE,0x7C,0x00,
0x07,0x1E,0x0E,0x1C,0x1C,0x38,0xFE,0x00,
0x0F,0x3B,0x03,0x0E,0x1C,0x70,0xFE,0x00,
0x1F,0x07,0x0E,0x0E,0x07,0xEE,0x7C,0x00,
0x03,0x0F,0x1F,0x7E,0x7F,0x1C,0x1C,0x00,
0x1F,0x38,0x3F,0x07,0x07,0xEE,0x7C,0x00,
0x0F,0x38,0x38,0x7E,0x77,0xEE,0x7C,0x00,
0x1F,0x03,0x07,0x1C,0x38,0x70,0x70,0x00,
0x0F,0x3B,0x3B,0x3E,0x77,0xEE,0x7C,0x00,
0x0F,0x3B,0x3B,0x3F,0x07,0x1C,0x78,0x00,
0x00,0x0E,0x0E,0x00,0x1C,0x38,0x00,0x00,
0x00,0x0E,0x0E,0x00,0x1C,0x38,0x70,0x00,
0x01,0x07,0x0E,0x38,0x1C,0x1C,0x0E,0x00,
0x00,0x00,0x3F,0x00,0x00,0xFE,0x00,0x00,
0x1C,0x1C,0x0E,0x0E,0x1C,0x70,0xE0,0x00,
0x0F,0x3B,0x03,0x0E,0x1C,0x00,0x38,0x00,
0x0F,0x3B,0x3F,0x7F,0x7F,0xE0,0x7E,0x00,
0x07,0x1F,0x3B,0x77,0x7F,0xEE,0xEE,0x00,
0x1F,0x3B,0x3B,0x7E,0x77,0xEE,0xFC,0x00,
0x0F,0x3B,0x38,0x70,0x70,0xEE,0x7C,0x00,
0x1F,0x3F,0x3B,0x77,0x77,0xFC,0xF8,0x00,
0x1F,0x38,0x38,0x7E,0x70,0xE0,0xFE,0x00,
0x1F,0x38,0x38,0x7E,0x70,0xE0,0xE0,0x00,
0x0F,0x38,0x38,0x7F,0x77,0xEE,0x7E,0x00,
0x1D,0x3B,0x3B,0x7F,0x77,0xEE,0xEE,0x00,
0x0F,0x0E,0x0E,0x1C,0x1C,0x38,0x7C,0x00,
0x01,0x03,0x03,0x07,0x07,0xEE,0x7C,0x00,
0x1D,0x3F,0x3E,0x78,0x7C,0xFC,0xEE,0x00,
0x1C,0x38,0x38,0x70,0x70,0xE0,0xFE,0x00,
0x39,0x7F,0x7F,0xFF,0xE7,0xCE,0xCE,0x00,
0x1D,0x3F,0x3F,0x7F,0x7F,0xEE,0xEE,0x00,
0x0F,0x3B,0x3B,0x77,0x77,0xEE,0x7C,0x00,
0x1F,0x3B,0x3B,0x7E,0x70,0xE0,0xE0,0x00,
0x0F,0x3B,0x3B,0x77,0x7F,0xFC,0x7E,0x00,
0x1F,0x3B,0x3B,0x7E,0x7E,0xEE,0xEE,0x00,
0x0F,0x3B,0x38,0x3E,0x07,0xEE,0x7C,0x00,
0x1F,0x0E,0x0E,0x1C,0x1C,0x38,0x38,0x00,
0x1D,0x3B,0x3B,0x77,0x77,0xEE,0x7E,0x00,
0x1D,0x3B,0x3B,0x77,0x77,0x7C,0x38,0x00,
0x39,0x73,0x73,0xFF,0xFF,0xFE,0xCE,0x00,
0x1D,0x3B,0x1F,0x1C,0x3E,0xEE,0xEE,0x00,
0x1D,0x3B,0x3B,0x3E,0x1C,0x38,0x38,0x00,
0x1F,0x03,0x07,0x1C,0x38,0xE0,0xFE,0x00,
0x07,0x0E,0x0E,0x1C,0x1C,0x38,0x3E,0x00,
0x18,0x38,0x1C,0x1C,0x0E,0x0E,0x06,0x00,
0x1F,0x0E,0x0E,0x1C,0x1C,0x38,0xF8,0x00,
0x06,0x1E,0x3F,0xE7,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x00,0x00,0xFE,0x00,
0x00,0x70,0x38,0x38,0x00,0x00,0x00,0x00,
0x00,0x00,0x1F,0x07,0x3F,0xEE,0x7E,0x00,
0x1C,0x38,0x3F,0x77,0x77,0xEE,0xFC,0x00,
0x00,0x00,0x1F,0x70,0x70,0xE0,0x7C,0x00,
0x01,0x03,0x1F,0x77,0x77,0xEE,0x7E,0x00,
0x00,0x00,0x1F,0x77,0x7F,0xE0,0x7C,0x00,
0x07,0x1C,0x3F,0x38,0x38,0x70,0x70,0x00,
0x00,0x00,0x1F,0x77,0x77,0x7E,0x0E,0xF8,
0x1C,0x38,0x3F,0x77,0x77,0xEE,0xEE,0x00,
0x07,0x00,0x1E,0x1C,0x1C,0x38,0x7C,0x00,
0x07,0x00,0x0E,0x1C,0x1C,0x38,0x38,0xE0,
0x1C,0x38,0x3B,0x7E,0x7C,0xFC,0xEE,0x00,
0x0F,0x0E,0x0E,0x1C,0x1C,0x38,0x7C,0x00,
0x00,0x00,0x7F,0xFF,0xFF,0xCE,0xCE,0x00,
0x00,0x00,0x3F,0x77,0x77,0xEE,0xEE,0x00,
0x00,0x00,0x1F,0x77,0x77,0xEE,0x7C,0x00,
0x00,0x00,0x3F,0x77,0x77,0xEE,0xFC,0xC0,
0x00,0x00,0x1F,0x77,0x77,0xEE,0x7E,0x1C,
0x00,0x00,0x3F,0x77,0x70,0xE0,0xE0,0x00,
0x00,0x00,0x1F,0x70,0x3E,0x0E,0xFC,0x00,
0x00,0x0E,0x3F,0x1C,0x1C,0x38,0x1E,0x00,
0x00,0x00,0x3B,0x77,0x77,0xEE,0x7E,0x00,
0x00,0x00,0x3B,0x77,0x77,0x7C,0x38,0x00,
0x00,0x00,0x73,0xE7,0xFF,0xFC,0xFC,0x00,
0x00,0x00,0x3B,0x3E,0x1C,0x7C,0xEE,0x00,
0x00,0x00,0x3B,0x77,0x77,0x7E,0x0E,0xF8,
0x00,0x00,0x3F,0x0E,0x1C,0x70,0xFE,0x00,
0x03,0x0E,0x0E,0x38,0x1C,0x38,0x1E,0x00,
0x07,0x0E,0x0E,0x1C,0x1C,0x38,0x38,0x70,
0x1E,0x0E,0x0E,0x0E,0x1C,0x38,0xF0,0x00,
0x00,0x38,0x7D,0xDF,0x0E,0x00,0x00,0x00,
0x00,0x0E,0x0E,0x3E,0x3E,0xE6,0xFE,0x00,
0x00,0x1F,0x3B,0x70,0x77,0x7C,0x18,0xF0,
0x1D,0x00,0x00,0x77,0x77,0xEE,0x7E,0x00,
0x03,0x0E,0x00,0x3E,0x7F,0xE0,0x7C,0x00,
0x07,0x3B,0x00,0x3E,0x07,0xFE,0x7E,0x00,
0x1D,0x00,0x1F,0x07,0x3F,0xEE,0x7E,0x00,
0x0E,0x0E,0x00,0x3E,0x07,0xFE,0x7E,0x00,
0x07,0x0E,0x00,0x3E,0x07,0xFE,0x7E,0x00,
0x00,0x00,0x1F,0x70,0x70,0x7C,0x18,0x70,
0x07,0x3B,0x00,0x3E,0x7F,0xE0,0x7C,0x00,
0x1D,0x00,0x1F,0x77,0x7F,0xE0,0x7C,0x00,
0x0E,0x0E,0x00,0x3E,0x7F,0xE0,0x7C,0x00,
0x1D,0x00,0x00,0x3C,0x1C,0x38,0x7C,0x00,
0x07,0x3B,0x00,0x3C,0x1C,0x38,0x7C,0x00,
0x1C,0x1C,0x00,0x3C,0x1C,0x38,0x7C,0x00,
0x1D,0x00,0x0E,0x3E,0x77,0xFE,0xEE,0x00,
0x07,0x00,0x0E,0x3E,0x77,0xFE,0xEE,0x00,
0x03,0x0E,0x3F,0x70,0x7E,0xE0,0xFE,0x00,
0x00,0x00,0x3F,0x1F,0x7F,0xF8,0xFE,0x00,
0x0F,0x3E,0x7E,0xFF,0xFC,0xF8,0xFF,0x00,
0x07,0x3B,0x00,0x3E,0x77,0xEE,0x7C,0x00,
0x1D,0x00,0x00,0x3E,0x77,0xEE,0x7C,0x00,
0x0E,0x0E,0x00,0x3E,0x77,0xEE,0x7C,0x00,
0x07,0x3B,0x00,0x77,0x77,0xEE,0x7E,0x00,
0x0E,0x0E,0x00,0x77,0x77,0xEE,0x7E,0x00,
0x1D,0x00,0x3B,0x77,0x77,0x7E,0x0E,0xF8,
0x1D,0x00,0x1F,0x77,0x77,0xEE,0x7C,0x00,
0x1D,0x00,0x3B,0x77,0x77,0xEE,0x7E,0x00,
0x07,0x0E,0x1F,0x70,0x70,0x7C,0x38,0x70,
0x07,0x1F,0x1C,0x7E,0x38,0x70,0xFE,0x00,
0x1D,0x3B,0x1F,0x1C,0x3E,0x38,0x38,0x00,
0x07,0x1F,0x3B,0x7E,0x77,0xEE,0xFC,0xC0,
0x07,0x1C,0x3F,0x38,0x38,0x70,0xE0,0x00,
0x03,0x0E,0x00,0x3E,0x07,0xFE,0x7E,0x00,
0x03,0x0E,0x00,0x3C,0x1C,0x38,0x7C,0x00,
0x03,0x0E,0x00,0x3E,0x77,0xEE,0x7C,0x00,
0x03,0x0E,0x00,0x77,0x77,0xEE,0x7E,0x00,
0x0F,0x3E,0x00,0x7E,0x77,0xEE,0xEE,0x00,
0x0F,0x3E,0x00,0x77,0x7F,0xFE,0xEE,0x00,
0x00,0x1F,0x03,0x3F,0x77,0x7E,0x00,0xF8,
0x00,0x1F,0x3B,0x77,0x77,0x7C,0x00,0xF8,
0x00,0x0E,0x00,0x1C,0x38,0xE0,0xEE,0xF8,
0x00,0x00,0x00,0x3F,0x38,0x70,0x70,0x00,
0x00,0x00,0x00,0x7E,0x0E,0x1C,0x1C,0x00,
0x39,0x77,0x7E,0x3F,0x7F,0xC7,0x8E,0x3E,
0x39,0x77,0x7E,0x3F,0x7F,0xFE,0xBF,0x1C,
0x00,0x0E,0x00,0x1C,0x1C,0x38,0x38,0x70,
0x07,0x1F,0x3F,0xFC,0x7E,0x7E,0x3F,0x00,
0x3F,0x3F,0x1F,0x1F,0x3F,0xFC,0xF8,0x00,
0x0F,0x3E,0x00,0x3E,0x07,0xFE,0x7E,0x00,
0x0F,0x3E,0x00,0x3E,0x77,0xEE,0x7C,0x00,
0x00,0x1F,0x3B,0x7F,0x7F,0xEE,0x7C,0x80,
0x00,0x01,0x1F,0x7F,0x7F,0xEE,0x7C,0x80,
0x00,0x00,0x3F,0xFF,0xFF,0xF8,0xFE,0x00,
0x1F,0x7E,0x7E,0xFF,0xFC,0xF8,0xFF,0x00,
0x0E,0x0E,0x00,0x1C,0x3E,0xEE,0xFE,0xDC,
0x0F,0x3E,0x00,0x1C,0x3E,0xEE,0xFE,0xDC,
0x0F,0x3E,0x1F,0x77,0x77,0xEE,0xEE,0xF8,
0x1D,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
0x03,0x0E,0x1C,0x00,0x00,0x00,0x00,0x00,
0x00,0x0C,0x1E,0x18,0x18,0x30,0x00,0x00,
0x1F,0x77,0x77,0xEF,0x7F,0x1E,0x1E,0x3C,
0x1F,0x71,0x7F,0xF9,0xF9,0xFF,0xC7,0xFC,
0x1F,0x71,0x7F,0xF7,0xFD,0xFF,0xC7,0xFC,
0x3E,0x3F,0x3F,0x7F,0x79,0x00,0x00,0x00,
0x1D,0x00,0x7B,0x77,0x77,0xFE,0x0E,0x78,
0x3F,0x3B,0x3B,0x77,0x77,0xFE,0x0E,0x78,
0x00,0x3B,0x3F,0x3E,0x7F,0xEE,0x00,0x00,
0x00,0x3F,0x07,0x0E,0x0E,0xFE,0x00,0x00,
0x00,0x0F,0x03,0x0F,0x1F,0x7E,0x00,0x00,
0x00,0x3F,0x07,0x0E,0x0E,0x1C,0x00,0x00,
0x00,0x3F,0x03,0x77,0x77,0xEE,0x00,0x00,
0x00,0x0F,0x07,0x0E,0x0E,0x1C,0x00,0x00,
0x00,0x0F,0x07,0x07,0x07,0x0E,0x00,0x00,
0x00,0x3F,0x1F,0x3F,0x3F,0x7E,0x00,0x00,
0x1C,0x3F,0x3B,0x77,0x77,0xFE,0x00,0x00,
0x00,0x1F,0x07,0x0E,0x00,0x00,0x00,0x00,
0x00,0x1F,0x03,0x07,0x07,0x7E,0x00,0x00,
0x1C,0x3F,0x03,0x07,0x07,0x1E,0x00,0x00,
0x00,0x3F,0x1F,0x77,0x77,0xFE,0x00,0x00,
0x00,0x0F,0x07,0x0E,0x0E,0x7C,0x00,0x00,
0x00,0x1F,0x1F,0x3F,0x3F,0x3C,0x00,0x00,
0x00,0x1F,0x1F,0x3F,0x3F,0xFE,0x00,0x00,
0x00,0x3F,0x3B,0x7F,0x07,0xFE,0x00,0x00,
0x00,0x3B,0x3B,0x3E,0x0F,0xFE,0x00,0x00,
0x00,0x1F,0x03,0x3F,0x3F,0x7C,0x70,0x00,
0x00,0x3E,0x07,0x0E,0x0E,0x1C,0x00,0x00,
0x00,0x7F,0x7F,0xFF,0xFF,0xFE,0x00,0x00,
0x00,0x3F,0x3F,0x7E,0x7E,0xFC,0x00,0x00,
0x00,0x0F,0x07,0x0E,0x0E,0x1C,0x1C,0x00,
0x00,0x1F,0x03,0x07,0x07,0x0E,0x0E,0x00,
0x00,0x7F,0x3B,0x77,0x77,0xFE,0x00,0x00,
0x00,0x3F,0x3B,0x7F,0x07,0x0E,0x0E,0x00,
0x00,0x1F,0x1F,0x1E,0x0E,0x1C,0x1C,0x00,
0x03,0x0F,0x1F,0x77,0x77,0x7C,0xF8,0xE0,
0x00,0x0C,0x1E,0x7E,0xE7,0x86,0x00,0x00,
0x1D,0x7F,0x6E,0xDD,0xFF,0xEE,0x00,0x00,
0x00,0x00,0x3F,0xFE,0xEC,0xFC,0xFE,0x00,
0x07,0x1F,0x3B,0x7E,0x77,0xEE,0xFC,0xC0,
0x00,0x7F,0x3B,0x73,0x70,0xE0,0xE0,0xF0,
0x00,0x00,0x7F,0x7E,0x7E,0xFC,0xFC,0xB0,
0x3F,0x3B,0x1C,0x1C,0x38,0xEE,0xFE,0x00,
0x00,0x0F,0x1E,0x7E,0x7E,0xFC,0x78,0x00,
0x00,0x00,0x3F,0x7E,0x7E,0xFC,0xFF,0x80,
0x00,0x00,0x3F,0x1C,0x1C,0x38,0x38,0x60,
0x0F,0x0E,0x1F,0x77,0x77,0x7C,0x38,0xF8,
0x00,0x1F,0x3B,0x7F,0x77,0xEE,0x7C,0x00,
0x00,0x1F,0x3B,0x77,0x77,0x6C,0xEE,0x00,
0x07,0x1F,0x3E,0xFE,0xEE,0xFC,0xF8,0x00,
0x03,0x0E,0x1E,0x7E,0x7E,0x78,0x70,0xC0,
0x00,0x0C,0x3F,0xFF,0xFF,0xFE,0xFC,0x60,
0x0F,0x3C,0x38,0x7F,0x70,0xF0,0x7E,0x00,
0x0F,0x3B,0x3B,0x77,0x77,0xEE,0xEE,0x00,
0x00,0x3F,0x00,0x7F,0x00,0xFE,0x00,0x00,
0x07,0x0E,0x3F,0x1C,0x1C,0x00,0xFE,0x00,
0x0E,0x0E,0x07,0x1C,0x38,0x00,0xFE,0x00,
0x03,0x0E,0x1C,0x1C,0x0E,0x00,0xFE,0x00,
0x00,0x07,0x0F,0x1F,0x1C,0x38,0x38,0x70,
0x07,0x0E,0x0E,0x1C,0xFC,0xF8,0xF0,0x00,
0x07,0x0E,0x00,0x7F,0x00,0x38,0x38,0x00,
0x00,0x1D,0x37,0x00,0x3B,0xDC,0x00,0x00,
0x0F,0x3F,0x1E,0x00,0x00,0x00,0x00,0x00,
0x0F,0x3F,0x1E,0x00,0x00,0x00,0x00,0x00,
0x00,0x00,0x00,0x00,0x1C,0x38,0x00,0x00,
0x00,0x00,0x07,0x1C,0xFC,0xF0,0x70,0x00,
0x0F,0x3F,0x3F,0x7E,0x7E,0x00,0x00,0x00,
0x0F,0x3F,0x0E,0x38,0x7E,0x00,0x00,0x00,
0x1F,0x07,0x1E,0x0E,0x7C,0x00,0x00,0x00,
0x00,0x7F,0x00,0x00,0x00,0x00,0x00,0x00
};
