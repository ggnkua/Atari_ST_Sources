#ifndef	INCLUDED_FONT8X8_H
#define	INCLUDED_FONT8X8_H

/* ###################################################################################
#  INCLUDES
################################################################################### */

#include	<GODLIB\BASE\BASE.H>


/* ###################################################################################
#  DEFINES
################################################################################### */


/* ###################################################################################
#  STRUCTS
################################################################################### */


/* ###################################################################################
#  PROTOTYPES
################################################################################### */

void	Font8x8_Print( char * apString, U16 * apScreen, U16 aX, U16 aY );


/* ################################################################################ */

#endif	/*	INCLUDED_FONT8X8_H */