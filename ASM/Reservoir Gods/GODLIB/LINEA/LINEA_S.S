**************************************************************************************
*	LINEA_S.S
*
*	TOS LineA calling routines
*
*	[c] 2001 Reservoir Gods
**************************************************************************************

**************************************************************************************
;	EXPORTS / IMPORTS
**************************************************************************************

	export	LineA_Init

	export	gpLineABase


**************************************************************************************
;	MACROS
**************************************************************************************

**************************************************************************************
	TEXT
**************************************************************************************

*------------------------------------------------------------------------------------*
* FUNCTION : LineA_Init
* ACTION   : 
* CREATION : 11.11.01 PNK
*------------------------------------------------------------------------------------*

LineA_Init:
	movem.l	d0-d7/a1-a6,-(a7)
	dc.w	$a000
	move.l	a0,gpLineABase
	sub.l	#910,a0
	movem.l	(a7)+,d0-d7/a1-a6
	rts

**************************************************************************************
	DATA
**************************************************************************************

gpLineABase:	dc.l	0