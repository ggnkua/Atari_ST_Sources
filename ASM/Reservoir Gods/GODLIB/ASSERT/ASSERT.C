/*::::::::::::::::::::::::::::::::::::::::::::::::::::::::::::::::::::::::::::::::::::
::
:: ASSERT.C
::
:: Assertion functions
::
:: [c] 2001 Reservoir Gods
::::::::::::::::::::::::::::::::::::::::::::::::::::::::::::::::::::::::::::::::::::*/


/* ###################################################################################
#  INCLUDES
################################################################################### */

#include	"ASSERT.H"


/* ###################################################################################
#  DATA
################################################################################### */

#ifdef	dAssertTXT	

char gAssertString[ 1024 ];

char *	Assert_GetpString( void )
{
	return( &gAssertString[ 0 ] );
}


/* ################################################################################ */

#endif
