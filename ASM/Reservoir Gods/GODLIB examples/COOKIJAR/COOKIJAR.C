/*************************************************************************************
 * GodLib Example Progam Suite
 * 
 * Demonstrates cookiejar functionality
 *
 * PINK 01.01.03
 *************************************************************************************
*/

/* ###################################################################################
#  INCLUDES
################################################################################### */

#include	<GODLIB\GEMDOS\GEMDOS.H>
#include	<GODLIB\COOKIE\COOKIE.H>


/* ###################################################################################
#  PROTOTYPES
################################################################################### */

void	Hardware_Init( void );
void	Hardware_DeInit( void );

void	Test_Loop( void );


/* ###################################################################################
#  CODE
################################################################################### */

/*-----------------------------------------------------------------------------------*
* FUNCTION : main( void )
* ACTION   : it begins  ...
* CREATION : 18.02.2002 PNK
*-----------------------------------------------------------------------------------*/

S16	main( S16 aArgCount, char * apArgs[] )
{
	GemDos_Super( 0 );

	if( CookieJar_Exists() )
	{
		if( CookieJar_CookieExists( '_MCH' ) )
		{
			printf( "_MCH value : %lX\n", CookieJar_GetCookieValue( '_MCH' ) );
		}
		else
		{
			printf( "_MCH Cookie not found\n" );
		}
	}
	else
	{
		printf( "No Cookie Jar found\n" );
	}

	GemDos_Cnecin();

	return( 0 );
}




/* ################################################################################ */
