extern U32 rldp_decrunch(void *);
extern U32 rldp_ice_decrunch_2(void *);
extern U32 rldp_atomic_decrunch(void *);