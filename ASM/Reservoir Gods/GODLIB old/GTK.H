extern	S32	gtk_init();
extern	S32	gtk_open(void *);
extern	S32	gtk_close();