 format 0-,1-,2-

 list +
           ***********************************************
           * MEGA-SCROLL BY THE TITAN OF DIGITAL JUSTICE *
           *                                             *
           *         WROTE USING DEVPAC 2 v2.07          *
           *                                             *
           *    THIS CODE WAS WROTE ABOUT 7 MONTHS AGO   *
           *          AND IS VERY CRAP!!!!!!!!           *
           ***********************************************
 list -

* FILES USED
*
*
* BAK.DAT 	- BAKGROUND DATA
* MEGAFONT.DAT 	- FONT
* OK6.BIN 	- MUSIC FILE


	BRA START

OLDS:	DC.L 0
OLDP:	DS.W 16
OLDR:	DC.W 0
	EVEN



START:	DC.W $A00A

	CLR.L -(SP)     ;SV MODE
	MOVE.W #$20,-(SP)
	TRAP #1
	ADDQ.L #6,SP
	MOVE.L D0,SPAR+4


	MOVEM.L ($FF8240),D0-D7
	MOVEM.L D0-D7,OLDP

	MOVE.W #2,-(SP)
	TRAP #14
	ADDQ.L #2,SP
	MOVE.L D0,(OLDS)

	MOVE.W #4,-(SP)
	TRAP #14
	ADDQ.L #2,SP
	MOVE.W D0,(OLDR)

	MOVE.W #0,-(SP)
	PEA SCR
	MOVE.L #-1,-(SP)
	MOVE.W #5,-(SP)
	TRAP #14
	ADD.L #12,SP

	MOVE.W #5,-(SP)
	MOVE.W #26,-(SP)
	TRAP #14
	ADDQ.L #4,SP

	PEA MOUSE
	MOVE.W #1,-(SP)
	MOVE.W #25,-(SP)
	TRAP #14
	ADDQ.L #8,SP

	MOVE.L #0,$FF8240
	MOVE.L #0,$FF8244
	MOVE.L #0,$FF8248
	MOVE.L #0,$FF824C
	MOVE.L #0,$FF8250
	MOVE.L #0,$FF8254
	MOVE.L #0,$FF8258
	MOVE.L #0,$FF825C

	JSR BAKPRIN

	BSR PAUSE1
	BSR PAUSE1
	BSR PAUSE1
	BSR PAUSE1
	MOVE.W #$101,$FF824C
	MOVE.W #$000,$FF8248
	MOVE.W #$000,$FF8244
	BSR PAUSE1
	BSR PAUSE1
	BSR PAUSE1
	BSR PAUSE1
	MOVE.W #$202,$FF824C
	MOVE.W #$101,$FF8248
	MOVE.W #$000,$FF8244
	BSR PAUSE1
	BSR PAUSE1
	BSR PAUSE1
	BSR PAUSE1
	MOVE.W #$303,$FF824C
	MOVE.W #$101,$FF8248
	MOVE.W #$000,$FF8244
	BSR PAUSE1
	BSR PAUSE1
	BSR PAUSE1
	BSR PAUSE1
	MOVE.W #$404,$FF824C
	MOVE.W #$202,$FF8248
	MOVE.W #$000,$FF8244
	BSR PAUSE1
	BSR PAUSE1
	BSR PAUSE1
	BSR PAUSE1
	MOVE.W #$505,$FF824C
	MOVE.W #$303,$FF8248
	MOVE.W #$101,$FF8244
	BSR PAUSE1
	BSR PAUSE1
	BSR PAUSE1
	BSR PAUSE1
	MOVE.W #$606,$FF824C
	MOVE.W #$404,$FF8248
	MOVE.W #$202,$FF8244
	BSR PAUSE1
	BSR PAUSE1
	BSR PAUSE1
	BSR PAUSE1
	MOVE.W #$707,$FF824C
	MOVE.W #$505,$FF8248
	MOVE.W #$303,$FF8244


	MOVEQ #1,D0	;INSERT OWN CODES
	JSR MUSIC

	MOVE.W #$2700,SR
	JSR INITRAST
	MOVE.L $70,OVBL
	MOVE.L #VBL,$70
	MOVE.W #$2300,SR

	MOVE.L #MYPAL,A0	;INSERT OWN PALETTE
	LEA $FF8240,A1
	MOVEQ #7,D0
	BSR COPY

DEADLOP:
	JSR PAUSE2
	MOVE.W #$507,$FF824C
	MOVE.W #$305,$FF8248
	MOVE.W #$103,$FF8244
	BSR PAUSE3
	MOVE.W #$307,$FF824C
	MOVE.W #$105,$FF8248
	MOVE.W #$003,$FF8244
	BSR PAUSE3
	MOVE.W #$107,$FF824C
	MOVE.W #$005,$FF8248
	MOVE.W #$003,$FF8244
	BSR PAUSE3
	MOVE.W #$007,$FF824C
	MOVE.W #$005,$FF8248
	MOVE.W #$003,$FF8244
	JSR PAUSE2

	MOVE.W #$017,$FF824C
	MOVE.W #$005,$FF8248
	MOVE.W #$003,$FF8244
	BSR PAUSE3
	MOVE.W #$037,$FF824C
	MOVE.W #$015,$FF8248
	MOVE.W #$003,$FF8244
	BSR PAUSE3
	MOVE.W #$057,$FF824C
	MOVE.W #$035,$FF8248
	MOVE.W #$013,$FF8244
	BSR PAUSE3
	MOVE.W #$077,$FF824C
	MOVE.W #$055,$FF8248
	MOVE.W #$033,$FF8244
	JSR PAUSE2

	MOVE.W #$075,$FF824C
	MOVE.W #$053,$FF8248
	MOVE.W #$031,$FF8244
	BSR PAUSE3
	MOVE.W #$073,$FF824C
	MOVE.W #$051,$FF8248
	MOVE.W #$030,$FF8244
	BSR PAUSE3
	MOVE.W #$071,$FF824C
	MOVE.W #$050,$FF8248
	MOVE.W #$030,$FF8244
	BSR PAUSE3
	MOVE.W #$070,$FF824C
	MOVE.W #$050,$FF8248
	MOVE.W #$030,$FF8244
	JSR PAUSE2

	MOVE.W #$170,$FF824C
	MOVE.W #$050,$FF8248
	MOVE.W #$030,$FF8244
	BSR PAUSE3
	MOVE.W #$370,$FF824C
	MOVE.W #$150,$FF8248
	MOVE.W #$030,$FF8244
	BSR PAUSE3
	MOVE.W #$570,$FF824C
	MOVE.W #$350,$FF8248
	MOVE.W #$130,$FF8244
	BSR PAUSE3
	MOVE.W #$770,$FF824C
	MOVE.W #$550,$FF8248
	MOVE.W #$330,$FF8244
	JSR PAUSE2

	MOVE.W #$750,$FF824C
	MOVE.W #$530,$FF8248
	MOVE.W #$310,$FF8244
	BSR PAUSE3
	MOVE.W #$730,$FF824C
	MOVE.W #$510,$FF8248
	MOVE.W #$300,$FF8244
	BSR PAUSE3
	MOVE.W #$710,$FF824C
	MOVE.W #$500,$FF8248
	MOVE.W #$300,$FF8244
	BSR PAUSE3
	MOVE.W #$700,$FF824C
	MOVE.W #$500,$FF8248
	MOVE.W #$300,$FF8244
	JSR PAUSE2

	MOVE.W #$701,$FF824C
	MOVE.W #$500,$FF8248
	MOVE.W #$300,$FF8244
	BSR PAUSE3
	MOVE.W #$703,$FF824C
	MOVE.W #$501,$FF8248
	MOVE.W #$300,$FF8244
	BSR PAUSE3
	MOVE.W #$705,$FF824C
	MOVE.W #$503,$FF8248
	MOVE.W #$301,$FF8244
	BSR PAUSE3
	MOVE.W #$707,$FF824C
	MOVE.W #$505,$FF8248
	MOVE.W #$303,$FF8244

	BRA DEADLOP


EXIT:
	MOVE.W #$2700,SR
	MOVE.L OVBL,$70
	JSR REMOVERAST
	MOVE.W #$2300,SR


	MOVE.W (OLDR),-(SP)
	MOVE.L (OLDS),-(SP)
	PEA SCR
	MOVE.W #5,-(SP)
	TRAP #14
	ADD.L #12,SP

	MOVE.L #OLDP,A0
	LEA $FF8240,A1
	MOVEQ #7,D0
	BSR COPY

	MOVE.W #5,-(SP)
	MOVE.W #27,-(SP)
	TRAP #14
	ADDQ.L #4,SP

	MOVE.L #$8080000,$FF8800
	MOVE.L #$9090000,$FF8800
	MOVE.L #$A0A0000,$FF8800

	MOVE.L SPAR+4,-(SP)
	MOVE.W #$20,-(SP)
	TRAP #1
	ADDQ.L #6,SP

	PEA MOUSE+2
	MOVE.W #1,-(SP)
	MOVE.W #25,-(SP)
	TRAP #14
	ADDQ.L #8,SP

	MOVE.W #0,-(SP)
	TRAP #1


COPY:
        MOVE.L (A0)+,(A1)+
        DBRA D0,COPY
        RTS

PAUSE1:	MOVE.W #37,-(SP)
	TRAP #14
	ADD.L #2,SP
	RTS

PAUSE2:	MOVE.W #500,D0

PB:	CMP.B #0,(FLAG)
	BEQ PB
	MOVE.B #0,(FLAG)
	CMP.B #$39,$FFFC02
	BEQ EXIT
	DBRA D0,PB
	RTS
PAUSE3:	BSR PBB
	BSR PBB
	BSR PBB
	BSR PBB
	BSR PBB
	BSR PBB
	BSR PBB
PBB	CMP.B #0,(FLAG)
	BEQ PBB
	MOVE.B #0,(FLAG)
	CMP.B #$39,$FFFC02
	BEQ EXIT
	RTS




VBL:
	MOVE.L D0,-(SP)
        MOVE.W #$0,$FF8240
        CLR.B $FFFA1B
        MOVEQ #4,D0
        MOVE.B D0,$FFFA21
        MOVE.B #8,$FFFA1B

        MOVE.L #CTAB,(CPOS)

	JSR SCROLLY
	JSR BAKPRIN
	JSR MUSIC+8

	MOVE.B #1,(FLAG)
	MOVE.L (SP)+,D0
        RTE
        
INITRAST:
        MOVE.L $120,SPAR2
        MOVE.B $FFFA09,SPAR4
        MOVE.B $FFFA07,SPAR4+1
        MOVE.B $FFFA13,SPAR4+2
        MOVE.L #CTAB,(CPOS)
        MOVE.L #RASTER1,$120
        ORI.B #1,$FFFA07
        ORI.B #1,$FFFA13
        RTS

REMOVERAST:
        MOVE.B SPAR4,$FFFA09
        MOVE.B SPAR4+1,$FFFA07
        MOVE.B SPAR4+2,$FFFA13
        MOVE.L SPAR2,$120
        RTS

RASTER1:
	MOVE.L A5,-(SP)
	MOVE.L (CPOS),A5
        MOVE.W (A5),$FF8242
        MOVE.W (A5),$FF8246
        MOVE.W (A5),$FF824A
        MOVE.W (A5),$FF824E
	ADDQ.L #2,(CPOS)
        BCLR #0,$FFFA0F
	MOVE.L (SP)+,A5
        RTE


NEWCHAR:
	MOVE.B #0,(TCOUNT)
NC1:	MOVE.L (TPOS),A2
	CLR.L D0
	MOVE.B (A2),D0

	CMP.B #$FF,D0
	BEQ WRAP

	SUB.B #32,D0
NC2:	ADDQ.L #1,(TPOS)

	MULU #416,D0

	MOVE.L #FONT,A1
	ADD.L D0,A1
	BRA LETPRIN


WRAP:	MOVE.L #TEXT,(TPOS)
	BRA NC1

LETPRIN:
	MOVE.L #SCRBAC+40,A0

	REPT 15
	MOVEM.W (A1)+,D0-D7
	MOVEM.W D0-D7,(A0)
	ADD.L #16,A0
	MOVEM.W (A1)+,D0-D4
	MOVEM.W D0-D4,(A0)
	ADD.L #66-26+10,A0
	ENDR
	BRA SCROLL


SCROLLY: 
	MOVE.B (TCOUNT),D0
	CMP.B #12,D0
	BEQ NEWCHAR
	ADD.B #1,(TCOUNT)
SCROLL:
	MOVE.L #SCRBAC,A0
SC1	MACRO
	MOVEM.L 2(A0),D0-D7
	MOVEM.L D0-D7,(A0)
	ADD.L #32,A0

	MOVEM.L 2(A0),D0-D7
	MOVEM.L D0-D7,(A0)
	ADD.L #34,A0
	ENDM

	REPT 15
	SC1
	ENDR

FLICK:
	MOVE.L #SCRBAC,A0
	MOVE.L #SCR+640,A1

FL1:	MACRO
	MOVEM.W (A0)+,D0-D7
LD:	SET 0
	MOVE.W D0,LD(A1)
	MOVE.W D1,LD+8(A1)
	MOVE.W D2,LD+16(A1)
	MOVE.W D3,LD+24(A1)
	MOVE.W D4,LD+32(A1)
	MOVE.W D5,LD+40(A1)
	MOVE.W D6,LD+48(A1)
	MOVE.W D7,LD+56(A1)
LD:	SET 160
	MOVE.W D0,LD(A1)
	MOVE.W D1,LD+8(A1)
	MOVE.W D2,LD+16(A1)
	MOVE.W D3,LD+24(A1)
	MOVE.W D4,LD+32(A1)
	MOVE.W D5,LD+40(A1)
	MOVE.W D6,LD+48(A1)
	MOVE.W D7,LD+56(A1)
LD:	SET 320
	MOVE.W D0,LD(A1)
	MOVE.W D1,LD+8(A1)
	MOVE.W D2,LD+16(A1)
	MOVE.W D3,LD+24(A1)
	MOVE.W D4,LD+32(A1)
	MOVE.W D5,LD+40(A1)
	MOVE.W D6,LD+48(A1)
	MOVE.W D7,LD+56(A1)
LD:	SET 480
	MOVE.W D0,LD(A1)
	MOVE.W D1,LD+8(A1)
	MOVE.W D2,LD+16(A1)
	MOVE.W D3,LD+24(A1)
	MOVE.W D4,LD+32(A1)
	MOVE.W D5,LD+40(A1)
	MOVE.W D6,LD+48(A1)
	MOVE.W D7,LD+56(A1)
LD:	SET 640
	MOVE.W D0,LD(A1)
	MOVE.W D1,LD+8(A1)
	MOVE.W D2,LD+16(A1)
	MOVE.W D3,LD+24(A1)
	MOVE.W D4,LD+32(A1)
	MOVE.W D5,LD+40(A1)
	MOVE.W D6,LD+48(A1)
	MOVE.W D7,LD+56(A1)
LD:	SET 800
	MOVE.W D0,LD(A1)
	MOVE.W D1,LD+8(A1)
	MOVE.W D2,LD+16(A1)
	MOVE.W D3,LD+24(A1)
	MOVE.W D4,LD+32(A1)
	MOVE.W D5,LD+40(A1)
	MOVE.W D6,LD+48(A1)
	MOVE.W D7,LD+56(A1)
LD:	SET 960
	MOVE.W D0,LD(A1)
	MOVE.W D1,LD+8(A1)
	MOVE.W D2,LD+16(A1)
	MOVE.W D3,LD+24(A1)
	MOVE.W D4,LD+32(A1)
	MOVE.W D5,LD+40(A1)
	MOVE.W D6,LD+48(A1)
	MOVE.W D7,LD+56(A1)
LD:	SET 1120
	MOVE.W D0,LD(A1)
	MOVE.W D1,LD+8(A1)
	MOVE.W D2,LD+16(A1)
	MOVE.W D3,LD+24(A1)
	MOVE.W D4,LD+32(A1)
	MOVE.W D5,LD+40(A1)
	MOVE.W D6,LD+48(A1)
	MOVE.W D7,LD+56(A1)
LD:	SET 1280
	MOVE.W D0,LD(A1)
	MOVE.W D1,LD+8(A1)
	MOVE.W D2,LD+16(A1)
	MOVE.W D3,LD+24(A1)
	MOVE.W D4,LD+32(A1)
	MOVE.W D5,LD+40(A1)
	MOVE.W D6,LD+48(A1)
	MOVE.W D7,LD+56(A1)
LD:	SET 1440
	MOVE.W D0,LD(A1)
	MOVE.W D1,LD+8(A1)
	MOVE.W D2,LD+16(A1)
	MOVE.W D3,LD+24(A1)
	MOVE.W D4,LD+32(A1)
	MOVE.W D5,LD+40(A1)
	MOVE.W D6,LD+48(A1)
	MOVE.W D7,LD+56(A1)
LD:	SET 1600
	MOVE.W D0,LD(A1)
	MOVE.W D1,LD+8(A1)
	MOVE.W D2,LD+16(A1)
	MOVE.W D3,LD+24(A1)
	MOVE.W D4,LD+32(A1)
	MOVE.W D5,LD+40(A1)
	MOVE.W D6,LD+48(A1)
	MOVE.W D7,LD+56(A1)
LD:	SET 1760
	MOVE.W D0,LD(A1)
	MOVE.W D1,LD+8(A1)
	MOVE.W D2,LD+16(A1)
	MOVE.W D3,LD+24(A1)
	MOVE.W D4,LD+32(A1)
	MOVE.W D5,LD+40(A1)
	MOVE.W D6,LD+48(A1)
	MOVE.W D7,LD+56(A1)
LD:	SET 1920
	MOVE.W D0,LD(A1)
	MOVE.W D1,LD+8(A1)
	MOVE.W D2,LD+16(A1)
	MOVE.W D3,LD+24(A1)
	MOVE.W D4,LD+32(A1)
	MOVE.W D5,LD+40(A1)
	MOVE.W D6,LD+48(A1)
	MOVE.W D7,LD+56(A1)


	MOVEM.W (A0)+,D0-D7
LD:	SET 64+0
	MOVE.W D0,LD(A1)
	MOVE.W D1,LD+8(A1)
	MOVE.W D2,LD+16(A1)
	MOVE.W D3,LD+24(A1)
	MOVE.W D4,LD+32(A1)
	MOVE.W D5,LD+40(A1)
	MOVE.W D6,LD+48(A1)
	MOVE.W D7,LD+56(A1)
LD:	SET 64+160
	MOVE.W D0,LD(A1)
	MOVE.W D1,LD+8(A1)
	MOVE.W D2,LD+16(A1)
	MOVE.W D3,LD+24(A1)
	MOVE.W D4,LD+32(A1)
	MOVE.W D5,LD+40(A1)
	MOVE.W D6,LD+48(A1)
	MOVE.W D7,LD+56(A1)
LD:	SET 64+320
	MOVE.W D0,LD(A1)
	MOVE.W D1,LD+8(A1)
	MOVE.W D2,LD+16(A1)
	MOVE.W D3,LD+24(A1)
	MOVE.W D4,LD+32(A1)
	MOVE.W D5,LD+40(A1)
	MOVE.W D6,LD+48(A1)
	MOVE.W D7,LD+56(A1)
LD:	SET 64+480
	MOVE.W D0,LD(A1)
	MOVE.W D1,LD+8(A1)
	MOVE.W D2,LD+16(A1)
	MOVE.W D3,LD+24(A1)
	MOVE.W D4,LD+32(A1)
	MOVE.W D5,LD+40(A1)
	MOVE.W D6,LD+48(A1)
	MOVE.W D7,LD+56(A1)
LD:	SET 64+640
	MOVE.W D0,LD(A1)
	MOVE.W D1,LD+8(A1)
	MOVE.W D2,LD+16(A1)
	MOVE.W D3,LD+24(A1)
	MOVE.W D4,LD+32(A1)
	MOVE.W D5,LD+40(A1)
	MOVE.W D6,LD+48(A1)
	MOVE.W D7,LD+56(A1)
LD:	SET 64+800
	MOVE.W D0,LD(A1)
	MOVE.W D1,LD+8(A1)
	MOVE.W D2,LD+16(A1)
	MOVE.W D3,LD+24(A1)
	MOVE.W D4,LD+32(A1)
	MOVE.W D5,LD+40(A1)
	MOVE.W D6,LD+48(A1)
	MOVE.W D7,LD+56(A1)
LD:	SET 64+960
	MOVE.W D0,LD(A1)
	MOVE.W D1,LD+8(A1)
	MOVE.W D2,LD+16(A1)
	MOVE.W D3,LD+24(A1)
	MOVE.W D4,LD+32(A1)
	MOVE.W D5,LD+40(A1)
	MOVE.W D6,LD+48(A1)
	MOVE.W D7,LD+56(A1)
LD:	SET 64+1120
	MOVE.W D0,LD(A1)
	MOVE.W D1,LD+8(A1)
	MOVE.W D2,LD+16(A1)
	MOVE.W D3,LD+24(A1)
	MOVE.W D4,LD+32(A1)
	MOVE.W D5,LD+40(A1)
	MOVE.W D6,LD+48(A1)
	MOVE.W D7,LD+56(A1)
LD:	SET 64+1280
	MOVE.W D0,LD(A1)
	MOVE.W D1,LD+8(A1)
	MOVE.W D2,LD+16(A1)
	MOVE.W D3,LD+24(A1)
	MOVE.W D4,LD+32(A1)
	MOVE.W D5,LD+40(A1)
	MOVE.W D6,LD+48(A1)
	MOVE.W D7,LD+56(A1)
LD:	SET 64+1440
	MOVE.W D0,LD(A1)
	MOVE.W D1,LD+8(A1)
	MOVE.W D2,LD+16(A1)
	MOVE.W D3,LD+24(A1)
	MOVE.W D4,LD+32(A1)
	MOVE.W D5,LD+40(A1)
	MOVE.W D6,LD+48(A1)
	MOVE.W D7,LD+56(A1)
LD:	SET 64+1600
	MOVE.W D0,LD(A1)
	MOVE.W D1,LD+8(A1)
	MOVE.W D2,LD+16(A1)
	MOVE.W D3,LD+24(A1)
	MOVE.W D4,LD+32(A1)
	MOVE.W D5,LD+40(A1)
	MOVE.W D6,LD+48(A1)
	MOVE.W D7,LD+56(A1)
LD:	SET 64+1760
	MOVE.W D0,LD(A1)
	MOVE.W D1,LD+8(A1)
	MOVE.W D2,LD+16(A1)
	MOVE.W D3,LD+24(A1)
	MOVE.W D4,LD+32(A1)
	MOVE.W D5,LD+40(A1)
	MOVE.W D6,LD+48(A1)
	MOVE.W D7,LD+56(A1)
LD:	SET 64+1920
	MOVE.W D0,LD(A1)
	MOVE.W D1,LD+8(A1)
	MOVE.W D2,LD+16(A1)
	MOVE.W D3,LD+24(A1)
	MOVE.W D4,LD+32(A1)
	MOVE.W D5,LD+40(A1)
	MOVE.W D6,LD+48(A1)
	MOVE.W D7,LD+56(A1)



	MOVEM.W (A0)+,D0-D3
LD:	SET 128+0
	MOVE.W D0,LD(A1)
	MOVE.W D1,LD+8(A1)
	MOVE.W D2,LD+16(A1)
	MOVE.W D3,LD+24(A1)
LD:	SET 128+160
	MOVE.W D0,LD(A1)
	MOVE.W D1,LD+8(A1)
	MOVE.W D2,LD+16(A1)
	MOVE.W D3,LD+24(A1)
LD:	SET 128+320
	MOVE.W D0,LD(A1)
	MOVE.W D1,LD+8(A1)
	MOVE.W D2,LD+16(A1)
	MOVE.W D3,LD+24(A1)
LD:	SET 128+480
	MOVE.W D0,LD(A1)
	MOVE.W D1,LD+8(A1)
	MOVE.W D2,LD+16(A1)
	MOVE.W D3,LD+24(A1)
LD:	SET 128+640
	MOVE.W D0,LD(A1)
	MOVE.W D1,LD+8(A1)
	MOVE.W D2,LD+16(A1)
	MOVE.W D3,LD+24(A1)
LD:	SET 128+800
	MOVE.W D0,LD(A1)
	MOVE.W D1,LD+8(A1)
	MOVE.W D2,LD+16(A1)
	MOVE.W D3,LD+24(A1)
LD:	SET 128+960
	MOVE.W D0,LD(A1)
	MOVE.W D1,LD+8(A1)
	MOVE.W D2,LD+16(A1)
	MOVE.W D3,LD+24(A1)
LD:	SET 128+1120
	MOVE.W D0,LD(A1)
	MOVE.W D1,LD+8(A1)
	MOVE.W D2,LD+16(A1)
	MOVE.W D3,LD+24(A1)
LD:	SET 128+1280
	MOVE.W D0,LD(A1)
	MOVE.W D1,LD+8(A1)
	MOVE.W D2,LD+16(A1)
	MOVE.W D3,LD+24(A1)
LD:	SET 128+1440
	MOVE.W D0,LD(A1)
	MOVE.W D1,LD+8(A1)
	MOVE.W D2,LD+16(A1)
	MOVE.W D3,LD+24(A1)
LD:	SET 128+1600
	MOVE.W D0,LD(A1)
	MOVE.W D1,LD+8(A1)
	MOVE.W D2,LD+16(A1)
	MOVE.W D3,LD+24(A1)
LD:	SET 128+1760
	MOVE.W D0,LD(A1)
	MOVE.W D1,LD+8(A1)
	MOVE.W D2,LD+16(A1)
	MOVE.W D3,LD+24(A1)
LD:	SET 128+1920
	MOVE.W D0,LD(A1)
	MOVE.W D1,LD+8(A1)
	MOVE.W D2,LD+16(A1)
	MOVE.W D3,LD+24(A1)
	ADD.L #26,A0
	ADD.L #2080,A1
	ENDM

	REPT 15
	FL1
	ENDR
	RTS


BAK1:	MACRO
	MOVEM.L (A0)+,D0-D7
	MOVE.L D0,(A1)
	MOVE.L D1,8(A1)
	MOVE.L D2,16(A1)
	MOVE.L D3,24(A1)
	MOVE.L D4,32(A1)
	MOVE.L D5,40(A1)
	MOVE.L D6,48(A1)
	MOVE.L D7,56(A1)
	MOVEM.L (A0)+,D0-D7
	MOVE.L D0,64(A1)
	MOVE.L D1,64+8(A1)
	MOVE.L D2,64+16(A1)
	MOVE.L D3,64+24(A1)
	MOVE.L D4,64+32(A1)
	MOVE.L D5,64+40(A1)
	MOVE.L D6,64+48(A1)
	MOVE.L D7,64+56(A1)
	MOVEM.L (A0)+,D0-D3
	MOVE.L D0,128(A1)
	MOVE.L D1,128+8(A1)
	MOVE.L D2,128+16(A1)
	MOVE.L D3,128+24(A1)
	ENDM

BAKSET:	MOVE.L #BAKTAB,(BAKPOS)

BAKPRIN:
	CMP.L #BAKEND,(BAKPOS)
	BEQ BAKSET
	ADD.L #2,(BAKPOS)
	MOVE.L (BAKPOS),A2
	MOVE.L #SCR+2+160,A1


	REPT 25
	MOVE.W (A2)+,D0
	LEA BAK,A0
	ADD.W D0,A0
	BAK1
	ADD.L #160,A1
	BAK1
	ADD.L #160,A1
	BAK1
	ADD.L #160,A1
	BAK1
	ADD.L #160,A1
	BAK1
	ADD.L #160,A1
	BAK1
	ADD.L #480,A1
	ENDR

	RTS

************** DATA IN DE AREA (THE REVENGE OF!!!) *************
FLAG:	DC.B 0
	EVEN
BAKPOS:	DC.L PRETAB

PRETAB	DS.W 100

BAKTAB

	REPT 5
	DC.W 0,640,1280,1920,2560,3200,3840,3840,4480,4480,4480,4480
	DC.W 3840,3840,3200,2560,1920,1280,640,0
	DC.W 4480,3840,3200,2560,1920,1280,1280,640,640,640,640
	DC.W 1280,1280,1920,2560,3200,3840,4480
	ENDR


	REPT 5
	DC.W 0,1280,2560,3200,3840,3840,4480,4480,4480,4480
	DC.W 3840,3840,3200,2560,1280,0
	DC.W 3840,2560,1920,1280,1280,640,640,640,640
	DC.W 1280,1280,1920,2560,3840
	ENDR


	REPT 7
	DC.W 0,640,1280,1920,2560,3200,3840,4480
	ENDR
	DS.W 25

	REPT 5
	DC.W 0,640,1280,1920,1920,2560,2560,2560
	DC.W 1920,1280,640,0
	DC.W 4480,3840,3200,3200,2560,2560,2560
	DC.W 3200,3200,3840,4480
	ENDR

	REPT 7
	DC.W 4480,3840,3200,2560,1920,1280,640,0
	ENDR
	DS.W 25

	REPT 10
	DC.W 0,1920,3840,640,2560,4480
	DC.W 4480,2560,640,3840,1920,0
	DC.W 3200,1280,4480,2560,640
	DC.W 640,2560,4480,1280,3200
	ENDR


	DC.W 0,640,1280,1920,2560,3200,3840,3840,4480,4480,4480,4480
	DC.W 3840,3840,3200,2560,1920,1280,640,0
	DC.W 4480,3840,3200,2560,1920,1280,1280,640,640,640,640
	DC.W 1280,1280,1920,2560,3200,3840,4480
BAKEND	REPT 5
	DC.W 0,640,1280,1920,2560,3200,3840,3840,4480,4480,4480,4480
	DC.W 3840,3840,3200,2560,1920,1280,640,0
	DC.W 4480,3840,3200,2560,1920,1280,1280,640,640,640,640
	DC.W 1280,1280,1920,2560,3200,3840,4480
	ENDR


SCRBAC:	DS.B 66*15
	EVEN

TCOUNT:	DC.B 0
	EVEN
TEXT:	
	DC.B '   ...... . . . .   .   .   .     '
	DC.B 'DIGITAL JUSTICE PROUDLY PRESENTS THE "SUPER-SCROLLER" SCREEN....            '
	DC.B 'THE ORGINAL TEXT HAS BEEN TAKEN OUT SO GET THE SUMMONING OF THE SPAWN MEGA-DEMO IF YOU WANT TO READ IT!!!!.........      '
	DC.B 'SPECIAL GREETS FOR THIS VERSION OF THE SCREEN GO TO ALL THE MEGA COOL GUYS THAT MAKE UP THE ENTERPRISE.......        LETS WRAP!!!           '
	DC.B $FF

	EVEN
TPOS:	DC.L TEXT

SPAR1:  DC.L 0
SPAR2:  DC.L 0
SPAR3:  DC.L 0
SPAR4:  DC.L 0
SPAR5:  DC.W 0
SCR:	EQU $78000

CPOS:	DC.L CTAB

CTAB:

 DC.W $001,$002,$003,$004,$005,$006
 DC.W $007,$017,$027,$037,$047,$057,$067,$077
 DC.W $067,$057,$047,$037,$027,$017
 DC.W $007,$006,$005,$004,$003,$002

 DC.W $001,$002,$003,$004,$005,$006
 DC.W $007,$017,$027,$037,$047,$057,$067,$077
 DC.W $067,$057,$047,$037,$027,$017
 DC.W $007,$006,$005,$004,$003,$002



SPAR:   DS.L 10

OVBL:
        DC.L 0

MOUSE:
        DC.B $12,$1A,$14,8
        EVEN
SYSPAL:	DC.W $777,$700,$070,$000,$007,$707,$007,$555,$333,$733,$373
	DC.W $773,$337,$737,$377,$000

MYPAL:	DC.W $000,$007,$303,$007,$505,$007,$707,$0606
	DC.W $101,$0111,$707,$0222,$505,$0333,$0444,$0444

BAK:	INCBIN 'A:\SOURCE\BAK.DAT'
	EVEN

FONT
	INCBIN 'A:\SOURCE\MEGAFONT.DAT'
	EVEN
MUSIC:
	INCBIN 'A:\SOURCE\OK6.BIN'
	EVEN
	END