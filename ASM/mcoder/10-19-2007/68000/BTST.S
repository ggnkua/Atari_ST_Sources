013A013A     BTST D0,$42158(PC)
033A033A     BTST D1,$42378(PC)
053A053A     BTST D2,$42598(PC)
073A073A     BTST D3,$427B8(PC)
083A083A083A BTST #$3A,$428BE(PC)
093A093A     BTST D4,$429D2(PC)
0B3A0B3A     BTST D5,$42BEC(PC)
0D3A0D3A     BTST D6,$42E0C(PC)
0F3A0F3A     BTST D7,$4302C(PC)
013B013B     BTST D0,$4304D(PC,D0.W)
033B033B     BTST D1,$4306D(PC,D0.W)
053B053B     BTST D2,$4308D(PC,D0.W)
073B073B     BTST D3,$430AD(PC,D0.W)
083B083B083B BTST #$3B,$430BF(PC,D0.L)
093B093B     BTST D4,$430D3(PC,D0.L)
0B3B0B3B     BTST D5,$430ED(PC,D0.L)
0D3B0D3B     BTST D6,$4310D(PC,D0.L)
0F3B0F3B     BTST D7,$4312D(PC,D0.L)
013C013C     BTST D0,#$13C
033C033C     BTST D1,#$33C
053C053C     BTST D2,#$53C
073C073C     BTST D3,#$73C
093C093C     BTST D4,#$93C
0B3C0B3C     BTST D5,#$B3C
0D3C0D3C     BTST D6,#$D3C
0F3C0F3C     BTST D7,#$F3C
