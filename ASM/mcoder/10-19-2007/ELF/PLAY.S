REPLAY=$80000
MUSIC=$90000
	MOVE	SR,D0
	AND	#$2000,D0
	BNE.S	SUPER
	CLR.L	-(SP)
	MOVE	#$20,-(SP)
	TRAP	#1
	ADDQ	#6,SP
SUPER:
	LEA	MUSIC,A0
	JSR	REPLAY
WAIT:
	MOVE	#37,-(SP)
	TRAP	#14
	ADDQ	#2,SP
	JSR	REPLAY+4
	MOVE	#$FF,-(SP)
	MOVE	#6,-(SP)
	TRAP	#1
	ADDQ	#4,SP
	TST	D0
	BEQ.S	WAIT
	ILLEGAL
