;	OPT	D+
;MOVEQ #$80,D5,AFF9
;2998 BYTES
	BRA.W	AFF0
	BRA.W	AFF1
	BRA.W	AFF2
	BRA.W	AFF3
	BRA.W	AFF4
	BRA.W	AFF5
	BRA.W	AFF6
	BRA.W	AFF7
	BRA.W	AFF8
	BRA.W	AFF9
	BRA.W	AFFA
	BRA.W	AFFB
	BRA.W	AFFC
	BRA.W	AFFD
	BRA.W	AFFE
	BRA.W	AFFF

;	dcb.w	5,-1
muls160:
x	set	-15*160
	rept	215
	dc.w	x
x	set	x+160
	endr
;	dcb.w	5,-1

AFF0:
	MOVE.L	#-$7FFF8002,D0
	OR.L	D0,800(A6)
	OR.L	D0,960(A6)

	MOVE.L	#-$3FFFC002,D0
	OR.L	D0,1120(A6)
	OR.L	D0,1280(A6)

	OR	#$7C0,2(A6)
	OR	#$1FF0,162(A6)
	OR	#$3FF8,322(A6)
	OR.L	#$C07FFC,480(A6)
	OR.L	#$607FFC,640(A6)
	OR.L	#-$1FFFE002,1440(A6)
	OR.L	#$70000FFC,1600(A6)
	OR.L	#$780007FC,1760(A6)
	OR.L	#$3C0003F8,1920(A6)
	OR.L	#$1F0000F0,2080(A6)
	OR	#$7C0,2240(A6)
	JMP	(A5)

AFF1:
	MOVE.L	#$40003FFF,D0
	OR.L	D0,800(A6)
	OR.L	D0,960(A6)

	MOVE.L	#$60001FFF,D0
	OR.L	D0,1120(A6)
	OR.L	D0,1280(A6)

	OR	#$3E0,2(A6)
	OR	#$FF8,162(A6)
	OR	#$1FFC,322(A6)
	OR.L	#$603FFE,480(A6)
	OR.L	#$303FFE,640(A6)
	OR.L	#$70000FFF,1440(A6)
	OR.L	#$380007FE,1600(A6)
	OR.L	#$3C0003FE,1760(A6)
	OR.L	#$1E0001FC,1920(A6)
	OR.L	#$F800078,2080(A6)
	OR	#$3E0,2240(A6)
	JMP	(A5)
AFF2:
	MOVE.L	#$20001FFF,D0
	OR.L	D0,800(A6)
	OR.L	D0,960(A6)

	MOVEQ.L	#$80,D0
	OR.B	D0,810(A6)
	OR.B	D0,970(A6)
	OR.B	D0,1130(A6)
	OR.B	D0,1290(A6)
	OR.B	D0,1450(A6)

	MOVE.L	#$30000FFF,D0
	OR.L	D0,1120(A6)
	OR.L	D0,1280(A6)

	OR	#$1F0,2(A6)
	OR	#$7FC,162(A6)
	OR	#$FFE,322(A6)
	OR.L	#$301FFF,480(A6)
	OR.L	#$181FFF,640(A6)
	OR.L	#$380007FF,1440(A6)
	OR.L	#$1C0003FF,1600(A6)
	OR.L	#$1E0001FF,1760(A6)
	OR.L	#$F0000FE,1920(A6)
	OR.L	#$7C0003C,2080(A6)
	OR	#$1F0,2240(A6)
	JMP	(A5)
AFF3:
	MOVE.L	#$180007FF,D0
	OR	D0,322(A6)
	OR.L	D0,1120(A6)
	OR.L	D0,1280(A6)
	MOVE.B	D0,1763(A6)

	MOVEQ.L	#$80,D0
	OR.B	D0,490(A6)
	OR.B	D0,650(A6)
	OR.B	D0,1610(A6)
	OR.B	D0,1770(A6)

	MOVE.L	#$10000FFF,D0
	OR.L	D0,800(A6)
	OR.L	D0,960(A6)

	MOVEQ	#-$40,D0
	OR.B	D0,810(A6)
	OR.B	D0,970(A6)
	OR.B	D0,1130(A6)
	OR.B	D0,1290(A6)
	OR.B	D0,1450(A6)

	MOVEQ.L	#$F8,D0
	OR.B	D0,2+1(A6)
	OR.B	D0,2240+1(A6)

	OR	#$3FE,162(A6)
	OR.L	#$180FFF,480(A6)
	OR.L	#$C0FFF,640(A6)
	OR.L	#$1C0003FF,1440(A6)
	OR.L	#$E0001FF,1600(A6)
	OR	#$F00,1760(A6)
	OR.L	#$780007F,1920(A6)
	OR.L	#$3E0001E,2080(A6)
	JMP	(A5)
AFF4:
	MOVE.L	#$C0003FF,D0
	OR	D0,322(A6)
	OR.L	D0,1120(A6)
	OR.L	D0,1280(A6)
	MOVE.B	D0,1603(A6)

	MOVEQ	#-$40,D0
	OR.B	D0,490(A6)
	OR.B	D0,650(A6)
	OR.B	D0,1610(A6)
	OR.B	D0,1770(A6)

	MOVE.L	#$80007FF,D0
	OR.L	D0,800(A6)
	OR.L	D0,960(A6)

	MOVEQ	#-$20,D0
	OR.B	D0,810(A6)
	OR.B	D0,970(A6)
	OR.B	D0,1130(A6)
	OR.B	D0,1290(A6)
	OR.B	D0,1450(A6)

	MOVEQ	#$7C,D0
	OR	D0,2(A6)
	OR	D0,2240(A6)

	MOVEQ.L	#$80,D0
	OR.B	D0,330(A6)
	OR.B	D0,1930(A6)

	MOVE.L	#$E0001FF,D0
	OR.L	D0,1440(A6)
	OR	D0,162(A6)

	OR.L	#$C07FF,480(A6)
	OR.L	#$607FF,640(A6)
	OR	#$700,1600(A6)
	OR.L	#$780007F,1760(A6)
	OR.L	#$3C0003F,1920(A6)
	OR.L	#$1F0000F,2080(A6)
	JMP	(A5)
AFF5:
	MOVE.L	#$60001FF,D0
	OR	D0,322(A6)
	OR.L	D0,1120(A6)
	OR.L	D0,1280(A6)
	MOVE.B	D0,1443(A6)
	MOVE.B	D0,163(A6)

	MOVEQ	#-$20,D0
	OR.B	D0,490(A6)
	OR.B	D0,650(A6)
	OR.B	D0,1610(A6)
	OR.B	D0,1770(A6)

	MOVE.L	#$40003FF,D0
	OR.L	D0,800(A6)
	OR.L	D0,960(A6)

	MOVEQ	#-$10,D0
	OR.B	D0,810(A6)
	OR.B	D0,970(A6)
	OR.B	D0,1130(A6)
	OR.B	D0,1290(A6)
	OR.B	D0,1450(A6)

	MOVEQ	#$3E,D0
	OR	D0,2(A6)
	OR	D0,2240(A6)

	MOVEQ	#-$40,D0
	OR.B	D0,1930(A6)
	OR.B	D0,330(A6)

	MOVE.L	#$F80007,D0
	OR.L	D0,2080(A6)
	OR.B	D0,1440(A6)

	MOVEQ.L	#$80,D0
	OR.B	D0,2090(A6)
	OR.B	D0,170(A6)

	OR.L	#$603FF,480(A6)
	OR.L	#$303FF,640(A6)
	OR.L	#$380007F,1600(A6)
	OR.L	#$3C0003F,1760(A6)
	OR.L	#$1E0001F,1920(A6)
	JMP	(A5)
AFF6:
	MOVE.L	#$1E0001F,D0
	OR	D0,2(A6)
	OR.L	D0,1760(A6)
	OR	D0,2240(A6)

	MOVE.L	#-$7FFF1000,D0
	OR	D0,490(A6)
	OR.L	D0,648(A6)
	OR	D0,1610(A6)
	OR	D0,1770(A6)

	MOVE.L	#$20001FF,D0
	OR.L	D0,800(A6)
	OR.L	D0,960(A6)
	MOVE.B	D0,1123(A6)
	MOVE.B	D0,1283(A6)
	MOVE.B	D0,323(A6)

	MOVEQ	#-$8,D0
	OR.B	D0,810(A6)
	OR.B	D0,970(A6)
	OR.B	D0,1130(A6)
	OR.B	D0,1290(A6)
	OR.B	D0,1450(A6)

	MOVE.L	#$380007F,D0
	OR.L	D0,1440(A6)
	OR	D0,162(A6)

	MOVEQ	#-$40,D0
	OR.B	D0,170(A6)
	OR.B	D0,2090(A6)

	MOVEQ	#-$20,D0
	OR.B	D0,330(A6)
	OR.B	D0,1930(A6)

	MOVE.L	#$7C0003,D0
	OR.L	D0,2080(A6)
	OR.B	D0,1120(A6)
	OR.B	D0,1280(A6)

	OR.L	#$301FF,480(A6)
	OR.L	#$101FF,640(A6)
	OR.L	#$1C0003F,1600(A6)
	OR.L	#$F0000F,1920(A6)
	JMP	(A5)
AFF7:
	MOVE.L	#$F0000F,D0
	OR	D0,2(A6)
	OR.L	D0,1760(A6)
	OR	D0,2240(A6)

	MOVE.L	#$180007F,D0
	OR	D0,322(A6)
	OR.L	D0,1120(A6)
	OR.L	D0,1280(A6)

	MOVE.L	#-$7FFF0800,D0
	OR.L	D0,488(A6)
	OR	D0,1610(A6)
	OR	D0,1770(A6)

	MOVEQ	#-$4,D0
	OR.B	D0,810(A6)
	OR.B	D0,970(A6)
	OR.B	D0,1130(A6)
	OR.B	D0,1290(A6)
	OR.B	D0,1450(A6)

	MOVEQ	#-1,D0
	MOVE.B	D0,483(A6)
	MOVE.B	D0,643(A6)
	MOVE.B	D0,803(A6)
	MOVE.B	D0,963(A6)

	MOVEQ	#-$20,D0
	OR.B	D0,170(A6)
	OR.B	D0,2090(A6)

	MOVEQ	#-$10,D0
	OR.B	D0,330(A6)
	OR.B	D0,1930(A6)

	MOVE.L	#$3E0001,D0
	OR.L	D0,2080(A6)
	OR.B	D0,800(A6)
	OR.B	D0,960(A6)
	OR.B	D0,480+1(A6)

	MOVEQ.L	#$80,D0
	OR.B	D0,10(A6)
	OR.B	D0,2248(A6)

	MOVE.L	#$1C0003F,D0
	OR.L	D0,1440(A6)
	OR	D0,162(A6)

	OR.L	#-$3FFF0800,648(A6)
	OR.L	#$E0001F,1600(A6)
	OR.L	#$780007,1920(A6)
	JMP	(A5)
AFF8:
	MOVE.L	#$780007,D0
	OR	D0,2(A6)
	OR.L	D0,1760(A6)
	OR	D0,2240(A6)

	MOVE.L	#$E0001F,D0
	OR	D0,162(A6)
	OR.L	D0,1440(A6)
	OR	D0,2080(A6)

	MOVE.L	#$C0003F,D0
	OR	D0,322(A6)
	OR.L	D0,1120(A6)
	OR.L	D0,1280(A6)

	MOVE.L	#$80007F,D0
	OR	D0,482(A6)
	OR	D0,642(A6)
	OR.L	D0,800(A6)
	OR.L	D0,960(A6)

	MOVE.L	#-$3FFF0400,D0
	OR.L	D0,488(A6)
	OR	D0,1610(A6)
	OR	D0,1770(A6)

	MOVEQ	#-$2,D0
	OR.B	D0,810(A6)
	OR.B	D0,970(A6)
	OR.B	D0,1130(A6)
	OR.B	D0,1290(A6)
	OR.B	D0,1450(A6)

	MOVEQ	#-$40,D0
	OR.B	D0,10(A6)
	OR.B	D0,2248(A6)

	MOVEQ	#-$10,D0
	OR.B	D0,170(A6)
	OR.B	D0,2090(A6)

	MOVEQ	#-8,D0
	OR.B	D0,330(A6)
	OR.B	D0,1930(A6)

	OR.L	#$6000FC00,648(A6)
	OR.L	#$70000F,1600(A6)
	OR.L	#$3C0003,1920(A6)
	JMP	(A5)
AFF9:
	MOVE.L	#$3C0003,D0
	OR	D0,2(A6)
	OR.L	D0,1760(A6)
	OR	D0,2240(A6)

	MOVE.L	#$70000F,D0
	OR	D0,162(A6)
	OR.L	D0,1440(A6)
	OR	D0,2080(A6)

	MOVE.L	#$60001F,D0
	OR	D0,322(A6)
	OR.L	D0,1120(A6)
	OR.L	D0,1280(A6)

	MOVE.L	#$40003F,D0
	OR	D0,482(A6)
	OR	D0,642(A6)
	OR.L	D0,800(A6)
	OR.L	D0,960(A6)

	MOVE.L	#$6000FE00,D0
	OR.L	D0,488(A6)
	OR	D0,1610(A6)
	OR	D0,1770(A6)

	MOVEQ	#-$20,D0
	OR.B	D0,10(A6)
	OR.B	D0,2248(A6)

	MOVEQ	#-4,D0
	OR.B	D0,330(A6)
	OR.B	D0,1930(A6)

	MOVEQ	#-1,D0
	MOVE.B	D0,810(A6)
	MOVE.B	D0,970(A6)
	MOVE.B	D0,1130(A6)
	MOVE.B	D0,1290(A6)
	MOVE.B	D0,1450(A6)

	OR	#-$800,170(A6)
	OR.L	#$3000FE00,648(A6)
	OR.L	#$380007,1600(A6)
	OR.L	#$1E0001,1920(A6)
	OR.L	#-$7FFF8800,2088(A6)
	JMP	(A5)
AFFA:
	MOVE.L	#$1E0001,D0
	OR	D0,2(A6)
	OR.L	D0,1760(A6)
	OR	D0,2240(A6)

	MOVE.L	#$380007,D0
	OR	D0,162(A6)
	OR.L	D0,1440(A6)
	OR	D0,2080(A6)

	MOVE.L	#$30000F,D0
	OR	D0,322(A6)
	OR.L	D0,1120(A6)
	OR.L	D0,1280(A6)
	OR	D0,1920(A6)

	MOVE.L	#$20001F,D0
	OR	D0,482(A6)
	OR	D0,642(A6)
	OR.L	D0,800(A6)
	OR.L	D0,960(A6)

	MOVEQ	#-$80,D0
	OR	D0,810(A6)
	OR	D0,970(A6)
	OR	D0,1130(A6)
	OR	D0,1290(A6)
	OR	D0,1450(A6)

	MOVEQ	#-$10,D0
	OR.B	D0,10(A6)
	OR.B	D0,2248(A6)

	MOVEQ	#-2,D0
	OR.B	D0,330(A6)
	OR.B	D0,1930(A6)

	MOVEQ	#-1,D0
	MOVE.B	D0,490(A6)
	MOVE.B	D0,650(A6)
	MOVE.B	D0,1610(A6)
	MOVE.B	D0,1770(A6)

	OR	#-$400,170(A6)
	OR	#$3000,488(A6)
	OR	#$1800,648(A6)
	OR.L	#$1C0003,1600(A6)
	OR.L	#-$3FFFC400,2088(A6)
	JMP	(A5)
AFFB:
	MOVE.L	#$1C0003,D0
	OR	D0,162(A6)
	OR.L	D0,1440(A6)
	OR	D0,2080(A6)

	MOVE.L	#$180007,D0
	OR	D0,322(A6)
	OR.L	D0,1120(A6)
	OR.L	D0,1280(A6)
	OR	D0,1920(A6)

	MOVE.L	#$10000F,D0
	OR	D0,482(A6)
	OR	D0,642(A6)
	OR.L	D0,800(A6)
	OR.L	D0,960(A6)
	OR	D0,1760(A6)

	MOVE.L	#$1800FF80,D0
	OR.L	D0,488(A6)
	OR	D0,1610(A6)
	OR	D0,1770(A6)

	MOVEQ	#-$40,D0
	OR	D0,810(A6)
	OR	D0,970(A6)
	OR	D0,1130(A6)
	OR	D0,1290(A6)
	OR	D0,1450(A6)

	MOVEQ	#-8,D0
	OR.B	D0,10(A6)
	OR.B	D0,2248(A6)

	OR	#-$200,170(A6)
	ST	330(A6)
	OR.L	#$C00FF80,648(A6)
	OR.L	#$E0001,1600(A6)
	OR.L	#-$7FFF8100,1928(A6)
	OR.L	#-$1FFFE200,2088(A6)
	JMP	(A5)
AFFC:
	MOVE.L	#$E0001,D0
	OR	D0,162(A6)
	OR.L	D0,1440(A6)
	OR	D0,2080(A6)

	MOVE.L	#$C0003,D0
	OR	D0,322(A6)
	OR.L	D0,1120(A6)
	OR.L	D0,1280(A6)
	OR	D0,1920(A6)

	MOVE.L	#$80007,D0
	OR	D0,482(A6)
	OR	D0,642(A6)
	OR.L	D0,800(A6)
	OR.L	D0,960(A6)
	OR	D0,1600(A6)
	OR	D0,1760(A6)

	MOVE.L	#$C00FFC0,D0
	OR.L	D0,488(A6)
	OR	D0,1610(A6)

	MOVEQ	#-$20,D0
	OR	D0,810(A6)
	OR	D0,970(A6)
	OR	D0,1130(A6)
	OR	D0,1290(A6)
	OR	D0,1450(A6)

	MOVEQ	#$7C,D0
	OR.B	D0,10(A6)
	OR.B	D0,2248(A6)

	ST	170(A6)
	OR	#-$80,330(A6)
	OR.L	#$600FFC0,648(A6)
	OR.L	#-$7FFF8040,1768(A6)
	OR.L	#-$3FFFC080,1928(A6)
	OR.L	#-$FFFF100,2088(A6)
	JMP	(A5)
AFFD:
	MOVE.L	#$60001,D0
	OR	D0,322(A6)
	OR.L	D0,1120(A6)
	OR.L	D0,1280(A6)
	OR	D0,1920(A6)

	MOVE.L	#$40003,D0
	OR	D0,482(A6)
	OR	D0,642(A6)
	OR.L	D0,800(A6)
	OR.L	D0,960(A6)
	OR	D0,1600(A6)
	OR	D0,1760(A6)

	MOVEQ	#-$10,D0
	OR	D0,810(A6)
	OR	D0,970(A6)
	OR	D0,1130(A6)
	OR	D0,1290(A6)
	OR	D0,1450(A6)

	MOVEQ	#$3E,D0
	OR.B	D0,10(A6)
	OR.B	D0,2248(A6)

	OR	#-$80,170(A6)
	OR	#-$40,330(A6)
	OR.L	#$600FFE0,488(A6)
	OR.L	#$300FFE0,648(A6)
	OR	#7,1440(A6)
	OR.L	#-$7FFF8020,1608(A6)
	OR.L	#-$3FFFC020,1768(A6)
	OR.L	#-$1FFFE040,1928(A6)
	OR.L	#-$7FFF880,2088(A6)
	JMP	(A5)
AFFE:
	MOVE.L	#$20001,D0
	OR	D0,482(A6)
	OR	D0,642(A6)
	OR.L	D0,800(A6)
	OR.L	D0,960(A6)
	OR	D0,1600(A6)
	OR	D0,1760(A6)

	MOVEQ	#-8,D0
	OR	D0,810(A6)
	OR	D0,970(A6)
	OR	D0,1130(A6)
	OR	D0,1290(A6)

	MOVEQ	#3,D0
	OR	D0,1120(A6)
	OR	D0,1280(A6)
	OR	D0,1440(A6)

	MOVEQ	#$1F,D0
	OR.B	D0,10(A6)
	OR.B	D0,2248(A6)

	OR	#$7FC0,170(A6)
	OR	#-$20,330(A6)
	OR.L	#$300FFF0,488(A6)
	OR.L	#$180FFF0,648(A6)
	OR.L	#-$7FFF8008,1448(A6)
	OR.L	#-$3FFFC010,1608(A6)
	OR.L	#-$1FFFE010,1768(A6)
	OR.L	#-$FFFF020,1928(A6)
	OR.L	#$7C0003C0,2088(A6)
	JMP	(A5)
AFFF:
	MOVEQ	#1,D0
	OR	D0,800(A6)
	OR	D0,960(A6)
	OR	D0,1120(A6)
	OR	D0,1280(A6)
	OR	D0,1440(A6)

	MOVE.L	#-$7FFF8004,D0
	OR.L	D0,1128(A6)
	OR.L	D0,1288(A6)

	MOVEQ	#-4,D0
	OR	D0,810(A6)
	OR	D0,970(A6)

	OR	#$F80,10(A6)
	OR	#$3FE0,170(A6)
	OR	#$7FF0,330(A6)
	OR.L	#$180FFF8,488(A6)
	OR.L	#$C0FFF8,648(A6)
	OR.L	#-$3FFFC004,1448(A6)
	OR.L	#-$1FFFE008,1608(A6)
	OR.L	#-$FFFF008,1768(A6)
	OR.L	#$780007F0,1928(A6)
	OR.L	#$3E0001E0,2088(A6)
	OR	#$F80,2248(A6)
	JMP	(A5)
