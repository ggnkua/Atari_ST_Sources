
	DC.W	0,$223,$333,$110
	DC.W	$444,$445,$666,$777
	DC.W	$70,$70,$70,$70
	DC.W	$70,$70,$70,$70
