	LEA	$80000+34,A0
	LEA	$90000,A1
	MOVE	#32000/4-1,D0
COP1:	MOVE.L	(A0)+,(A1)+
	DBRA	D0,COP1

	LEA	$90000,A5	;SOURCE
	LEA	$A0000,A6	;DEST

	MOVEQ	#5-1,D6
TAKE0:
	MOVEQ	#20-1,D7
TAKE1:
	MOVEQ	#25-1,D0
	MOVE.L	A5,A0
TAKE2:
	MOVE	(A0),(A6)+
	NOT	(A0)
	LEA	160(A0),A0
	DBRA	D0,TAKE2

	BSR	AFF

	ADDQ	#8,A5
	DBRA	D7,TAKE1

	LEA	-160(A5),A5
	LEA	25*160(A5),A5
	DBRA	D6,TAKE0

	LEA	$A0000,A0
	MOVE.L	A6,A1

	LEA	-500(A1),A1

	LEA	$A0000,A6
	MOVEQ	#-1,D7
O:
	ADDQ.L	#1,D7
	MOVE	#100/4-1,D0
	MOVEQ	#0,D1
XX:	OR.L	(A6)+,D1
	DBRA	D0,XX
	TST.L	D1
	BNE.S	O
	ILLEGAL
AFF:
	LEA	$90000,A0
	LEA	$1f8000,A1
	MOVE	#32000/4-1,D0
COP2:	MOVE.L	(A0)+,(A1)+
	DBRA	D0,COP2
	RTS
