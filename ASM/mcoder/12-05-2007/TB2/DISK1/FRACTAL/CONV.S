;
; CONVERTIT LE TEXTE
;
	LEA	TEXTE,A0
	LEA	DEST,A6
	MOVEQ	#0,D0
CONV:	MOVE.B	(A0)+,D0
	BEQ.S	FINCONV
	CMP.B	#13,D0
	BEQ.S	CONV
	CMP.B	#10,D0
	BEQ.S	CONV

	LEA	CONVTBL(pc),A1
TSTLET:
	MOVE.B	(A1)+,D1
	BEQ.S	SPC
	CMP.B	D1,D0
	BNE.S	TSTLET
	MOVE.L	A1,D1
	SUB.L	#CONVTBL+1,D1
	MOVE.B	D1,(A6)+
	BRA.S	CONV
SPC:
	ILLEGAL
FINCONV:
	ST	(A6)+
	LEA	DEST,A0
	MOVE.L	A6,A1
	ILLEGAL
CONVTBL:
	DC.B	"ABCDEFGHIJKLMNOPQRSTUVWXYZ"
	DC.B	"!?:'0123456789()-., "
	dc.b	0
;	DC.B	" 0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ"
;	DC.B	"().:!?,;'-",0
	EVEN
TEXTE:

	dc.b	"      SO YOU TRIED TO LEAVE US ??  DID YOU FIND THE 2 HIDDEN SCREENS ?? "
	DC.B	"WHAT DO YOU THINK OF THIS LONG AND DEEP TRIP IN MANDELBROT AND JULIA'S LAND ?? "
	dc.b	" AS ALWAYS IN THE TRANSBEAUCE DEMOS, THE RESET DEMO WAS DONE BY MCODER (YES, RIGHT, I SAID MCODER !) "
;	dc.b	" AND THIS GREAT AND WELL-KNOWN CODER IS NOW SLEEPING ON MY BED INSTEAD OF DEBUGGING THIS DEMO .... "
	DC.B	"... "
	DC.B	"I GUESS YOU'RE WONDERING WHO IS NOW TYPING THIS TEXT ?? DID YOU NOTICE THIS TEXT IS IN ENGLISH AND NOT IN FRANGLISH ?? "
	DC.B	" THAT IS TO SAY THAT I AM NOT ZIGGY STARDUST !   MCODER WORKED REALLY HARD (REALLY ??) FOR THIS DEMO , HE CODED THE LOADER, THIS RESET SCREEN "
	DC.B	" AND ALL THE LOADING AND DEPACKING ROUTINES.     "
	DC.B	" AS I AM HERE I WILL TELL TO ALL THE PEOPLE COMPLAINING ABOUT THE BUGS IN THE MAIN MENU THAT IF THEY ARE ANGRY OR IF THEY WANT TO ANNOY ME THEY JUST HAVE TO"
	DC.B	" WRITE ME AND WITH GREAT PLEASURE WILL I SEND THEM THE GRAPHIX AND THE MUSIC AND ASK THEM TO DO JUST THE SAME ... EVEN WITH THE SAME BUGS I DON'T MIND ! "
	DC.B	"  OF COURSE WE COULD HAVE DEBUGGED IT BUT TIME HAS COME TO RELEASE THIS DEMO, OR KRAZY REX WILL SQUEEZE US. AND I MUST ADMIT THAT I AM COMPLETELY FED UP"
	DC.B	" WITH CODING THIS MENU. IN FACT THERE IS ENOUGH PROCESSOR TIME TO MAKE IT WORK WITH A 15 KHZ SOUNDTRACK (A REAL SOUNDTRACK NOT A ULM SOUNDTRACK !) ."
	DC.B	"  AS FURY IS NOW READING I WILL ASK HIM TO WRITE SOME FEW SENTENCES INSTEAD OF TRYING TO BEAT MCODER IN LAZYNESS....                  "
	DC.B	"  HI TO DOGUE DE MAUVE AS I THINK HE WILL BE READING ALL THIS SCROLLTEXT ! AND BIG KISS(ES) TO VIRGINIE, EV'RYWHERE ON HER BEAUTIFUL BODY ......"
	DC.B	"ARH! THIS LITTLE GNOMISH FIEND (THAT IS, TERENCE) HAS SUCCEEDED IN MAKING "
	DC.B	"ME WRITE SOME CRAP IN DIS SCROLLER. I STILL DON'T "
	DC.B	"UNDERSTAND HOW, BUT HE DID IT ANYWAY. WELL, WHAT AM I "
	DC.B	"GONNA TELL YOU TO MAKE MY APPEARANCE HERE WORTH IT. "
	DC.B	"TOUGH SHIT! I'M BEING TOLD THAT MY ENGLISH IS SOOOO "
	DC.B	"PERFECT THAT NO ONE IN FRANCE'LL BE ABLE TO UNDERSTAND "
	DC.B	"MY SCROLL PART, SO I GUESS I'LL HAVE TO REACH A LOWER "
	DC.B	"LEVEL FOR MY FRENCH FELLOWS... HERE GOES... "
	DC.B	"ZIS DAIMO WAZ DONE FAUR ZE TRANSBEAUCE 2 (THIS WORD "
	DC.B	"IS FRENCH BY DEFINITION, SO I DON'T NEED TO GO "
	DC.B	"TO THE POOR ENGLISH LEVEL OF FRENCHIES), WITCH WAS "
	DC.B	"CONSTITUED OF AU LEAST (YES, AT LEAST) 250 FRENCHIES "
	DC.B	"IN TOTAL CALOR (UH! THAT'S SPANISH!) WHICH EARS WERE "
	DC.B	"BLASTED TO A PULPE BY A (DAMN MCODER! HE'S USING HIS "
	DC.B	"PC WITH ITS SCREEN RIGHT IN FRONT OF ME, AND AS THE "
	DC.B	"ST'S MONITOR IS SOMETHING LIKE 1 METER AWAY, I'M "
	DC.B	"HAVING LOTSA FUN WRITING THIS STUFF WHILE MISTAKING "
	DC.B	"THE PC MONITOR WITH THE ST'S ONE...) BY A UGLY "
	DC.B	"SOUND THAT WAS AT LEAST SHOUTING IN OUR EARS SO MUCH "
	DC.B	"THAT THINKING IN A GOOD WAY WAS COMPLETELY OUT OF "
	DC.B	"THE QUESTION TO CODE... UH! IT SEEMS I'LL HAVE TO "
	DC.B	"QUIT NOW AS WE'VE GOT A BUS TO TAKE RIGHT NOW!!! "
	DC.B	"WELL, BYE!!! AND YA'LL HERE MORE FROM ME IN "
	DC.B	"THE ICC 2 DEMO... SOOO LONG!!!... FURY OVER... "

	DC.B	"HELLO, HELLO, HERE IS SILVER OF THE PENDRAGONS ON THE "
	DC.B	"KEYBOARD. AT THE MOMENT, I AM TYPING ON THE KEYBOARD OF "
	DC.B	"THE 2080 ST OF MCODER AND THIS ST IS VERY STRANGE. IN FACT, "
	DC.B	"2 MINUTES AGO, I WAS WRITING THIS TEXT AND HIS DEVICE SWITCHED OFF "
	DC.B	"WITHOUT REASON AND IT SWITCHED ON ALONE AGAIN. IS THIS NORMAL?? "
	DC.B	"I DON'T THINK SO. NOW, WE KNOW THE SECRET OF MCODER. THIS IS NOT HIM "
	DC.B	"WHO CODE BUT THIS IS HIS INTELLIGENT MACHINE. "
	DC.B	"    NOW, A LITTLE THOUGHT TO MY BROTHER CRYSTAR WHO WORKED AT I.B.M. AT THE "
	DC.B	"MOMENT. POOR GUY WHO WOKE UP VERY EARLY IN THE MORNING. ARF! ARF! "
	DC.B	"I WILL JOIN HIM NEXT WEEK SO ...          "
	DC.B	"ANOTHER THOUGHT TO MY SISTER WHO LIKE HOLIDAYS. I AM SURE. "
	DC.B	"HELLO (VA FAIRE LA VAISSELLE !) NANIE!!! HOW ARE YOU TODAY???    ARF!!! ARF!!! I WANT TO SEE HIS HEAD WHEN "
	DC.B	"SHE SEES THAT. "
	DC.B	"IT IS TIME TO GO AWAY FOR ME SO...    GOODBYE EVERYBODY         "

	DC.B	"OK, ENOUGH OF THIS CRAP. IT'S MCODER BACK AND I CAN NOW SAY WHAT I WANT (NOBODY'S HERE) "
	DC.B	"I WANT TO GREET THE FOLLOWING FOLKS : ALGERNON, ZIGGY STARDUST, ALTAIR, ZARATHOUSTRA, "
	DC.B	"TERENCE, XERCES, MR BEE, ADSO, DOCLANDS, THE SERGEANT AND KRAVEN. THANK YOU GUYS FOR BEING SO COOL... "
	DC.B	"OH NO ! NO MEMORY FREE, LET'S WRA"
	DC.B	0
DEST:
