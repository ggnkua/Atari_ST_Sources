
corps:
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,A0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	regscroll,D5/A2-5
	MOVE.L	#bri,D6
	MOVE.L	A2,$300.W
	MOVEQ	#0,D1
	MOVEA.L	$300.W,A2
	MOVE.B	(A2)+,D1
	MOVE.L	A2,$300.W
	LSL.W	#7,D1
	MOVEA.L	D6,A2
	ADDA.W	D1,A2
	ADDA.W	D5,A2
	MOVEM.L	(A2),D1-4
	MOVEM.L	D1-2,(A3)
	MOVEM.L	D1-2,(A4)
	MOVEM.L	D1-2,(A5)
	MOVEM.L	D3-4,$E6(A3)
	MOVEM.L	D3-4,$E6(A4)
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	D3-4,$E6(A5)
	ADDQ.L	#8,A3
	ADDQ.L	#8,A4
	ADDQ.L	#8,A5
	MOVE.W	A1,(A1)
	MOVEQ	#0,D1
	MOVE.B	D0,(A1)
	MOVEA.L	$300.W,A2
	MOVE.B	(A2)+,D1
	MOVE.L	A2,$300.W
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	LSL.W	#7,D1
	MOVEA.L	D6,A2
	ADDA.W	D1,A2
	ADDA.W	D5,A2
	MOVEM.L	(A2),D1-4
	MOVEM.L	D1-2,(A3)
	MOVEM.L	D1-2,(A4)
	MOVEM.L	D1-2,(A5)
	MOVEM.L	D3-4,$E6(A3)
	MOVEM.L	D3-4,$E6(A4)
	MOVEM.L	D3-4,$E6(A5)
	ADDQ.L	#8,A3
	ADDQ.L	#8,A4
	ADDQ.L	#8,A5
	MOVEQ	#0,D1
	MOVEA.L	$300.W,A2
	MOVE.B	(A2)+,D1
	MOVE.L	A2,$300.W
	LSL.W	#7,D1
	MOVEA.L	D6,A2
	ADDA.W	D1,A2
	ADDA.W	D5,A2
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,A0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	(A2),D1-4
	MOVEM.L	D1-2,(A3)
	MOVEM.L	D1-2,(A4)
	MOVEM.L	D1-2,(A5)
	MOVEM.L	D3-4,$E6(A3)
	MOVEM.L	D3-4,$E6(A4)
	MOVEM.L	D3-4,$E6(A5)
	ADDQ.L	#8,A3
	ADDQ.L	#8,A4
	ADDQ.L	#8,A5
	MOVEQ	#0,D1
	MOVEA.L	$300.W,A2
	MOVE.B	(A2)+,D1
	MOVE.L	A2,$300.W
	LSL.W	#7,D1
	MOVEA.L	D6,A2
	ADDA.W	D1,A2
	ADDA.W	D5,A2
	MOVEM.L	(A2),D1-4
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	D1-2,(A3)
	MOVEM.L	D1-2,(A4)
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-2,(A5)
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D3-4,$E6(A3)
	MOVEM.L	D3-4,$E6(A4)
	MOVEM.L	D3-4,$E6(A5)
	ADDQ.L	#8,A3
	ADDQ.L	#8,A4
	ADDQ.L	#8,A5
	MOVEQ	#0,D1
	MOVEA.L	$300.W,A2
	MOVE.B	(A2)+,D1
	MOVE.L	A2,$300.W
	LSL.W	#7,D1
	MOVEA.L	D6,A2
	ADDA.W	D1,A2
	ADDA.W	D5,A2
	MOVEM.L	(A2),D1-4
	MOVEM.L	D1-2,(A3)
	MOVEM.L	D1-2,(A4)
	MOVEM.L	D1-2,(A5)
	MOVEM.L	D3-4,$E6(A3)
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,A0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	D3-4,$E6(A4)
	MOVEM.L	D3-4,$E6(A5)
	ADDQ.L	#8,A3
	ADDQ.L	#8,A4
	ADDQ.L	#8,A5
	MOVEQ	#0,D1
	MOVEA.L	$300.W,A2
	MOVE.B	(A2)+,D1
	MOVE.L	A2,$300.W
	LSL.W	#7,D1
	MOVEA.L	D6,A2
	ADDA.W	D1,A2
	ADDA.W	D5,A2
	MOVEM.L	(A2),D1-4
	MOVEM.L	D1-2,(A3)
	MOVEM.L	D1-2,(A4)
	MOVEM.L	D1-2,(A5)
	MOVEM.L	D3-4,$E6(A3)
	MOVEM.L	D3-4,$E6(A4)
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	D3-4,$E6(A5)
	ADDQ.L	#8,A3
	ADDQ.L	#8,A4
	ADDQ.L	#8,A5
	MOVE.W	A1,(A1)
	MOVEQ	#0,D1
	MOVE.B	D0,(A1)
	MOVEA.L	$300.W,A2
	MOVE.B	(A2)+,D1
	MOVE.L	A2,$300.W
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	LSL.W	#7,D1
	MOVEA.L	D6,A2
	ADDA.W	D1,A2
	ADDA.W	D5,A2
	MOVEM.L	(A2),D1-4
	MOVEM.L	D1-2,(A3)
	MOVEM.L	D1-2,(A4)
	MOVEM.L	D1-2,(A5)
	MOVEM.L	D3-4,$E6(A3)
	MOVEM.L	D3-4,$E6(A4)
	MOVEM.L	D3-4,$E6(A5)
	ADDQ.L	#8,A3
	ADDQ.L	#8,A4
	ADDQ.L	#8,A5
	MOVEQ	#0,D1
	MOVEA.L	$300.W,A2
	MOVE.B	(A2)+,D1
	MOVE.L	A2,$300.W
	LSL.W	#7,D1
	MOVEA.L	D6,A2
	ADDA.W	D1,A2
	ADDA.W	D5,A2
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,A0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	(A2),D1-4
	MOVEM.L	D1-2,(A3)
	MOVEM.L	D1-2,(A4)
	MOVEM.L	D1-2,(A5)
	MOVEM.L	D3-4,$E6(A3)
	MOVEM.L	D3-4,$E6(A4)
	MOVEM.L	D3-4,$E6(A5)
	ADDQ.L	#8,A3
	ADDQ.L	#8,A4
	ADDQ.L	#8,A5
	MOVEQ	#0,D1
	MOVEA.L	$300.W,A2
	MOVE.B	(A2)+,D1
	MOVE.L	A2,$300.W
	LSL.W	#7,D1
	MOVEA.L	D6,A2
	ADDA.W	D1,A2
	ADDA.W	D5,A2
	MOVEM.L	(A2),D1-4
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	D1-2,(A3)
	MOVEM.L	D1-2,(A4)
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-2,(A5)
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D3-4,$E6(A3)
	MOVEM.L	D3-4,$E6(A4)
	MOVEM.L	D3-4,$E6(A5)
	ADDQ.L	#8,A3
	ADDQ.L	#8,A4
	ADDQ.L	#8,A5
	MOVEQ	#0,D1
	MOVEA.L	$300.W,A2
	MOVE.B	(A2)+,D1
	MOVE.L	A2,$300.W
	LSL.W	#7,D1
	MOVEA.L	D6,A2
	ADDA.W	D1,A2
	ADDA.W	D5,A2
	MOVEM.L	(A2),D1-4
	MOVEM.L	D1-2,(A3)
	MOVEM.L	D1-2,(A4)
	MOVEM.L	D1-2,(A5)
	MOVEM.L	D3-4,$E6(A3)
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,A0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	D3-4,$E6(A4)
	MOVEM.L	D3-4,$E6(A5)
	ADDQ.L	#8,A3
	ADDQ.L	#8,A4
	ADDQ.L	#8,A5
	MOVEQ	#0,D1
	MOVEA.L	$300.W,A2
	MOVE.B	(A2)+,D1
	MOVE.L	A2,$300.W
	LSL.W	#7,D1
	MOVEA.L	D6,A2
	ADDA.W	D1,A2
	ADDA.W	D5,A2
	MOVEM.L	(A2),D1-4
	MOVEM.L	D1-2,(A3)
	MOVEM.L	D1-2,(A4)
	MOVEM.L	D1-2,(A5)
	MOVEM.L	D3-4,$E6(A3)
	MOVEM.L	D3-4,$E6(A4)
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	D3-4,$E6(A5)
	ADDQ.L	#8,A3
	ADDQ.L	#8,A4
	ADDQ.L	#8,A5
	MOVE.W	A1,(A1)
	MOVEQ	#0,D1
	MOVE.B	D0,(A1)
	MOVEA.L	$300.W,A2
	MOVE.B	(A2)+,D1
	MOVE.L	A2,$300.W
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	LSL.W	#7,D1
	MOVEA.L	D6,A2
	ADDA.W	D1,A2
	ADDA.W	D5,A2
	MOVEM.L	(A2),D1-4
	MOVEM.L	D1-2,(A3)
	MOVEM.L	D1-2,(A4)
	MOVEM.L	D1-2,(A5)
	MOVEM.L	D3-4,$E6(A3)
	MOVEM.L	D3-4,$E6(A4)
	MOVEM.L	D3-4,$E6(A5)
	ADDQ.L	#8,A3
	ADDQ.L	#8,A4
	ADDQ.L	#8,A5
	MOVEQ	#0,D1
	MOVEA.L	$300.W,A2
	MOVE.B	(A2)+,D1
	MOVE.L	A2,$300.W
	LSL.W	#7,D1
	MOVEA.L	D6,A2
	ADDA.W	D1,A2
	ADDA.W	D5,A2
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,A0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	(A2),D1-4
	MOVEM.L	D1-2,(A3)
	MOVEM.L	D1-2,(A4)
	MOVEM.L	D1-2,(A5)
	MOVEM.L	D3-4,$E6(A3)
	MOVEM.L	D3-4,$E6(A4)
	MOVEM.L	D3-4,$E6(A5)
	ADDQ.L	#8,A3
	ADDQ.L	#8,A4
	ADDQ.L	#8,A5
	MOVEQ	#0,D1
	MOVEA.L	$300.W,A2
	MOVE.B	(A2)+,D1
	MOVE.L	A2,$300.W
	LSL.W	#7,D1
	MOVEA.L	D6,A2
	ADDA.W	D1,A2
	ADDA.W	D5,A2
	MOVEM.L	(A2),D1-4
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	D1-2,(A3)
	MOVEM.L	D1-2,(A4)
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-2,(A5)
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D3-4,$E6(A3)
	MOVEM.L	D3-4,$E6(A4)
	MOVEM.L	D3-4,$E6(A5)
	ADDQ.L	#8,A3
	ADDQ.L	#8,A4
	ADDQ.L	#8,A5
	MOVEQ	#0,D1
	MOVEA.L	$300.W,A2
	MOVE.B	(A2)+,D1
	MOVE.L	A2,$300.W
	LSL.W	#7,D1
	MOVEA.L	D6,A2
	ADDA.W	D1,A2
	ADDA.W	D5,A2
	MOVEM.L	(A2),D1-4
	MOVEM.L	D1-2,(A3)
	MOVEM.L	D1-2,(A4)
	MOVEM.L	D1-2,(A5)
	MOVEM.L	D3-4,$E6(A3)
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,A0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	D3-4,$E6(A4)
	MOVEM.L	D3-4,$E6(A5)
	ADDQ.L	#8,A3
	ADDQ.L	#8,A4
	ADDQ.L	#8,A5
	MOVEQ	#0,D1
	MOVEA.L	$300.W,A2
	MOVE.B	(A2)+,D1
	MOVE.L	A2,$300.W
	LSL.W	#7,D1
	MOVEA.L	D6,A2
	ADDA.W	D1,A2
	ADDA.W	D5,A2
	MOVEM.L	(A2),D1-4
	MOVEM.L	D1-2,(A3)
	MOVEM.L	D1-2,(A4)
	MOVEM.L	D1-2,(A5)
	MOVEM.L	D3-4,$E6(A3)
	MOVEM.L	D3-4,$E6(A4)
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	D3-4,$E6(A5)
	ADDQ.L	#8,A3
	ADDQ.L	#8,A4
	ADDQ.L	#8,A5
	MOVE.W	A1,(A1)
	MOVEQ	#0,D1
	MOVE.B	D0,(A1)
	MOVEA.L	$300.W,A2
	MOVE.B	(A2)+,D1
	MOVE.L	A2,$300.W
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	LSL.W	#7,D1
	MOVEA.L	D6,A2
	ADDA.W	D1,A2
	ADDA.W	D5,A2
	MOVEM.L	(A2),D1-4
	MOVEM.L	D1-2,(A3)
	MOVEM.L	D1-2,(A4)
	MOVEM.L	D1-2,(A5)
	MOVEM.L	D3-4,$E6(A3)
	MOVEM.L	D3-4,$E6(A4)
	MOVEM.L	D3-4,$E6(A5)
	ADDQ.L	#8,A3
	ADDQ.L	#8,A4
	ADDQ.L	#8,A5
	MOVEQ	#0,D1
	MOVEA.L	$300.W,A2
	MOVE.B	(A2)+,D1
	MOVE.L	A2,$300.W
	LSL.W	#7,D1
	MOVEA.L	D6,A2
	ADDA.W	D1,A2
	ADDA.W	D5,A2
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,A0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	(A2),D1-4
	MOVEM.L	D1-2,(A3)
	MOVEM.L	D1-2,(A4)
	MOVEM.L	D1-2,(A5)
	MOVEM.L	D3-4,$E6(A3)
	MOVEM.L	D3-4,$E6(A4)
	MOVEM.L	D3-4,$E6(A5)
	ADDQ.L	#8,A3
	ADDQ.L	#8,A4
	ADDQ.L	#8,A5
	MOVEQ	#0,D1
	MOVEA.L	$300.W,A2
	MOVE.B	(A2)+,D1
	MOVE.L	A2,$300.W
	LSL.W	#7,D1
	MOVEA.L	D6,A2
	ADDA.W	D1,A2
	ADDA.W	D5,A2
	MOVEM.L	(A2),D1-4
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	D1-2,(A3)
	MOVEM.L	D1-2,(A4)
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-2,(A5)
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D3-4,$E6(A3)
	MOVEM.L	D3-4,$E6(A4)
	MOVEM.L	D3-4,$E6(A5)
	ADDQ.L	#8,A3
	ADDQ.L	#8,A4
	ADDQ.L	#8,A5
	MOVEQ	#0,D1
	MOVEA.L	$300.W,A2
	MOVE.B	(A2)+,D1
	MOVE.L	A2,$300.W
	LSL.W	#7,D1
	MOVEA.L	D6,A2
	ADDA.W	D1,A2
	ADDA.W	D5,A2
	MOVEM.L	(A2),D1-4
	MOVEM.L	D1-2,(A3)
	MOVEM.L	D1-2,(A4)
	MOVEM.L	D1-2,(A5)
	MOVEM.L	D3-4,$E6(A3)
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,A0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	D3-4,$E6(A4)
	MOVEM.L	D3-4,$E6(A5)
	ADDQ.L	#8,A3
	ADDQ.L	#8,A4
	ADDQ.L	#8,A5
	MOVEQ	#0,D1
	MOVEA.L	$300.W,A2
	MOVE.B	(A2)+,D1
	MOVE.L	A2,$300.W
	LSL.W	#7,D1
	MOVEA.L	D6,A2
	ADDA.W	D1,A2
	ADDA.W	D5,A2
	MOVEM.L	(A2),D1-4
	MOVEM.L	D1-2,(A3)
	MOVEM.L	D1-2,(A4)
	MOVEM.L	D1-2,(A5)
	MOVEM.L	D3-4,$E6(A3)
	MOVEM.L	D3-4,$E6(A4)
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	D3-4,$E6(A5)
	ADDQ.L	#8,A3
	ADDQ.L	#8,A4
	ADDQ.L	#8,A5
	MOVE.W	A1,(A1)
	MOVEQ	#0,D1
	MOVE.B	D0,(A1)
	MOVEA.L	$300.W,A2
	MOVE.B	(A2)+,D1
	MOVE.L	A2,$300.W
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	LSL.W	#7,D1
	MOVEA.L	D6,A2
	ADDA.W	D1,A2
	ADDA.W	D5,A2
	MOVEM.L	(A2),D1-4
	MOVEM.L	D1-2,(A3)
	MOVEM.L	D1-2,(A4)
	MOVEM.L	D1-2,(A5)
	MOVEM.L	D3-4,$E6(A3)
	MOVEM.L	D3-4,$E6(A4)
	MOVEM.L	D3-4,$E6(A5)
	ADDQ.L	#8,A3
	ADDQ.L	#8,A4
	ADDQ.L	#8,A5
	MOVEQ	#0,D1
	MOVEA.L	$300.W,A2
	MOVE.B	(A2)+,D1
	MOVE.L	A2,$300.W
	LSL.W	#7,D1
	MOVEA.L	D6,A2
	ADDA.W	D1,A2
	ADDA.W	D5,A2
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,A0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	(A2),D1-4
	MOVEM.L	D1-2,(A3)
	MOVEM.L	D1-2,(A4)
	MOVEM.L	D1-2,(A5)
	MOVEM.L	D3-4,$E6(A3)
	MOVEM.L	D3-4,$E6(A4)
	MOVEM.L	D3-4,$E6(A5)
	ADDQ.L	#8,A3
	ADDQ.L	#8,A4
	ADDQ.L	#8,A5
	MOVEQ	#0,D1
	MOVEA.L	$300.W,A2
	MOVE.B	(A2)+,D1
	MOVE.L	A2,$300.W
	LSL.W	#7,D1
	MOVEA.L	D6,A2
	ADDA.W	D1,A2
	ADDA.W	D5,A2
	MOVEM.L	(A2),D1-4
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	D1-2,(A3)
	MOVEM.L	D1-2,(A4)
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-2,(A5)
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D3-4,$E6(A3)
	MOVEM.L	D3-4,$E6(A4)
	MOVEM.L	D3-4,$E6(A5)
	ADDQ.L	#8,A3
	ADDQ.L	#8,A4
	ADDQ.L	#8,A5
	MOVEQ	#0,D1
	MOVEA.L	$300.W,A2
	MOVE.B	(A2)+,D1
	MOVE.L	A2,$300.W
	LSL.W	#7,D1
	MOVEA.L	D6,A2
	ADDA.W	D1,A2
	ADDA.W	D5,A2
	MOVEM.L	(A2),D1-4
	MOVEM.L	D1-2,(A3)
	MOVEM.L	D1-2,(A4)
	MOVEM.L	D1-2,(A5)
	MOVEM.L	D3-4,$E6(A3)
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,A0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	D3-4,$E6(A4)
	MOVEM.L	D3-4,$E6(A5)
	ADDQ.L	#8,A3
	ADDQ.L	#8,A4
	ADDQ.L	#8,A5
	MOVEQ	#0,D1
	MOVEA.L	$300.W,A2
	MOVE.B	(A2)+,D1
	MOVE.L	A2,$300.W
	LSL.W	#7,D1
	MOVEA.L	D6,A2
	ADDA.W	D1,A2
	ADDA.W	D5,A2
	MOVEM.L	(A2),D1-4
	MOVEM.L	D1-2,(A3)
	MOVEM.L	D1-2,(A4)
	MOVEM.L	D1-2,(A5)
	MOVEM.L	D3-4,$E6(A3)
	MOVEM.L	D3-4,$E6(A4)
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	D3-4,$E6(A5)
	ADDQ.L	#8,A3
	ADDQ.L	#8,A4
	ADDQ.L	#8,A5
	MOVE.W	A1,(A1)
	MOVEQ	#0,D1
	MOVE.B	D0,(A1)
	MOVEA.L	$300.W,A2
	MOVE.B	(A2)+,D1
	MOVE.L	A2,$300.W
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	LSL.W	#7,D1
	MOVEA.L	D6,A2
	ADDA.W	D1,A2
	ADDA.W	D5,A2
	MOVEM.L	(A2),D1-4
	MOVEM.L	D1-2,(A3)
	MOVEM.L	D1-2,(A4)
	MOVEM.L	D1-2,(A5)
	MOVEM.L	D3-4,$E6(A3)
	MOVEM.L	D3-4,$E6(A4)
	MOVEM.L	D3-4,$E6(A5)
	ADDQ.L	#8,A3
	ADDQ.L	#8,A4
	ADDQ.L	#8,A5
	MOVEQ	#0,D1
	MOVEA.L	$300.W,A2
	MOVE.B	(A2)+,D1
	MOVE.L	A2,$300.W
	LSL.W	#7,D1
	MOVEA.L	D6,A2
	ADDA.W	D1,A2
	ADDA.W	D5,A2
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,A0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	(A2),D1-4
	MOVEM.L	D1-2,(A3)
	MOVEM.L	D1-2,(A4)
	MOVEM.L	D1-2,(A5)
	MOVEM.L	D3-4,$E6(A3)
	MOVEM.L	D3-4,$E6(A4)
	MOVEM.L	D3-4,$E6(A5)
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP

