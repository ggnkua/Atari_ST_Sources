 "THE LOST BALLS"  -  OWNER'S MANUAL...

 CONTROL THE BALL(S) WITH YOUR JOYSTICK
 OR USE THE "^+<>" KEYS IF THE JOYSTICK
 IS FUCKED UP (KAPUTT!).

 GO FIND YOUR FELLOWBALLS, YOU CAN ONLY
 LOVE THEM!

 PRESS "FIRE" OR "SPACE" TO REVERSE THE
 CATERPILLAR'S DIRECTION.

          CREDITS COMING UP...
