sprite:
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEA.L	ptrestore11,A4
	MOVEA.L	(A4)+,A2
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$C94(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$BAE(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$AC8(A2)
	MOVEM.L	(A4)+,D1-4
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	D1-4,$9E2(A2)
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	(A4)+,D1-4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$8FC(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$816(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$730(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$64A(A2)
	MOVEM.L	(A4)+,D1-4
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$564(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$47E(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$398(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$2B2(A2)
	MOVEM.L	(A4)+,D1-4
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	D1-4,$1CC(A2)
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	(A4)+,D1-4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$E6(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,(A2)
	MOVEA.L	ptrestore21,A4
	MOVEA.L	(A4)+,A2
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$C94(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$BAE(A2)
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$AC8(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$9E2(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$8FC(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$816(A2)
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	(A4)+,D1-4
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$730(A2)
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$64A(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$564(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$47E(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$398(A2)
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$2B2(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$1CC(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$E6(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,(A2)
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEA.L	ptrestore31,A4
	MOVEA.L	(A4)+,A2
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	(A4)+,D1-4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$C94(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$BAE(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$AC8(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$9E2(A2)
	MOVEM.L	(A4)+,D1-4
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$8FC(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$816(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$730(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$64A(A2)
	MOVEM.L	(A4)+,D1-4
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	D1-4,$564(A2)
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	(A4)+,D1-4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$47E(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$398(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$2B2(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$1CC(A2)
	MOVEM.L	(A4)+,D1-4
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$E6(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,(A2)
	MOVEA.L	ptrestore41,A4
	MOVEA.L	(A4)+,A2
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$C94(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$BAE(A2)
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	(A4)+,D1-4
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$AC8(A2)
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$9E2(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$8FC(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$816(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$730(A2)
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$64A(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$564(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$47E(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$398(A2)
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	(A4)+,D1-4
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$2B2(A2)
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$1CC(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$E6(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,(A2)
	MOVEA.L	ptrestore51,A4
	MOVEA.L	(A4)+,A2
	MOVEM.L	(A4)+,D1-4
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$C94(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$BAE(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$AC8(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$9E2(A2)
	MOVEM.L	(A4)+,D1-4
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	D1-4,$8FC(A2)
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	(A4)+,D1-4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$816(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$730(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$64A(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$564(A2)
	MOVEM.L	(A4)+,D1-4
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$47E(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$398(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$2B2(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$1CC(A2)
	MOVEM.L	(A4)+,D1-4
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	D1-4,$E6(A2)
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	(A4)+,D1-4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,(A2)
	MOVEA.L	ptrestore61,A4
	MOVEA.L	(A4)+,A2
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$C94(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$BAE(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$AC8(A2)
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$9E2(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$8FC(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$816(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$730(A2)
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	(A4)+,D1-4
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$64A(A2)
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$564(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$47E(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$398(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$2B2(A2)
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$1CC(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$E6(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,(A2)
	MOVEA.L	ptrestore71,A4
	MOVEA.L	(A4)+,A2
	MOVEM.L	(A4)+,D1-4
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	D1-4,$C94(A2)
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	(A4)+,D1-4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$BAE(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$AC8(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$9E2(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$8FC(A2)
	MOVEM.L	(A4)+,D1-4
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$816(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$730(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$64A(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$564(A2)
	MOVEM.L	(A4)+,D1-4
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	D1-4,$47E(A2)
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	(A4)+,D1-4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$398(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$2B2(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$1CC(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$E6(A2)
	MOVEM.L	(A4)+,D1-4
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,(A2)
	MOVEA.L	ptrestore81,A4
	MOVEA.L	(A4)+,A2
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$C94(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$BAE(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$AC8(A2)
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	(A4)+,D1-4
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$9E2(A2)
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$8FC(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$816(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$730(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$64A(A2)
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$564(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$47E(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$398(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$2B2(A2)
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	(A4)+,D1-4
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$1CC(A2)
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$E6(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,(A2)
	MOVEA.L	ptrestore91,A4
	MOVEA.L	(A4)+,A2
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$C94(A2)
	MOVEM.L	(A4)+,D1-4
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$BAE(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$AC8(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$9E2(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$8FC(A2)
	MOVEM.L	(A4)+,D1-4
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	D1-4,$816(A2)
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	(A4)+,D1-4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$730(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$64A(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$564(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$47E(A2)
	MOVEM.L	(A4)+,D1-4
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$398(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$2B2(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$1CC(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$E6(A2)
	MOVEM.L	(A4)+,D1-4
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	D1-4,(A2)
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEA.L	ptrestore101,A4
	MOVEA.L	(A4)+,A2
	NOP
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$C94(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$BAE(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$AC8(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$9E2(A2)
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$8FC(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$816(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$730(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$64A(A2)
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	(A4)+,D1-4
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$564(A2)
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$47E(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$398(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$2B2(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$1CC(A2)
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,$E6(A2)
	MOVEM.L	(A4)+,D1-4
	MOVEM.L	D1-4,(A2)
	MOVE.W	posx1,D1
	MOVE.W	posy1,D2
	MOVEA.L	ecr1,A2
	ADDA.W	#$128,A2
	LEA	tab230,A3
	ADD.W	D2,D2
	ADD.W	D2,D2
	ADDA.W	D2,A3
	MOVE.L	(A3),D2
	ADDA.L	D2,A2
	MOVE.W	D1,D2
	LSR.W	#4,D2
	LSL.W	#3,D2
	ADDA.W	D2,A2
	MOVEA.L	ptrestore11,A4
	MOVE.L	A2,(A4)+
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	ADDA.W	#$F0,A4
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	(A2),D1-4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$E6(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$1CC(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$2B2(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	$398(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$47E(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$564(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$64A(A2),D1-4
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	D1-4,-(a4)
	nop
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	$730(A2),D1-4
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$816(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$8FC(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$9E2(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	$AC8(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$BAE(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$C94(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVE.W	posx2,D1
	MOVE.W	posy2,D2
	MOVEA.L	ecr1,A2
	ADDA.W	#$128,A2
	LEA	tab230,A3
	ADD.W	D2,D2
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	ADD.W	D2,D2
	ADDA.W	D2,A3
	MOVE.L	(A3),D2
	ADDA.L	D2,A2
	MOVE.W	D1,D2
	LSR.W	#4,D2
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	LSL.W	#3,D2
	ADDA.W	D2,A2
	MOVEA.L	ptrestore21,A4
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVE.L	A2,(A4)+
	ADDA.W	#$F0,A4
	MOVEM.L	(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$E6(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$1CC(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$2B2(A2),D1-4
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$398(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$47E(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$564(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	$64A(A2),D1-4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,-(a4)
	nop
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	$730(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$816(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$8FC(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$9E2(A2),D1-4
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$AC8(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$BAE(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$C94(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVE.W	posx3,D1
	MOVE.W	posy3,D2
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEA.L	ecr1,A2
	ADDA.W	#$128,A2
	LEA	tab230,A3
	ADD.W	D2,D2
	ADD.W	D2,D2
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	ADDA.W	D2,A3
	MOVE.L	(A3),D2
	ADDA.L	D2,A2
	MOVE.W	D1,D2
	LSR.W	#4,D2
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	LSL.W	#3,D2
	ADDA.W	D2,A2
	MOVEA.L	ptrestore31,A4
	MOVE.L	A2,(A4)+
	ADDA.W	#$F0,A4
	MOVEM.L	(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$E6(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$1CC(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	$2B2(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$398(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$47E(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$564(A2),D1-4
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	D1-4,-(a4)
	nop
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	$64A(A2),D1-4
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$730(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$816(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$8FC(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	$9E2(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$AC8(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$BAE(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$C94(A2),D1-4
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	D1-4,-(a4)
	nop
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVE.W	posx4,D1
	MOVE.W	posy4,D2
	NOP
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEA.L	ecr1,A2
	ADDA.W	#$128,A2
	LEA	tab230,A3
	ADD.W	D2,D2
	ADD.W	D2,D2
	ADDA.W	D2,A3
	MOVE.L	(A3),D2
	ADDA.L	D2,A2
	MOVE.W	D1,D2
	LSR.W	#4,D2
	LSL.W	#3,D2
	ADDA.W	D2,A2
	MOVEA.L	ptrestore41,A4
	MOVE.L	A2,(A4)+
	ADDA.W	#$F0,A4
	MOVEM.L	(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$E6(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	$1CC(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$2B2(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$398(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$47E(A2),D1-4
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	D1-4,-(a4)
	nop
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	$564(A2),D1-4
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$64A(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$730(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$816(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	$8FC(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$9E2(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$AC8(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$BAE(A2),D1-4
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	D1-4,-(a4)
	nop
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	$C94(A2),D1-4
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,-(a4)
	nop
	MOVE.W	posx5,D1
	MOVE.W	posy5,D2
	MOVEA.L	ecr1,A2
	ADDA.W	#$128,A2
	LEA	tab230,A3
	ADD.W	D2,D2
	ADD.W	D2,D2
	ADDA.W	D2,A3
	MOVE.L	(A3),D2
	ADDA.L	D2,A2
	MOVE.W	D1,D2
	LSR.W	#4,D2
	LSL.W	#3,D2
	ADDA.W	D2,A2
	MOVEA.L	ptrestore51,A4
	MOVE.L	A2,(A4)+
	ADDA.W	#$F0,A4
	MOVEM.L	(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	$E6(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$1CC(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$2B2(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$398(A2),D1-4
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	D1-4,-(a4)
	nop
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	$47E(A2),D1-4
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$564(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$64A(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$730(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	$816(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$8FC(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$9E2(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$AC8(A2),D1-4
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	D1-4,-(a4)
	nop
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	$BAE(A2),D1-4
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$C94(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVE.W	posx6,D1
	MOVE.W	posy6,D2
	MOVEA.L	ecr1,A2
	ADDA.W	#$128,A2
	LEA	tab230,A3
	ADD.W	D2,D2
	ADD.W	D2,D2
	ADDA.W	D2,A3
	MOVE.L	(A3),D2
	ADDA.L	D2,A2
	MOVE.W	D1,D2
	LSR.W	#4,D2
	LSL.W	#3,D2
	ADDA.W	D2,A2
	MOVEA.L	ptrestore61,A4
	MOVE.L	A2,(A4)+
	ADDA.W	#$F0,A4
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$E6(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$1CC(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$2B2(A2),D1-4
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	D1-4,-(a4)
	nop
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	$398(A2),D1-4
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$47E(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$564(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$64A(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	$730(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$816(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$8FC(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$9E2(A2),D1-4
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	D1-4,-(a4)
	nop
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	$AC8(A2),D1-4
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$BAE(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$C94(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVE.W	posx7,D1
	MOVE.W	posy7,D2
	MOVEA.L	ecr1,A2
	ADDA.W	#$128,A2
	LEA	tab230,A3
	ADD.W	D2,D2
	ADD.W	D2,D2
	ADDA.W	D2,A3
	MOVE.L	(A3),D2
	ADDA.L	D2,A2
	MOVE.W	D1,D2
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	LSR.W	#4,D2
	LSL.W	#3,D2
	ADDA.W	D2,A2
	MOVEA.L	ptrestore71,A4
	MOVE.L	A2,(A4)+
	ADDA.W	#$F0,A4
	MOVEM.L	(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$E6(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$1CC(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	$2B2(A2),D1-4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,-(a4)
	nop
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	$398(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$47E(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$564(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$64A(A2),D1-4
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$730(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$816(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$8FC(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	$9E2(A2),D1-4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,-(a4)
	nop
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	$AC8(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$BAE(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$C94(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVE.W	posx8,D1
	MOVE.W	posy8,D2
	MOVEA.L	ecr1,A2
	ADDA.W	#$128,A2
	LEA	tab230,A3
	ADD.W	D2,D2
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	ADD.W	D2,D2
	ADDA.W	D2,A3
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVE.L	(A3),D2
	ADDA.L	D2,A2
	MOVE.W	D1,D2
	LSR.W	#4,D2
	LSL.W	#3,D2
	ADDA.W	D2,A2
	MOVEA.L	ptrestore81,A4
	MOVE.L	A2,(A4)+
	ADDA.W	#$F0,A4
	MOVEM.L	(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$E6(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$1CC(A2),D1-4
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	D1-4,-(a4)
	nop
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	$2B2(A2),D1-4
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$398(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$47E(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$564(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	$64A(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$730(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$816(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$8FC(A2),D1-4
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	D1-4,-(a4)
	nop
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	$9E2(A2),D1-4
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$AC8(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$BAE(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$C94(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVE.W	posx9,D1
	MOVE.W	posy9,D2
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEA.L	ecr1,A2
	ADDA.W	#$128,A2
	LEA	tab230,A3
	ADD.W	D2,D2
	ADD.W	D2,D2
	ADDA.W	D2,A3
	MOVE.L	(A3),D2
	ADDA.L	D2,A2
	MOVE.W	D1,D2
	LSR.W	#4,D2
	LSL.W	#3,D2
	ADDA.W	D2,A2
	MOVEA.L	ptrestore91,A4
	MOVE.L	A2,(A4)+
	ADDA.W	#$F0,A4
	MOVEM.L	(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$E6(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	$1CC(A2),D1-4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,-(a4)
	nop
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	$2B2(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$398(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$47E(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$564(A2),D1-4
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$64A(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$730(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$816(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	$8FC(A2),D1-4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,-(a4)
	nop
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	$9E2(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$AC8(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$BAE(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$C94(A2),D1-4
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,-(a4)
	nop
	MOVE.W	posx10,D1
	MOVE.W	posy10,D2
	MOVEA.L	ecr1,A2
	ADDA.W	#$128,A2
	LEA	tab230,A3
	ADD.W	D2,D2
	ADD.W	D2,D2
	ADDA.W	D2,A3
	MOVE.L	(A3),D2
	ADDA.L	D2,A2
	MOVE.W	D1,D2
	LSR.W	#4,D2
	LSL.W	#3,D2
	ADDA.W	D2,A2
	MOVEA.L	ptrestore101,A4
	MOVE.L	A2,(A4)+
	ADDA.W	#$F0,A4
	MOVEM.L	(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	$E6(A2),D1-4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,-(a4)
	nop
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	$1CC(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$2B2(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$398(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$47E(A2),D1-4
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$564(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$64A(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$730(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	$816(A2),D1-4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,-(a4)
	nop
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	$8FC(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$9E2(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$AC8(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$BAE(A2),D1-4
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEM.L	$C94(A2),D1-4
	MOVEM.L	D1-4,-(a4)
	nop
	MOVEA.L	ptrestore11,A4
	MOVEA.L	(A4),A2
	MOVE.W	posx1,D1
	ANDI.W	#$F,D1
	MOVEA.L	pttabpred1,A3
	ADD.W	D1,D1
	ADD.W	D1,D1
	ADDA.W	D1,A3
	MOVEA.L	(A3),A3
	MOVEM.L	(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	NOP
	NOP


	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	OR.L	(A3)+,D4
	MOVEM.L	D1-d3,(A2)

	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	move.l	d4,12(a2)	* 4
	MOVEM.L	$E6(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$E6(A2)
	MOVEM.L	$1CC(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	dcb.w	6,$4e71



	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$1CC(A2)
	MOVEM.L	$2B2(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$2B2(A2)
	NOP
	NOP
	NOP


	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	$398(A2),D1-4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$398(A2)
	MOVEM.L	$47E(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$47E(A2)
	NOP
	NOP
	NOP


	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	$564(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$564(A2)
	MOVEM.L	$64A(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$64A(A2)
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	$730(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$730(A2)
	MOVEM.L	$816(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$816(A2)
	MOVEM.L	$8FC(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$8FC(A2)
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	$9E2(A2),D1-4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$9E2(A2)
	MOVEM.L	$AC8(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$AC8(A2)
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	$BAE(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$BAE(A2)
	MOVEM.L	$C94(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$C94(A2)
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEA.L	ptrestore21,A4
	MOVEA.L	(A4),A2
	MOVE.W	posx2,D1
	ANDI.W	#$F,D1
	MOVEA.L	pttabpred2,A3
	ADD.W	D1,D1
	ADD.W	D1,D1
	ADDA.W	D1,A3
	MOVEA.L	(A3),A3
	MOVEM.L	(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,(A2)
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	$E6(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$E6(A2)
	MOVEM.L	$1CC(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$1CC(A2)
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	$2B2(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$2B2(A2)
	MOVEM.L	$398(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$398(A2)
	MOVEM.L	$47E(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$47E(A2)
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	$564(A2),D1-4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$564(A2)
	MOVEM.L	$64A(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$64A(A2)
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	$730(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$730(A2)
	MOVEM.L	$816(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$816(A2)
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	$8FC(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$8FC(A2)
	MOVEM.L	$9E2(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$9E2(A2)
	MOVEM.L	$AC8(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$AC8(A2)
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	$BAE(A2),D1-4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$BAE(A2)
	MOVEM.L	$C94(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$C94(A2)
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEA.L	ptrestore31,A4
	MOVEA.L	(A4),A2
	MOVE.W	posx3,D1
	ANDI.W	#$F,D1
	MOVEA.L	pttabpred3,A3
	ADD.W	D1,D1
	ADD.W	D1,D1
	ADDA.W	D1,A3
	MOVEA.L	(A3),A3
	MOVEM.L	(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,(A2)
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	$E6(A2),D1-4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$E6(A2)
	MOVEM.L	$1CC(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$1CC(A2)
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	$2B2(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$2B2(A2)
	MOVEM.L	$398(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$398(A2)
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	$47E(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$47E(A2)
	MOVEM.L	$564(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$564(A2)
	MOVEM.L	$64A(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$64A(A2)
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	$730(A2),D1-4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$730(A2)
	MOVEM.L	$816(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$816(A2)
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	$8FC(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$8FC(A2)
	MOVEM.L	$9E2(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$9E2(A2)
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	$AC8(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$AC8(A2)
	MOVEM.L	$BAE(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$BAE(A2)
	MOVEM.L	$C94(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$C94(A2)
	MOVEA.L	ptrestore41,A4
	MOVEA.L	(A4),A2
	NOP
	NOP
	NOP

	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	posx4,D1
	ANDI.W	#$F,D1
	MOVEA.L	pttabpred4,A3
	ADD.W	D1,D1
	ADD.W	D1,D1
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	ADDA.W	D1,A3
	MOVEA.L	(A3),A3
	MOVEM.L	(A2),D1-2	* 6
*	dcb.w	1,$4e71
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	8(A2),D3-d4	* 7
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,(A2)
	MOVEM.L	$E6(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	dcb.w	3,$4e71

	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$E6(A2)
	MOVEM.L	$1CC(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$1CC(A2)
	MOVEM.L	$2B2(A2),D1-4
	NOP
	NOP
	NOP

	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$2B2(A2)
	MOVEM.L	$398(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$398(A2)
	MOVEM.L	$47E(A2),D1-4
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$47E(A2)
	MOVEM.L	$564(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	D1-4,$564(A2)
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	$64A(A2),D1-4
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$64A(A2)
	MOVEM.L	$730(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$730(A2)
	MOVEM.L	$816(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$816(A2)
	MOVEM.L	$8FC(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$8FC(A2)
	MOVEM.L	$9E2(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$9E2(A2)
	MOVEM.L	$AC8(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$AC8(A2)
	MOVEM.L	$BAE(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	D1-4,$BAE(A2)
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	$C94(A2),D1-4
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$C94(A2)
	MOVEA.L	ptrestore51,A4
	MOVEA.L	(A4),A2
	MOVE.W	posx5,D1
	ANDI.W	#$F,D1
	MOVEA.L	pttabpred5,A3
	ADD.W	D1,D1
	ADD.W	D1,D1
	ADDA.W	D1,A3
	MOVEA.L	(A3),A3
	MOVEM.L	(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,(A2)
	MOVEM.L	$E6(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$E6(A2)

	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	$1CC(A2),D1-4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$1CC(A2)
	MOVEM.L	$2B2(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$2B2(A2)
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	$398(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$398(A2)
	MOVEM.L	$47E(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$47E(A2)
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	$564(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$564(A2)
	MOVEM.L	$64A(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$64A(A2)
	MOVEM.L	$730(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$730(A2)
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	$816(A2),D1-4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$816(A2)
	MOVEM.L	$8FC(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$8FC(A2)
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	$9E2(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$9E2(A2)
	MOVEM.L	$AC8(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$AC8(A2)
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	$BAE(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$BAE(A2)
	MOVEM.L	$C94(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$C94(A2)
	MOVEA.L	ptrestore61,A4
	MOVEA.L	(A4),A2
	MOVE.W	posx6,D1
	ANDI.W	#$F,D1
	MOVEA.L	pttabpred6,A3
	ADD.W	D1,D1
	ADD.W	D1,D1
	ADDA.W	D1,A3
	MOVEA.L	(A3),A3
	MOVEM.L	(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	OR.L	(A3)+,D4
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,(A2)
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	$E6(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$E6(A2)
	MOVEM.L	$1CC(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$1CC(A2)
	MOVEM.L	$2B2(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$2B2(A2)
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	$398(A2),D1-4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$398(A2)
	MOVEM.L	$47E(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$47E(A2)
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	$564(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$564(A2)
	MOVEM.L	$64A(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$64A(A2)
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	$730(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$730(A2)
	MOVEM.L	$816(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$816(A2)
	MOVEM.L	$8FC(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$8FC(A2)
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	$9E2(A2),D1-4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$9E2(A2)
	MOVEM.L	$AC8(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$AC8(A2)
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	$BAE(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$BAE(A2)
	MOVEM.L	$C94(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$C94(A2)
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEA.L	ptrestore71,A4
	MOVEA.L	(A4),A2
	MOVE.W	posx7,D1
	ANDI.W	#$F,D1
	MOVEA.L	pttabpred7,A3
	ADD.W	D1,D1
	ADD.W	D1,D1
	ADDA.W	D1,A3
	MOVEA.L	(A3),A3
	MOVEM.L	(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,(A2)
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	$E6(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$E6(A2)
	MOVEM.L	$1CC(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$1CC(A2)
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	$2B2(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$2B2(A2)
	MOVEM.L	$398(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$398(A2)
	MOVEM.L	$47E(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$47E(A2)
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	$564(A2),D1-4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$564(A2)
	MOVEM.L	$64A(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$64A(A2)
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	$730(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$730(A2)
	MOVEM.L	$816(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$816(A2)
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	$8FC(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$8FC(A2)
	MOVEM.L	$9E2(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$9E2(A2)
	MOVEM.L	$AC8(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$AC8(A2)
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	$BAE(A2),D1-4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$BAE(A2)
	MOVEM.L	$C94(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$C94(A2)
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEA.L	ptrestore81,A4
	MOVEA.L	(A4),A2
	MOVE.W	posx8,D1
	ANDI.W	#$F,D1
	MOVEA.L	pttabpred8,A3
	ADD.W	D1,D1
	ADD.W	D1,D1
	ADDA.W	D1,A3
	MOVEA.L	(A3),A3
	MOVEM.L	(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,(A2)
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	$E6(A2),D1-4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$E6(A2)
	MOVEM.L	$1CC(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$1CC(A2)
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	$2B2(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$2B2(A2)
	MOVEM.L	$398(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$398(A2)
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	$47E(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$47E(A2)
	MOVEM.L	$564(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$564(A2)
	MOVEM.L	$64A(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$64A(A2)
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	$730(A2),D1-4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$730(A2)
	MOVEM.L	$816(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$816(A2)
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	$8FC(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$8FC(A2)
	MOVEM.L	$9E2(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$9E2(A2)
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	$AC8(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$AC8(A2)
	MOVEM.L	$BAE(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$BAE(A2)
	MOVEM.L	$C94(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$C94(A2)
	MOVEA.L	ptrestore91,A4
	MOVEA.L	(A4),A2
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	posx9,D1
	ANDI.W	#$F,D1
	MOVEA.L	pttabpred9,A3
	ADD.W	D1,D1
	ADD.W	D1,D1
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	ADDA.W	D1,A3
	MOVEA.L	(A3),A3
	MOVEM.L	(A2),D1-2
*	dcb.w	7,$4e71
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	8(A2),D3-d4

	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,(A2)
	MOVEM.L	$E6(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	dcb.w	3,$4e71

	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$E6(A2)
	MOVEM.L	$1CC(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$1CC(A2)
	MOVEM.L	$2B2(A2),D1-4
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$2B2(A2)
	MOVEM.L	$398(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$398(A2)
	MOVEM.L	$47E(A2),D1-4
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$47E(A2)
	MOVEM.L	$564(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	D1-4,$564(A2)
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	$64A(A2),D1-4
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$64A(A2)
	MOVEM.L	$730(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$730(A2)
	MOVEM.L	$816(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$816(A2)
	MOVEM.L	$8FC(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$8FC(A2)
	MOVEM.L	$9E2(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$9E2(A2)
	MOVEM.L	$AC8(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$AC8(A2)
	MOVEM.L	$BAE(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	D1-4,$BAE(A2)
	NOP
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	$C94(A2),D1-4
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$C94(A2)
	MOVEA.L	ptrestore101,A4
	MOVEA.L	(A4),A2
	MOVE.W	posx10,D1
	ANDI.W	#$F,D1
	MOVEA.L	pttabpred10,A3
	ADD.W	D1,D1
	ADD.W	D1,D1
	ADDA.W	D1,A3
	MOVEA.L	(A3),A3
	MOVEM.L	(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,(A2)
	MOVEM.L	$E6(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$E6(A2)
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	$1CC(A2),D1-4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$1CC(A2)
	MOVEM.L	$2B2(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$2B2(A2)
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	$398(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$398(A2)
	MOVEM.L	$47E(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$47E(A2)
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	$564(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$564(A2)
	MOVEM.L	$64A(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$64A(A2)
	MOVEM.L	$730(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$730(A2)
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVEM.L	$816(A2),D1-4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$816(A2)
	MOVEM.L	$8FC(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$8FC(A2)
	NOP
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	MOVEM.L	$9E2(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$9E2(A2)
	MOVEM.L	$AC8(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	D1-4,$AC8(A2)
	NOP
	MOVE.W	A1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVEM.L	$BAE(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$BAE(A2)
	MOVEM.L	$C94(A2),D1-4
	AND.L	(A3),D1
	AND.L	(A3)+,D2
	OR.L	(A3)+,D1
	OR.L	(A3)+,D2
	AND.L	(A3),D3
	NOP
	NOP
	MOVE.B	D0,(A0)
	MOVE.W	A1,(A0)
	MOVE.W	(A6)+,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	ADD.W	D0,D0
	LEA	snd_out2+4,a0
	ADDA.W	D0,A0
	MOVE.L	(A0)+,D0
	MOVE.W	A1,(A1)
	MOVE.B	#0,(A1)
	MOVEP.L	D0,$5A0(A1)
	LEA	$FFFF820A.W,A0
	NOP
	NOP
	NOP
	MOVE.W	A1,(A1)
	MOVEQ	#0,D0
	MOVE.B	D0,(A1)
	AND.L	(A3)+,D4
	OR.L	(A3)+,D3
	OR.L	(A3)+,D4
	MOVEM.L	D1-4,$C94(A2)
	dcb.w	66,$4e71
