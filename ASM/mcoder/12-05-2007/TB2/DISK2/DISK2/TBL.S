	OPT	X+
	CLR	D7
	LEA	TABLE_VECTEUR,A4	;SOURCE
	LEA	OPTIM,A5		;PUSH POINTS
	LEA	PTS,A6

TAKE1:
	MOVE	(A4)+,D0
	BMI	FINI

	LEA	OPTIM,A0
COMP:
	CMP.L	A5,A0
	BHS.S	INSERT

	CMP	(A0)+,D0
	BNE	COMP

	MOVE.L	A0,D1
	SUB.L	#OPTIM,D1
	SUBQ.L	#2,D1
	LSR	#1,D1


	ASL	#2,D1
	MOVE	D1,(A6)+
	BRA	TAKE1


INSERT	MOVE	D0,(A5)+
	MOVE	D7,(A6)+
	ADDQ	#4,D7
	BRA	TAKE1
FINI:

	LEA	OPTIM,A0
	MOVE.L	A5,A1

	LEA	PTS,A2
	MOVE.L	A6,A3
	ILLEGAL



***	TABLES DES VECTEURS	:
***		TOUT LES VECTEURS NON VERTICAUX SONT
***		DECOUPES EN PETIT MORCEAUX POUR DONNER
***		UN EFFET D'ARRONDI
***		A LA RIGUEUR ON PEUT LES SUPPRIMER POUR
***		GAGNER DU TEMPS, MAIS ON PERDRA BEAUCOUP
***		EN BEAUTE (VOIR LE <L> OU ENCORE LE <N>)

I	EQU	4*20
J	EQU	4

TABLE_VECTEUR
	DC.W	3*20+0*J,4*J	;L
	;	3*20 CAR SI 0 LE L EST PENCHE EN ARRIERE !!!
	DC.W	4*J,4*J+I
	DC.W	4*J+I,4*J+I*2
	DC.W	4*J+I*2,4*J+I*3
	DC.W	4*J+I*3,4*J+I*4

	DC.W	5*I+J,5*I+J*3	;O
	DC.W	5*I+J*3,6*I+J*4
	DC.W	6*I+J*4,7*I+J*4
	DC.W	7*I+J*4,8*I+J*4
	DC.W	8*I+J*4,9*I+3*J
	DC.W	9*I+3*J,9*I+1*J
	DC.W	9*I+1*J,8*I
	DC.W	8*I,7*I
	DC.W	7*I,6*I
	DC.W	6*I,5*I+J

	DC.W	10*I+J,10*I+J*4	;A
	DC.W	14*I+J,14*I+J*4
	DC.W	10*I+2*J,11*I+2*J
	DC.W	11*I+2*J,12*I+2*J
	DC.W	12*I+2*J,13*I+2*J
	DC.W	13*I+2*J,14*I+2*J
	DC.W	10*I+J,11*I
	DC.W	11*I,12*I
	DC.W	12*I,13*I
	DC.W	13*I,14*I+J

	DC.W	15*I,15*I+4*J	;D
	DC.W	15*I+4*J,16*I+4*J
	DC.W	16*I+4*J,17*I+4*J
	DC.W	17*I+4*J,18*I+4*J
	DC.W	18*I+4*J,19*I+3*J
	DC.W	19*I+3*J,19*I+J
	DC.W	19*I+J,18*I
	DC.W	18*I,17*I
	DC.W	17*I,16*I
	DC.W	16*I,15*I

	DC.W	21*I,22*I		;I
	DC.W	22*I,23*I
	DC.W	22*I,22*I+4*J
	DC.W	21*I+4*J,22*I+4*J
	DC.W	22*I+4*J,23*I+4*J

	DC.W	25*I,25*I+4*J	;N
	DC.W	25*I,26*I+J
	DC.W	26*I+J,27*I+2*J
	DC.W	27*I+2*J,28*I+3*J
	DC.W	28*I+3*J,29*I+4*J
	DC.W	29*I+4*J,29*I
	
	DC.W	34*I+J,33*I	;G
	DC.W	33*I,32*I
	DC.W	32*I,31*I
	DC.W	31*I,30*I+J
	DC.W	30*I+J,30*I+3*J
	DC.W	30*I+3*J,31*I+4*J
	DC.W	31*I+4*J,32*I+4*J
	DC.W	32*I+4*J,33*I+4*J
	DC.W	33*I+4*J,34*I+3*J
	DC.W	34*I+3*J,34*I+2*J
	DC.W	34*I+2*J,33*I+2*J
	DC.W	33*I+2*J,32*I+2*J
	DC.W	-1
	SECTION	BSS
OPTIM:	DS.W	1000
PTS:	DS.W	1000
