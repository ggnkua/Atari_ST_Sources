	move.l	phy,a1
	lea	2+160-32+66+8(a1),a1
	lea	dessin,a0

	MOVE	#278-1,D7
DECOMPV:
	MOVE	#(224-16)/8-1,D6
DECOMP:
	MOVEQ	#4-1,D5
DECOMPH:
	MOVE	(A0)+,D0

	REPT	4
	ADD	D0,D0
	ADDX	D1,D1
	ADD	D0,D0
	ADDX	D2,D2
	ADD	D0,D0
	ADDX	D3,D3
	ADD	D0,D0
	ADDX	D4,D4
	ENDR
	DBRA	D5,DECOMPH
	MOVEM	D1-D4,(A1)
	ADDQ	#8,A1
	DBRA	D6,DECOMP

	LEA	8+8+6(A1),A1

	DBRA	D7,DECOMPV

