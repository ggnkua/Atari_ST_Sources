	LEA	$80000,A0
	LEA	$90000,A1
	MOVE	#62272/8-1,D7
TAKE8:
	MOVEM	(A0)+,D0-D3
	MOVEQ	#4-1,D5
TAKE2:
	MOVEQ	#1,D4
TKL:
	ADD	D0,D0
	ADDX	D4,D4
	ADD	D1,D1
	ADDX	D4,D4
	ADD	D2,D2
	ADDX	D4,D4
	ADD	D3,D3
	ADDX	D4,D4
	BCC.S	TKL
	MOVE	D4,(A1)+
	DBRA	D5,TAKE2

	DBRA	D7,TAKE8
	ILLEGAL
