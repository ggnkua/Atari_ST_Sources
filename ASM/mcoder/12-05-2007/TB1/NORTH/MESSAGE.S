  SO, YOU FINALLY DECIDED TO QUIT US. 
BEFORE EVERYTHING IS FINISHED, LET'S TAKE A LOOK AT THIS 
GREAT (?) RESET-DEMO (YOU CAN PRESS F1 TO F8 TO CHANGE THE MUSIC). 
THIS SCREEN IS THE CONVERSION OF AN AMIGA DEMO ORIGINALLY CODED 
BY CELEBRANDIL FROM NORTHSTAR. 
YOU SURELY DON'T CARE BUT THE CODING ON ST HAS BEEN DONE BY MCODER 
AND THE MUZAK BY MAD MAX. 
THE ORIGINAL DEMO RUNS 2 TIMES FASTER THAN THIS VERSION... 
THE EXACT CONVERSION WAS IMPOSSIBLE BECAUSE THERE ARE 144 POINTS 
WHICH ROTATE AROUND THE 3 AXES (IT MEANS LOT OF REAL-TIME 
CALCULATIONS...) AND THESE POINTS FORM 264 SEGMENTS 
(AND THE ST HAS NO BLITTER TO DRAW LINES).  
I -MCODER- WISH TO THANK : 
HEMOROIDS (HI TO SKYRACE), THE BUSHWACKERS (HI TO THE SERGEANT, 
GREAT ORGANIZATION, DON'T FORGET TO INVITE ME AT YOUR NEXT PARTY), 
THE OVERLANDERS (VERY COOL CODERS), 
EQUINOX (GREAT SCREEN KRUEGER, I HAD NO PROBLEM TO PUT IT IN THIS 
DEMO-DISK, GOOD LUCK FOR EQUINOX MEGADEMO), 
FUZION (I'M WAITING FOR SPEEDER'S WORK), 
MAD-VISION (I THINK YOU'LL LIKE THESE 3D VECTORS), 
PHENIX AND THE BLACK CATS (I HOPE TO BE PRESENT AT YOUR CODING-PARTY), 
PIERRE (YOUR DEMOS ON AMIGA ARE SO GOOD THAT I'LL TRY TO CONVERT 
SOME OF THEM ON ST...) 
AND LAST BUT NOT LEAST I WISH TO THANK ZIGGY STARDUST AND ALGERNON, 
WHO ARE NOW WORKING WITH ME ON GREAT FILLED 3D ROUTINES.  
OK THAT'S ALL FOR NOW. I HOPE YOU ENJOYED THIS LITTLE RESET DEMO, 
BYE...    TRANSBEAUCE DEMO-PARTY, RELEASE DATE : 15 AUGUST 1990.
                                                   
