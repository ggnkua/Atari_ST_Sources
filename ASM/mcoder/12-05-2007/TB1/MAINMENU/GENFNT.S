	LEA	$40000,A0
	LEA	$50000,A1

MOVEIT:
	MOVE	(A0)+,D6	;X
	BEQ.S	FINI

	MOVE	(A0)+,D7	;Y
	ADDQ	#1,D7

	ADD	#16,D6
	AND	#-16,D6

	MOVE	D6,(A1)+
	MOVE	D7,(A1)+
	LSR	#1,D6
	MULU	D6,D7
	MOVE.L	A0,(A1)+
	ADD.L	D7,A0
	BRA.S	MOVEIT

FINI:	ILLEGAL
