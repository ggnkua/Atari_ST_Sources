
	LEA	$40000,A0
	LEA	$50000,A1
	MOVE.L	(A0)+,(A1)+

	MOVE	#3200/8-1,D0
COPY:
	ADDQ	#2,A0		;MASQUE
	MOVE.L	(A0)+,(A1)+
	TST.L	(A0)+
	BNE.S	ERREUR
	DBRA	D0,COPY
ERREUR:
	ILLEGAL
