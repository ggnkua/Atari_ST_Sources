	LEA	$40000+4,A0
	LEA	$50000,A1

	MOVE	#160/8-1,D0
COPY:
	MOVE	(A0)+,(A1)+
	ADDQ	#6,A0
	DBRA	D0,COPY
	ILLEGAL
