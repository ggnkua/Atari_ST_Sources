;$D($3A8)
IMAGECASES:
	DC.L	CASES+$0,$9090000
	DC.L	CASES+$48,$9090000
	DC.L	CASES+$90,$9090000
	DC.L	CASES+$D8,$9090000
	DC.L	CASES+$120,$9090000
	DC.L	CASES+$168,$9090000
	DC.L	CASES+$1B0,$9090000
	DC.L	CASES+$1F8,$9090000
	DC.L	CASES+$240,$9090000
	DC.L	CASES+$288,$9090000
	DC.L	CASES+$2D0,$9090000
	DC.L	CASES+$318,$9090000
	DC.L	CASES+$360,$9090000
