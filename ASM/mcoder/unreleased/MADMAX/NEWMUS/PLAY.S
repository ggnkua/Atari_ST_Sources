MUS=1
	LEA	BASE,A0
	LEA	FIN,A1
SRC:
	CMP.L	A1,A0
	BHS.S	OK
	CMP	#$4E73,(A0)+
	BNE.S	SRC
;	ILLEGAL
OK:
	MOVE	SR,D0
	AND	#$2000,D0
	BNE.S	SUPER
	CLR.L	-(SP)
	MOVE	#$20,-(SP)
	TRAP	#1
	ADDQ	#6,SP
SUPER:
	lea	MUSIK,a0
	MOVEQ	#MUS,D0
	JSR	BASE
	JSR	BASE+8		;INIT DIGIT
BCL:
	MOVE	#37,-(SP)
	TRAP	#14
	ADDQ	#2,SP

	MOVEQ	#0,D0
.WW	MOVE.B	$FFFF8209.W,D0
	BEQ.S	.WW
	NOT	D0
	LSR	D0,D0
	MOVE	#$700,$FFFF8240.W
	JSR	BASE+4
	CLR	$FFFF8240.W

	MOVE	#$FF,-(SP)
	MOVE	#6,-(SP)
	TRAP	#1
	ADDQ	#4,SP

	TST	D0
	BEQ.S	BCL

	JSR	BASE+12
	MOVE.L	#$08080000,$FFFF8800.W
	MOVE.L	#$09090000,$FFFF8800.W
	MOVE.L	#$0A0A0000,$FFFF8800.W
;	ILLEGAL
	CLR	-(SP)
	TRAP	#1

BASE:
	INCBIN	ghost12.MUS
;	incbin	ghost4.mus
MUSIK:
	incbin	ghost10.mus
FIN:
