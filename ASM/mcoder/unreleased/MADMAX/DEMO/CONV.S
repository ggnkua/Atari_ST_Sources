TEXTE=$40000
DEST=$50000
;
; CONVERTIT LE TEXTE
;
	LEA	TEXTE,A0
	LEA	DEST,A6
	MOVEQ	#0,D0
CONV:	MOVE.B	(A0)+,D0
	BEQ.S	FINCONV
	CMP.B	#13,D0
	BEQ.S	CONV
	CMP.B	#10,D0
	BEQ.S	CONV

	LEA	CONVTBL(pc),A1
TSTLET:
	MOVE.B	(A1)+,D1
	BEQ.S	SPC
	CMP.B	D1,D0
	BNE.S	TSTLET
	MOVE.L	A1,D1
	SUB.L	#CONVTBL+1,D1
	MOVE.B	D1,(A6)+
	BRA.S	CONV
SPC:
	ILLEGAL
FINCONV:
	ST	(A6)+
	LEA	DEST,A0
	MOVE.L	A6,A1
	ILLEGAL
CONVTBL:
	DC.B	" 0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ"
	DC.B	"().:!?,;'-",0
