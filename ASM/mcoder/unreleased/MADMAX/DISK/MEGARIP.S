;
	PEA	MESS(PC)
	MOVE	#9,-(SP)
	TRAP	#1
	ADDQ	#6,SP
	DC.W	$A009

	MOVE	SR,D0
	AND	#$2000,D0
	BNE.S	SUPER
	CLR.L	-(SP)
	MOVE	#$20,-(SP)
	TRAP	#1
	ADDQ	#6,SP
SUPER:
	MOVE	#$2700,SR
	MOVEQ	#0,D0
	MOVE.L	D0,A0
	MOVEP.L	D0,$FFFFFA01(A0)
	MOVEP.L	D0,$FFFFFA09(A0)
	MOVEP.L	D0,$FFFFFA11(A0)
	MOVEP.L	D0,$FFFFFA19(A0)
	MOVE.B	#$40,$FFFFFA17.W	;AEI
	MOVE.L	#VBL,$70.W
	MOVE	#$2300,SR

	MOVEQ	#1,D0
	BSR	INIT

	MOVE.B	$FFFFFC02.W,LAST
	MOVE	$FFFF8240.W,SAV0
BCL:
	MOVE	SYNC,D0
.WW	CMP	SYNC,D0
	BEQ.S	.WW

	MOVE	#5000,D0
WAIT:	DBRA	D0,WAIT
	MOVE	#$700,$FFFF8240.W
	JSR	BASE+4
	MOVE	SAV0,$FFFF8240.W

	MOVEQ	#0,D0
	MOVE.B	$FFFFFC02.W,D0
	CMP.B	LAST,D0
	BEQ.S	BCL
	MOVE.B	D0,LAST
	TST	D0
	BEQ.S	BCL
	CMP	#26,D0
	BHS	BCL
	BSR	INIT
	BRA	BCL
INIT:
	SUBQ	#1,D0
	DIVU	#5,D0

	LEA	MUZAK1,A0
	TST	D0
	BEQ.S	.OK
	LEA	MUZAK2,A0
	SUBQ	#1,D0
	BEQ.S	.OK
	LEA	MUZAK3,A0
	SUBQ	#1,D0
	BEQ.S	.OK
	LEA	MUZAK4,A0
	SUBQ	#1,D0
	BEQ.S	.OK
	LEA	MUZAK5,A0
.OK
	CLR	D0
	SWAP	D0
	addq	#1,d0
	JSR	BASE
	JSR	BASE+8
	RTS

VBL:	ADDQ	#1,SYNC
	RTE
LAST:	DC.W	0
SAV0:	DC.W	0
SYNC:	DC.W	0
MESS:	DC.B	27,"E"
	DC.B	"Mega-music rip of Turrican",13,10
	dc.b	"Done by Mcoder",13,10
	dc.b	10
	dc.b	"Press ESC to etc..."
	dc.b	0
	even

BASE:	BRA	L3
	BRA	L7
	BRA	L47
	BRA	L4F
	BRA	L0
	MOVEQ	#0,D0
	MOVE	L63(PC),D0
	RTS
L0:	MOVEM.L	A0-A6/D0-D7,-(A7)
	BSR	L1
	MOVE.L	24(A0),A1
	ADD.L	A0,A1
	ADD	D0,D0
	ADD	D0,D0
	ADD	D0,A1
	MOVE	(A1)+,D2
	MOVE	(A1)+,D0
	BSR	L45
	MOVEM.L	(A7)+,A0-A6/D0-D7
	RTS
L1:	LEA	L71(PC),A0
	LEA	L54(PC),A1
	TST.B	(A1)
	BNE.S	L2
	ST	(A1)
	LEA	L67(PC),A6
	MOVE.L	A0,(A6)
	MOVE.L	4(A0),A1
	ADD.L	A0,A1
	LEA	L68(PC),A6
	MOVE.L	A1,(A6)
	MOVE.L	8(A0),A1
	ADD.L	A0,A1
	LEA	L69(PC),A6
	MOVE.L	A1,(A6)
L2:	RTS
L3:	MOVEM.L	A0-A6/D0-D7,-(A7)
	BSR	L4
	MOVEM.L	(A7)+,A0-A6/D0-D7
	RTS
L4:	LEA	28(A0),A0
	BSR	L48
	BSR.S	L6
	TST	D0
	BEQ.S	L5
	SUBQ	#1,D0
	MOVE.L	L65(PC),A1
	ADD	D0,D0
	MOVE	D0,D1
	ADD	D0,D0
	ADD	D1,D0
	ADD	D0,A1
	MOVE	(A1)+,D0
	MOVE	(A1)+,D1
	LEA	L5A(PC),A6
	MOVE	(A1)+,(A6)
	BSR	L42
	RTS
L5:	LEA	L5B(PC),A0
	ST	(A0)
	BRA	L7
L6:	LEA	L6A(PC),A6
	MOVE.L	A0,(A6)
	MOVE.L	4(A0),A1
	ADD.L	A0,A1
	LEA	L6B(PC),A6
	MOVE.L	A1,(A6)
	MOVE.L	8(A0),A1
	ADD.L	A0,A1
	LEA	L6C(PC),A6
	MOVE.L	A1,(A6)
	MOVE.L	12(A0),A1
	ADD.L	A0,A1
	LEA	L61(PC),A6
	MOVE.L	A1,(A6)
	MOVE.L	16(A0),A1
	ADD.L	A0,A1
	LEA	L60(PC),A6
	MOVE.L	A1,(A6)
	MOVE.L	20(A0),A1
	ADD.L	A0,A1
	LEA	L65(PC),A6
	MOVE.L	A1,(A6)+
	MOVE.L	28(A0),A1
	ADD.L	A0,A1
	LEA	L66(PC),A6
	MOVE.L	A1,(A6)
	RTS
L7:	LEA	L57(PC),A6
	LEA	L59(PC),A5
	TST.B	4(A5)
	BEQ.S	L9
	TST.B	5(A5)
	BNE.S	L8
	ST	5(A5)
	MOVEQ	#0,D0
	MOVE.B	D0,34(A6)
	MOVE.B	D0,38(A6)
	MOVE.B	D0,42(A6)
	MOVE	SR,-(A7)
	MOVE	#$2700,SR
	MOVEM.L	28(A6),D0-D3
	MOVEM.L	D0-D3,$FFFF8800.W
	MOVE.B	#$A,$FFFF8800.W
	MOVE	(A7)+,SR
L8:	RTS
L9:	LEA	L6A(PC),A0
	LEA	L6D(PC),A1
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	SUBQ	#1,(A5)+
	BNE.S	LA
	MOVE	(A5),-(A5)
	MOVEQ	#0,D5
	LEA	L5C(PC),A0
	BSR	L11
	LEA	L5D(PC),A0
	BSR	L11
	LEA	L5E(PC),A0
	BSR	L11
LA:	LEA	L62(PC),A5
	LEA	L5C(PC),A0
	BSR	L1D
	MOVE	D0,-(A7)
	MOVE.B	(A7)+,6(A6)
	MOVE.B	D0,2(A6)
	MOVE.B	D1,34(A6)
	LEA	L5D(PC),A0
	BSR	L1D
	MOVE	D0,-(A7)
	MOVE.B	(A7)+,14(A6)
	MOVE.B	D0,10(A6)
	MOVE.B	D1,38(A6)
	LEA	L5E(PC),A0
	BSR	L1D
	MOVE	D0,-(A7)
	MOVE.B	(A7)+,22(A6)
	MOVE.B	D0,18(A6)
	MOVE.B	D1,42(A6)
	MOVE	4(A5),D0
	BEQ.S	LD
	MOVE	D0,-(A7)
	LEA	L67(PC),A0
	LEA	L6D(PC),A1
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	LEA	L5F(PC),A0
	BSR	L1D
	MOVE.L	10(A0),A1
	ADD.L	14(A0),A1
	CMP.B	#$E1,1(A1)
	BNE.S	LB
	CLR	4(A5)
LB:	MOVE	(A7)+,D7
	LEA	L58(PC),A1
	ADD	D7,D7
	ADD	D7,D7
	ADD	D7,A1
	MOVEQ	#0,D6
	MOVE.B	(A1)+,D6
	MOVE	D0,-(A7)
	MOVE.B	D0,0(A6,D6.W)
	MOVE.B	(A1)+,D6
	MOVE.B	(A7)+,0(A6,D6.W)
	MOVE.B	(A1)+,D6
	CMP.B	#$10,D1
	BEQ.S	LC
	SUBQ.B	#1,D1
	BPL.S	LC
	SF	D1
LC:	MOVE.B	D1,0(A6,D6.W)
LD:	MOVE.B	(A5)+,D7
	OR.B	#$C0,D7
	LEA	L53(PC),A4
	TST.B	(A4)
	BEQ.S	LE
	OR.B	#$24,D7
LE:	MOVE.B	D7,30(A6)
	MOVE.B	(A5)+,26(A6)
	MOVEM.L	(A6),A0-A2/D0-D7
	LEA	L53(PC),A3
	TST.B	(A3)
	BNE.S	L10
	MOVEM.L	A0-A2/D0-D7,$FFFF8800.W
LF:	RTS
L10:	MOVE	SR,-(A7)
	MOVE	#$2700,SR
	MOVEM.L	A0-A1/D0-D7,$FFFF8800.W
	MOVE.B	#$A,$FFFF8800.W
	MOVE	(A7)+,SR
	RTS
L11:	SUBQ.B	#1,38(A0)
	BPL.S	LF
	MOVE.B	39(A0),38(A0)
L12:	MOVE.L	34(A0),A1
L13:	MOVE.B	(A1)+,D0
	CMP.B	#-1,D0
	BNE.S	L17
	MOVE.L	52(A0),A3
	MOVE.L	(A0),A2
	ADD.L	4(A0),A2
	CMP.L	A3,A2
	BNE.S	L14
	MOVE.L	D5,4(A0)
	MOVE.L	(A0),A2
L14:	MOVEQ	#0,D1
	MOVE.B	(A2),D1
	MOVE.B	1(A2),44(A0)
	MOVE.B	2(A2),22(A0)
	MOVE.B	3(A2),D0
	MOVE.B	D0,D2
	AND	#$F0,D2
	CMP	#$F0,D2
	BNE.S	L15
	MOVE.B	D0,D2
	AND.B	#$F,D2
	MOVE.B	D2,40(A0)
	BRA.S	L16
L15:	CMP.B	#$E0,D2
	BNE.S	L16
	MOVE.B	D0,D2
	AND	#$F,D2
	MOVE	D2,2(A5)
L16:	ADD	D1,D1
	ADD	D1,D1
	MOVE.L	L61(PC),A3
	MOVE.L	0(A3,D1.W),A3
	ADD.L	L6D(PC),A3
	MOVE.L	A3,34(A0)
	ADD.L	#$C,4(A0)
	BRA	L12
L17:	CMP.B	#-2,D0
	BNE.S	L18
	MOVE.B	(A1),39(A0)
	MOVE.B	(A1)+,38(A0)
	BRA	L13
L18:	CMP.B	#-3,D0
	BNE.S	L19
	MOVE.B	(A1),39(A0)
	MOVE.B	(A1)+,38(A0)
	MOVE.L	A1,34(A0)
	RTS
L19:	MOVE.B	D0,8(A0)
	MOVE.B	(A1)+,D1
	MOVE.B	D1,9(A0)
	AND	#$E0,D1
	BEQ.S	L1A
	MOVE.B	(A1)+,31(A0)
L1A:	MOVE.L	A1,34(A0)
	MOVE.L	D5,56(A0)
	TST.B	D0
	BMI.S	L1C
	MOVE.B	9(A0),D1
	MOVE.B	D1,D0
	AND	#$1F,D1
	ADD.B	22(A0),D1
	MOVE.L	L6F(PC),A2
	ADD	D1,D1
	ADD	D1,D1
	MOVE.L	0(A2,D1.W),A2
	ADD.L	L6D(PC),A2
	MOVE.L	D5,14(A0)
	MOVE.B	(A2),23(A0)
	MOVE.B	(A2)+,24(A0)
	MOVEQ	#0,D1
	MOVE.B	(A2)+,D1
	MOVE.B	(A2)+,27(A0)
	MOVE.B	#$40,46(A0)
	MOVE.B	(A2)+,D2
	MOVE.B	D2,28(A0)
	MOVE.B	D2,29(A0)
	MOVE.B	(A2)+,30(A0)
	MOVE.L	A2,10(A0)
	AND.B	#$40,D0
	BEQ.S	L1B
	MOVE.B	31(A0),D1
L1B:	MOVE.L	L6E(PC),A2
	ADD	D1,D1
	ADD	D1,D1
	MOVE.L	0(A2,D1.W),A2
	ADD.L	L6D(PC),A2
	MOVE.L	A2,18(A0)
	MOVE.L	D5,48(A0)
	MOVE.B	D5,26(A0)
	MOVE.B	D5,25(A0)
L1C:	RTS
L1D:	MOVEQ	#0,D7
	MOVE.B	D7,32(A0)
L1E:	TST.B	26(A0)
	BEQ.S	L1F
	SUBQ.B	#1,26(A0)
	BRA	L2A
L1F:	MOVE.L	18(A0),A1
	ADD.L	48(A0),A1
	CMP.B	#$E1,(A1)
	BEQ	L2A
	CMP.B	#$E0,(A1)
	BNE	L20
	MOVE.B	1(A1),D0
	AND.L	#$3F,D0
	MOVE.L	D0,48(A0)
	MOVE.L	18(A0),A1
	ADD.L	D0,A1
L20:	CMP.B	#$E2,(A1)
	BNE	L21
	CLR.L	14(A0)
	MOVE.B	#1,23(A0)
	ADDQ.L	#1,48(A0)
	BRA	L1F
L21:	CMP.B	#$E9,(A1)
	BNE	L22
	MOVE	SR,-(A7)
	MOVE	#$2700,SR
	MOVE.B	#$B,$FFFF8800.W
	MOVE.B	1(A1),$FFFF8802.W
	MOVE.B	#$C,$FFFF8800.W
	MOVE.B	#0,$FFFF8802.W
	MOVE.B	#$D,$FFFF8800.W
	MOVE.B	#$A,$FFFF8802.W
	MOVE.B	#$A,$FFFF8800.W
	MOVE	(A7)+,SR
	ADDQ.L	#2,48(A0)
	BRA	L1F
L22:	CMP.B	#$E7,(A1)
	BNE.S	L23
	LEA	L53(PC),A4
	SF	(A4)
	AND.B	#$F,$FFFFFA1D.W
	ADDQ.L	#1,48(A0)
	BRA	L1F
L23:	CMP.B	#$E8,(A1)
	BNE.S	L24
	MOVE.B	1(A1),26(A0)
	ADDQ.L	#2,48(A0)
	BRA	L1E
L24:	CMP.B	#$E4,(A1)
	BNE.S	L25
	MOVE.B	D7,42(A0)
	MOVE.B	1(A1),32(A0)
	ADDQ.L	#2,48(A0)
	BRA	L29
L25:	CMP.B	#$E5,(A1)
	BNE.S	L26
	MOVE.B	#1,42(A0)
	ADDQ.L	#1,48(A0)
	BRA	L1E
L26:	CMP.B	#$E6,(A1)
	BNE.S	L27
	MOVE.B	#2,42(A0)
	ADDQ.L	#1,48(A0)
	BRA	L29
L27:	CMP.B	#$E3,(A1)
	BNE.S	L28
	ADDQ.L	#3,48(A0)
	MOVE.B	1(A1),27(A0)
	MOVE.B	2(A1),28(A0)
L28:	CMP.B	#$EA,(A1)
	BNE	L29
	MOVEQ	#0,D0
	MOVEQ	#0,D1
	MOVE.B	1(A1),D0
	ADD	D0,D0
	ADD	D0,D0
	ADD	D0,D0
	ADD.L	L66(PC),D0
	MOVE.L	D0,A2
	LEA	L53(PC),A4
	ST	(A4)
	MOVE	(A2)+,A1
	ADD.L	L66(PC),A1
	LEA	L51(PC),A2
	SUB.L	A2,A1
	MOVE	A1,(A2)

	AND.B	#$F,$FFFFFA1D.W
	OR.B	#$10,$FFFFFA1D.W
	MOVE.B	#$7A,$FFFFFA23.W
	ADDQ.L	#3,48(A0)
	RTS
L29:	MOVE.L	18(A0),A1
	ADD.L	48(A0),A1
	MOVE.B	(A1),43(A0)
	ADDQ.L	#1,48(A0)
L2A:	TST.B	25(A0)
	BEQ.S	L2B
	SUBQ.B	#1,25(A0)
	BRA.S	L2F
L2B:	SUBQ.B	#1,23(A0)
	BNE.S	L2F
	MOVE.B	24(A0),23(A0)
L2C:	MOVE.L	10(A0),A1
	ADD.L	14(A0),A1
	MOVE.B	(A1),D0
	CMP.B	#$E8,D0
	BNE.S	L2D
	ADDQ.L	#2,14(A0)
	MOVE.B	1(A1),25(A0)
	BRA.S	L2A
L2D:	CMP.B	#$E1,D0
	BEQ.S	L2F
	CMP.B	#$E0,D0
	BNE.S	L2E
	MOVE.B	1(A1),D0
	AND.L	#$3F,D0
	SUBQ.L	#5,D0
	MOVE.L	D0,14(A0)
	BRA.S	L2C
L2E:	MOVE.B	(A1),45(A0)
	ADDQ.L	#1,14(A0)
L2F:	MOVE.B	43(A0),D0
	BMI.S	L30
	ADD.B	8(A0),D0
	ADD.B	44(A0),D0
L30:	AND	#$7F,D0
	LEA	L70(PC),A1
	ADD	D0,D0
	MOVE	D0,D1
	ADD	D0,A1
	MOVE	(A1),D0
	MOVE.B	33(A0),D3
	MOVE.B	42(A0),D2
	AND.L	#$F,D2
	BNE.S	L31
	BCLR	D3,(A5)
	ADDQ	#3,D3
	BCLR	D3,(A5)
	BRA.S	L34
L31:	CMP.B	#1,D2
	BNE.S	L33
	BSET	D3,(A5)
	ADDQ	#3,D3
	BCLR	D3,(A5)
	MOVE.B	8(A0),32(A0)
	MOVE.B	43(A0),D4
	BPL.S	L32
	AND.B	#$7F,D4
	MOVE.B	D4,32(A0)
	BRA.S	L34
L32:	ADD.B	D4,32(A0)
	BRA.S	L34
L33:	BCLR	D3,(A5)
	ADDQ	#3,D3
	BSET	D3,(A5)
L34:	TST.B	32(A0)
	BEQ.S	L35
	MOVE.B	32(A0),D3
	AND.B	#$1F,D3
	EOR.B	#$1F,D3
	MOVE.B	D3,1(A5)
L35:	MOVE.B	46(A0),D7
	TST.B	30(A0)
	BEQ.S	L36
	SUBQ.B	#1,30(A0)
	BRA.S	L3E
L36:	MOVE.B	D1,D5
	MOVE.B	28(A0),D4
	ADD.B	D4,D4
	MOVE.B	29(A0),D1
	TST.B	D7
	BPL.S	L37
	BTST	#0,D7
	BNE.S	L3A
L37:	BTST	#5,D7
	BNE.S	L38
	SUB.B	27(A0),D1
	BCC.S	L39
	BSET	#5,D7
	MOVEQ	#0,D1
	BRA.S	L39
L38:	ADD.B	27(A0),D1
	CMP.B	D4,D1
	BCS.S	L39
	BCLR	#5,D7
	MOVE.B	D4,D1
L39:	MOVE.B	D1,29(A0)
L3A:	LSR.B	#1,D4
	SUB.B	D4,D1
	BCC.S	L3B
	SUB	#$100,D1
L3B:	ADD.B	#$A0,D5
	BCS.S	L3D
L3C:	ADD	D1,D1
	ADD.B	#$18,D5
	BCC.S	L3C
L3D:	ADD	D1,D0
L3E:	EOR.B	#1,D7
	MOVE.B	D7,46(A0)
	BTST	#5,9(A0)
	BEQ	L3F
	MOVEQ	#0,D7
	MOVE	D7,D1
	MOVE.B	31(A0),D1
	EXT	D1
	MOVE.L	56(A0),D2
	MOVEQ	#$C,D3
	ASL.L	D3,D1
	ADD.L	D1,D2
	MOVE.L	D2,56(A0)
	SWAP	D2
	SUB	D2,D0
L3F:	MOVE.B	45(A0),D1
	SUB.B	40(A0),D1
	CMP.B	#$10,D1
	BEQ.S	L41
	LEA	L63(PC),A1
	TST	(A1)
	BEQ.S	L40
	LEA	L5F(PC),A1
	CMP.L	A1,A0
	BEQ.S	L40
	SUBQ.B	#1,D1
L40:	TST.B	D1
	BPL.S	L41
	MOVEQ	#0,D1
L41:	RTS
L42:	LEA	L64(PC),A0
	CLR.L	(A0)
	MOVE.L	D0,D7
	MULU	#$C,D7
	MOVE.L	D1,D6
	ADDQ.L	#1,D6
	MULU	#$C,D6
	MOVEQ	#2,D0
	LEA	L5C(PC),A0
	LEA	L55(PC),A1
	LEA	L56(PC),A2
L43:	MOVE.L	A1,10(A0)
	CLR.L	14(A0)
	CLR.B	45(A0)
	CLR.B	8(A0)
	CLR.B	9(A0)
	MOVE.L	A1,18(A0)
	CLR.L	48(A0)
	MOVE.B	#1,23(A0)
	MOVE.B	#1,24(A0)
	CLR.B	25(A0)
	CLR.L	26(A0)
	CLR	30(A0)
	CLR.B	32(A0)
	MOVE.B	(A2),D3
	AND.L	#$F,D3
	ADD	D3,D3
	ADD	D3,D3
	MOVE.B	(A2)+,33(A0)
	MOVE.L	L60(PC),(A0)
	MOVE.L	L60(PC),52(A0)
	ADD.L	D6,52(A0)
	ADD.L	D3,52(A0)
	ADD.L	D7,(A0)
	ADD.L	D3,(A0)
	MOVE.L	#$C,4(A0)
	MOVE.L	(A0),A3
	MOVE.B	(A3),D1
	AND.L	#$FF,D1
	ADD	D1,D1
	ADD	D1,D1
	MOVE.L	L61(PC),A4
	MOVE.L	0(A4,D1.W),A4
	ADD.L	L6A(PC),A4
	MOVE.L	A4,34(A0)
	CLR.L	38(A0)
	MOVE.B	#2,42(A0)
	MOVE.B	1(A3),44(A0)
	CLR.B	43(A0)
	MOVE.B	2(A3),22(A0)
	CLR.B	40(A0)
	MOVE.B	3(A3),D1
	AND	#$F0,D1
	CMP	#$F0,D1
	BNE.S	L44
	MOVE.B	3(A3),D1
	AND.B	#$F,D1
	MOVE.B	D1,40(A0)
L44:	CLR.B	45(A0)
	CLR.L	56(A0)
	ADD.L	#$3C,A0
	DBF	D0,L43
	LEA	L59(PC),A0
	MOVE	#1,(A0)
	CLR	4(A0)
	LEA	L53(PC),A0
	SF	(A0)
	RTS
L45:	MOVEQ	#1,D1
	TST	D2
	BEQ	L46
	LEA	L5F(PC),A0
	LEA	L62(PC),A5
	MOVE.B	D2,8(A0)
	MOVE.B	D1,33(A0)
	CLR.B	22(A0)
	MOVEQ	#0,D5
	AND	#$FF,D0
	MOVE.L	L69(PC),A2
	ADD	D0,D0
	ADD	D0,D0
	MOVE.L	0(A2,D0.W),A2
	ADD.L	L67(PC),A2
	MOVE.L	D5,14(A0)
	MOVE.B	(A2),23(A0)
	MOVE.B	(A2)+,24(A0)
	MOVE.B	(A2)+,D0
	AND	#$FF,D0
	MOVE.B	(A2)+,27(A0)
	MOVEQ	#0,D2
	MOVE.B	#$40,46(A0)
	MOVE.B	(A2)+,D2
	MOVE.B	D2,28(A0)
	MOVE.B	D2,29(A0)
	MOVE.B	(A2)+,30(A0)
	MOVE.L	A2,10(A0)
	MOVE.L	L68(PC),A2
	ADD	D0,D0
	ADD	D0,D0
	MOVE.L	0(A2,D0.W),A2
	ADD.L	L67(PC),A2
	MOVE.L	A2,18(A0)
	MOVE.L	D5,48(A0)
	CLR.B	25(A0)
	CLR.B	26(A0)
	CLR.L	56(A0)
	CLR.B	31(A0)
	ADDQ	#1,D1
	MOVE	D1,4(A5)
L46:	RTS
L47:	MOVE	SR,-(A7)
	MOVE	#$2700,SR
	BSET	#5,$FFFFFA09.W
	BSET	#5,$FFFFFA0D.W
	BSET	#5,$FFFFFA15.W
	BCLR	#5,$FFFFFA11.W
	AND.B	#7,$FFFFFA1D.W
	LEA	L50(PC),A1
	MOVE.L	A1,$114.W
	MOVE.L	#$707FFFF,$FFFF8800.W
	MOVE.B	#$A,$FFFF8800.W
	MOVE	(A7)+,SR
	RTS
L48:	MOVE.L	A0,A1
	MOVE.L	28(A1),A1
	ADD.L	A0,A1
	CMP.L	#$4A4F4348,192(A1)
	BEQ.S	L49
	MOVE.L	#$4A4F4348,192(A1)
	MOVEM.L	A0/D0,-(A7)
	BSR	L4A
	MOVEM.L	(A7)+,A0/D0
L49:	RTS
L4A:	MOVE.L	A1,A0
	LEA	256(A0),A1
	MOVE.L	A1,A2
	MOVE.L	252(A0),D0
	SUB.L	#$100,D0
	ADD.L	D0,A2
L4B:	MOVE.B	(A1),D0
	CMP.B	#-1,D0
	BNE.S	L4C
	MOVE.B	#-$78,D0
	BRA.S	L4D
L4C:	EOR.B	#-$80,D0
	LSR.B	#4,D0
	AND	#$F,D0
	MOVE.B	L4E(PC,D0.W),D0
L4D:	MOVE.B	D0,(A1)+
	CMP.L	A2,A1
	BLE.S	L4B
	RTS
L4E:	DC.B	$00,$07,$09,$0A,$0B,$0C,$0C,$0D
	DC.B	$0D,$0D,$0E,$0E,$0E,$0F,$0F,$0F
L4F:	MOVE	SR,-(A7)
	MOVE	#$2700,SR
	AND.B	#$F,$FFFFFA1D.W
	MOVE	(A7)+,SR
	RTS
L50:	MOVE.B	L50(PC),$FFFF8802.W
L51	EQU	L50+2
	BMI.S	L52
	ADDQ	#1,L51
;	BCLR	#5,$FFFFFA11.W		;A DEGAGER
	RTE
L52:	PEA	(A0)
	LEA	L53(PC),A0
	SF	(A0)
	AND.B	#$F,$FFFFFA1D.W
;	BCLR	#5,$FFFFFA11.W		;A DEGAGER
	MOVE.L	(A7)+,A0
	RTE
L53:	DC.B	$00
L54:	DC.B	$00,$00,$00,$00,$00,$00,$00,$00,$00
L55:	DC.B	$01,$00,$00,$00,$00,$00,$00,$E1
L56:	DC.B	$00,$01,$02,$00
L57:
	DC.W	0,0
	DC.W	$101,0
	DC.W	$202,0
	DC.W	$303,0
	DC.W	$404,0
	DC.W	$505,0
	DC.W	$606,0
	DC.W	$707,-1
	DC.W	$808,0
	DC.W	$909,0
	DC.W	$A0A,0

L58:	DC.B	$00,$00,$00,$00
	DC.B	$02,$06,$22,$00,$0A,$0E,$26,$00
	DC.B	$12,$16,$2A,$00
L59:	DC.W	4
L5A:	DC.W	4
L5B:	DC.B	$FF,$00,$00,$01,$02,$03,$04,$05
	DC.B	$06,$07,$08,$09,$0A,$0B,$0F,$0F
	DC.B	$0F,$0F,$0F,$0F

L5C:	DCB.W	30,0
L5D:	DCB.W	30,0
L5E:	DCB.W	30,0
L5F:	DCB.W	30,0
L60:	DCB.W	2,0
L61:	DCB.W	2,0
L62:	DCB.W	2,0
L63:	DCB.W	2,0
L64:	DCB.W	2,0
L65:	DCB.W	2,0
L66:	DCB.W	2,0
L67:	DCB.W	2,0
L68:	DCB.W	2,0
L69:	DCB.W	2,0
L6A:	DCB.W	2,0
L6B:	DCB.W	2,0
L6C:	DCB.W	2,0
L6D:	DCB.W	2,0
L6E:	DCB.W	2,0
L6F:	DCB.W	3,0
L70:
	DC.W	$EEE
	DC.W	$E17,$D4D,$C8E,$BD9
	DC.W	$B2F,$A8E,$9F7,$967
	DC.W	$8E0,$861,$7E8,$777
	DC.W	$70B,$6A6,$647,$5EC
	DC.W	$597,$547,$4FB,$4B3
	DC.W	$470,$430,$3F4,$3BB
	DC.W	$385,$353,$323,$2F6
	DC.W	$2CB,$2A3,$27D,$259
	DC.W	$238,$218,$1FA,$1DD
	DC.W	$1C2,$1A9,$191,$17B
	DC.W	$165,$151,$13E,$12C
	DC.W	$11C,$10C,$FD,$EE
	DC.W	$E1,$D4,$C8,$BD
	DC.W	$B2,$A8,$9F,$96
	DC.W	$8E,$86,$7E,$77
	DC.W	$70,$6A,$64,$5E
	DC.W	$59,$54,$4F,$4B
	DC.W	$47,$43,$3F,$3B
	DC.W	$38,$35,$32,$2F
	DC.W	$2C,$2A,$27,$25
	DC.W	$23,$21,$1F,$1D
	DC.W	$1C,$1A,$19,$17
	DC.W	$16,$15,$13,$12
	DC.W	$11,$10,$F

L71:	DC.B	'COSO'

	DC.L	$40
	DC.L	$278,$50E
	DC.L	$516,$522
	DC.L	$528,$5B2

	DC.B	'TFMX'
	DC.W	$15,$15,0
	DC.W	0,$40,3,0
	DC.W	$16,0,0,0
	DC.W	0,0,0,0
	DC.W	$98,0,$AE,0
	DC.W	$C9,0,$CF,0
	DC.W	$F3,0,$10A,0
	DC.W	$118,0,$124,0
	DC.W	$130,0,$13C,0
	DC.W	$144,0,$152,0
	DC.W	$162,0,$193,0
	DC.W	$197,0,$1AB,0
	DC.W	$1B9,0,$1CB,0
	DC.W	$1DB,0,$21B,0
	DC.W	$226,0,$238,$E2E5
	DC.W	$93E6,$201E,$1C1A,$1816
	DC.W	$1412,$100E,$C0A,$806
	DC.W	$402,$E1,$E2E5,$93E6
	DC.W	$201E,$1C1A,$1816,$1E1C
	DC.W	$1A18,$1614,$1210,$E0C
	DC.W	$A08,$604,$200,$E1E2
	DC.W	$E602,$E0,$2E2,$E924
	DC.W	$E482,$A0B,$C0D,$E0E
	DC.W	$F0E,$D0C,$B0A,$908
	DC.W	$706,$504,$302,$100
	DC.W	$102,$304,$506,$7E0
	DC.W	$5E2,$E593,$E602,$4E4
	DC.W	$8100,$302,$E581,$8891
	DC.W	$8881,$8891,$8881,$E00C
	DC.W	$E2E6,$100E,$C0A,$806
	DC.W	$80A,$C0E,$10E1,$E2E6
	DC.W	1,$203,$405,$607
	DC.W	$E002,$E2E5,$91E6,4
	DC.W	$200,$E498,$CFE1,$E2E6
	DC.W	$201C,$1814,$100C,$804
	DC.W	$E1,$E2E5,$93E6,$200
	DC.W	$E001,$E2E5,$9381,$93E6
	DC.W	$200,$200,$200,$E001
	DC.W	$E2E6,$1011,$1213,$1415
	DC.W	$1617,$1819,$1A1B,$E002
	DC.W	$E2E6,$200,$E806,$200
	DC.W	$E806,$200,$E806,$200
	DC.W	$E806,$200,$E806,$200
	DC.W	$E806,$200,$E806,$200
	DC.W	$E806,$E593,$E68E,$A0E4
	DC.W	$8398,$E588,$8F81,$83E0
	DC.W	$2BE2,$E600,$E1E2,$E593
	DC.W	$E494,$1816,$1412,$10E4
	DC.W	$C0A,$806,$402,$E0
	DC.W	$2E2,$E598,$E607,$605
	DC.W	$403,$201,$E0,$4E2
	DC.W	$E593,$E61E,$E495,$201E
	DC.W	$1CE6,$1816,$1412,$E581
	DC.W	$E1E2,$E500,$E604,$608
	DC.W	$204,$608,$A0C,$E10
	DC.W	$E1E2,$E434,$59E5,$67E6
	DC.W	$8275,$69E5,$7562,$9375
	DC.W	$69E5,$4693,$7569,$3576
	DC.W	$9235,$4628,$9546,$9823
	DC.W	$45E4,$8675,$2894,$5623
	DC.W	$95E5,$3954,$6723,$4576
	DC.W	$2357,$6398,$4562,$3895
	DC.W	$4689,$3745,$9237,$56E0
	DC.W	$3E2,$E593,$E610,$E0C
	DC.W	$A08,$E001,$E2E5,$93E6
	DC.W	$1E20,$E594,$9241,$24E6
	DC.W	$804,$200,$E006,$E2E5
	DC.W	$38E6,$68E5,$3568,$9745
	DC.W	$6985,$4623,$9745,$6398
	DC.W	$4563,$9562,$3562,$8954
	DC.W	$6295,$4628,$7956,$3974
	DC.W	$5638,$6592,$7456,$2367
	DC.W	$3859,$4678,$9456,$4384
	DC.W	$5468,$9456,$2357,$6285
	DC.W	$9463,$98E0,$200,0
	DC.W	$2D0,0,$2F2,0
	DC.W	$318,0,$324,0
	DC.W	$32F,0,$349,0
	DC.W	$35C,0,$373,0
	DC.W	$381,0,$38E,0
	DC.W	$39B,0,$3B1,0
	DC.W	$3C1,0,$3FF,0
	DC.W	$408,0,$446,0
	DC.W	$461,0,$481,0
	DC.W	$494,0,$4AA,0
	DC.W	$4D1,0,$4F8,$100
	DC.W	0,$E,$F0F,$E0E
	DC.W	$D0D,$C0C,$B0B,$A0A
	DC.W	$909,$808,$707,$706
	DC.W	$605,$403,$201,$E1
	DC.W	$101,0,$D,$F0F
	DC.W	$E0E,$D0D,$C0C,$B0B
	DC.W	$A0A,$909,$808,$707
	DC.W	$606,$505,$404,$303
	DC.W	$202,$101,$E1,$102
	DC.W	0,$D,$F0F,$D00
	DC.W	$E1,$103,0,$10
	DC.W	$1010,$10E0,$602,$400
	DC.W	0,$D0F,$F0F,$E0E
	DC.W	$D0C,$B0A,$908,$706
	DC.W	$504,$302,$100,$E101
	DC.W	$505,$400,$D0E,$E0E
	DC.W	$E0E,$E0E,$D0D,$D0C
	DC.W	$E1,$206,0,$E
	DC.W	$F0E,$D0C,$B0A,$908
	DC.W	$706,$504,$302,$100
	DC.W	$E101,$700,0,$D0F
	DC.W	$F0D,$D0D,$A00,$E101
	DC.W	$800,0,$E0D,$C0B
	DC.W	$A07,$E1,$109,0
	DC.W	$F,$E0D,$C0B,$A00
	DC.W	$E102,$A00,0,$F0E
	DC.W	$D0C,$B0A,$908,$706
	DC.W	$504,$302,$100,$E102
	DC.W	$B00,0,$EE8,$240D
	DC.W	$A08,$604,$200,$E102
	DC.W	$C00,0,$F00,0
	DC.W	$F00,0,$F00,0
	DC.W	$F00,0,$F00,0
	DC.W	$F00,0,$F00,0
	DC.W	$F00,0,$F0E,$D0C
	DC.W	$B0A,$909,$808,$707
	DC.W	$606,$505,$404,$303
	DC.W	$202,$100,$E101,0
	DC.W	0,0,$E1,$20E
	DC.W	0,$F,$E0D,$C0B
	DC.W	$A0E,$D0C,$B0A,$90D
	DC.W	$C0B,$A09,$80C,$B0A
	DC.W	$908,$70B,$A09,$807
	DC.W	$60A,$908,$706,$509
	DC.W	$807,$605,$408,$706
	DC.W	$504,$307,$605,$403
	DC.W	$201,$E1,$10F,0
	DC.W	$D,$F0F,$E0E,$D0D
	DC.W	$C0C,$A0A,$808,$606
	DC.W	$404,$302,$100,$E101
	DC.W	$1002,$100,$D0F,$F0E
	DC.W	$E0D,$D0C,$C0B,$B0A
	DC.W	$A09,$908,$807,$706
	DC.W	$504,$302,$100,$E101
	DC.W	$1100,0,$D0F,$F0E
	DC.W	$D0C,$A08,$604,$201
	DC.W	$E1,$312,0,$F
	DC.W	$E0D,$C0B,$A09,$807
	DC.W	$605,$403,$201,$E1
	DC.W	$113,0,$D,$F0F
	DC.W	$E0E,$D0D,$C0C,$B0B
	DC.W	$A0A,$909,$808,$707
	DC.W	$606,$505,$404,$303
	DC.W	$202,$101,0,$E101
	DC.W	$1400,0,$D0F,$F0F
	DC.W	$E0E,$D0D,$C0C,$B0B
	DC.W	$A0A,$909,$808,$707
	DC.W	$606,$505,$404,$303
	DC.W	$202,$101,$E1,$315
	DC.W	0,$F,$E0D,$C0B
	DC.W	$A09,$807,$605,$403
	DC.W	$201,$E1,0,$512
	DC.W	$FD1F,$FF00,0,0
	DC.W	0,0,0,0
	DC.W	0,0,3,$13
	DC.W	0,$B,1,$4A
	DC.W	2,$30,3,$1B
	DC.W	4,$38,5,$43
	DC.W	6,$16,7,$30
	DC.W	8,$16,9,$10
	DC.W	$A,$33,$B,$4D
	DC.W	$C,7,$D,$1A
	DC.W	$E,$15,$F,3
	DC.W	$10,$1B,$11,$31
	DC.W	$12,$F,$13,1
	DC.W	$14,$1F,$15,0
	DC.W	0,0,0,0
MUZAK1:	INCBIN	MAD18.MUS
MUZAK2:	INCBIN	MAD26.MUS
MUZAK3:	INCBIN	MAD34.MUS
MUZAK4:	INCBIN	MAD42.MUS
MUZAK5:	INCBIN	MAD50.MUS
