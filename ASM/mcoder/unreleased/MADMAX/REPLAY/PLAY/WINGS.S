BASE=$40000
	MOVE	SR,D0
	AND	#$2000,D0
	BNE.S	SUPER
	CLR.L	-(SP)
	MOVE	#$20,-(SP)
	TRAP	#1
	ADDQ	#6,SP
SUPER:
	MOVEQ	#0,D0
	MOVE.L	D0,A0
	MOVEP.L	D0,$FFFFFA01(A0)
	MOVEP.L	D0,$FFFFFA09(A0)
	MOVEP.L	D0,$FFFFFA11(A0)
	MOVEP.L	D0,$FFFFFA19(A0)
	MOVE.B	#$40,$FFFFFA17.W

	MOVEQ	#1,D0
	JSR	BASE+8		;MODE NORMAL

	MOVEQ	#1,D0
	JSR	BASE+0		;MUSIQUE 1
BCL:
	MOVE	#37,-(SP)
	TRAP	#14
	ADDQ	#2,SP
	JSR	BASE+4		;PLAY MUS
	BRA	BCL
