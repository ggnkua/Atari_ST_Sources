 THIS IS THE CONTRIBUTION OF MCODER TO THIS DEMO-DISK.
 CREDITS FOR THIS DEMO : CODE BY MCODER, MUZAK BY MAD MAX
 AND OBJECTS SAVAGELY RIPPED FROM THE WILD COPPER DEMO.
 GREETINGS TO : THE CAREBEARS (WAITING ANXIOUSLY YOUR DEMO),
 THE LOST BOYS (WAITING ANXIOUSLY ETC...),
 ALGERNON (YOU HAVE GREAT IDEAS !),
 ZIGGY STARDUST (GOOD/FAST CODER AND EVEN GREATER IDEAS),
 ILLEGAL (THANK YOU FOR THE GREAT WORK),
 CKAOS FROM HMD
 (GREAT FULLSCREEN-MEGASCROLLER-MEGADISTER-SOUNDTRACK-PLUS-LOTSA-MORE,
 SORRY YOU'LL STOP CODING),
 SKYRACE FROM HMD (WHEN YOU'LL GET OLDER, YOU'LL GET STRONGER),
 THE SERGEANT (DON'T FORGET TO INVITE ME TO YOUR NEXT DEMO-PARTY !!!),
 DOM FROM THE REPLICANTS (WHAT ABOUT YOUR PROTECTION ?),
 THE OVERLANDERS (ESPECIALLY ADSO -COOL SCREEN, GUY-),
 ST CONNEXION (ALWAYS WAITING FOR YOUR MEGA-LATE-MEGADEMO,
 CRAZY REX IS VERY GOOD -ARRRRGGGH-),
 AND THAT'S ALL FOR THIS TIME.
 OK, NOW A PERSONAL MESSAGE TO NICK OF THE CAREBEARS
 (DON'T LOOK FORWARD, REPLICANTS !):
 DO YOU REMEMBER MY DISKS WITH THE LAME DEMOS ?
 YOU WROTE ME BACK AND SEND ME A DISK WITH GREAT STUFF WHERE YOU
 WROTE 'DON'T DEBUG JEAN'. I'LL SURELY SEND YOU MY LAST WORK
 IN SOME DAYS/MONTHS UNLESS YOU WRITE TO ME BEFORE
 (I'VE ALWAYS THE BEST TECHNIQUE TO DISPLAY REAL-TIME SHIFTED SPRITES
 !!!).
                                              
