	opt	l2
	XDEF	Cylindre
	include	define.s

Cylindre:	dc.l	P_cylindre0
	dc.l	P_cylindre1
	dc.l	P_cylindre2
	dc.l	P_cylindre3
	dc.l	P_cylindre4
	dc.l	P_cylindre5
	dc.l	P_cylindre6
	dc.l	P_cylindre7
	dc.l	P_cylindre8
	dc.l	P_cylindre9
	dc.l	P_cylindre10
	dc.l	P_cylindre11
	dc.l	P_cylindre12
	dc.l	P_cylindre13
	dc.l	P_cylindre14
	dc.l	P_cylindre15
	dc.l	P_cylindre16
	dc.l	P_cylindre17
	dc.l	P_cylindre18
	dc.l	P_cylindre19
	dc.l	P_cylindre20
	dc.l	P_cylindre21
	dc.l	P_cylindre22
	dc.l	P_cylindre23
	dc.l	P_cylindre24
	dc.l	P_cylindre25
	dc.l	P_cylindre26
	dc.l	P_cylindre27
	dc.l	P_cylindre28
	dc.l	P_cylindre29
	dc.l	P_cylindre30
	dc.l	P_cylindre31
	dc.l	P_cylindre32
	dc.l	P_cylindre33
	dc.l	P_cylindre34
	dc.l	P_cylindre35
	dc.l	P_cylindre36
	dc.l	P_cylindre37
	dc.l	P_cylindre38
	dc.l	P_cylindre39
	dc.l	P_cylindre40
	dc.l	P_cylindre41
	dc.l	P_cylindre42
	dc.l	P_cylindre43
	dc.l	P_cylindre44
	dc.l	P_cylindre45
	dc.l	P_cylindre46
	dc.l	P_cylindre47
	dc.l	P_cylindre48
	dc.l	P_cylindre49
	dc.l	P_cylindre50
	dc.l	P_cylindre51
	dc.l	P_cylindre52
	dc.l	P_cylindre53
	dc.l	P_cylindre54
	dc.l	P_cylindre55
	dc.l	P_cylindre56
	dc.l	P_cylindre57
	dc.l	P_cylindre58
	dc.l	P_cylindre59
	dc.l	P_cylindre60
	dc.l	P_cylindre61
	dc.l	P_cylindre62
	dc.l	P_cylindre63
	dc.l	P_cylindre64
	dc.l	P_cylindre65
	dc.l	P_cylindre66
	dc.l	P_cylindre67
	dc.l	P_cylindre68
	dc.l	P_cylindre69
	dc.l	P_cylindre70
	dc.l	P_cylindre71
	dc.l	P_cylindre72
	dc.l	P_cylindre73
	dc.l	P_cylindre74
	dc.l	P_cylindre75
	dc.l	P_cylindre76
	dc.l	P_cylindre77
	dc.l	P_cylindre78
	dc.l	P_cylindre79
	dc.l	P_cylindre80
	dc.l	P_cylindre81
	dc.l	P_cylindre82
	dc.l	P_cylindre83
	dc.l	P_cylindre84
	dc.l	P_cylindre85
	dc.l	P_cylindre86
	dc.l	P_cylindre87
	dc.l	P_cylindre88
	dc.l	P_cylindre89
	dc.l	P_cylindre90
	dc.l	P_cylindre91
	dc.l	P_cylindre92
	dc.l	P_cylindre93
	dc.l	P_cylindre94
	dc.l	P_cylindre95
	dc.l	P_cylindre96
	dc.l	P_cylindre97
	dc.l	P_cylindre98
	dc.l	P_cylindre99
	dc.l	P_cylindre100
	dc.l	P_cylindre101
	dc.l	P_cylindre102
	dc.l	P_cylindre103
	dc.l	P_cylindre104
	dc.l	P_cylindre105
	dc.l	P_cylindre106
	dc.l	P_cylindre107
	dc.l	P_cylindre108
	dc.l	P_cylindre109
	dc.l	P_cylindre110
	dc.l	P_cylindre111
	dc.l	P_cylindre112
	dc.l	P_cylindre113
	dc.l	P_cylindre114
	dc.l	P_cylindre115
	dc.l	P_cylindre116
	dc.l	P_cylindre117
	dc.l	P_cylindre118
	dc.l	P_cylindre119
	dc.l	P_cylindre120
	dc.l	P_cylindre121
	dc.l	P_cylindre122
	dc.l	P_cylindre123
	dc.l	P_cylindre124
	dc.l	P_cylindre125
	dc.l	P_cylindre126
	dc.l	P_cylindre127
	dc.l	0
	dc.l	Cylindre

F_cylindre:	VERTICES	0,4,5,1,-1,-1,-1,-1
	COLOR	1
	dc.l	0
	VERTICES	1,5,6,2,-1,-1,-1,-1
	COLOR	2
	dc.l	0
	VERTICES	2,6,7,3,-1,-1,-1,-1
	COLOR	1
	dc.l	0
	VERTICES	3,7,4,0,-1,-1,-1,-1
	COLOR	2
	dc.l	0

	VERTICES	4,8,9,5,-1,-1,-1,-1
	COLOR	2
	dc.l	0
	VERTICES	5,9,10,6,-1,-1,-1,-1
	COLOR	1
	dc.l	0
	VERTICES	6,10,11,7,-1,-1,-1,-1
	COLOR	2
	dc.l	0
	VERTICES	7,11,8,4,-1,-1,-1,-1
	COLOR	1
	dc.l	0

	VERTICES	8,12,13,9,-1,-1,-1,-1
	COLOR	1
	dc.l	0
	VERTICES	9,13,14,10,-1,-1,-1,-1
	COLOR	2
	dc.l	0
	VERTICES	10,14,15,11,-1,-1,-1,-1
	COLOR	1
	dc.l	0
	VERTICES	11,15,12,8,-1,-1,-1,-1
	COLOR	2
	dc.l	0

	VERTICES	12,16,17,13,-1,-1,-1,-1
	COLOR	2
	dc.l	0
	VERTICES	13,17,18,14,-1,-1,-1,-1
	COLOR	1
	dc.l	0
	VERTICES	14,18,19,15,-1,-1,-1,-1
	COLOR	2
	dc.l	0
	VERTICES	15,19,16,12,-1,-1,-1,-1
	COLOR	1
	dc.l	0

	VERTICES	16,20,21,17,-1,-1,-1,-1
	COLOR	1
	dc.l	0
	VERTICES	17,21,22,18,-1,-1,-1,-1
	COLOR	2
	dc.l	0
	VERTICES	18,22,23,19,-1,-1,-1,-1
	COLOR	1
	dc.l	0
	VERTICES	19,23,20,16,-1,-1,-1,-1
	COLOR	2
	dc.l	0

	VERTICES	20,24,25,21,-1,-1,-1,-1
	COLOR	2
	dc.l	0
	VERTICES	21,25,26,22,-1,-1,-1,-1
	COLOR	1
	dc.l	0
	VERTICES	22,26,27,23,-1,-1,-1,-1
	COLOR	2
	dc.l	0
	VERTICES	23,27,24,20,-1,-1,-1,-1
	COLOR	1
	dc.l	0

	VERTICES	0,1,2,3,-1,-1,-1,-1
	COLOR	3
	dc.l	0
	VERTICES	27,26,25,24,-1,-1,-1,-1
	COLOR	4
	dc.l	0
	dc.w	-1
	
P_cylindre0:	dc.w	27
	dc.w	+$00,-$0B,-$3C
	dc.w	-$0B,+$00,-$3C
	dc.w	+$00,+$0B,-$3C
	dc.w	+$0B,+$00,-$3C
	dc.w	+$00,-$19,-$16
	dc.w	-$19,+$00,-$16
	dc.w	+$00,+$19,-$16
	dc.w	+$19,+$00,-$16
	dc.w	+$00,-$1C,+$0C
	dc.w	-$1C,+$00,+$0C
	dc.w	+$00,+$1C,+$0C
	dc.w	+$1C,+$00,+$0C
	dc.w	+$00,-$10,+$2B
	dc.w	-$10,+$00,+$2B
	dc.w	+$00,+$10,+$2B
	dc.w	+$10,+$00,+$2B
	dc.w	+$00,-$0A,+$45
	dc.w	-$0A,+$00,+$45
	dc.w	+$00,+$0A,+$45
	dc.w	+$0A,+$00,+$45
	dc.w	+$00,-$0C,+$59
	dc.w	-$0C,+$00,+$59
	dc.w	+$00,+$0C,+$59
	dc.w	+$0C,+$00,+$59
	dc.w	+$00,-$11,+$67
	dc.w	-$11,+$00,+$67
	dc.w	+$00,+$11,+$67
	dc.w	+$11,+$00,+$67
	dc.l	F_cylindre

P_cylindre1:	dc.w	27
	dc.w	+$00,-$0C,-$39
	dc.w	-$0C,+$00,-$39
	dc.w	+$00,+$0C,-$39
	dc.w	+$0C,+$00,-$39
	dc.w	+$00,-$1A,-$14
	dc.w	-$1A,+$00,-$14
	dc.w	+$00,+$1A,-$14
	dc.w	+$1A,+$00,-$14
	dc.w	+$00,-$1B,+$0D
	dc.w	-$1B,+$00,+$0D
	dc.w	+$00,+$1B,+$0D
	dc.w	+$1B,+$00,+$0D
	dc.w	+$00,-$0F,+$2C
	dc.w	-$0F,+$00,+$2C
	dc.w	+$00,+$0F,+$2C
	dc.w	+$0F,+$00,+$2C
	dc.w	+$00,-$0A,+$45
	dc.w	-$0A,+$00,+$45
	dc.w	+$00,+$0A,+$45
	dc.w	+$0A,+$00,+$45
	dc.w	+$00,-$0C,+$58
	dc.w	-$0C,+$00,+$58
	dc.w	+$00,+$0C,+$58
	dc.w	+$0C,+$00,+$58
	dc.w	+$00,-$11,+$66
	dc.w	-$11,+$00,+$66
	dc.w	+$00,+$11,+$66
	dc.w	+$11,+$00,+$66
	dc.l	F_cylindre

P_cylindre2:	dc.w	27
	dc.w	+$00,-$0D,-$37
	dc.w	-$0D,+$00,-$37
	dc.w	+$00,+$0D,-$37
	dc.w	+$0D,+$00,-$37
	dc.w	+$00,-$1B,-$12
	dc.w	-$1B,+$00,-$12
	dc.w	+$00,+$1B,-$12
	dc.w	+$1B,+$00,-$12
	dc.w	+$00,-$1B,+$0F
	dc.w	-$1B,+$00,+$0F
	dc.w	+$00,+$1B,+$0F
	dc.w	+$1B,+$00,+$0F
	dc.w	+$00,-$0F,+$2D
	dc.w	-$0F,+$00,+$2D
	dc.w	+$00,+$0F,+$2D
	dc.w	+$0F,+$00,+$2D
	dc.w	+$00,-$0A,+$45
	dc.w	-$0A,+$00,+$45
	dc.w	+$00,+$0A,+$45
	dc.w	+$0A,+$00,+$45
	dc.w	+$00,-$0D,+$58
	dc.w	-$0D,+$00,+$58
	dc.w	+$00,+$0D,+$58
	dc.w	+$0D,+$00,+$58
	dc.w	+$00,-$11,+$64
	dc.w	-$11,+$00,+$64
	dc.w	+$00,+$11,+$64
	dc.w	+$11,+$00,+$64
	dc.l	F_cylindre

P_cylindre3:	dc.w	27
	dc.w	+$00,-$0E,-$34
	dc.w	-$0E,+$00,-$34
	dc.w	+$00,+$0E,-$34
	dc.w	+$0E,+$00,-$34
	dc.w	+$00,-$1C,-$10
	dc.w	-$1C,+$00,-$10
	dc.w	+$00,+$1C,-$10
	dc.w	+$1C,+$00,-$10
	dc.w	+$00,-$1A,+$11
	dc.w	-$1A,+$00,+$11
	dc.w	+$00,+$1A,+$11
	dc.w	+$1A,+$00,+$11
	dc.w	+$00,-$0E,+$2E
	dc.w	-$0E,+$00,+$2E
	dc.w	+$00,+$0E,+$2E
	dc.w	+$0E,+$00,+$2E
	dc.w	+$00,-$0A,+$45
	dc.w	-$0A,+$00,+$45
	dc.w	+$00,+$0A,+$45
	dc.w	+$0A,+$00,+$45
	dc.w	+$00,-$0D,+$57
	dc.w	-$0D,+$00,+$57
	dc.w	+$00,+$0D,+$57
	dc.w	+$0D,+$00,+$57
	dc.w	+$00,-$11,+$63
	dc.w	-$11,+$00,+$63
	dc.w	+$00,+$11,+$63
	dc.w	+$11,+$00,+$63
	dc.l	F_cylindre

P_cylindre4:	dc.w	27
	dc.w	+$00,-$0F,-$32
	dc.w	-$0F,+$00,-$32
	dc.w	+$00,+$0F,-$32
	dc.w	+$0F,+$00,-$32
	dc.w	+$00,-$1D,-$0E
	dc.w	-$1D,+$00,-$0E
	dc.w	+$00,+$1D,-$0E
	dc.w	+$1D,+$00,-$0E
	dc.w	+$00,-$19,+$12
	dc.w	-$19,+$00,+$12
	dc.w	+$00,+$19,+$12
	dc.w	+$19,+$00,+$12
	dc.w	+$00,-$0D,+$2F
	dc.w	-$0D,+$00,+$2F
	dc.w	+$00,+$0D,+$2F
	dc.w	+$0D,+$00,+$2F
	dc.w	+$00,-$0A,+$45
	dc.w	-$0A,+$00,+$45
	dc.w	+$00,+$0A,+$45
	dc.w	+$0A,+$00,+$45
	dc.w	+$00,-$0D,+$56
	dc.w	-$0D,+$00,+$56
	dc.w	+$00,+$0D,+$56
	dc.w	+$0D,+$00,+$56
	dc.w	+$00,-$11,+$61
	dc.w	-$11,+$00,+$61
	dc.w	+$00,+$11,+$61
	dc.w	+$11,+$00,+$61
	dc.l	F_cylindre

P_cylindre5:	dc.w	27
	dc.w	+$00,-$11,-$2F
	dc.w	-$11,+$00,-$2F
	dc.w	+$00,+$11,-$2F
	dc.w	+$11,+$00,-$2F
	dc.w	+$00,-$1D,-$0B
	dc.w	-$1D,+$00,-$0B
	dc.w	+$00,+$1D,-$0B
	dc.w	+$1D,+$00,-$0B
	dc.w	+$00,-$18,+$14
	dc.w	-$18,+$00,+$14
	dc.w	+$00,+$18,+$14
	dc.w	+$18,+$00,+$14
	dc.w	+$00,-$0D,+$30
	dc.w	-$0D,+$00,+$30
	dc.w	+$00,+$0D,+$30
	dc.w	+$0D,+$00,+$30
	dc.w	+$00,-$0A,+$45
	dc.w	-$0A,+$00,+$45
	dc.w	+$00,+$0A,+$45
	dc.w	+$0A,+$00,+$45
	dc.w	+$00,-$0D,+$55
	dc.w	-$0D,+$00,+$55
	dc.w	+$00,+$0D,+$55
	dc.w	+$0D,+$00,+$55
	dc.w	+$00,-$11,+$5F
	dc.w	-$11,+$00,+$5F
	dc.w	+$00,+$11,+$5F
	dc.w	+$11,+$00,+$5F
	dc.l	F_cylindre

P_cylindre6:	dc.w	27
	dc.w	+$00,-$12,-$2D
	dc.w	-$12,+$00,-$2D
	dc.w	+$00,+$12,-$2D
	dc.w	+$12,+$00,-$2D
	dc.w	+$00,-$1D,-$09
	dc.w	-$1D,+$00,-$09
	dc.w	+$00,+$1D,-$09
	dc.w	+$1D,+$00,-$09
	dc.w	+$00,-$17,+$15
	dc.w	-$17,+$00,+$15
	dc.w	+$00,+$17,+$15
	dc.w	+$17,+$00,+$15
	dc.w	+$00,-$0C,+$30
	dc.w	-$0C,+$00,+$30
	dc.w	+$00,+$0C,+$30
	dc.w	+$0C,+$00,+$30
	dc.w	+$00,-$0A,+$45
	dc.w	-$0A,+$00,+$45
	dc.w	+$00,+$0A,+$45
	dc.w	+$0A,+$00,+$45
	dc.w	+$00,-$0D,+$54
	dc.w	-$0D,+$00,+$54
	dc.w	+$00,+$0D,+$54
	dc.w	+$0D,+$00,+$54
	dc.w	+$00,-$10,+$5E
	dc.w	-$10,+$00,+$5E
	dc.w	+$00,+$10,+$5E
	dc.w	+$10,+$00,+$5E
	dc.l	F_cylindre

P_cylindre7:	dc.w	27
	dc.w	+$00,-$14,-$2B
	dc.w	-$14,+$00,-$2B
	dc.w	+$00,+$14,-$2B
	dc.w	+$14,+$00,-$2B
	dc.w	+$00,-$1D,-$08
	dc.w	-$1D,+$00,-$08
	dc.w	+$00,+$1D,-$08
	dc.w	+$1D,+$00,-$08
	dc.w	+$00,-$16,+$17
	dc.w	-$16,+$00,+$17
	dc.w	+$00,+$16,+$17
	dc.w	+$16,+$00,+$17
	dc.w	+$00,-$0C,+$31
	dc.w	-$0C,+$00,+$31
	dc.w	+$00,+$0C,+$31
	dc.w	+$0C,+$00,+$31
	dc.w	+$00,-$0A,+$45
	dc.w	-$0A,+$00,+$45
	dc.w	+$00,+$0A,+$45
	dc.w	+$0A,+$00,+$45
	dc.w	+$00,-$0D,+$53
	dc.w	-$0D,+$00,+$53
	dc.w	+$00,+$0D,+$53
	dc.w	+$0D,+$00,+$53
	dc.w	+$00,-$10,+$5C
	dc.w	-$10,+$00,+$5C
	dc.w	+$00,+$10,+$5C
	dc.w	+$10,+$00,+$5C
	dc.l	F_cylindre

P_cylindre8:	dc.w	27
	dc.w	+$00,-$15,-$28
	dc.w	-$15,+$00,-$28
	dc.w	+$00,+$15,-$28
	dc.w	+$15,+$00,-$28
	dc.w	+$00,-$1D,-$06
	dc.w	-$1D,+$00,-$06
	dc.w	+$00,+$1D,-$06
	dc.w	+$1D,+$00,-$06
	dc.w	+$00,-$15,+$18
	dc.w	-$15,+$00,+$18
	dc.w	+$00,+$15,+$18
	dc.w	+$15,+$00,+$18
	dc.w	+$00,-$0B,+$31
	dc.w	-$0B,+$00,+$31
	dc.w	+$00,+$0B,+$31
	dc.w	+$0B,+$00,+$31
	dc.w	+$00,-$0A,+$44
	dc.w	-$0A,+$00,+$44
	dc.w	+$00,+$0A,+$44
	dc.w	+$0A,+$00,+$44
	dc.w	+$00,-$0D,+$52
	dc.w	-$0D,+$00,+$52
	dc.w	+$00,+$0D,+$52
	dc.w	+$0D,+$00,+$52
	dc.w	+$00,-$10,+$5A
	dc.w	-$10,+$00,+$5A
	dc.w	+$00,+$10,+$5A
	dc.w	+$10,+$00,+$5A
	dc.l	F_cylindre

P_cylindre9:	dc.w	27
	dc.w	+$00,-$17,-$26
	dc.w	-$17,+$00,-$26
	dc.w	+$00,+$17,-$26
	dc.w	+$17,+$00,-$26
	dc.w	+$00,-$1D,-$04
	dc.w	-$1D,+$00,-$04
	dc.w	+$00,+$1D,-$04
	dc.w	+$1D,+$00,-$04
	dc.w	+$00,-$14,+$19
	dc.w	-$14,+$00,+$19
	dc.w	+$00,+$14,+$19
	dc.w	+$14,+$00,+$19
	dc.w	+$00,-$0B,+$31
	dc.w	-$0B,+$00,+$31
	dc.w	+$00,+$0B,+$31
	dc.w	+$0B,+$00,+$31
	dc.w	+$00,-$0A,+$44
	dc.w	-$0A,+$00,+$44
	dc.w	+$00,+$0A,+$44
	dc.w	+$0A,+$00,+$44
	dc.w	+$00,-$0D,+$50
	dc.w	-$0D,+$00,+$50
	dc.w	+$00,+$0D,+$50
	dc.w	+$0D,+$00,+$50
	dc.w	+$00,-$0F,+$58
	dc.w	-$0F,+$00,+$58
	dc.w	+$00,+$0F,+$58
	dc.w	+$0F,+$00,+$58
	dc.l	F_cylindre

P_cylindre10:	dc.w	27
	dc.w	+$00,-$18,-$24
	dc.w	-$18,+$00,-$24
	dc.w	+$00,+$18,-$24
	dc.w	+$18,+$00,-$24
	dc.w	+$00,-$1D,-$02
	dc.w	-$1D,+$00,-$02
	dc.w	+$00,+$1D,-$02
	dc.w	+$1D,+$00,-$02
	dc.w	+$00,-$13,+$1A
	dc.w	-$13,+$00,+$1A
	dc.w	+$00,+$13,+$1A
	dc.w	+$13,+$00,+$1A
	dc.w	+$00,-$0B,+$31
	dc.w	-$0B,+$00,+$31
	dc.w	+$00,+$0B,+$31
	dc.w	+$0B,+$00,+$31
	dc.w	+$00,-$0A,+$43
	dc.w	-$0A,+$00,+$43
	dc.w	+$00,+$0A,+$43
	dc.w	+$0A,+$00,+$43
	dc.w	+$00,-$0D,+$4F
	dc.w	-$0D,+$00,+$4F
	dc.w	+$00,+$0D,+$4F
	dc.w	+$0D,+$00,+$4F
	dc.w	+$00,-$0F,+$56
	dc.w	-$0F,+$00,+$56
	dc.w	+$00,+$0F,+$56
	dc.w	+$0F,+$00,+$56
	dc.l	F_cylindre

P_cylindre11:	dc.w	27
	dc.w	+$00,-$19,-$22
	dc.w	-$19,+$00,-$22
	dc.w	+$00,+$19,-$22
	dc.w	+$19,+$00,-$22
	dc.w	+$00,-$1C,-$01
	dc.w	-$1C,+$00,-$01
	dc.w	+$00,+$1C,-$01
	dc.w	+$1C,+$00,-$01
	dc.w	+$00,-$12,+$1B
	dc.w	-$12,+$00,+$1B
	dc.w	+$00,+$12,+$1B
	dc.w	+$12,+$00,+$1B
	dc.w	+$00,-$0A,+$31
	dc.w	-$0A,+$00,+$31
	dc.w	+$00,+$0A,+$31
	dc.w	+$0A,+$00,+$31
	dc.w	+$00,-$0A,+$42
	dc.w	-$0A,+$00,+$42
	dc.w	+$00,+$0A,+$42
	dc.w	+$0A,+$00,+$42
	dc.w	+$00,-$0C,+$4D
	dc.w	-$0C,+$00,+$4D
	dc.w	+$00,+$0C,+$4D
	dc.w	+$0C,+$00,+$4D
	dc.w	+$00,-$0F,+$54
	dc.w	-$0F,+$00,+$54
	dc.w	+$00,+$0F,+$54
	dc.w	+$0F,+$00,+$54
	dc.l	F_cylindre

P_cylindre12:	dc.w	27
	dc.w	+$00,-$1A,-$20
	dc.w	-$1A,+$00,-$20
	dc.w	+$00,+$1A,-$20
	dc.w	+$1A,+$00,-$20
	dc.w	+$00,-$1C,+$00
	dc.w	-$1C,+$00,+$00
	dc.w	+$00,+$1C,+$00
	dc.w	+$1C,+$00,+$00
	dc.w	+$00,-$11,+$1C
	dc.w	-$11,+$00,+$1C
	dc.w	+$00,+$11,+$1C
	dc.w	+$11,+$00,+$1C
	dc.w	+$00,-$0A,+$31
	dc.w	-$0A,+$00,+$31
	dc.w	+$00,+$0A,+$31
	dc.w	+$0A,+$00,+$31
	dc.w	+$00,-$0A,+$41
	dc.w	-$0A,+$00,+$41
	dc.w	+$00,+$0A,+$41
	dc.w	+$0A,+$00,+$41
	dc.w	+$00,-$0C,+$4C
	dc.w	-$0C,+$00,+$4C
	dc.w	+$00,+$0C,+$4C
	dc.w	+$0C,+$00,+$4C
	dc.w	+$00,-$0E,+$52
	dc.w	-$0E,+$00,+$52
	dc.w	+$00,+$0E,+$52
	dc.w	+$0E,+$00,+$52
	dc.l	F_cylindre

P_cylindre13:	dc.w	27
	dc.w	+$00,-$1B,-$1E
	dc.w	-$1B,+$00,-$1E
	dc.w	+$00,+$1B,-$1E
	dc.w	+$1B,+$00,-$1E
	dc.w	+$00,-$1B,+$01
	dc.w	-$1B,+$00,+$01
	dc.w	+$00,+$1B,+$01
	dc.w	+$1B,+$00,+$01
	dc.w	+$00,-$10,+$1C
	dc.w	-$10,+$00,+$1C
	dc.w	+$00,+$10,+$1C
	dc.w	+$10,+$00,+$1C
	dc.w	+$00,-$0A,+$31
	dc.w	-$0A,+$00,+$31
	dc.w	+$00,+$0A,+$31
	dc.w	+$0A,+$00,+$31
	dc.w	+$00,-$0A,+$40
	dc.w	-$0A,+$00,+$40
	dc.w	+$00,+$0A,+$40
	dc.w	+$0A,+$00,+$40
	dc.w	+$00,-$0C,+$4A
	dc.w	-$0C,+$00,+$4A
	dc.w	+$00,+$0C,+$4A
	dc.w	+$0C,+$00,+$4A
	dc.w	+$00,-$0E,+$4F
	dc.w	-$0E,+$00,+$4F
	dc.w	+$00,+$0E,+$4F
	dc.w	+$0E,+$00,+$4F
	dc.l	F_cylindre

P_cylindre14:	dc.w	27
	dc.w	+$00,-$1C,-$1C
	dc.w	-$1C,+$00,-$1C
	dc.w	+$00,+$1C,-$1C
	dc.w	+$1C,+$00,-$1C
	dc.w	+$00,-$1A,+$03
	dc.w	-$1A,+$00,+$03
	dc.w	+$00,+$1A,+$03
	dc.w	+$1A,+$00,+$03
	dc.w	+$00,-$10,+$1D
	dc.w	-$10,+$00,+$1D
	dc.w	+$00,+$10,+$1D
	dc.w	+$10,+$00,+$1D
	dc.w	+$00,-$0A,+$31
	dc.w	-$0A,+$00,+$31
	dc.w	+$00,+$0A,+$31
	dc.w	+$0A,+$00,+$31
	dc.w	+$00,-$0A,+$3F
	dc.w	-$0A,+$00,+$3F
	dc.w	+$00,+$0A,+$3F
	dc.w	+$0A,+$00,+$3F
	dc.w	+$00,-$0C,+$48
	dc.w	-$0C,+$00,+$48
	dc.w	+$00,+$0C,+$48
	dc.w	+$0C,+$00,+$48
	dc.w	+$00,-$0E,+$4D
	dc.w	-$0E,+$00,+$4D
	dc.w	+$00,+$0E,+$4D
	dc.w	+$0E,+$00,+$4D
	dc.l	F_cylindre

P_cylindre15:	dc.w	27
	dc.w	+$00,-$1D,-$1A
	dc.w	-$1D,+$00,-$1A
	dc.w	+$00,+$1D,-$1A
	dc.w	+$1D,+$00,-$1A
	dc.w	+$00,-$1A,+$04
	dc.w	-$1A,+$00,+$04
	dc.w	+$00,+$1A,+$04
	dc.w	+$1A,+$00,+$04
	dc.w	+$00,-$0F,+$1D
	dc.w	-$0F,+$00,+$1D
	dc.w	+$00,+$0F,+$1D
	dc.w	+$0F,+$00,+$1D
	dc.w	+$00,-$0A,+$30
	dc.w	-$0A,+$00,+$30
	dc.w	+$00,+$0A,+$30
	dc.w	+$0A,+$00,+$30
	dc.w	+$00,-$0A,+$3E
	dc.w	-$0A,+$00,+$3E
	dc.w	+$00,+$0A,+$3E
	dc.w	+$0A,+$00,+$3E
	dc.w	+$00,-$0C,+$46
	dc.w	-$0C,+$00,+$46
	dc.w	+$00,+$0C,+$46
	dc.w	+$0C,+$00,+$46
	dc.w	+$00,-$0D,+$4B
	dc.w	-$0D,+$00,+$4B
	dc.w	+$00,+$0D,+$4B
	dc.w	+$0D,+$00,+$4B
	dc.l	F_cylindre

P_cylindre16:	dc.w	27
	dc.w	+$00,-$1D,-$18
	dc.w	-$1D,+$00,-$18
	dc.w	+$00,+$1D,-$18
	dc.w	+$1D,+$00,-$18
	dc.w	+$00,-$19,+$05
	dc.w	-$19,+$00,+$05
	dc.w	+$00,+$19,+$05
	dc.w	+$19,+$00,+$05
	dc.w	+$00,-$0F,+$1D
	dc.w	-$0F,+$00,+$1D
	dc.w	+$00,+$0F,+$1D
	dc.w	+$0F,+$00,+$1D
	dc.w	+$00,-$0A,+$30
	dc.w	-$0A,+$00,+$30
	dc.w	+$00,+$0A,+$30
	dc.w	+$0A,+$00,+$30
	dc.w	+$00,-$0A,+$3C
	dc.w	-$0A,+$00,+$3C
	dc.w	+$00,+$0A,+$3C
	dc.w	+$0A,+$00,+$3C
	dc.w	+$00,-$0B,+$44
	dc.w	-$0B,+$00,+$44
	dc.w	+$00,+$0B,+$44
	dc.w	+$0B,+$00,+$44
	dc.w	+$00,-$0D,+$48
	dc.w	-$0D,+$00,+$48
	dc.w	+$00,+$0D,+$48
	dc.w	+$0D,+$00,+$48
	dc.l	F_cylindre

P_cylindre17:	dc.w	27
	dc.w	+$00,-$1D,-$16
	dc.w	-$1D,+$00,-$16
	dc.w	+$00,+$1D,-$16
	dc.w	+$1D,+$00,-$16
	dc.w	+$00,-$18,+$06
	dc.w	-$18,+$00,+$06
	dc.w	+$00,+$18,+$06
	dc.w	+$18,+$00,+$06
	dc.w	+$00,-$0E,+$1D
	dc.w	-$0E,+$00,+$1D
	dc.w	+$00,+$0E,+$1D
	dc.w	+$0E,+$00,+$1D
	dc.w	+$00,-$0A,+$2F
	dc.w	-$0A,+$00,+$2F
	dc.w	+$00,+$0A,+$2F
	dc.w	+$0A,+$00,+$2F
	dc.w	+$00,-$0A,+$3B
	dc.w	-$0A,+$00,+$3B
	dc.w	+$00,+$0A,+$3B
	dc.w	+$0A,+$00,+$3B
	dc.w	+$00,-$0B,+$42
	dc.w	-$0B,+$00,+$42
	dc.w	+$00,+$0B,+$42
	dc.w	+$0B,+$00,+$42
	dc.w	+$00,-$0C,+$46
	dc.w	-$0C,+$00,+$46
	dc.w	+$00,+$0C,+$46
	dc.w	+$0C,+$00,+$46
	dc.l	F_cylindre

P_cylindre18:	dc.w	27
	dc.w	+$00,-$1D,-$15
	dc.w	-$1D,+$00,-$15
	dc.w	+$00,+$1D,-$15
	dc.w	+$1D,+$00,-$15
	dc.w	+$00,-$17,+$07
	dc.w	-$17,+$00,+$07
	dc.w	+$00,+$17,+$07
	dc.w	+$17,+$00,+$07
	dc.w	+$00,-$0E,+$1D
	dc.w	-$0E,+$00,+$1D
	dc.w	+$00,+$0E,+$1D
	dc.w	+$0E,+$00,+$1D
	dc.w	+$00,-$0A,+$2E
	dc.w	-$0A,+$00,+$2E
	dc.w	+$00,+$0A,+$2E
	dc.w	+$0A,+$00,+$2E
	dc.w	+$00,-$0A,+$39
	dc.w	-$0A,+$00,+$39
	dc.w	+$00,+$0A,+$39
	dc.w	+$0A,+$00,+$39
	dc.w	+$00,-$0B,+$40
	dc.w	-$0B,+$00,+$40
	dc.w	+$00,+$0B,+$40
	dc.w	+$0B,+$00,+$40
	dc.w	+$00,-$0C,+$44
	dc.w	-$0C,+$00,+$44
	dc.w	+$00,+$0C,+$44
	dc.w	+$0C,+$00,+$44
	dc.l	F_cylindre

P_cylindre19:	dc.w	27
	dc.w	+$00,-$1D,-$13
	dc.w	-$1D,+$00,-$13
	dc.w	+$00,+$1D,-$13
	dc.w	+$1D,+$00,-$13
	dc.w	+$00,-$16,+$07
	dc.w	-$16,+$00,+$07
	dc.w	+$00,+$16,+$07
	dc.w	+$16,+$00,+$07
	dc.w	+$00,-$0D,+$1D
	dc.w	-$0D,+$00,+$1D
	dc.w	+$00,+$0D,+$1D
	dc.w	+$0D,+$00,+$1D
	dc.w	+$00,-$0A,+$2D
	dc.w	-$0A,+$00,+$2D
	dc.w	+$00,+$0A,+$2D
	dc.w	+$0A,+$00,+$2D
	dc.w	+$00,-$0A,+$38
	dc.w	-$0A,+$00,+$38
	dc.w	+$00,+$0A,+$38
	dc.w	+$0A,+$00,+$38
	dc.w	+$00,-$0B,+$3E
	dc.w	-$0B,+$00,+$3E
	dc.w	+$00,+$0B,+$3E
	dc.w	+$0B,+$00,+$3E
	dc.w	+$00,-$0C,+$41
	dc.w	-$0C,+$00,+$41
	dc.w	+$00,+$0C,+$41
	dc.w	+$0C,+$00,+$41
	dc.l	F_cylindre

P_cylindre20:	dc.w	27
	dc.w	+$00,-$1D,-$12
	dc.w	-$1D,+$00,-$12
	dc.w	+$00,+$1D,-$12
	dc.w	+$1D,+$00,-$12
	dc.w	+$00,-$16,+$08
	dc.w	-$16,+$00,+$08
	dc.w	+$00,+$16,+$08
	dc.w	+$16,+$00,+$08
	dc.w	+$00,-$0D,+$1D
	dc.w	-$0D,+$00,+$1D
	dc.w	+$00,+$0D,+$1D
	dc.w	+$0D,+$00,+$1D
	dc.w	+$00,-$0A,+$2C
	dc.w	-$0A,+$00,+$2C
	dc.w	+$00,+$0A,+$2C
	dc.w	+$0A,+$00,+$2C
	dc.w	+$00,-$0A,+$36
	dc.w	-$0A,+$00,+$36
	dc.w	+$00,+$0A,+$36
	dc.w	+$0A,+$00,+$36
	dc.w	+$00,-$0B,+$3C
	dc.w	-$0B,+$00,+$3C
	dc.w	+$00,+$0B,+$3C
	dc.w	+$0B,+$00,+$3C
	dc.w	+$00,-$0B,+$3F
	dc.w	-$0B,+$00,+$3F
	dc.w	+$00,+$0B,+$3F
	dc.w	+$0B,+$00,+$3F
	dc.l	F_cylindre

P_cylindre21:	dc.w	27
	dc.w	+$00,-$1D,-$11
	dc.w	-$1D,+$00,-$11
	dc.w	+$00,+$1D,-$11
	dc.w	+$1D,+$00,-$11
	dc.w	+$00,-$15,+$09
	dc.w	-$15,+$00,+$09
	dc.w	+$00,+$15,+$09
	dc.w	+$15,+$00,+$09
	dc.w	+$00,-$0D,+$1D
	dc.w	-$0D,+$00,+$1D
	dc.w	+$00,+$0D,+$1D
	dc.w	+$0D,+$00,+$1D
	dc.w	+$00,-$0A,+$2B
	dc.w	-$0A,+$00,+$2B
	dc.w	+$00,+$0A,+$2B
	dc.w	+$0A,+$00,+$2B
	dc.w	+$00,-$0A,+$34
	dc.w	-$0A,+$00,+$34
	dc.w	+$00,+$0A,+$34
	dc.w	+$0A,+$00,+$34
	dc.w	+$00,-$0A,+$39
	dc.w	-$0A,+$00,+$39
	dc.w	+$00,+$0A,+$39
	dc.w	+$0A,+$00,+$39
	dc.w	+$00,-$0B,+$3C
	dc.w	-$0B,+$00,+$3C
	dc.w	+$00,+$0B,+$3C
	dc.w	+$0B,+$00,+$3C
	dc.l	F_cylindre

P_cylindre22:	dc.w	27
	dc.w	+$00,-$1D,-$0F
	dc.w	-$1D,+$00,-$0F
	dc.w	+$00,+$1D,-$0F
	dc.w	+$1D,+$00,-$0F
	dc.w	+$00,-$14,+$09
	dc.w	-$14,+$00,+$09
	dc.w	+$00,+$14,+$09
	dc.w	+$14,+$00,+$09
	dc.w	+$00,-$0D,+$1C
	dc.w	-$0D,+$00,+$1C
	dc.w	+$00,+$0D,+$1C
	dc.w	+$0D,+$00,+$1C
	dc.w	+$00,-$0A,+$2A
	dc.w	-$0A,+$00,+$2A
	dc.w	+$00,+$0A,+$2A
	dc.w	+$0A,+$00,+$2A
	dc.w	+$00,-$0A,+$32
	dc.w	-$0A,+$00,+$32
	dc.w	+$00,+$0A,+$32
	dc.w	+$0A,+$00,+$32
	dc.w	+$00,-$0A,+$37
	dc.w	-$0A,+$00,+$37
	dc.w	+$00,+$0A,+$37
	dc.w	+$0A,+$00,+$37
	dc.w	+$00,-$0B,+$3D
	dc.w	-$0B,+$00,+$3D
	dc.w	+$00,+$0B,+$3D
	dc.w	+$0B,+$00,+$3D
	dc.l	F_cylindre

P_cylindre23:	dc.w	27
	dc.w	+$00,-$1C,-$0E
	dc.w	-$1C,+$00,-$0E
	dc.w	+$00,+$1C,-$0E
	dc.w	+$1C,+$00,-$0E
	dc.w	+$00,-$14,+$09
	dc.w	-$14,+$00,+$09
	dc.w	+$00,+$14,+$09
	dc.w	+$14,+$00,+$09
	dc.w	+$00,-$0C,+$1C
	dc.w	-$0C,+$00,+$1C
	dc.w	+$00,+$0C,+$1C
	dc.w	+$0C,+$00,+$1C
	dc.w	+$00,-$0A,+$29
	dc.w	-$0A,+$00,+$29
	dc.w	+$00,+$0A,+$29
	dc.w	+$0A,+$00,+$29
	dc.w	+$00,-$0A,+$30
	dc.w	-$0A,+$00,+$30
	dc.w	+$00,+$0A,+$30
	dc.w	+$0A,+$00,+$30
	dc.w	+$00,-$0A,+$35
	dc.w	-$0A,+$00,+$35
	dc.w	+$00,+$0A,+$35
	dc.w	+$0A,+$00,+$35
	dc.w	+$00,-$0C,+$40
	dc.w	-$0C,+$00,+$40
	dc.w	+$00,+$0C,+$40
	dc.w	+$0C,+$00,+$40
	dc.l	F_cylindre

P_cylindre24:	dc.w	27
	dc.w	+$00,-$1C,-$0D
	dc.w	-$1C,+$00,-$0D
	dc.w	+$00,+$1C,-$0D
	dc.w	+$1C,+$00,-$0D
	dc.w	+$00,-$13,+$09
	dc.w	-$13,+$00,+$09
	dc.w	+$00,+$13,+$09
	dc.w	+$13,+$00,+$09
	dc.w	+$00,-$0C,+$1B
	dc.w	-$0C,+$00,+$1B
	dc.w	+$00,+$0C,+$1B
	dc.w	+$0C,+$00,+$1B
	dc.w	+$00,-$0A,+$27
	dc.w	-$0A,+$00,+$27
	dc.w	+$00,+$0A,+$27
	dc.w	+$0A,+$00,+$27
	dc.w	+$00,-$0A,+$2E
	dc.w	-$0A,+$00,+$2E
	dc.w	+$00,+$0A,+$2E
	dc.w	+$0A,+$00,+$2E
	dc.w	+$00,-$0A,+$32
	dc.w	-$0A,+$00,+$32
	dc.w	+$00,+$0A,+$32
	dc.w	+$0A,+$00,+$32
	dc.w	+$00,-$0E,+$42
	dc.w	-$0E,+$00,+$42
	dc.w	+$00,+$0E,+$42
	dc.w	+$0E,+$00,+$42
	dc.l	F_cylindre

P_cylindre25:	dc.w	27
	dc.w	+$00,-$1B,-$0C
	dc.w	-$1B,+$00,-$0C
	dc.w	+$00,+$1B,-$0C
	dc.w	+$1B,+$00,-$0C
	dc.w	+$00,-$13,+$09
	dc.w	-$13,+$00,+$09
	dc.w	+$00,+$13,+$09
	dc.w	+$13,+$00,+$09
	dc.w	+$00,-$0C,+$1A
	dc.w	-$0C,+$00,+$1A
	dc.w	+$00,+$0C,+$1A
	dc.w	+$0C,+$00,+$1A
	dc.w	+$00,-$0A,+$26
	dc.w	-$0A,+$00,+$26
	dc.w	+$00,+$0A,+$26
	dc.w	+$0A,+$00,+$26
	dc.w	+$00,-$0A,+$2C
	dc.w	-$0A,+$00,+$2C
	dc.w	+$00,+$0A,+$2C
	dc.w	+$0A,+$00,+$2C
	dc.w	+$00,-$0A,+$30
	dc.w	-$0A,+$00,+$30
	dc.w	+$00,+$0A,+$30
	dc.w	+$0A,+$00,+$30
	dc.w	+$00,-$0F,+$44
	dc.w	-$0F,+$00,+$44
	dc.w	+$00,+$0F,+$44
	dc.w	+$0F,+$00,+$44
	dc.l	F_cylindre

P_cylindre26:	dc.w	27
	dc.w	+$00,-$1B,-$0C
	dc.w	-$1B,+$00,-$0C
	dc.w	+$00,+$1B,-$0C
	dc.w	+$1B,+$00,-$0C
	dc.w	+$00,-$12,+$09
	dc.w	-$12,+$00,+$09
	dc.w	+$00,+$12,+$09
	dc.w	+$12,+$00,+$09
	dc.w	+$00,-$0C,+$19
	dc.w	-$0C,+$00,+$19
	dc.w	+$00,+$0C,+$19
	dc.w	+$0C,+$00,+$19
	dc.w	+$00,-$0A,+$24
	dc.w	-$0A,+$00,+$24
	dc.w	+$00,+$0A,+$24
	dc.w	+$0A,+$00,+$24
	dc.w	+$00,-$0A,+$2A
	dc.w	-$0A,+$00,+$2A
	dc.w	+$00,+$0A,+$2A
	dc.w	+$0A,+$00,+$2A
	dc.w	+$00,-$0A,+$2D
	dc.w	-$0A,+$00,+$2D
	dc.w	+$00,+$0A,+$2D
	dc.w	+$0A,+$00,+$2D
	dc.w	+$00,-$10,+$47
	dc.w	-$10,+$00,+$47
	dc.w	+$00,+$10,+$47
	dc.w	+$10,+$00,+$47
	dc.l	F_cylindre

P_cylindre27:	dc.w	27
	dc.w	+$00,-$1A,-$0B
	dc.w	-$1A,+$00,-$0B
	dc.w	+$00,+$1A,-$0B
	dc.w	+$1A,+$00,-$0B
	dc.w	+$00,-$12,+$09
	dc.w	-$12,+$00,+$09
	dc.w	+$00,+$12,+$09
	dc.w	+$12,+$00,+$09
	dc.w	+$00,-$0C,+$18
	dc.w	-$0C,+$00,+$18
	dc.w	+$00,+$0C,+$18
	dc.w	+$0C,+$00,+$18
	dc.w	+$00,-$0A,+$22
	dc.w	-$0A,+$00,+$22
	dc.w	+$00,+$0A,+$22
	dc.w	+$0A,+$00,+$22
	dc.w	+$00,-$0A,+$28
	dc.w	-$0A,+$00,+$28
	dc.w	+$00,+$0A,+$28
	dc.w	+$0A,+$00,+$28
	dc.w	+$00,-$0A,+$2B
	dc.w	-$0A,+$00,+$2B
	dc.w	+$00,+$0A,+$2B
	dc.w	+$0A,+$00,+$2B
	dc.w	+$00,-$12,+$49
	dc.w	-$12,+$00,+$49
	dc.w	+$00,+$12,+$49
	dc.w	+$12,+$00,+$49
	dc.l	F_cylindre

P_cylindre28:	dc.w	27
	dc.w	+$00,-$1A,-$0A
	dc.w	-$1A,+$00,-$0A
	dc.w	+$00,+$1A,-$0A
	dc.w	+$1A,+$00,-$0A
	dc.w	+$00,-$11,+$09
	dc.w	-$11,+$00,+$09
	dc.w	+$00,+$11,+$09
	dc.w	+$11,+$00,+$09
	dc.w	+$00,-$0C,+$17
	dc.w	-$0C,+$00,+$17
	dc.w	+$00,+$0C,+$17
	dc.w	+$0C,+$00,+$17
	dc.w	+$00,-$0A,+$20
	dc.w	-$0A,+$00,+$20
	dc.w	+$00,+$0A,+$20
	dc.w	+$0A,+$00,+$20
	dc.w	+$00,-$0A,+$26
	dc.w	-$0A,+$00,+$26
	dc.w	+$00,+$0A,+$26
	dc.w	+$0A,+$00,+$26
	dc.w	+$00,-$0A,+$29
	dc.w	-$0A,+$00,+$29
	dc.w	+$00,+$0A,+$29
	dc.w	+$0A,+$00,+$29
	dc.w	+$00,-$13,+$4C
	dc.w	-$13,+$00,+$4C
	dc.w	+$00,+$13,+$4C
	dc.w	+$13,+$00,+$4C
	dc.l	F_cylindre

P_cylindre29:	dc.w	27
	dc.w	+$00,-$19,-$0A
	dc.w	-$19,+$00,-$0A
	dc.w	+$00,+$19,-$0A
	dc.w	+$19,+$00,-$0A
	dc.w	+$00,-$11,+$08
	dc.w	-$11,+$00,+$08
	dc.w	+$00,+$11,+$08
	dc.w	+$11,+$00,+$08
	dc.w	+$00,-$0C,+$16
	dc.w	-$0C,+$00,+$16
	dc.w	+$00,+$0C,+$16
	dc.w	+$0C,+$00,+$16
	dc.w	+$00,-$0A,+$1F
	dc.w	-$0A,+$00,+$1F
	dc.w	+$00,+$0A,+$1F
	dc.w	+$0A,+$00,+$1F
	dc.w	+$00,-$0A,+$23
	dc.w	-$0A,+$00,+$23
	dc.w	+$00,+$0A,+$23
	dc.w	+$0A,+$00,+$23
	dc.w	+$00,-$0A,+$29
	dc.w	-$0A,+$00,+$29
	dc.w	+$00,+$0A,+$29
	dc.w	+$0A,+$00,+$29
	dc.w	+$00,-$15,+$4E
	dc.w	-$15,+$00,+$4E
	dc.w	+$00,+$15,+$4E
	dc.w	+$15,+$00,+$4E
	dc.l	F_cylindre

P_cylindre30:	dc.w	27
	dc.w	+$00,-$19,-$0A
	dc.w	-$19,+$00,-$0A
	dc.w	+$00,+$19,-$0A
	dc.w	+$19,+$00,-$0A
	dc.w	+$00,-$11,+$08
	dc.w	-$11,+$00,+$08
	dc.w	+$00,+$11,+$08
	dc.w	+$11,+$00,+$08
	dc.w	+$00,-$0C,+$15
	dc.w	-$0C,+$00,+$15
	dc.w	+$00,+$0C,+$15
	dc.w	+$0C,+$00,+$15
	dc.w	+$00,-$0A,+$1D
	dc.w	-$0A,+$00,+$1D
	dc.w	+$00,+$0A,+$1D
	dc.w	+$0A,+$00,+$1D
	dc.w	+$00,-$0A,+$21
	dc.w	-$0A,+$00,+$21
	dc.w	+$00,+$0A,+$21
	dc.w	+$0A,+$00,+$21
	dc.w	+$00,-$0A,+$2B
	dc.w	-$0A,+$00,+$2B
	dc.w	+$00,+$0A,+$2B
	dc.w	+$0A,+$00,+$2B
	dc.w	+$00,-$16,+$50
	dc.w	-$16,+$00,+$50
	dc.w	+$00,+$16,+$50
	dc.w	+$16,+$00,+$50
	dc.l	F_cylindre

P_cylindre31:	dc.w	27
	dc.w	+$00,-$18,-$0A
	dc.w	-$18,+$00,-$0A
	dc.w	+$00,+$18,-$0A
	dc.w	+$18,+$00,-$0A
	dc.w	+$00,-$11,+$07
	dc.w	-$11,+$00,+$07
	dc.w	+$00,+$11,+$07
	dc.w	+$11,+$00,+$07
	dc.w	+$00,-$0C,+$13
	dc.w	-$0C,+$00,+$13
	dc.w	+$00,+$0C,+$13
	dc.w	+$0C,+$00,+$13
	dc.w	+$00,-$0A,+$1B
	dc.w	-$0A,+$00,+$1B
	dc.w	+$00,+$0A,+$1B
	dc.w	+$0A,+$00,+$1B
	dc.w	+$00,-$0A,+$1F
	dc.w	-$0A,+$00,+$1F
	dc.w	+$00,+$0A,+$1F
	dc.w	+$0A,+$00,+$1F
	dc.w	+$00,-$0A,+$2E
	dc.w	-$0A,+$00,+$2E
	dc.w	+$00,+$0A,+$2E
	dc.w	+$0A,+$00,+$2E
	dc.w	+$00,-$18,+$52
	dc.w	-$18,+$00,+$52
	dc.w	+$00,+$18,+$52
	dc.w	+$18,+$00,+$52
	dc.l	F_cylindre

P_cylindre32:	dc.w	27
	dc.w	+$00,-$18,-$0A
	dc.w	-$18,+$00,-$0A
	dc.w	+$00,+$18,-$0A
	dc.w	+$18,+$00,-$0A
	dc.w	+$00,-$11,+$06
	dc.w	-$11,+$00,+$06
	dc.w	+$00,+$11,+$06
	dc.w	+$11,+$00,+$06
	dc.w	+$00,-$0C,+$12
	dc.w	-$0C,+$00,+$12
	dc.w	+$00,+$0C,+$12
	dc.w	+$0C,+$00,+$12
	dc.w	+$00,-$0B,+$19
	dc.w	-$0B,+$00,+$19
	dc.w	+$00,+$0B,+$19
	dc.w	+$0B,+$00,+$19
	dc.w	+$00,-$0A,+$1C
	dc.w	-$0A,+$00,+$1C
	dc.w	+$00,+$0A,+$1C
	dc.w	+$0A,+$00,+$1C
	dc.w	+$00,-$0B,+$30
	dc.w	-$0B,+$00,+$30
	dc.w	+$00,+$0B,+$30
	dc.w	+$0B,+$00,+$30
	dc.w	+$00,-$19,+$55
	dc.w	-$19,+$00,+$55
	dc.w	+$00,+$19,+$55
	dc.w	+$19,+$00,+$55
	dc.l	F_cylindre

P_cylindre33:	dc.w	27
	dc.w	+$00,-$17,-$0A
	dc.w	-$17,+$00,-$0A
	dc.w	+$00,+$17,-$0A
	dc.w	+$17,+$00,-$0A
	dc.w	+$00,-$10,+$06
	dc.w	-$10,+$00,+$06
	dc.w	+$00,+$10,+$06
	dc.w	+$10,+$00,+$06
	dc.w	+$00,-$0D,+$10
	dc.w	-$0D,+$00,+$10
	dc.w	+$00,+$0D,+$10
	dc.w	+$0D,+$00,+$10
	dc.w	+$00,-$0B,+$16
	dc.w	-$0B,+$00,+$16
	dc.w	+$00,+$0B,+$16
	dc.w	+$0B,+$00,+$16
	dc.w	+$00,-$0A,+$1A
	dc.w	-$0A,+$00,+$1A
	dc.w	+$00,+$0A,+$1A
	dc.w	+$0A,+$00,+$1A
	dc.w	+$00,-$0C,+$33
	dc.w	-$0C,+$00,+$33
	dc.w	+$00,+$0C,+$33
	dc.w	+$0C,+$00,+$33
	dc.w	+$00,-$1A,+$57
	dc.w	-$1A,+$00,+$57
	dc.w	+$00,+$1A,+$57
	dc.w	+$1A,+$00,+$57
	dc.l	F_cylindre

P_cylindre34:	dc.w	27
	dc.w	+$00,-$17,-$0A
	dc.w	-$17,+$00,-$0A
	dc.w	+$00,+$17,-$0A
	dc.w	+$17,+$00,-$0A
	dc.w	+$00,-$10,+$05
	dc.w	-$10,+$00,+$05
	dc.w	+$00,+$10,+$05
	dc.w	+$10,+$00,+$05
	dc.w	+$00,-$0D,+$0E
	dc.w	-$0D,+$00,+$0E
	dc.w	+$00,+$0D,+$0E
	dc.w	+$0D,+$00,+$0E
	dc.w	+$00,-$0B,+$14
	dc.w	-$0B,+$00,+$14
	dc.w	+$00,+$0B,+$14
	dc.w	+$0B,+$00,+$14
	dc.w	+$00,-$0A,+$17
	dc.w	-$0A,+$00,+$17
	dc.w	+$00,+$0A,+$17
	dc.w	+$0A,+$00,+$17
	dc.w	+$00,-$0D,+$35
	dc.w	-$0D,+$00,+$35
	dc.w	+$00,+$0D,+$35
	dc.w	+$0D,+$00,+$35
	dc.w	+$00,-$1B,+$59
	dc.w	-$1B,+$00,+$59
	dc.w	+$00,+$1B,+$59
	dc.w	+$1B,+$00,+$59
	dc.l	F_cylindre

P_cylindre35:	dc.w	27
	dc.w	+$00,-$17,-$0A
	dc.w	-$17,+$00,-$0A
	dc.w	+$00,+$17,-$0A
	dc.w	+$17,+$00,-$0A
	dc.w	+$00,-$10,+$03
	dc.w	-$10,+$00,+$03
	dc.w	+$00,+$10,+$03
	dc.w	+$10,+$00,+$03
	dc.w	+$00,-$0D,+$0D
	dc.w	-$0D,+$00,+$0D
	dc.w	+$00,+$0D,+$0D
	dc.w	+$0D,+$00,+$0D
	dc.w	+$00,-$0B,+$12
	dc.w	-$0B,+$00,+$12
	dc.w	+$00,+$0B,+$12
	dc.w	+$0B,+$00,+$12
	dc.w	+$00,-$0B,+$15
	dc.w	-$0B,+$00,+$15
	dc.w	+$00,+$0B,+$15
	dc.w	+$0B,+$00,+$15
	dc.w	+$00,-$0E,+$37
	dc.w	-$0E,+$00,+$37
	dc.w	+$00,+$0E,+$37
	dc.w	+$0E,+$00,+$37
	dc.w	+$00,-$1C,+$5B
	dc.w	-$1C,+$00,+$5B
	dc.w	+$00,+$1C,+$5B
	dc.w	+$1C,+$00,+$5B
	dc.l	F_cylindre

P_cylindre36:	dc.w	27
	dc.w	+$00,-$16,-$0A
	dc.w	-$16,+$00,-$0A
	dc.w	+$00,+$16,-$0A
	dc.w	+$16,+$00,-$0A
	dc.w	+$00,-$10,+$02
	dc.w	-$10,+$00,+$02
	dc.w	+$00,+$10,+$02
	dc.w	+$10,+$00,+$02
	dc.w	+$00,-$0D,+$0B
	dc.w	-$0D,+$00,+$0B
	dc.w	+$00,+$0D,+$0B
	dc.w	+$0D,+$00,+$0B
	dc.w	+$00,-$0C,+$10
	dc.w	-$0C,+$00,+$10
	dc.w	+$00,+$0C,+$10
	dc.w	+$0C,+$00,+$10
	dc.w	+$00,-$0B,+$15
	dc.w	-$0B,+$00,+$15
	dc.w	+$00,+$0B,+$15
	dc.w	+$0B,+$00,+$15
	dc.w	+$00,-$0F,+$3A
	dc.w	-$0F,+$00,+$3A
	dc.w	+$00,+$0F,+$3A
	dc.w	+$0F,+$00,+$3A
	dc.w	+$00,-$1C,+$5C
	dc.w	-$1C,+$00,+$5C
	dc.w	+$00,+$1C,+$5C
	dc.w	+$1C,+$00,+$5C
	dc.l	F_cylindre

P_cylindre37:	dc.w	27
	dc.w	+$00,-$16,-$0B
	dc.w	-$16,+$00,-$0B
	dc.w	+$00,+$16,-$0B
	dc.w	+$16,+$00,-$0B
	dc.w	+$00,-$10,+$01
	dc.w	-$10,+$00,+$01
	dc.w	+$00,+$10,+$01
	dc.w	+$10,+$00,+$01
	dc.w	+$00,-$0D,+$09
	dc.w	-$0D,+$00,+$09
	dc.w	+$00,+$0D,+$09
	dc.w	+$0D,+$00,+$09
	dc.w	+$00,-$0C,+$0D
	dc.w	-$0C,+$00,+$0D
	dc.w	+$00,+$0C,+$0D
	dc.w	+$0C,+$00,+$0D
	dc.w	+$00,-$0A,+$17
	dc.w	-$0A,+$00,+$17
	dc.w	+$00,+$0A,+$17
	dc.w	+$0A,+$00,+$17
	dc.w	+$00,-$11,+$3C
	dc.w	-$11,+$00,+$3C
	dc.w	+$00,+$11,+$3C
	dc.w	+$11,+$00,+$3C
	dc.w	+$00,-$1D,+$5E
	dc.w	-$1D,+$00,+$5E
	dc.w	+$00,+$1D,+$5E
	dc.w	+$1D,+$00,+$5E
	dc.l	F_cylindre

P_cylindre38:	dc.w	27
	dc.w	+$00,-$16,-$0C
	dc.w	-$16,+$00,-$0C
	dc.w	+$00,+$16,-$0C
	dc.w	+$16,+$00,-$0C
	dc.w	+$00,-$11,+$00
	dc.w	-$11,+$00,+$00
	dc.w	+$00,+$11,+$00
	dc.w	+$11,+$00,+$00
	dc.w	+$00,-$0E,+$07
	dc.w	-$0E,+$00,+$07
	dc.w	+$00,+$0E,+$07
	dc.w	+$0E,+$00,+$07
	dc.w	+$00,-$0C,+$0B
	dc.w	-$0C,+$00,+$0B
	dc.w	+$00,+$0C,+$0B
	dc.w	+$0C,+$00,+$0B
	dc.w	+$00,-$0A,+$19
	dc.w	-$0A,+$00,+$19
	dc.w	+$00,+$0A,+$19
	dc.w	+$0A,+$00,+$19
	dc.w	+$00,-$12,+$3E
	dc.w	-$12,+$00,+$3E
	dc.w	+$00,+$12,+$3E
	dc.w	+$12,+$00,+$3E
	dc.w	+$00,-$1D,+$60
	dc.w	-$1D,+$00,+$60
	dc.w	+$00,+$1D,+$60
	dc.w	+$1D,+$00,+$60
	dc.l	F_cylindre

P_cylindre39:	dc.w	27
	dc.w	+$00,-$16,-$0C
	dc.w	-$16,+$00,-$0C
	dc.w	+$00,+$16,-$0C
	dc.w	+$16,+$00,-$0C
	dc.w	+$00,-$11,-$01
	dc.w	-$11,+$00,-$01
	dc.w	+$00,+$11,-$01
	dc.w	+$11,+$00,-$01
	dc.w	+$00,-$0E,+$05
	dc.w	-$0E,+$00,+$05
	dc.w	+$00,+$0E,+$05
	dc.w	+$0E,+$00,+$05
	dc.w	+$00,-$0D,+$08
	dc.w	-$0D,+$00,+$08
	dc.w	+$00,+$0D,+$08
	dc.w	+$0D,+$00,+$08
	dc.w	+$00,-$0A,+$1C
	dc.w	-$0A,+$00,+$1C
	dc.w	+$00,+$0A,+$1C
	dc.w	+$0A,+$00,+$1C
	dc.w	+$00,-$14,+$40
	dc.w	-$14,+$00,+$40
	dc.w	+$00,+$14,+$40
	dc.w	+$14,+$00,+$40
	dc.w	+$00,-$1D,+$62
	dc.w	-$1D,+$00,+$62
	dc.w	+$00,+$1D,+$62
	dc.w	+$1D,+$00,+$62
	dc.l	F_cylindre

P_cylindre40:	dc.w	27
	dc.w	+$00,-$16,-$0D
	dc.w	-$16,+$00,-$0D
	dc.w	+$00,+$16,-$0D
	dc.w	+$16,+$00,-$0D
	dc.w	+$00,-$11,-$03
	dc.w	-$11,+$00,-$03
	dc.w	+$00,+$11,-$03
	dc.w	+$11,+$00,-$03
	dc.w	+$00,-$0F,+$03
	dc.w	-$0F,+$00,+$03
	dc.w	+$00,+$0F,+$03
	dc.w	+$0F,+$00,+$03
	dc.w	+$00,-$0D,+$06
	dc.w	-$0D,+$00,+$06
	dc.w	+$00,+$0D,+$06
	dc.w	+$0D,+$00,+$06
	dc.w	+$00,-$0A,+$1E
	dc.w	-$0A,+$00,+$1E
	dc.w	+$00,+$0A,+$1E
	dc.w	+$0A,+$00,+$1E
	dc.w	+$00,-$15,+$42
	dc.w	-$15,+$00,+$42
	dc.w	+$00,+$15,+$42
	dc.w	+$15,+$00,+$42
	dc.w	+$00,-$1D,+$63
	dc.w	-$1D,+$00,+$63
	dc.w	+$00,+$1D,+$63
	dc.w	+$1D,+$00,+$63
	dc.l	F_cylindre

P_cylindre41:	dc.w	27
	dc.w	+$00,-$16,-$0E
	dc.w	-$16,+$00,-$0E
	dc.w	+$00,+$16,-$0E
	dc.w	+$16,+$00,-$0E
	dc.w	+$00,-$11,-$04
	dc.w	-$11,+$00,-$04
	dc.w	+$00,+$11,-$04
	dc.w	+$11,+$00,-$04
	dc.w	+$00,-$0F,+$00
	dc.w	-$0F,+$00,+$00
	dc.w	+$00,+$0F,+$00
	dc.w	+$0F,+$00,+$00
	dc.w	+$00,-$0E,+$04
	dc.w	-$0E,+$00,+$04
	dc.w	+$00,+$0E,+$04
	dc.w	+$0E,+$00,+$04
	dc.w	+$00,-$0A,+$21
	dc.w	-$0A,+$00,+$21
	dc.w	+$00,+$0A,+$21
	dc.w	+$0A,+$00,+$21
	dc.w	+$00,-$16,+$44
	dc.w	-$16,+$00,+$44
	dc.w	+$00,+$16,+$44
	dc.w	+$16,+$00,+$44
	dc.w	+$00,-$1D,+$65
	dc.w	-$1D,+$00,+$65
	dc.w	+$00,+$1D,+$65
	dc.w	+$1D,+$00,+$65
	dc.l	F_cylindre

P_cylindre42:	dc.w	27
	dc.w	+$00,-$15,-$0F
	dc.w	-$15,+$00,-$0F
	dc.w	+$00,+$15,-$0F
	dc.w	+$15,+$00,-$0F
	dc.w	+$00,-$11,-$06
	dc.w	-$11,+$00,-$06
	dc.w	+$00,+$11,-$06
	dc.w	+$11,+$00,-$06
	dc.w	+$00,-$0F,-$01
	dc.w	-$0F,+$00,-$01
	dc.w	+$00,+$0F,-$01
	dc.w	+$0F,+$00,-$01
	dc.w	+$00,-$0E,+$01
	dc.w	-$0E,+$00,+$01
	dc.w	+$00,+$0E,+$01
	dc.w	+$0E,+$00,+$01
	dc.w	+$00,-$0B,+$23
	dc.w	-$0B,+$00,+$23
	dc.w	+$00,+$0B,+$23
	dc.w	+$0B,+$00,+$23
	dc.w	+$00,-$18,+$46
	dc.w	-$18,+$00,+$46
	dc.w	+$00,+$18,+$46
	dc.w	+$18,+$00,+$46
	dc.w	+$00,-$1D,+$66
	dc.w	-$1D,+$00,+$66
	dc.w	+$00,+$1D,+$66
	dc.w	+$1D,+$00,+$66
	dc.l	F_cylindre

P_cylindre43:	dc.w	27
	dc.w	+$00,-$16,-$11
	dc.w	-$16,+$00,-$11
	dc.w	+$00,+$16,-$11
	dc.w	+$16,+$00,-$11
	dc.w	+$00,-$12,-$08
	dc.w	-$12,+$00,-$08
	dc.w	+$00,+$12,-$08
	dc.w	+$12,+$00,-$08
	dc.w	+$00,-$10,-$03
	dc.w	-$10,+$00,-$03
	dc.w	+$00,+$10,-$03
	dc.w	+$10,+$00,-$03
	dc.w	+$00,-$0E,+$00
	dc.w	-$0E,+$00,+$00
	dc.w	+$00,+$0E,+$00
	dc.w	+$0E,+$00,+$00
	dc.w	+$00,-$0B,+$25
	dc.w	-$0B,+$00,+$25
	dc.w	+$00,+$0B,+$25
	dc.w	+$0B,+$00,+$25
	dc.w	+$00,-$19,+$48
	dc.w	-$19,+$00,+$48
	dc.w	+$00,+$19,+$48
	dc.w	+$19,+$00,+$48
	dc.w	+$00,-$1D,+$67
	dc.w	-$1D,+$00,+$67
	dc.w	+$00,+$1D,+$67
	dc.w	+$1D,+$00,+$67
	dc.l	F_cylindre

P_cylindre44:	dc.w	27
	dc.w	+$00,-$16,-$12
	dc.w	-$16,+$00,-$12
	dc.w	+$00,+$16,-$12
	dc.w	+$16,+$00,-$12
	dc.w	+$00,-$12,-$0A
	dc.w	-$12,+$00,-$0A
	dc.w	+$00,+$12,-$0A
	dc.w	+$12,+$00,-$0A
	dc.w	+$00,-$10,-$06
	dc.w	-$10,+$00,-$06
	dc.w	+$00,+$10,-$06
	dc.w	+$10,+$00,-$06
	dc.w	+$00,-$0D,+$03
	dc.w	-$0D,+$00,+$03
	dc.w	+$00,+$0D,+$03
	dc.w	+$0D,+$00,+$03
	dc.w	+$00,-$0C,+$28
	dc.w	-$0C,+$00,+$28
	dc.w	+$00,+$0C,+$28
	dc.w	+$0C,+$00,+$28
	dc.w	+$00,-$1A,+$4A
	dc.w	-$1A,+$00,+$4A
	dc.w	+$00,+$1A,+$4A
	dc.w	+$1A,+$00,+$4A
	dc.w	+$00,-$1D,+$68
	dc.w	-$1D,+$00,+$68
	dc.w	+$00,+$1D,+$68
	dc.w	+$1D,+$00,+$68
	dc.l	F_cylindre

P_cylindre45:	dc.w	27
	dc.w	+$00,-$16,-$13
	dc.w	-$16,+$00,-$13
	dc.w	+$00,+$16,-$13
	dc.w	+$16,+$00,-$13
	dc.w	+$00,-$13,-$0C
	dc.w	-$13,+$00,-$0C
	dc.w	+$00,+$13,-$0C
	dc.w	+$13,+$00,-$0C
	dc.w	+$00,-$11,-$08
	dc.w	-$11,+$00,-$08
	dc.w	+$00,+$11,-$08
	dc.w	+$11,+$00,-$08
	dc.w	+$00,-$0C,+$05
	dc.w	-$0C,+$00,+$05
	dc.w	+$00,+$0C,+$05
	dc.w	+$0C,+$00,+$05
	dc.w	+$00,-$0D,+$2A
	dc.w	-$0D,+$00,+$2A
	dc.w	+$00,+$0D,+$2A
	dc.w	+$0D,+$00,+$2A
	dc.w	+$00,-$1B,+$4C
	dc.w	-$1B,+$00,+$4C
	dc.w	+$00,+$1B,+$4C
	dc.w	+$1B,+$00,+$4C
	dc.w	+$00,-$1C,+$69
	dc.w	-$1C,+$00,+$69
	dc.w	+$00,+$1C,+$69
	dc.w	+$1C,+$00,+$69
	dc.l	F_cylindre

P_cylindre46:	dc.w	27
	dc.w	+$00,-$16,-$15
	dc.w	-$16,+$00,-$15
	dc.w	+$00,+$16,-$15
	dc.w	+$16,+$00,-$15
	dc.w	+$00,-$13,-$0E
	dc.w	-$13,+$00,-$0E
	dc.w	+$00,+$13,-$0E
	dc.w	+$13,+$00,-$0E
	dc.w	+$00,-$11,-$0A
	dc.w	-$11,+$00,-$0A
	dc.w	+$00,+$11,-$0A
	dc.w	+$11,+$00,-$0A
	dc.w	+$00,-$0B,+$08
	dc.w	-$0B,+$00,+$08
	dc.w	+$00,+$0B,+$08
	dc.w	+$0B,+$00,+$08
	dc.w	+$00,-$0F,+$2C
	dc.w	-$0F,+$00,+$2C
	dc.w	+$00,+$0F,+$2C
	dc.w	+$0F,+$00,+$2C
	dc.w	+$00,-$1C,+$4D
	dc.w	-$1C,+$00,+$4D
	dc.w	+$00,+$1C,+$4D
	dc.w	+$1C,+$00,+$4D
	dc.w	+$00,-$1C,+$6A
	dc.w	-$1C,+$00,+$6A
	dc.w	+$00,+$1C,+$6A
	dc.w	+$1C,+$00,+$6A
	dc.l	F_cylindre

P_cylindre47:	dc.w	27
	dc.w	+$00,-$16,-$16
	dc.w	-$16,+$00,-$16
	dc.w	+$00,+$16,-$16
	dc.w	+$16,+$00,-$16
	dc.w	+$00,-$13,-$10
	dc.w	-$13,+$00,-$10
	dc.w	+$00,+$13,-$10
	dc.w	+$13,+$00,-$10
	dc.w	+$00,-$12,-$0D
	dc.w	-$12,+$00,-$0D
	dc.w	+$00,+$12,-$0D
	dc.w	+$12,+$00,-$0D
	dc.w	+$00,-$0A,+$0A
	dc.w	-$0A,+$00,+$0A
	dc.w	+$00,+$0A,+$0A
	dc.w	+$0A,+$00,+$0A
	dc.w	+$00,-$10,+$2E
	dc.w	-$10,+$00,+$2E
	dc.w	+$00,+$10,+$2E
	dc.w	+$10,+$00,+$2E
	dc.w	+$00,-$1C,+$4F
	dc.w	-$1C,+$00,+$4F
	dc.w	+$00,+$1C,+$4F
	dc.w	+$1C,+$00,+$4F
	dc.w	+$00,-$1B,+$6B
	dc.w	-$1B,+$00,+$6B
	dc.w	+$00,+$1B,+$6B
	dc.w	+$1B,+$00,+$6B
	dc.l	F_cylindre

P_cylindre48:	dc.w	27
	dc.w	+$00,-$16,-$18
	dc.w	-$16,+$00,-$18
	dc.w	+$00,+$16,-$18
	dc.w	+$16,+$00,-$18
	dc.w	+$00,-$14,-$12
	dc.w	-$14,+$00,-$12
	dc.w	+$00,+$14,-$12
	dc.w	+$14,+$00,-$12
	dc.w	+$00,-$12,-$0F
	dc.w	-$12,+$00,-$0F
	dc.w	+$00,+$12,-$0F
	dc.w	+$12,+$00,-$0F
	dc.w	+$00,-$0A,+$0C
	dc.w	-$0A,+$00,+$0C
	dc.w	+$00,+$0A,+$0C
	dc.w	+$0A,+$00,+$0C
	dc.w	+$00,-$11,+$30
	dc.w	-$11,+$00,+$30
	dc.w	+$00,+$11,+$30
	dc.w	+$11,+$00,+$30
	dc.w	+$00,-$1D,+$50
	dc.w	-$1D,+$00,+$50
	dc.w	+$00,+$1D,+$50
	dc.w	+$1D,+$00,+$50
	dc.w	+$00,-$1B,+$6C
	dc.w	-$1B,+$00,+$6C
	dc.w	+$00,+$1B,+$6C
	dc.w	+$1B,+$00,+$6C
	dc.l	F_cylindre

P_cylindre49:	dc.w	27
	dc.w	+$00,-$17,-$1A
	dc.w	-$17,+$00,-$1A
	dc.w	+$00,+$17,-$1A
	dc.w	+$17,+$00,-$1A
	dc.w	+$00,-$14,-$15
	dc.w	-$14,+$00,-$15
	dc.w	+$00,+$14,-$15
	dc.w	+$14,+$00,-$15
	dc.w	+$00,-$13,-$12
	dc.w	-$13,+$00,-$12
	dc.w	+$00,+$13,-$12
	dc.w	+$13,+$00,-$12
	dc.w	+$00,-$0A,+$0F
	dc.w	-$0A,+$00,+$0F
	dc.w	+$00,+$0A,+$0F
	dc.w	+$0A,+$00,+$0F
	dc.w	+$00,-$13,+$32
	dc.w	-$13,+$00,+$32
	dc.w	+$00,+$13,+$32
	dc.w	+$13,+$00,+$32
	dc.w	+$00,-$1D,+$52
	dc.w	-$1D,+$00,+$52
	dc.w	+$00,+$1D,+$52
	dc.w	+$1D,+$00,+$52
	dc.w	+$00,-$1A,+$6C
	dc.w	-$1A,+$00,+$6C
	dc.w	+$00,+$1A,+$6C
	dc.w	+$1A,+$00,+$6C
	dc.l	F_cylindre

P_cylindre50:	dc.w	27
	dc.w	+$00,-$17,-$1C
	dc.w	-$17,+$00,-$1C
	dc.w	+$00,+$17,-$1C
	dc.w	+$17,+$00,-$1C
	dc.w	+$00,-$15,-$17
	dc.w	-$15,+$00,-$17
	dc.w	+$00,+$15,-$17
	dc.w	+$15,+$00,-$17
	dc.w	+$00,-$13,-$13
	dc.w	-$13,+$00,-$13
	dc.w	+$00,+$13,-$13
	dc.w	+$13,+$00,-$13
	dc.w	+$00,-$0A,+$11
	dc.w	-$0A,+$00,+$11
	dc.w	+$00,+$0A,+$11
	dc.w	+$0A,+$00,+$11
	dc.w	+$00,-$14,+$34
	dc.w	-$14,+$00,+$34
	dc.w	+$00,+$14,+$34
	dc.w	+$14,+$00,+$34
	dc.w	+$00,-$1D,+$53
	dc.w	-$1D,+$00,+$53
	dc.w	+$00,+$1D,+$53
	dc.w	+$1D,+$00,+$53
	dc.w	+$00,-$19,+$6D
	dc.w	-$19,+$00,+$6D
	dc.w	+$00,+$19,+$6D
	dc.w	+$19,+$00,+$6D
	dc.l	F_cylindre

P_cylindre51:	dc.w	27
	dc.w	+$00,-$17,-$1E
	dc.w	-$17,+$00,-$1E
	dc.w	+$00,+$17,-$1E
	dc.w	+$17,+$00,-$1E
	dc.w	+$00,-$15,-$19
	dc.w	-$15,+$00,-$19
	dc.w	+$00,+$15,-$19
	dc.w	+$15,+$00,-$19
	dc.w	+$00,-$12,-$11
	dc.w	-$12,+$00,-$11
	dc.w	+$00,+$12,-$11
	dc.w	+$12,+$00,-$11
	dc.w	+$00,-$0A,+$13
	dc.w	-$0A,+$00,+$13
	dc.w	+$00,+$0A,+$13
	dc.w	+$0A,+$00,+$13
	dc.w	+$00,-$15,+$36
	dc.w	-$15,+$00,+$36
	dc.w	+$00,+$15,+$36
	dc.w	+$15,+$00,+$36
	dc.w	+$00,-$1D,+$54
	dc.w	-$1D,+$00,+$54
	dc.w	+$00,+$1D,+$54
	dc.w	+$1D,+$00,+$54
	dc.w	+$00,-$19,+$6D
	dc.w	-$19,+$00,+$6D
	dc.w	+$00,+$19,+$6D
	dc.w	+$19,+$00,+$6D
	dc.l	F_cylindre

P_cylindre52:	dc.w	27
	dc.w	+$00,-$18,-$20
	dc.w	-$18,+$00,-$20
	dc.w	+$00,+$18,-$20
	dc.w	+$18,+$00,-$20
	dc.w	+$00,-$16,-$1C
	dc.w	-$16,+$00,-$1C
	dc.w	+$00,+$16,-$1C
	dc.w	+$16,+$00,-$1C
	dc.w	+$00,-$10,-$0E
	dc.w	-$10,+$00,-$0E
	dc.w	+$00,+$10,-$0E
	dc.w	+$10,+$00,-$0E
	dc.w	+$00,-$0A,+$16
	dc.w	-$0A,+$00,+$16
	dc.w	+$00,+$0A,+$16
	dc.w	+$0A,+$00,+$16
	dc.w	+$00,-$16,+$38
	dc.w	-$16,+$00,+$38
	dc.w	+$00,+$16,+$38
	dc.w	+$16,+$00,+$38
	dc.w	+$00,-$1D,+$55
	dc.w	-$1D,+$00,+$55
	dc.w	+$00,+$1D,+$55
	dc.w	+$1D,+$00,+$55
	dc.w	+$00,-$18,+$6D
	dc.w	-$18,+$00,+$6D
	dc.w	+$00,+$18,+$6D
	dc.w	+$18,+$00,+$6D
	dc.l	F_cylindre

P_cylindre53:	dc.w	27
	dc.w	+$00,-$18,-$22
	dc.w	-$18,+$00,-$22
	dc.w	+$00,+$18,-$22
	dc.w	+$18,+$00,-$22
	dc.w	+$00,-$16,-$1E
	dc.w	-$16,+$00,-$1E
	dc.w	+$00,+$16,-$1E
	dc.w	+$16,+$00,-$1E
	dc.w	+$00,-$0F,-$0C
	dc.w	-$0F,+$00,-$0C
	dc.w	+$00,+$0F,-$0C
	dc.w	+$0F,+$00,-$0C
	dc.w	+$00,-$0B,+$18
	dc.w	-$0B,+$00,+$18
	dc.w	+$00,+$0B,+$18
	dc.w	+$0B,+$00,+$18
	dc.w	+$00,-$17,+$39
	dc.w	-$17,+$00,+$39
	dc.w	+$00,+$17,+$39
	dc.w	+$17,+$00,+$39
	dc.w	+$00,-$1D,+$56
	dc.w	-$1D,+$00,+$56
	dc.w	+$00,+$1D,+$56
	dc.w	+$1D,+$00,+$56
	dc.w	+$00,-$18,+$6D
	dc.w	-$18,+$00,+$6D
	dc.w	+$00,+$18,+$6D
	dc.w	+$18,+$00,+$6D
	dc.l	F_cylindre

P_cylindre54:	dc.w	27
	dc.w	+$00,-$18,-$24
	dc.w	-$18,+$00,-$24
	dc.w	+$00,+$18,-$24
	dc.w	+$18,+$00,-$24
	dc.w	+$00,-$17,-$20
	dc.w	-$17,+$00,-$20
	dc.w	+$00,+$17,-$20
	dc.w	+$17,+$00,-$20
	dc.w	+$00,-$0D,-$09
	dc.w	-$0D,+$00,-$09
	dc.w	+$00,+$0D,-$09
	dc.w	+$0D,+$00,-$09
	dc.w	+$00,-$0C,+$1A
	dc.w	-$0C,+$00,+$1A
	dc.w	+$00,+$0C,+$1A
	dc.w	+$0C,+$00,+$1A
	dc.w	+$00,-$18,+$3B
	dc.w	-$18,+$00,+$3B
	dc.w	+$00,+$18,+$3B
	dc.w	+$18,+$00,+$3B
	dc.w	+$00,-$1D,+$57
	dc.w	-$1D,+$00,+$57
	dc.w	+$00,+$1D,+$57
	dc.w	+$1D,+$00,+$57
	dc.w	+$00,-$18,+$6D
	dc.w	-$18,+$00,+$6D
	dc.w	+$00,+$18,+$6D
	dc.w	+$18,+$00,+$6D
	dc.l	F_cylindre

P_cylindre55:	dc.w	27
	dc.w	+$00,-$19,-$26
	dc.w	-$19,+$00,-$26
	dc.w	+$00,+$19,-$26
	dc.w	+$19,+$00,-$26
	dc.w	+$00,-$17,-$23
	dc.w	-$17,+$00,-$23
	dc.w	+$00,+$17,-$23
	dc.w	+$17,+$00,-$23
	dc.w	+$00,-$0C,-$07
	dc.w	-$0C,+$00,-$07
	dc.w	+$00,+$0C,-$07
	dc.w	+$0C,+$00,-$07
	dc.w	+$00,-$0D,+$1C
	dc.w	-$0D,+$00,+$1C
	dc.w	+$00,+$0D,+$1C
	dc.w	+$0D,+$00,+$1C
	dc.w	+$00,-$19,+$3C
	dc.w	-$19,+$00,+$3C
	dc.w	+$00,+$19,+$3C
	dc.w	+$19,+$00,+$3C
	dc.w	+$00,-$1D,+$58
	dc.w	-$1D,+$00,+$58
	dc.w	+$00,+$1D,+$58
	dc.w	+$1D,+$00,+$58
	dc.w	+$00,-$17,+$6D
	dc.w	-$17,+$00,+$6D
	dc.w	+$00,+$17,+$6D
	dc.w	+$17,+$00,+$6D
	dc.l	F_cylindre

P_cylindre56:	dc.w	27
	dc.w	+$00,-$19,-$28
	dc.w	-$19,+$00,-$28
	dc.w	+$00,+$19,-$28
	dc.w	+$19,+$00,-$28
	dc.w	+$00,-$18,-$25
	dc.w	-$18,+$00,-$25
	dc.w	+$00,+$18,-$25
	dc.w	+$18,+$00,-$25
	dc.w	+$00,-$0B,-$04
	dc.w	-$0B,+$00,-$04
	dc.w	+$00,+$0B,-$04
	dc.w	+$0B,+$00,-$04
	dc.w	+$00,-$0E,+$1E
	dc.w	-$0E,+$00,+$1E
	dc.w	+$00,+$0E,+$1E
	dc.w	+$0E,+$00,+$1E
	dc.w	+$00,-$1A,+$3E
	dc.w	-$1A,+$00,+$3E
	dc.w	+$00,+$1A,+$3E
	dc.w	+$1A,+$00,+$3E
	dc.w	+$00,-$1D,+$58
	dc.w	-$1D,+$00,+$58
	dc.w	+$00,+$1D,+$58
	dc.w	+$1D,+$00,+$58
	dc.w	+$00,-$17,+$6D
	dc.w	-$17,+$00,+$6D
	dc.w	+$00,+$17,+$6D
	dc.w	+$17,+$00,+$6D
	dc.l	F_cylindre

P_cylindre57:	dc.w	27
	dc.w	+$00,-$1A,-$2B
	dc.w	-$1A,+$00,-$2B
	dc.w	+$00,+$1A,-$2B
	dc.w	+$1A,+$00,-$2B
	dc.w	+$00,-$18,-$27
	dc.w	-$18,+$00,-$27
	dc.w	+$00,+$18,-$27
	dc.w	+$18,+$00,-$27
	dc.w	+$00,-$0B,-$02
	dc.w	-$0B,+$00,-$02
	dc.w	+$00,+$0B,-$02
	dc.w	+$0B,+$00,-$02
	dc.w	+$00,-$0F,+$20
	dc.w	-$0F,+$00,+$20
	dc.w	+$00,+$0F,+$20
	dc.w	+$0F,+$00,+$20
	dc.w	+$00,-$1B,+$3F
	dc.w	-$1B,+$00,+$3F
	dc.w	+$00,+$1B,+$3F
	dc.w	+$1B,+$00,+$3F
	dc.w	+$00,-$1D,+$59
	dc.w	-$1D,+$00,+$59
	dc.w	+$00,+$1D,+$59
	dc.w	+$1D,+$00,+$59
	dc.w	+$00,-$16,+$6D
	dc.w	-$16,+$00,+$6D
	dc.w	+$00,+$16,+$6D
	dc.w	+$16,+$00,+$6D
	dc.l	F_cylindre

P_cylindre58:	dc.w	27
	dc.w	+$00,-$1A,-$2D
	dc.w	-$1A,+$00,-$2D
	dc.w	+$00,+$1A,-$2D
	dc.w	+$1A,+$00,-$2D
	dc.w	+$00,-$17,-$25
	dc.w	-$17,+$00,-$25
	dc.w	+$00,+$17,-$25
	dc.w	+$17,+$00,-$25
	dc.w	+$00,-$0A,+$00
	dc.w	-$0A,+$00,+$00
	dc.w	+$00,+$0A,+$00
	dc.w	+$0A,+$00,+$00
	dc.w	+$00,-$10,+$22
	dc.w	-$10,+$00,+$22
	dc.w	+$00,+$10,+$22
	dc.w	+$10,+$00,+$22
	dc.w	+$00,-$1C,+$40
	dc.w	-$1C,+$00,+$40
	dc.w	+$00,+$1C,+$40
	dc.w	+$1C,+$00,+$40
	dc.w	+$00,-$1C,+$59
	dc.w	-$1C,+$00,+$59
	dc.w	+$00,+$1C,+$59
	dc.w	+$1C,+$00,+$59
	dc.w	+$00,-$16,+$6C
	dc.w	-$16,+$00,+$6C
	dc.w	+$00,+$16,+$6C
	dc.w	+$16,+$00,+$6C
	dc.l	F_cylindre

P_cylindre59:	dc.w	27
	dc.w	+$00,-$1A,-$2F
	dc.w	-$1A,+$00,-$2F
	dc.w	+$00,+$1A,-$2F
	dc.w	+$1A,+$00,-$2F
	dc.w	+$00,-$15,-$22
	dc.w	-$15,+$00,-$22
	dc.w	+$00,+$15,-$22
	dc.w	+$15,+$00,-$22
	dc.w	+$00,-$0A,+$01
	dc.w	-$0A,+$00,+$01
	dc.w	+$00,+$0A,+$01
	dc.w	+$0A,+$00,+$01
	dc.w	+$00,-$11,+$23
	dc.w	-$11,+$00,+$23
	dc.w	+$00,+$11,+$23
	dc.w	+$11,+$00,+$23
	dc.w	+$00,-$1C,+$41
	dc.w	-$1C,+$00,+$41
	dc.w	+$00,+$1C,+$41
	dc.w	+$1C,+$00,+$41
	dc.w	+$00,-$1C,+$59
	dc.w	-$1C,+$00,+$59
	dc.w	+$00,+$1C,+$59
	dc.w	+$1C,+$00,+$59
	dc.w	+$00,-$16,+$6C
	dc.w	-$16,+$00,+$6C
	dc.w	+$00,+$16,+$6C
	dc.w	+$16,+$00,+$6C
	dc.l	F_cylindre

P_cylindre60:	dc.w	27
	dc.w	+$00,-$1B,-$32
	dc.w	-$1B,+$00,-$32
	dc.w	+$00,+$1B,-$32
	dc.w	+$1B,+$00,-$32
	dc.w	+$00,-$14,-$20
	dc.w	-$14,+$00,-$20
	dc.w	+$00,+$14,-$20
	dc.w	+$14,+$00,-$20
	dc.w	+$00,-$0A,+$04
	dc.w	-$0A,+$00,+$04
	dc.w	+$00,+$0A,+$04
	dc.w	+$0A,+$00,+$04
	dc.w	+$00,-$12,+$25
	dc.w	-$12,+$00,+$25
	dc.w	+$00,+$12,+$25
	dc.w	+$12,+$00,+$25
	dc.w	+$00,-$1D,+$42
	dc.w	-$1D,+$00,+$42
	dc.w	+$00,+$1D,+$42
	dc.w	+$1D,+$00,+$42
	dc.w	+$00,-$1C,+$59
	dc.w	-$1C,+$00,+$59
	dc.w	+$00,+$1C,+$59
	dc.w	+$1C,+$00,+$59
	dc.w	+$00,-$16,+$6B
	dc.w	-$16,+$00,+$6B
	dc.w	+$00,+$16,+$6B
	dc.w	+$16,+$00,+$6B
	dc.l	F_cylindre

P_cylindre61:	dc.w	27
	dc.w	+$00,-$1B,-$34
	dc.w	-$1B,+$00,-$34
	dc.w	+$00,+$1B,-$34
	dc.w	+$1B,+$00,-$34
	dc.w	+$00,-$12,-$1D
	dc.w	-$12,+$00,-$1D
	dc.w	+$00,+$12,-$1D
	dc.w	+$12,+$00,-$1D
	dc.w	+$00,-$0A,+$06
	dc.w	-$0A,+$00,+$06
	dc.w	+$00,+$0A,+$06
	dc.w	+$0A,+$00,+$06
	dc.w	+$00,-$13,+$27
	dc.w	-$13,+$00,+$27
	dc.w	+$00,+$13,+$27
	dc.w	+$13,+$00,+$27
	dc.w	+$00,-$1D,+$43
	dc.w	-$1D,+$00,+$43
	dc.w	+$00,+$1D,+$43
	dc.w	+$1D,+$00,+$43
	dc.w	+$00,-$1C,+$59
	dc.w	-$1C,+$00,+$59
	dc.w	+$00,+$1C,+$59
	dc.w	+$1C,+$00,+$59
	dc.w	+$00,-$16,+$6A
	dc.w	-$16,+$00,+$6A
	dc.w	+$00,+$16,+$6A
	dc.w	+$16,+$00,+$6A
	dc.l	F_cylindre

P_cylindre62:	dc.w	27
	dc.w	+$00,-$1B,-$37
	dc.w	-$1B,+$00,-$37
	dc.w	+$00,+$1B,-$37
	dc.w	+$1B,+$00,-$37
	dc.w	+$00,-$11,-$1B
	dc.w	-$11,+$00,-$1B
	dc.w	+$00,+$11,-$1B
	dc.w	+$11,+$00,-$1B
	dc.w	+$00,-$0A,+$08
	dc.w	-$0A,+$00,+$08
	dc.w	+$00,+$0A,+$08
	dc.w	+$0A,+$00,+$08
	dc.w	+$00,-$15,+$28
	dc.w	-$15,+$00,+$28
	dc.w	+$00,+$15,+$28
	dc.w	+$15,+$00,+$28
	dc.w	+$00,-$1D,+$44
	dc.w	-$1D,+$00,+$44
	dc.w	+$00,+$1D,+$44
	dc.w	+$1D,+$00,+$44
	dc.w	+$00,-$1B,+$59
	dc.w	-$1B,+$00,+$59
	dc.w	+$00,+$1B,+$59
	dc.w	+$1B,+$00,+$59
	dc.w	+$00,-$16,+$69
	dc.w	-$16,+$00,+$69
	dc.w	+$00,+$16,+$69
	dc.w	+$16,+$00,+$69
	dc.l	F_cylindre

P_cylindre63:	dc.w	27
	dc.w	+$00,-$1C,-$39
	dc.w	-$1C,+$00,-$39
	dc.w	+$00,+$1C,-$39
	dc.w	+$1C,+$00,-$39
	dc.w	+$00,-$0F,-$19
	dc.w	-$0F,+$00,-$19
	dc.w	+$00,+$0F,-$19
	dc.w	+$0F,+$00,-$19
	dc.w	+$00,-$0A,+$0A
	dc.w	-$0A,+$00,+$0A
	dc.w	+$00,+$0A,+$0A
	dc.w	+$0A,+$00,+$0A
	dc.w	+$00,-$16,+$2A
	dc.w	-$16,+$00,+$2A
	dc.w	+$00,+$16,+$2A
	dc.w	+$16,+$00,+$2A
	dc.w	+$00,-$1D,+$44
	dc.w	-$1D,+$00,+$44
	dc.w	+$00,+$1D,+$44
	dc.w	+$1D,+$00,+$44
	dc.w	+$00,-$1B,+$59
	dc.w	-$1B,+$00,+$59
	dc.w	+$00,+$1B,+$59
	dc.w	+$1B,+$00,+$59
	dc.w	+$00,-$16,+$68
	dc.w	-$16,+$00,+$68
	dc.w	+$00,+$16,+$68
	dc.w	+$16,+$00,+$68
	dc.l	F_cylindre

P_cylindre64:	dc.w	27
	dc.w	+$00,-$1C,-$3C
	dc.w	-$1C,+$00,-$3C
	dc.w	+$00,+$1C,-$3C
	dc.w	+$1C,+$00,-$3C
	dc.w	+$00,-$0E,-$16
	dc.w	-$0E,+$00,-$16
	dc.w	+$00,+$0E,-$16
	dc.w	+$0E,+$00,-$16
	dc.w	+$00,-$0B,+$0C
	dc.w	-$0B,+$00,+$0C
	dc.w	+$00,+$0B,+$0C
	dc.w	+$0B,+$00,+$0C
	dc.w	+$00,-$17,+$2B
	dc.w	-$17,+$00,+$2B
	dc.w	+$00,+$17,+$2B
	dc.w	+$17,+$00,+$2B
	dc.w	+$00,-$1D,+$45
	dc.w	-$1D,+$00,+$45
	dc.w	+$00,+$1D,+$45
	dc.w	+$1D,+$00,+$45
	dc.w	+$00,-$1B,+$59
	dc.w	-$1B,+$00,+$59
	dc.w	+$00,+$1B,+$59
	dc.w	+$1B,+$00,+$59
	dc.w	+$00,-$16,+$67
	dc.w	-$16,+$00,+$67
	dc.w	+$00,+$16,+$67
	dc.w	+$16,+$00,+$67
	dc.l	F_cylindre

P_cylindre65:	dc.w	27
	dc.w	+$00,-$1B,-$39
	dc.w	-$1B,+$00,-$39
	dc.w	+$00,+$1B,-$39
	dc.w	+$1B,+$00,-$39
	dc.w	+$00,-$0D,-$14
	dc.w	-$0D,+$00,-$14
	dc.w	+$00,+$0D,-$14
	dc.w	+$0D,+$00,-$14
	dc.w	+$00,-$0C,+$0D
	dc.w	-$0C,+$00,+$0D
	dc.w	+$00,+$0C,+$0D
	dc.w	+$0C,+$00,+$0D
	dc.w	+$00,-$18,+$2C
	dc.w	-$18,+$00,+$2C
	dc.w	+$00,+$18,+$2C
	dc.w	+$18,+$00,+$2C
	dc.w	+$00,-$1D,+$45
	dc.w	-$1D,+$00,+$45
	dc.w	+$00,+$1D,+$45
	dc.w	+$1D,+$00,+$45
	dc.w	+$00,-$1B,+$58
	dc.w	-$1B,+$00,+$58
	dc.w	+$00,+$1B,+$58
	dc.w	+$1B,+$00,+$58
	dc.w	+$00,-$16,+$66
	dc.w	-$16,+$00,+$66
	dc.w	+$00,+$16,+$66
	dc.w	+$16,+$00,+$66
	dc.l	F_cylindre

P_cylindre66:	dc.w	27
	dc.w	+$00,-$1A,-$37
	dc.w	-$1A,+$00,-$37
	dc.w	+$00,+$1A,-$37
	dc.w	+$1A,+$00,-$37
	dc.w	+$00,-$0C,-$12
	dc.w	-$0C,+$00,-$12
	dc.w	+$00,+$0C,-$12
	dc.w	+$0C,+$00,-$12
	dc.w	+$00,-$0C,+$0F
	dc.w	-$0C,+$00,+$0F
	dc.w	+$00,+$0C,+$0F
	dc.w	+$0C,+$00,+$0F
	dc.w	+$00,-$18,+$2D
	dc.w	-$18,+$00,+$2D
	dc.w	+$00,+$18,+$2D
	dc.w	+$18,+$00,+$2D
	dc.w	+$00,-$1D,+$45
	dc.w	-$1D,+$00,+$45
	dc.w	+$00,+$1D,+$45
	dc.w	+$1D,+$00,+$45
	dc.w	+$00,-$1A,+$58
	dc.w	-$1A,+$00,+$58
	dc.w	+$00,+$1A,+$58
	dc.w	+$1A,+$00,+$58
	dc.w	+$00,-$16,+$64
	dc.w	-$16,+$00,+$64
	dc.w	+$00,+$16,+$64
	dc.w	+$16,+$00,+$64
	dc.l	F_cylindre

P_cylindre67:	dc.w	27
	dc.w	+$00,-$19,-$34
	dc.w	-$19,+$00,-$34
	dc.w	+$00,+$19,-$34
	dc.w	+$19,+$00,-$34
	dc.w	+$00,-$0B,-$10
	dc.w	-$0B,+$00,-$10
	dc.w	+$00,+$0B,-$10
	dc.w	+$0B,+$00,-$10
	dc.w	+$00,-$0D,+$11
	dc.w	-$0D,+$00,+$11
	dc.w	+$00,+$0D,+$11
	dc.w	+$0D,+$00,+$11
	dc.w	+$00,-$19,+$2E
	dc.w	-$19,+$00,+$2E
	dc.w	+$00,+$19,+$2E
	dc.w	+$19,+$00,+$2E
	dc.w	+$00,-$1D,+$45
	dc.w	-$1D,+$00,+$45
	dc.w	+$00,+$1D,+$45
	dc.w	+$1D,+$00,+$45
	dc.w	+$00,-$1A,+$57
	dc.w	-$1A,+$00,+$57
	dc.w	+$00,+$1A,+$57
	dc.w	+$1A,+$00,+$57
	dc.w	+$00,-$16,+$63
	dc.w	-$16,+$00,+$63
	dc.w	+$00,+$16,+$63
	dc.w	+$16,+$00,+$63
	dc.l	F_cylindre

P_cylindre68:	dc.w	27
	dc.w	+$00,-$18,-$32
	dc.w	-$18,+$00,-$32
	dc.w	+$00,+$18,-$32
	dc.w	+$18,+$00,-$32
	dc.w	+$00,-$0A,-$0E
	dc.w	-$0A,+$00,-$0E
	dc.w	+$00,+$0A,-$0E
	dc.w	+$0A,+$00,-$0E
	dc.w	+$00,-$0E,+$12
	dc.w	-$0E,+$00,+$12
	dc.w	+$00,+$0E,+$12
	dc.w	+$0E,+$00,+$12
	dc.w	+$00,-$1A,+$2F
	dc.w	-$1A,+$00,+$2F
	dc.w	+$00,+$1A,+$2F
	dc.w	+$1A,+$00,+$2F
	dc.w	+$00,-$1D,+$45
	dc.w	-$1D,+$00,+$45
	dc.w	+$00,+$1D,+$45
	dc.w	+$1D,+$00,+$45
	dc.w	+$00,-$1A,+$56
	dc.w	-$1A,+$00,+$56
	dc.w	+$00,+$1A,+$56
	dc.w	+$1A,+$00,+$56
	dc.w	+$00,-$16,+$61
	dc.w	-$16,+$00,+$61
	dc.w	+$00,+$16,+$61
	dc.w	+$16,+$00,+$61
	dc.l	F_cylindre

P_cylindre69:	dc.w	27
	dc.w	+$00,-$16,-$2F
	dc.w	-$16,+$00,-$2F
	dc.w	+$00,+$16,-$2F
	dc.w	+$16,+$00,-$2F
	dc.w	+$00,-$0A,-$0B
	dc.w	-$0A,+$00,-$0B
	dc.w	+$00,+$0A,-$0B
	dc.w	+$0A,+$00,-$0B
	dc.w	+$00,-$0F,+$14
	dc.w	-$0F,+$00,+$14
	dc.w	+$00,+$0F,+$14
	dc.w	+$0F,+$00,+$14
	dc.w	+$00,-$1A,+$30
	dc.w	-$1A,+$00,+$30
	dc.w	+$00,+$1A,+$30
	dc.w	+$1A,+$00,+$30
	dc.w	+$00,-$1D,+$45
	dc.w	-$1D,+$00,+$45
	dc.w	+$00,+$1D,+$45
	dc.w	+$1D,+$00,+$45
	dc.w	+$00,-$1A,+$55
	dc.w	-$1A,+$00,+$55
	dc.w	+$00,+$1A,+$55
	dc.w	+$1A,+$00,+$55
	dc.w	+$00,-$16,+$5F
	dc.w	-$16,+$00,+$5F
	dc.w	+$00,+$16,+$5F
	dc.w	+$16,+$00,+$5F
	dc.l	F_cylindre

P_cylindre70:	dc.w	27
	dc.w	+$00,-$15,-$2D
	dc.w	-$15,+$00,-$2D
	dc.w	+$00,+$15,-$2D
	dc.w	+$15,+$00,-$2D
	dc.w	+$00,-$0A,-$09
	dc.w	-$0A,+$00,-$09
	dc.w	+$00,+$0A,-$09
	dc.w	+$0A,+$00,-$09
	dc.w	+$00,-$10,+$15
	dc.w	-$10,+$00,+$15
	dc.w	+$00,+$10,+$15
	dc.w	+$10,+$00,+$15
	dc.w	+$00,-$1B,+$30
	dc.w	-$1B,+$00,+$30
	dc.w	+$00,+$1B,+$30
	dc.w	+$1B,+$00,+$30
	dc.w	+$00,-$1D,+$45
	dc.w	-$1D,+$00,+$45
	dc.w	+$00,+$1D,+$45
	dc.w	+$1D,+$00,+$45
	dc.w	+$00,-$1A,+$54
	dc.w	-$1A,+$00,+$54
	dc.w	+$00,+$1A,+$54
	dc.w	+$1A,+$00,+$54
	dc.w	+$00,-$17,+$5E
	dc.w	-$17,+$00,+$5E
	dc.w	+$00,+$17,+$5E
	dc.w	+$17,+$00,+$5E
	dc.l	F_cylindre

P_cylindre71:	dc.w	27
	dc.w	+$00,-$13,-$2B
	dc.w	-$13,+$00,-$2B
	dc.w	+$00,+$13,-$2B
	dc.w	+$13,+$00,-$2B
	dc.w	+$00,-$0A,-$08
	dc.w	-$0A,+$00,-$08
	dc.w	+$00,+$0A,-$08
	dc.w	+$0A,+$00,-$08
	dc.w	+$00,-$11,+$17
	dc.w	-$11,+$00,+$17
	dc.w	+$00,+$11,+$17
	dc.w	+$11,+$00,+$17
	dc.w	+$00,-$1B,+$31
	dc.w	-$1B,+$00,+$31
	dc.w	+$00,+$1B,+$31
	dc.w	+$1B,+$00,+$31
	dc.w	+$00,-$1D,+$45
	dc.w	-$1D,+$00,+$45
	dc.w	+$00,+$1D,+$45
	dc.w	+$1D,+$00,+$45
	dc.w	+$00,-$1A,+$53
	dc.w	-$1A,+$00,+$53
	dc.w	+$00,+$1A,+$53
	dc.w	+$1A,+$00,+$53
	dc.w	+$00,-$17,+$5C
	dc.w	-$17,+$00,+$5C
	dc.w	+$00,+$17,+$5C
	dc.w	+$17,+$00,+$5C
	dc.l	F_cylindre

P_cylindre72:	dc.w	27
	dc.w	+$00,-$12,-$28
	dc.w	-$12,+$00,-$28
	dc.w	+$00,+$12,-$28
	dc.w	+$12,+$00,-$28
	dc.w	+$00,-$0A,-$06
	dc.w	-$0A,+$00,-$06
	dc.w	+$00,+$0A,-$06
	dc.w	+$0A,+$00,-$06
	dc.w	+$00,-$12,+$18
	dc.w	-$12,+$00,+$18
	dc.w	+$00,+$12,+$18
	dc.w	+$12,+$00,+$18
	dc.w	+$00,-$1C,+$31
	dc.w	-$1C,+$00,+$31
	dc.w	+$00,+$1C,+$31
	dc.w	+$1C,+$00,+$31
	dc.w	+$00,-$1D,+$44
	dc.w	-$1D,+$00,+$44
	dc.w	+$00,+$1D,+$44
	dc.w	+$1D,+$00,+$44
	dc.w	+$00,-$1A,+$52
	dc.w	-$1A,+$00,+$52
	dc.w	+$00,+$1A,+$52
	dc.w	+$1A,+$00,+$52
	dc.w	+$00,-$17,+$5A
	dc.w	-$17,+$00,+$5A
	dc.w	+$00,+$17,+$5A
	dc.w	+$17,+$00,+$5A
	dc.l	F_cylindre

P_cylindre73:	dc.w	27
	dc.w	+$00,-$10,-$26
	dc.w	-$10,+$00,-$26
	dc.w	+$00,+$10,-$26
	dc.w	+$10,+$00,-$26
	dc.w	+$00,-$0A,-$04
	dc.w	-$0A,+$00,-$04
	dc.w	+$00,+$0A,-$04
	dc.w	+$0A,+$00,-$04
	dc.w	+$00,-$13,+$19
	dc.w	-$13,+$00,+$19
	dc.w	+$00,+$13,+$19
	dc.w	+$13,+$00,+$19
	dc.w	+$00,-$1C,+$31
	dc.w	-$1C,+$00,+$31
	dc.w	+$00,+$1C,+$31
	dc.w	+$1C,+$00,+$31
	dc.w	+$00,-$1D,+$44
	dc.w	-$1D,+$00,+$44
	dc.w	+$00,+$1D,+$44
	dc.w	+$1D,+$00,+$44
	dc.w	+$00,-$1A,+$50
	dc.w	-$1A,+$00,+$50
	dc.w	+$00,+$1A,+$50
	dc.w	+$1A,+$00,+$50
	dc.w	+$00,-$18,+$58
	dc.w	-$18,+$00,+$58
	dc.w	+$00,+$18,+$58
	dc.w	+$18,+$00,+$58
	dc.l	F_cylindre

P_cylindre74:	dc.w	27
	dc.w	+$00,-$0F,-$24
	dc.w	-$0F,+$00,-$24
	dc.w	+$00,+$0F,-$24
	dc.w	+$0F,+$00,-$24
	dc.w	+$00,-$0A,-$02
	dc.w	-$0A,+$00,-$02
	dc.w	+$00,+$0A,-$02
	dc.w	+$0A,+$00,-$02
	dc.w	+$00,-$14,+$1A
	dc.w	-$14,+$00,+$1A
	dc.w	+$00,+$14,+$1A
	dc.w	+$14,+$00,+$1A
	dc.w	+$00,-$1C,+$31
	dc.w	-$1C,+$00,+$31
	dc.w	+$00,+$1C,+$31
	dc.w	+$1C,+$00,+$31
	dc.w	+$00,-$1D,+$43
	dc.w	-$1D,+$00,+$43
	dc.w	+$00,+$1D,+$43
	dc.w	+$1D,+$00,+$43
	dc.w	+$00,-$1A,+$4F
	dc.w	-$1A,+$00,+$4F
	dc.w	+$00,+$1A,+$4F
	dc.w	+$1A,+$00,+$4F
	dc.w	+$00,-$18,+$56
	dc.w	-$18,+$00,+$56
	dc.w	+$00,+$18,+$56
	dc.w	+$18,+$00,+$56
	dc.l	F_cylindre

P_cylindre75:	dc.w	27
	dc.w	+$00,-$0E,-$22
	dc.w	-$0E,+$00,-$22
	dc.w	+$00,+$0E,-$22
	dc.w	+$0E,+$00,-$22
	dc.w	+$00,-$0B,-$01
	dc.w	-$0B,+$00,-$01
	dc.w	+$00,+$0B,-$01
	dc.w	+$0B,+$00,-$01
	dc.w	+$00,-$15,+$1B
	dc.w	-$15,+$00,+$1B
	dc.w	+$00,+$15,+$1B
	dc.w	+$15,+$00,+$1B
	dc.w	+$00,-$1D,+$31
	dc.w	-$1D,+$00,+$31
	dc.w	+$00,+$1D,+$31
	dc.w	+$1D,+$00,+$31
	dc.w	+$00,-$1D,+$42
	dc.w	-$1D,+$00,+$42
	dc.w	+$00,+$1D,+$42
	dc.w	+$1D,+$00,+$42
	dc.w	+$00,-$1B,+$4D
	dc.w	-$1B,+$00,+$4D
	dc.w	+$00,+$1B,+$4D
	dc.w	+$1B,+$00,+$4D
	dc.w	+$00,-$18,+$54
	dc.w	-$18,+$00,+$54
	dc.w	+$00,+$18,+$54
	dc.w	+$18,+$00,+$54
	dc.l	F_cylindre

P_cylindre76:	dc.w	27
	dc.w	+$00,-$0D,-$20
	dc.w	-$0D,+$00,-$20
	dc.w	+$00,+$0D,-$20
	dc.w	+$0D,+$00,-$20
	dc.w	+$00,-$0B,+$00
	dc.w	-$0B,+$00,+$00
	dc.w	+$00,+$0B,+$00
	dc.w	+$0B,+$00,+$00
	dc.w	+$00,-$16,+$1C
	dc.w	-$16,+$00,+$1C
	dc.w	+$00,+$16,+$1C
	dc.w	+$16,+$00,+$1C
	dc.w	+$00,-$1D,+$31
	dc.w	-$1D,+$00,+$31
	dc.w	+$00,+$1D,+$31
	dc.w	+$1D,+$00,+$31
	dc.w	+$00,-$1D,+$41
	dc.w	-$1D,+$00,+$41
	dc.w	+$00,+$1D,+$41
	dc.w	+$1D,+$00,+$41
	dc.w	+$00,-$1B,+$4C
	dc.w	-$1B,+$00,+$4C
	dc.w	+$00,+$1B,+$4C
	dc.w	+$1B,+$00,+$4C
	dc.w	+$00,-$19,+$52
	dc.w	-$19,+$00,+$52
	dc.w	+$00,+$19,+$52
	dc.w	+$19,+$00,+$52
	dc.l	F_cylindre

P_cylindre77:	dc.w	27
	dc.w	+$00,-$0C,-$1E
	dc.w	-$0C,+$00,-$1E
	dc.w	+$00,+$0C,-$1E
	dc.w	+$0C,+$00,-$1E
	dc.w	+$00,-$0C,+$01
	dc.w	-$0C,+$00,+$01
	dc.w	+$00,+$0C,+$01
	dc.w	+$0C,+$00,+$01
	dc.w	+$00,-$17,+$1C
	dc.w	-$17,+$00,+$1C
	dc.w	+$00,+$17,+$1C
	dc.w	+$17,+$00,+$1C
	dc.w	+$00,-$1D,+$31
	dc.w	-$1D,+$00,+$31
	dc.w	+$00,+$1D,+$31
	dc.w	+$1D,+$00,+$31
	dc.w	+$00,-$1D,+$40
	dc.w	-$1D,+$00,+$40
	dc.w	+$00,+$1D,+$40
	dc.w	+$1D,+$00,+$40
	dc.w	+$00,-$1B,+$4A
	dc.w	-$1B,+$00,+$4A
	dc.w	+$00,+$1B,+$4A
	dc.w	+$1B,+$00,+$4A
	dc.w	+$00,-$19,+$4F
	dc.w	-$19,+$00,+$4F
	dc.w	+$00,+$19,+$4F
	dc.w	+$19,+$00,+$4F
	dc.l	F_cylindre

P_cylindre78:	dc.w	27
	dc.w	+$00,-$0B,-$1C
	dc.w	-$0B,+$00,-$1C
	dc.w	+$00,+$0B,-$1C
	dc.w	+$0B,+$00,-$1C
	dc.w	+$00,-$0D,+$03
	dc.w	-$0D,+$00,+$03
	dc.w	+$00,+$0D,+$03
	dc.w	+$0D,+$00,+$03
	dc.w	+$00,-$17,+$1D
	dc.w	-$17,+$00,+$1D
	dc.w	+$00,+$17,+$1D
	dc.w	+$17,+$00,+$1D
	dc.w	+$00,-$1D,+$31
	dc.w	-$1D,+$00,+$31
	dc.w	+$00,+$1D,+$31
	dc.w	+$1D,+$00,+$31
	dc.w	+$00,-$1D,+$3F
	dc.w	-$1D,+$00,+$3F
	dc.w	+$00,+$1D,+$3F
	dc.w	+$1D,+$00,+$3F
	dc.w	+$00,-$1B,+$48
	dc.w	-$1B,+$00,+$48
	dc.w	+$00,+$1B,+$48
	dc.w	+$1B,+$00,+$48
	dc.w	+$00,-$19,+$4D
	dc.w	-$19,+$00,+$4D
	dc.w	+$00,+$19,+$4D
	dc.w	+$19,+$00,+$4D
	dc.l	F_cylindre

P_cylindre79:	dc.w	27
	dc.w	+$00,-$0A,-$1A
	dc.w	-$0A,+$00,-$1A
	dc.w	+$00,+$0A,-$1A
	dc.w	+$0A,+$00,-$1A
	dc.w	+$00,-$0D,+$04
	dc.w	-$0D,+$00,+$04
	dc.w	+$00,+$0D,+$04
	dc.w	+$0D,+$00,+$04
	dc.w	+$00,-$18,+$1D
	dc.w	-$18,+$00,+$1D
	dc.w	+$00,+$18,+$1D
	dc.w	+$18,+$00,+$1D
	dc.w	+$00,-$1D,+$30
	dc.w	-$1D,+$00,+$30
	dc.w	+$00,+$1D,+$30
	dc.w	+$1D,+$00,+$30
	dc.w	+$00,-$1D,+$3E
	dc.w	-$1D,+$00,+$3E
	dc.w	+$00,+$1D,+$3E
	dc.w	+$1D,+$00,+$3E
	dc.w	+$00,-$1B,+$46
	dc.w	-$1B,+$00,+$46
	dc.w	+$00,+$1B,+$46
	dc.w	+$1B,+$00,+$46
	dc.w	+$00,-$1A,+$4B
	dc.w	-$1A,+$00,+$4B
	dc.w	+$00,+$1A,+$4B
	dc.w	+$1A,+$00,+$4B
	dc.l	F_cylindre

P_cylindre80:	dc.w	27
	dc.w	+$00,-$0A,-$18
	dc.w	-$0A,+$00,-$18
	dc.w	+$00,+$0A,-$18
	dc.w	+$0A,+$00,-$18
	dc.w	+$00,-$0E,+$05
	dc.w	-$0E,+$00,+$05
	dc.w	+$00,+$0E,+$05
	dc.w	+$0E,+$00,+$05
	dc.w	+$00,-$18,+$1D
	dc.w	-$18,+$00,+$1D
	dc.w	+$00,+$18,+$1D
	dc.w	+$18,+$00,+$1D
	dc.w	+$00,-$1D,+$30
	dc.w	-$1D,+$00,+$30
	dc.w	+$00,+$1D,+$30
	dc.w	+$1D,+$00,+$30
	dc.w	+$00,-$1D,+$3C
	dc.w	-$1D,+$00,+$3C
	dc.w	+$00,+$1D,+$3C
	dc.w	+$1D,+$00,+$3C
	dc.w	+$00,-$1C,+$44
	dc.w	-$1C,+$00,+$44
	dc.w	+$00,+$1C,+$44
	dc.w	+$1C,+$00,+$44
	dc.w	+$00,-$1A,+$48
	dc.w	-$1A,+$00,+$48
	dc.w	+$00,+$1A,+$48
	dc.w	+$1A,+$00,+$48
	dc.l	F_cylindre

P_cylindre81:	dc.w	27
	dc.w	+$00,-$0A,-$16
	dc.w	-$0A,+$00,-$16
	dc.w	+$00,+$0A,-$16
	dc.w	+$0A,+$00,-$16
	dc.w	+$00,-$0F,+$06
	dc.w	-$0F,+$00,+$06
	dc.w	+$00,+$0F,+$06
	dc.w	+$0F,+$00,+$06
	dc.w	+$00,-$19,+$1D
	dc.w	-$19,+$00,+$1D
	dc.w	+$00,+$19,+$1D
	dc.w	+$19,+$00,+$1D
	dc.w	+$00,-$1D,+$2F
	dc.w	-$1D,+$00,+$2F
	dc.w	+$00,+$1D,+$2F
	dc.w	+$1D,+$00,+$2F
	dc.w	+$00,-$1D,+$3B
	dc.w	-$1D,+$00,+$3B
	dc.w	+$00,+$1D,+$3B
	dc.w	+$1D,+$00,+$3B
	dc.w	+$00,-$1C,+$42
	dc.w	-$1C,+$00,+$42
	dc.w	+$00,+$1C,+$42
	dc.w	+$1C,+$00,+$42
	dc.w	+$00,-$1B,+$46
	dc.w	-$1B,+$00,+$46
	dc.w	+$00,+$1B,+$46
	dc.w	+$1B,+$00,+$46
	dc.l	F_cylindre

P_cylindre82:	dc.w	27
	dc.w	+$00,-$0A,-$15
	dc.w	-$0A,+$00,-$15
	dc.w	+$00,+$0A,-$15
	dc.w	+$0A,+$00,-$15
	dc.w	+$00,-$10,+$07
	dc.w	-$10,+$00,+$07
	dc.w	+$00,+$10,+$07
	dc.w	+$10,+$00,+$07
	dc.w	+$00,-$19,+$1D
	dc.w	-$19,+$00,+$1D
	dc.w	+$00,+$19,+$1D
	dc.w	+$19,+$00,+$1D
	dc.w	+$00,-$1D,+$2E
	dc.w	-$1D,+$00,+$2E
	dc.w	+$00,+$1D,+$2E
	dc.w	+$1D,+$00,+$2E
	dc.w	+$00,-$1D,+$39
	dc.w	-$1D,+$00,+$39
	dc.w	+$00,+$1D,+$39
	dc.w	+$1D,+$00,+$39
	dc.w	+$00,-$1C,+$40
	dc.w	-$1C,+$00,+$40
	dc.w	+$00,+$1C,+$40
	dc.w	+$1C,+$00,+$40
	dc.w	+$00,-$1B,+$44
	dc.w	-$1B,+$00,+$44
	dc.w	+$00,+$1B,+$44
	dc.w	+$1B,+$00,+$44
	dc.l	F_cylindre

P_cylindre83:	dc.w	27
	dc.w	+$00,-$0A,-$13
	dc.w	-$0A,+$00,-$13
	dc.w	+$00,+$0A,-$13
	dc.w	+$0A,+$00,-$13
	dc.w	+$00,-$11,+$07
	dc.w	-$11,+$00,+$07
	dc.w	+$00,+$11,+$07
	dc.w	+$11,+$00,+$07
	dc.w	+$00,-$1A,+$1D
	dc.w	-$1A,+$00,+$1D
	dc.w	+$00,+$1A,+$1D
	dc.w	+$1A,+$00,+$1D
	dc.w	+$00,-$1D,+$2D
	dc.w	-$1D,+$00,+$2D
	dc.w	+$00,+$1D,+$2D
	dc.w	+$1D,+$00,+$2D
	dc.w	+$00,-$1D,+$38
	dc.w	-$1D,+$00,+$38
	dc.w	+$00,+$1D,+$38
	dc.w	+$1D,+$00,+$38
	dc.w	+$00,-$1C,+$3E
	dc.w	-$1C,+$00,+$3E
	dc.w	+$00,+$1C,+$3E
	dc.w	+$1C,+$00,+$3E
	dc.w	+$00,-$1B,+$41
	dc.w	-$1B,+$00,+$41
	dc.w	+$00,+$1B,+$41
	dc.w	+$1B,+$00,+$41
	dc.l	F_cylindre

P_cylindre84:	dc.w	27
	dc.w	+$00,-$0A,-$12
	dc.w	-$0A,+$00,-$12
	dc.w	+$00,+$0A,-$12
	dc.w	+$0A,+$00,-$12
	dc.w	+$00,-$11,+$08
	dc.w	-$11,+$00,+$08
	dc.w	+$00,+$11,+$08
	dc.w	+$11,+$00,+$08
	dc.w	+$00,-$1A,+$1D
	dc.w	-$1A,+$00,+$1D
	dc.w	+$00,+$1A,+$1D
	dc.w	+$1A,+$00,+$1D
	dc.w	+$00,-$1D,+$2C
	dc.w	-$1D,+$00,+$2C
	dc.w	+$00,+$1D,+$2C
	dc.w	+$1D,+$00,+$2C
	dc.w	+$00,-$1D,+$36
	dc.w	-$1D,+$00,+$36
	dc.w	+$00,+$1D,+$36
	dc.w	+$1D,+$00,+$36
	dc.w	+$00,-$1C,+$3C
	dc.w	-$1C,+$00,+$3C
	dc.w	+$00,+$1C,+$3C
	dc.w	+$1C,+$00,+$3C
	dc.w	+$00,-$1C,+$3F
	dc.w	-$1C,+$00,+$3F
	dc.w	+$00,+$1C,+$3F
	dc.w	+$1C,+$00,+$3F
	dc.l	F_cylindre

P_cylindre85:	dc.w	27
	dc.w	+$00,-$0A,-$11
	dc.w	-$0A,+$00,-$11
	dc.w	+$00,+$0A,-$11
	dc.w	+$0A,+$00,-$11
	dc.w	+$00,-$12,+$09
	dc.w	-$12,+$00,+$09
	dc.w	+$00,+$12,+$09
	dc.w	+$12,+$00,+$09
	dc.w	+$00,-$1A,+$1D
	dc.w	-$1A,+$00,+$1D
	dc.w	+$00,+$1A,+$1D
	dc.w	+$1A,+$00,+$1D
	dc.w	+$00,-$1D,+$2B
	dc.w	-$1D,+$00,+$2B
	dc.w	+$00,+$1D,+$2B
	dc.w	+$1D,+$00,+$2B
	dc.w	+$00,-$1D,+$34
	dc.w	-$1D,+$00,+$34
	dc.w	+$00,+$1D,+$34
	dc.w	+$1D,+$00,+$34
	dc.w	+$00,-$1D,+$39
	dc.w	-$1D,+$00,+$39
	dc.w	+$00,+$1D,+$39
	dc.w	+$1D,+$00,+$39
	dc.w	+$00,-$1C,+$3C
	dc.w	-$1C,+$00,+$3C
	dc.w	+$00,+$1C,+$3C
	dc.w	+$1C,+$00,+$3C
	dc.l	F_cylindre

P_cylindre86:	dc.w	27
	dc.w	+$00,-$0A,-$0F
	dc.w	-$0A,+$00,-$0F
	dc.w	+$00,+$0A,-$0F
	dc.w	+$0A,+$00,-$0F
	dc.w	+$00,-$13,+$09
	dc.w	-$13,+$00,+$09
	dc.w	+$00,+$13,+$09
	dc.w	+$13,+$00,+$09
	dc.w	+$00,-$1A,+$1C
	dc.w	-$1A,+$00,+$1C
	dc.w	+$00,+$1A,+$1C
	dc.w	+$1A,+$00,+$1C
	dc.w	+$00,-$1D,+$2A
	dc.w	-$1D,+$00,+$2A
	dc.w	+$00,+$1D,+$2A
	dc.w	+$1D,+$00,+$2A
	dc.w	+$00,-$1D,+$32
	dc.w	-$1D,+$00,+$32
	dc.w	+$00,+$1D,+$32
	dc.w	+$1D,+$00,+$32
	dc.w	+$00,-$1D,+$37
	dc.w	-$1D,+$00,+$37
	dc.w	+$00,+$1D,+$37
	dc.w	+$1D,+$00,+$37
	dc.w	+$00,-$1C,+$3D
	dc.w	-$1C,+$00,+$3D
	dc.w	+$00,+$1C,+$3D
	dc.w	+$1C,+$00,+$3D
	dc.l	F_cylindre

P_cylindre87:	dc.w	27
	dc.w	+$00,-$0B,-$0E
	dc.w	-$0B,+$00,-$0E
	dc.w	+$00,+$0B,-$0E
	dc.w	+$0B,+$00,-$0E
	dc.w	+$00,-$13,+$09
	dc.w	-$13,+$00,+$09
	dc.w	+$00,+$13,+$09
	dc.w	+$13,+$00,+$09
	dc.w	+$00,-$1B,+$1C
	dc.w	-$1B,+$00,+$1C
	dc.w	+$00,+$1B,+$1C
	dc.w	+$1B,+$00,+$1C
	dc.w	+$00,-$1D,+$29
	dc.w	-$1D,+$00,+$29
	dc.w	+$00,+$1D,+$29
	dc.w	+$1D,+$00,+$29
	dc.w	+$00,-$1D,+$30
	dc.w	-$1D,+$00,+$30
	dc.w	+$00,+$1D,+$30
	dc.w	+$1D,+$00,+$30
	dc.w	+$00,-$1D,+$35
	dc.w	-$1D,+$00,+$35
	dc.w	+$00,+$1D,+$35
	dc.w	+$1D,+$00,+$35
	dc.w	+$00,-$1B,+$40
	dc.w	-$1B,+$00,+$40
	dc.w	+$00,+$1B,+$40
	dc.w	+$1B,+$00,+$40
	dc.l	F_cylindre

P_cylindre88:	dc.w	27
	dc.w	+$00,-$0B,-$0D
	dc.w	-$0B,+$00,-$0D
	dc.w	+$00,+$0B,-$0D
	dc.w	+$0B,+$00,-$0D
	dc.w	+$00,-$14,+$09
	dc.w	-$14,+$00,+$09
	dc.w	+$00,+$14,+$09
	dc.w	+$14,+$00,+$09
	dc.w	+$00,-$1B,+$1B
	dc.w	-$1B,+$00,+$1B
	dc.w	+$00,+$1B,+$1B
	dc.w	+$1B,+$00,+$1B
	dc.w	+$00,-$1D,+$27
	dc.w	-$1D,+$00,+$27
	dc.w	+$00,+$1D,+$27
	dc.w	+$1D,+$00,+$27
	dc.w	+$00,-$1D,+$2E
	dc.w	-$1D,+$00,+$2E
	dc.w	+$00,+$1D,+$2E
	dc.w	+$1D,+$00,+$2E
	dc.w	+$00,-$1D,+$32
	dc.w	-$1D,+$00,+$32
	dc.w	+$00,+$1D,+$32
	dc.w	+$1D,+$00,+$32
	dc.w	+$00,-$19,+$42
	dc.w	-$19,+$00,+$42
	dc.w	+$00,+$19,+$42
	dc.w	+$19,+$00,+$42
	dc.l	F_cylindre

P_cylindre89:	dc.w	27
	dc.w	+$00,-$0C,-$0C
	dc.w	-$0C,+$00,-$0C
	dc.w	+$00,+$0C,-$0C
	dc.w	+$0C,+$00,-$0C
	dc.w	+$00,-$14,+$09
	dc.w	-$14,+$00,+$09
	dc.w	+$00,+$14,+$09
	dc.w	+$14,+$00,+$09
	dc.w	+$00,-$1B,+$1A
	dc.w	-$1B,+$00,+$1A
	dc.w	+$00,+$1B,+$1A
	dc.w	+$1B,+$00,+$1A
	dc.w	+$00,-$1D,+$26
	dc.w	-$1D,+$00,+$26
	dc.w	+$00,+$1D,+$26
	dc.w	+$1D,+$00,+$26
	dc.w	+$00,-$1D,+$2C
	dc.w	-$1D,+$00,+$2C
	dc.w	+$00,+$1D,+$2C
	dc.w	+$1D,+$00,+$2C
	dc.w	+$00,-$1D,+$30
	dc.w	-$1D,+$00,+$30
	dc.w	+$00,+$1D,+$30
	dc.w	+$1D,+$00,+$30
	dc.w	+$00,-$18,+$44
	dc.w	-$18,+$00,+$44
	dc.w	+$00,+$18,+$44
	dc.w	+$18,+$00,+$44
	dc.l	F_cylindre

P_cylindre90:	dc.w	27
	dc.w	+$00,-$0C,-$0C
	dc.w	-$0C,+$00,-$0C
	dc.w	+$00,+$0C,-$0C
	dc.w	+$0C,+$00,-$0C
	dc.w	+$00,-$15,+$09
	dc.w	-$15,+$00,+$09
	dc.w	+$00,+$15,+$09
	dc.w	+$15,+$00,+$09
	dc.w	+$00,-$1B,+$19
	dc.w	-$1B,+$00,+$19
	dc.w	+$00,+$1B,+$19
	dc.w	+$1B,+$00,+$19
	dc.w	+$00,-$1D,+$24
	dc.w	-$1D,+$00,+$24
	dc.w	+$00,+$1D,+$24
	dc.w	+$1D,+$00,+$24
	dc.w	+$00,-$1D,+$2A
	dc.w	-$1D,+$00,+$2A
	dc.w	+$00,+$1D,+$2A
	dc.w	+$1D,+$00,+$2A
	dc.w	+$00,-$1D,+$2D
	dc.w	-$1D,+$00,+$2D
	dc.w	+$00,+$1D,+$2D
	dc.w	+$1D,+$00,+$2D
	dc.w	+$00,-$17,+$47
	dc.w	-$17,+$00,+$47
	dc.w	+$00,+$17,+$47
	dc.w	+$17,+$00,+$47
	dc.l	F_cylindre

P_cylindre91:	dc.w	27
	dc.w	+$00,-$0D,-$0B
	dc.w	-$0D,+$00,-$0B
	dc.w	+$00,+$0D,-$0B
	dc.w	+$0D,+$00,-$0B
	dc.w	+$00,-$15,+$09
	dc.w	-$15,+$00,+$09
	dc.w	+$00,+$15,+$09
	dc.w	+$15,+$00,+$09
	dc.w	+$00,-$1B,+$18
	dc.w	-$1B,+$00,+$18
	dc.w	+$00,+$1B,+$18
	dc.w	+$1B,+$00,+$18
	dc.w	+$00,-$1D,+$22
	dc.w	-$1D,+$00,+$22
	dc.w	+$00,+$1D,+$22
	dc.w	+$1D,+$00,+$22
	dc.w	+$00,-$1D,+$28
	dc.w	-$1D,+$00,+$28
	dc.w	+$00,+$1D,+$28
	dc.w	+$1D,+$00,+$28
	dc.w	+$00,-$1D,+$2B
	dc.w	-$1D,+$00,+$2B
	dc.w	+$00,+$1D,+$2B
	dc.w	+$1D,+$00,+$2B
	dc.w	+$00,-$15,+$49
	dc.w	-$15,+$00,+$49
	dc.w	+$00,+$15,+$49
	dc.w	+$15,+$00,+$49
	dc.l	F_cylindre

P_cylindre92:	dc.w	27
	dc.w	+$00,-$0D,-$0A
	dc.w	-$0D,+$00,-$0A
	dc.w	+$00,+$0D,-$0A
	dc.w	+$0D,+$00,-$0A
	dc.w	+$00,-$16,+$09
	dc.w	-$16,+$00,+$09
	dc.w	+$00,+$16,+$09
	dc.w	+$16,+$00,+$09
	dc.w	+$00,-$1B,+$17
	dc.w	-$1B,+$00,+$17
	dc.w	+$00,+$1B,+$17
	dc.w	+$1B,+$00,+$17
	dc.w	+$00,-$1D,+$20
	dc.w	-$1D,+$00,+$20
	dc.w	+$00,+$1D,+$20
	dc.w	+$1D,+$00,+$20
	dc.w	+$00,-$1D,+$26
	dc.w	-$1D,+$00,+$26
	dc.w	+$00,+$1D,+$26
	dc.w	+$1D,+$00,+$26
	dc.w	+$00,-$1D,+$29
	dc.w	-$1D,+$00,+$29
	dc.w	+$00,+$1D,+$29
	dc.w	+$1D,+$00,+$29
	dc.w	+$00,-$14,+$4C
	dc.w	-$14,+$00,+$4C
	dc.w	+$00,+$14,+$4C
	dc.w	+$14,+$00,+$4C
	dc.l	F_cylindre

P_cylindre93:	dc.w	27
	dc.w	+$00,-$0E,-$0A
	dc.w	-$0E,+$00,-$0A
	dc.w	+$00,+$0E,-$0A
	dc.w	+$0E,+$00,-$0A
	dc.w	+$00,-$16,+$08
	dc.w	-$16,+$00,+$08
	dc.w	+$00,+$16,+$08
	dc.w	+$16,+$00,+$08
	dc.w	+$00,-$1B,+$16
	dc.w	-$1B,+$00,+$16
	dc.w	+$00,+$1B,+$16
	dc.w	+$1B,+$00,+$16
	dc.w	+$00,-$1D,+$1F
	dc.w	-$1D,+$00,+$1F
	dc.w	+$00,+$1D,+$1F
	dc.w	+$1D,+$00,+$1F
	dc.w	+$00,-$1D,+$23
	dc.w	-$1D,+$00,+$23
	dc.w	+$00,+$1D,+$23
	dc.w	+$1D,+$00,+$23
	dc.w	+$00,-$1D,+$29
	dc.w	-$1D,+$00,+$29
	dc.w	+$00,+$1D,+$29
	dc.w	+$1D,+$00,+$29
	dc.w	+$00,-$12,+$4E
	dc.w	-$12,+$00,+$4E
	dc.w	+$00,+$12,+$4E
	dc.w	+$12,+$00,+$4E
	dc.l	F_cylindre

P_cylindre94:	dc.w	27
	dc.w	+$00,-$0E,-$0A
	dc.w	-$0E,+$00,-$0A
	dc.w	+$00,+$0E,-$0A
	dc.w	+$0E,+$00,-$0A
	dc.w	+$00,-$16,+$08
	dc.w	-$16,+$00,+$08
	dc.w	+$00,+$16,+$08
	dc.w	+$16,+$00,+$08
	dc.w	+$00,-$1B,+$15
	dc.w	-$1B,+$00,+$15
	dc.w	+$00,+$1B,+$15
	dc.w	+$1B,+$00,+$15
	dc.w	+$00,-$1D,+$1D
	dc.w	-$1D,+$00,+$1D
	dc.w	+$00,+$1D,+$1D
	dc.w	+$1D,+$00,+$1D
	dc.w	+$00,-$1D,+$21
	dc.w	-$1D,+$00,+$21
	dc.w	+$00,+$1D,+$21
	dc.w	+$1D,+$00,+$21
	dc.w	+$00,-$1D,+$2B
	dc.w	-$1D,+$00,+$2B
	dc.w	+$00,+$1D,+$2B
	dc.w	+$1D,+$00,+$2B
	dc.w	+$00,-$11,+$50
	dc.w	-$11,+$00,+$50
	dc.w	+$00,+$11,+$50
	dc.w	+$11,+$00,+$50
	dc.l	F_cylindre

P_cylindre95:	dc.w	27
	dc.w	+$00,-$0F,-$0A
	dc.w	-$0F,+$00,-$0A
	dc.w	+$00,+$0F,-$0A
	dc.w	+$0F,+$00,-$0A
	dc.w	+$00,-$16,+$07
	dc.w	-$16,+$00,+$07
	dc.w	+$00,+$16,+$07
	dc.w	+$16,+$00,+$07
	dc.w	+$00,-$1B,+$13
	dc.w	-$1B,+$00,+$13
	dc.w	+$00,+$1B,+$13
	dc.w	+$1B,+$00,+$13
	dc.w	+$00,-$1D,+$1B
	dc.w	-$1D,+$00,+$1B
	dc.w	+$00,+$1D,+$1B
	dc.w	+$1D,+$00,+$1B
	dc.w	+$00,-$1D,+$1F
	dc.w	-$1D,+$00,+$1F
	dc.w	+$00,+$1D,+$1F
	dc.w	+$1D,+$00,+$1F
	dc.w	+$00,-$1D,+$2E
	dc.w	-$1D,+$00,+$2E
	dc.w	+$00,+$1D,+$2E
	dc.w	+$1D,+$00,+$2E
	dc.w	+$00,-$0F,+$52
	dc.w	-$0F,+$00,+$52
	dc.w	+$00,+$0F,+$52
	dc.w	+$0F,+$00,+$52
	dc.l	F_cylindre

P_cylindre96:	dc.w	27
	dc.w	+$00,-$0F,-$0A
	dc.w	-$0F,+$00,-$0A
	dc.w	+$00,+$0F,-$0A
	dc.w	+$0F,+$00,-$0A
	dc.w	+$00,-$16,+$06
	dc.w	-$16,+$00,+$06
	dc.w	+$00,+$16,+$06
	dc.w	+$16,+$00,+$06
	dc.w	+$00,-$1B,+$12
	dc.w	-$1B,+$00,+$12
	dc.w	+$00,+$1B,+$12
	dc.w	+$1B,+$00,+$12
	dc.w	+$00,-$1C,+$19
	dc.w	-$1C,+$00,+$19
	dc.w	+$00,+$1C,+$19
	dc.w	+$1C,+$00,+$19
	dc.w	+$00,-$1D,+$1C
	dc.w	-$1D,+$00,+$1C
	dc.w	+$00,+$1D,+$1C
	dc.w	+$1D,+$00,+$1C
	dc.w	+$00,-$1C,+$30
	dc.w	-$1C,+$00,+$30
	dc.w	+$00,+$1C,+$30
	dc.w	+$1C,+$00,+$30
	dc.w	+$00,-$0E,+$55
	dc.w	-$0E,+$00,+$55
	dc.w	+$00,+$0E,+$55
	dc.w	+$0E,+$00,+$55
	dc.l	F_cylindre

P_cylindre97:	dc.w	27
	dc.w	+$00,-$10,-$0A
	dc.w	-$10,+$00,-$0A
	dc.w	+$00,+$10,-$0A
	dc.w	+$10,+$00,-$0A
	dc.w	+$00,-$17,+$06
	dc.w	-$17,+$00,+$06
	dc.w	+$00,+$17,+$06
	dc.w	+$17,+$00,+$06
	dc.w	+$00,-$1A,+$10
	dc.w	-$1A,+$00,+$10
	dc.w	+$00,+$1A,+$10
	dc.w	+$1A,+$00,+$10
	dc.w	+$00,-$1C,+$16
	dc.w	-$1C,+$00,+$16
	dc.w	+$00,+$1C,+$16
	dc.w	+$1C,+$00,+$16
	dc.w	+$00,-$1D,+$1A
	dc.w	-$1D,+$00,+$1A
	dc.w	+$00,+$1D,+$1A
	dc.w	+$1D,+$00,+$1A
	dc.w	+$00,-$1B,+$33
	dc.w	-$1B,+$00,+$33
	dc.w	+$00,+$1B,+$33
	dc.w	+$1B,+$00,+$33
	dc.w	+$00,-$0D,+$57
	dc.w	-$0D,+$00,+$57
	dc.w	+$00,+$0D,+$57
	dc.w	+$0D,+$00,+$57
	dc.l	F_cylindre

P_cylindre98:	dc.w	27
	dc.w	+$00,-$10,-$0A
	dc.w	-$10,+$00,-$0A
	dc.w	+$00,+$10,-$0A
	dc.w	+$10,+$00,-$0A
	dc.w	+$00,-$17,+$05
	dc.w	-$17,+$00,+$05
	dc.w	+$00,+$17,+$05
	dc.w	+$17,+$00,+$05
	dc.w	+$00,-$1A,+$0E
	dc.w	-$1A,+$00,+$0E
	dc.w	+$00,+$1A,+$0E
	dc.w	+$1A,+$00,+$0E
	dc.w	+$00,-$1C,+$14
	dc.w	-$1C,+$00,+$14
	dc.w	+$00,+$1C,+$14
	dc.w	+$1C,+$00,+$14
	dc.w	+$00,-$1D,+$17
	dc.w	-$1D,+$00,+$17
	dc.w	+$00,+$1D,+$17
	dc.w	+$1D,+$00,+$17
	dc.w	+$00,-$1A,+$35
	dc.w	-$1A,+$00,+$35
	dc.w	+$00,+$1A,+$35
	dc.w	+$1A,+$00,+$35
	dc.w	+$00,-$0C,+$59
	dc.w	-$0C,+$00,+$59
	dc.w	+$00,+$0C,+$59
	dc.w	+$0C,+$00,+$59
	dc.l	F_cylindre

P_cylindre99:	dc.w	27
	dc.w	+$00,-$10,-$0A
	dc.w	-$10,+$00,-$0A
	dc.w	+$00,+$10,-$0A
	dc.w	+$10,+$00,-$0A
	dc.w	+$00,-$17,+$03
	dc.w	-$17,+$00,+$03
	dc.w	+$00,+$17,+$03
	dc.w	+$17,+$00,+$03
	dc.w	+$00,-$1A,+$0D
	dc.w	-$1A,+$00,+$0D
	dc.w	+$00,+$1A,+$0D
	dc.w	+$1A,+$00,+$0D
	dc.w	+$00,-$1C,+$12
	dc.w	-$1C,+$00,+$12
	dc.w	+$00,+$1C,+$12
	dc.w	+$1C,+$00,+$12
	dc.w	+$00,-$1C,+$15
	dc.w	-$1C,+$00,+$15
	dc.w	+$00,+$1C,+$15
	dc.w	+$1C,+$00,+$15
	dc.w	+$00,-$19,+$37
	dc.w	-$19,+$00,+$37
	dc.w	+$00,+$19,+$37
	dc.w	+$19,+$00,+$37
	dc.w	+$00,-$0B,+$5B
	dc.w	-$0B,+$00,+$5B
	dc.w	+$00,+$0B,+$5B
	dc.w	+$0B,+$00,+$5B
	dc.l	F_cylindre

P_cylindre100:	dc.w	27
	dc.w	+$00,-$11,-$0A
	dc.w	-$11,+$00,-$0A
	dc.w	+$00,+$11,-$0A
	dc.w	+$11,+$00,-$0A
	dc.w	+$00,-$17,+$02
	dc.w	-$17,+$00,+$02
	dc.w	+$00,+$17,+$02
	dc.w	+$17,+$00,+$02
	dc.w	+$00,-$1A,+$0B
	dc.w	-$1A,+$00,+$0B
	dc.w	+$00,+$1A,+$0B
	dc.w	+$1A,+$00,+$0B
	dc.w	+$00,-$1B,+$10
	dc.w	-$1B,+$00,+$10
	dc.w	+$00,+$1B,+$10
	dc.w	+$1B,+$00,+$10
	dc.w	+$00,-$1C,+$15
	dc.w	-$1C,+$00,+$15
	dc.w	+$00,+$1C,+$15
	dc.w	+$1C,+$00,+$15
	dc.w	+$00,-$18,+$3A
	dc.w	-$18,+$00,+$3A
	dc.w	+$00,+$18,+$3A
	dc.w	+$18,+$00,+$3A
	dc.w	+$00,-$0B,+$5C
	dc.w	-$0B,+$00,+$5C
	dc.w	+$00,+$0B,+$5C
	dc.w	+$0B,+$00,+$5C
	dc.l	F_cylindre

P_cylindre101:	dc.w	27
	dc.w	+$00,-$11,-$0B
	dc.w	-$11,+$00,-$0B
	dc.w	+$00,+$11,-$0B
	dc.w	+$11,+$00,-$0B
	dc.w	+$00,-$17,+$01
	dc.w	-$17,+$00,+$01
	dc.w	+$00,+$17,+$01
	dc.w	+$17,+$00,+$01
	dc.w	+$00,-$1A,+$09
	dc.w	-$1A,+$00,+$09
	dc.w	+$00,+$1A,+$09
	dc.w	+$1A,+$00,+$09
	dc.w	+$00,-$1B,+$0D
	dc.w	-$1B,+$00,+$0D
	dc.w	+$00,+$1B,+$0D
	dc.w	+$1B,+$00,+$0D
	dc.w	+$00,-$1D,+$17
	dc.w	-$1D,+$00,+$17
	dc.w	+$00,+$1D,+$17
	dc.w	+$1D,+$00,+$17
	dc.w	+$00,-$16,+$3C
	dc.w	-$16,+$00,+$3C
	dc.w	+$00,+$16,+$3C
	dc.w	+$16,+$00,+$3C
	dc.w	+$00,-$0A,+$5E
	dc.w	-$0A,+$00,+$5E
	dc.w	+$00,+$0A,+$5E
	dc.w	+$0A,+$00,+$5E
	dc.l	F_cylindre

P_cylindre102:	dc.w	27
	dc.w	+$00,-$11,-$0C
	dc.w	-$11,+$00,-$0C
	dc.w	+$00,+$11,-$0C
	dc.w	+$11,+$00,-$0C
	dc.w	+$00,-$16,+$00
	dc.w	-$16,+$00,+$00
	dc.w	+$00,+$16,+$00
	dc.w	+$16,+$00,+$00
	dc.w	+$00,-$19,+$07
	dc.w	-$19,+$00,+$07
	dc.w	+$00,+$19,+$07
	dc.w	+$19,+$00,+$07
	dc.w	+$00,-$1B,+$0B
	dc.w	-$1B,+$00,+$0B
	dc.w	+$00,+$1B,+$0B
	dc.w	+$1B,+$00,+$0B
	dc.w	+$00,-$1D,+$19
	dc.w	-$1D,+$00,+$19
	dc.w	+$00,+$1D,+$19
	dc.w	+$1D,+$00,+$19
	dc.w	+$00,-$15,+$3E
	dc.w	-$15,+$00,+$3E
	dc.w	+$00,+$15,+$3E
	dc.w	+$15,+$00,+$3E
	dc.w	+$00,-$0A,+$60
	dc.w	-$0A,+$00,+$60
	dc.w	+$00,+$0A,+$60
	dc.w	+$0A,+$00,+$60
	dc.l	F_cylindre

P_cylindre103:	dc.w	27
	dc.w	+$00,-$11,-$0C
	dc.w	-$11,+$00,-$0C
	dc.w	+$00,+$11,-$0C
	dc.w	+$11,+$00,-$0C
	dc.w	+$00,-$16,-$01
	dc.w	-$16,+$00,-$01
	dc.w	+$00,+$16,-$01
	dc.w	+$16,+$00,-$01
	dc.w	+$00,-$19,+$05
	dc.w	-$19,+$00,+$05
	dc.w	+$00,+$19,+$05
	dc.w	+$19,+$00,+$05
	dc.w	+$00,-$1A,+$08
	dc.w	-$1A,+$00,+$08
	dc.w	+$00,+$1A,+$08
	dc.w	+$1A,+$00,+$08
	dc.w	+$00,-$1D,+$1C
	dc.w	-$1D,+$00,+$1C
	dc.w	+$00,+$1D,+$1C
	dc.w	+$1D,+$00,+$1C
	dc.w	+$00,-$13,+$40
	dc.w	-$13,+$00,+$40
	dc.w	+$00,+$13,+$40
	dc.w	+$13,+$00,+$40
	dc.w	+$00,-$0A,+$62
	dc.w	-$0A,+$00,+$62
	dc.w	+$00,+$0A,+$62
	dc.w	+$0A,+$00,+$62
	dc.l	F_cylindre

P_cylindre104:	dc.w	27
	dc.w	+$00,-$11,-$0D
	dc.w	-$11,+$00,-$0D
	dc.w	+$00,+$11,-$0D
	dc.w	+$11,+$00,-$0D
	dc.w	+$00,-$16,-$03
	dc.w	-$16,+$00,-$03
	dc.w	+$00,+$16,-$03
	dc.w	+$16,+$00,-$03
	dc.w	+$00,-$19,+$03
	dc.w	-$19,+$00,+$03
	dc.w	+$00,+$19,+$03
	dc.w	+$19,+$00,+$03
	dc.w	+$00,-$1A,+$06
	dc.w	-$1A,+$00,+$06
	dc.w	+$00,+$1A,+$06
	dc.w	+$1A,+$00,+$06
	dc.w	+$00,-$1D,+$1E
	dc.w	-$1D,+$00,+$1E
	dc.w	+$00,+$1D,+$1E
	dc.w	+$1D,+$00,+$1E
	dc.w	+$00,-$12,+$42
	dc.w	-$12,+$00,+$42
	dc.w	+$00,+$12,+$42
	dc.w	+$12,+$00,+$42
	dc.w	+$00,-$0A,+$63
	dc.w	-$0A,+$00,+$63
	dc.w	+$00,+$0A,+$63
	dc.w	+$0A,+$00,+$63
	dc.l	F_cylindre

P_cylindre105:	dc.w	27
	dc.w	+$00,-$11,-$0E
	dc.w	-$11,+$00,-$0E
	dc.w	+$00,+$11,-$0E
	dc.w	+$11,+$00,-$0E
	dc.w	+$00,-$16,-$04
	dc.w	-$16,+$00,-$04
	dc.w	+$00,+$16,-$04
	dc.w	+$16,+$00,-$04
	dc.w	+$00,-$18,+$00
	dc.w	-$18,+$00,+$00
	dc.w	+$00,+$18,+$00
	dc.w	+$18,+$00,+$00
	dc.w	+$00,-$19,+$04
	dc.w	-$19,+$00,+$04
	dc.w	+$00,+$19,+$04
	dc.w	+$19,+$00,+$04
	dc.w	+$00,-$1D,+$21
	dc.w	-$1D,+$00,+$21
	dc.w	+$00,+$1D,+$21
	dc.w	+$1D,+$00,+$21
	dc.w	+$00,-$11,+$44
	dc.w	-$11,+$00,+$44
	dc.w	+$00,+$11,+$44
	dc.w	+$11,+$00,+$44
	dc.w	+$00,-$0A,+$65
	dc.w	-$0A,+$00,+$65
	dc.w	+$00,+$0A,+$65
	dc.w	+$0A,+$00,+$65
	dc.l	F_cylindre

P_cylindre106:	dc.w	27
	dc.w	+$00,-$12,-$0F
	dc.w	-$12,+$00,-$0F
	dc.w	+$00,+$12,-$0F
	dc.w	+$12,+$00,-$0F
	dc.w	+$00,-$16,-$06
	dc.w	-$16,+$00,-$06
	dc.w	+$00,+$16,-$06
	dc.w	+$16,+$00,-$06
	dc.w	+$00,-$18,-$01
	dc.w	-$18,+$00,-$01
	dc.w	+$00,+$18,-$01
	dc.w	+$18,+$00,-$01
	dc.w	+$00,-$19,+$01
	dc.w	-$19,+$00,+$01
	dc.w	+$00,+$19,+$01
	dc.w	+$19,+$00,+$01
	dc.w	+$00,-$1C,+$23
	dc.w	-$1C,+$00,+$23
	dc.w	+$00,+$1C,+$23
	dc.w	+$1C,+$00,+$23
	dc.w	+$00,-$0F,+$46
	dc.w	-$0F,+$00,+$46
	dc.w	+$00,+$0F,+$46
	dc.w	+$0F,+$00,+$46
	dc.w	+$00,-$0A,+$66
	dc.w	-$0A,+$00,+$66
	dc.w	+$00,+$0A,+$66
	dc.w	+$0A,+$00,+$66
	dc.l	F_cylindre

P_cylindre107:	dc.w	27
	dc.w	+$00,-$11,-$11
	dc.w	-$11,+$00,-$11
	dc.w	+$00,+$11,-$11
	dc.w	+$11,+$00,-$11
	dc.w	+$00,-$15,-$08
	dc.w	-$15,+$00,-$08
	dc.w	+$00,+$15,-$08
	dc.w	+$15,+$00,-$08
	dc.w	+$00,-$17,-$03
	dc.w	-$17,+$00,-$03
	dc.w	+$00,+$17,-$03
	dc.w	+$17,+$00,-$03
	dc.w	+$00,-$19,+$00
	dc.w	-$19,+$00,+$00
	dc.w	+$00,+$19,+$00
	dc.w	+$19,+$00,+$00
	dc.w	+$00,-$1C,+$25
	dc.w	-$1C,+$00,+$25
	dc.w	+$00,+$1C,+$25
	dc.w	+$1C,+$00,+$25
	dc.w	+$00,-$0E,+$48
	dc.w	-$0E,+$00,+$48
	dc.w	+$00,+$0E,+$48
	dc.w	+$0E,+$00,+$48
	dc.w	+$00,-$0A,+$67
	dc.w	-$0A,+$00,+$67
	dc.w	+$00,+$0A,+$67
	dc.w	+$0A,+$00,+$67
	dc.l	F_cylindre

P_cylindre108:	dc.w	27
	dc.w	+$00,-$11,-$12
	dc.w	-$11,+$00,-$12
	dc.w	+$00,+$11,-$12
	dc.w	+$11,+$00,-$12
	dc.w	+$00,-$15,-$0A
	dc.w	-$15,+$00,-$0A
	dc.w	+$00,+$15,-$0A
	dc.w	+$15,+$00,-$0A
	dc.w	+$00,-$17,-$06
	dc.w	-$17,+$00,-$06
	dc.w	+$00,+$17,-$06
	dc.w	+$17,+$00,-$06
	dc.w	+$00,-$1A,+$03
	dc.w	-$1A,+$00,+$03
	dc.w	+$00,+$1A,+$03
	dc.w	+$1A,+$00,+$03
	dc.w	+$00,-$1B,+$28
	dc.w	-$1B,+$00,+$28
	dc.w	+$00,+$1B,+$28
	dc.w	+$1B,+$00,+$28
	dc.w	+$00,-$0D,+$4A
	dc.w	-$0D,+$00,+$4A
	dc.w	+$00,+$0D,+$4A
	dc.w	+$0D,+$00,+$4A
	dc.w	+$00,-$0A,+$68
	dc.w	-$0A,+$00,+$68
	dc.w	+$00,+$0A,+$68
	dc.w	+$0A,+$00,+$68
	dc.l	F_cylindre

P_cylindre109:	dc.w	27
	dc.w	+$00,-$11,-$13
	dc.w	-$11,+$00,-$13
	dc.w	+$00,+$11,-$13
	dc.w	+$11,+$00,-$13
	dc.w	+$00,-$14,-$0C
	dc.w	-$14,+$00,-$0C
	dc.w	+$00,+$14,-$0C
	dc.w	+$14,+$00,-$0C
	dc.w	+$00,-$16,-$08
	dc.w	-$16,+$00,-$08
	dc.w	+$00,+$16,-$08
	dc.w	+$16,+$00,-$08
	dc.w	+$00,-$1B,+$05
	dc.w	-$1B,+$00,+$05
	dc.w	+$00,+$1B,+$05
	dc.w	+$1B,+$00,+$05
	dc.w	+$00,-$1A,+$2A
	dc.w	-$1A,+$00,+$2A
	dc.w	+$00,+$1A,+$2A
	dc.w	+$1A,+$00,+$2A
	dc.w	+$00,-$0C,+$4C
	dc.w	-$0C,+$00,+$4C
	dc.w	+$00,+$0C,+$4C
	dc.w	+$0C,+$00,+$4C
	dc.w	+$00,-$0B,+$69
	dc.w	-$0B,+$00,+$69
	dc.w	+$00,+$0B,+$69
	dc.w	+$0B,+$00,+$69
	dc.l	F_cylindre

P_cylindre110:	dc.w	27
	dc.w	+$00,-$11,-$15
	dc.w	-$11,+$00,-$15
	dc.w	+$00,+$11,-$15
	dc.w	+$11,+$00,-$15
	dc.w	+$00,-$14,-$0E
	dc.w	-$14,+$00,-$0E
	dc.w	+$00,+$14,-$0E
	dc.w	+$14,+$00,-$0E
	dc.w	+$00,-$16,-$0A
	dc.w	-$16,+$00,-$0A
	dc.w	+$00,+$16,-$0A
	dc.w	+$16,+$00,-$0A
	dc.w	+$00,-$1C,+$08
	dc.w	-$1C,+$00,+$08
	dc.w	+$00,+$1C,+$08
	dc.w	+$1C,+$00,+$08
	dc.w	+$00,-$18,+$2C
	dc.w	-$18,+$00,+$2C
	dc.w	+$00,+$18,+$2C
	dc.w	+$18,+$00,+$2C
	dc.w	+$00,-$0B,+$4D
	dc.w	-$0B,+$00,+$4D
	dc.w	+$00,+$0B,+$4D
	dc.w	+$0B,+$00,+$4D
	dc.w	+$00,-$0B,+$6A
	dc.w	-$0B,+$00,+$6A
	dc.w	+$00,+$0B,+$6A
	dc.w	+$0B,+$00,+$6A
	dc.l	F_cylindre

P_cylindre111:	dc.w	27
	dc.w	+$00,-$11,-$16
	dc.w	-$11,+$00,-$16
	dc.w	+$00,+$11,-$16
	dc.w	+$11,+$00,-$16
	dc.w	+$00,-$14,-$10
	dc.w	-$14,+$00,-$10
	dc.w	+$00,+$14,-$10
	dc.w	+$14,+$00,-$10
	dc.w	+$00,-$15,-$0D
	dc.w	-$15,+$00,-$0D
	dc.w	+$00,+$15,-$0D
	dc.w	+$15,+$00,-$0D
	dc.w	+$00,-$1D,+$0A
	dc.w	-$1D,+$00,+$0A
	dc.w	+$00,+$1D,+$0A
	dc.w	+$1D,+$00,+$0A
	dc.w	+$00,-$17,+$2E
	dc.w	-$17,+$00,+$2E
	dc.w	+$00,+$17,+$2E
	dc.w	+$17,+$00,+$2E
	dc.w	+$00,-$0B,+$4F
	dc.w	-$0B,+$00,+$4F
	dc.w	+$00,+$0B,+$4F
	dc.w	+$0B,+$00,+$4F
	dc.w	+$00,-$0C,+$6B
	dc.w	-$0C,+$00,+$6B
	dc.w	+$00,+$0C,+$6B
	dc.w	+$0C,+$00,+$6B
	dc.l	F_cylindre

P_cylindre112:	dc.w	27
	dc.w	+$00,-$11,-$18
	dc.w	-$11,+$00,-$18
	dc.w	+$00,+$11,-$18
	dc.w	+$11,+$00,-$18
	dc.w	+$00,-$13,-$12
	dc.w	-$13,+$00,-$12
	dc.w	+$00,+$13,-$12
	dc.w	+$13,+$00,-$12
	dc.w	+$00,-$15,-$0F
	dc.w	-$15,+$00,-$0F
	dc.w	+$00,+$15,-$0F
	dc.w	+$15,+$00,-$0F
	dc.w	+$00,-$1D,+$0C
	dc.w	-$1D,+$00,+$0C
	dc.w	+$00,+$1D,+$0C
	dc.w	+$1D,+$00,+$0C
	dc.w	+$00,-$16,+$30
	dc.w	-$16,+$00,+$30
	dc.w	+$00,+$16,+$30
	dc.w	+$16,+$00,+$30
	dc.w	+$00,-$0A,+$50
	dc.w	-$0A,+$00,+$50
	dc.w	+$00,+$0A,+$50
	dc.w	+$0A,+$00,+$50
	dc.w	+$00,-$0C,+$6C
	dc.w	-$0C,+$00,+$6C
	dc.w	+$00,+$0C,+$6C
	dc.w	+$0C,+$00,+$6C
	dc.l	F_cylindre

P_cylindre113:	dc.w	27
	dc.w	+$00,-$10,-$1A
	dc.w	-$10,+$00,-$1A
	dc.w	+$00,+$10,-$1A
	dc.w	+$10,+$00,-$1A
	dc.w	+$00,-$13,-$15
	dc.w	-$13,+$00,-$15
	dc.w	+$00,+$13,-$15
	dc.w	+$13,+$00,-$15
	dc.w	+$00,-$14,-$12
	dc.w	-$14,+$00,-$12
	dc.w	+$00,+$14,-$12
	dc.w	+$14,+$00,-$12
	dc.w	+$00,-$1D,+$0F
	dc.w	-$1D,+$00,+$0F
	dc.w	+$00,+$1D,+$0F
	dc.w	+$1D,+$00,+$0F
	dc.w	+$00,-$14,+$32
	dc.w	-$14,+$00,+$32
	dc.w	+$00,+$14,+$32
	dc.w	+$14,+$00,+$32
	dc.w	+$00,-$0A,+$52
	dc.w	-$0A,+$00,+$52
	dc.w	+$00,+$0A,+$52
	dc.w	+$0A,+$00,+$52
	dc.w	+$00,-$0D,+$6C
	dc.w	-$0D,+$00,+$6C
	dc.w	+$00,+$0D,+$6C
	dc.w	+$0D,+$00,+$6C
	dc.l	F_cylindre

P_cylindre114:	dc.w	27
	dc.w	+$00,-$10,-$1C
	dc.w	-$10,+$00,-$1C
	dc.w	+$00,+$10,-$1C
	dc.w	+$10,+$00,-$1C
	dc.w	+$00,-$12,-$17
	dc.w	-$12,+$00,-$17
	dc.w	+$00,+$12,-$17
	dc.w	+$12,+$00,-$17
	dc.w	+$00,-$14,-$13
	dc.w	-$14,+$00,-$13
	dc.w	+$00,+$14,-$13
	dc.w	+$14,+$00,-$13
	dc.w	+$00,-$1D,+$11
	dc.w	-$1D,+$00,+$11
	dc.w	+$00,+$1D,+$11
	dc.w	+$1D,+$00,+$11
	dc.w	+$00,-$13,+$34
	dc.w	-$13,+$00,+$34
	dc.w	+$00,+$13,+$34
	dc.w	+$13,+$00,+$34
	dc.w	+$00,-$0A,+$53
	dc.w	-$0A,+$00,+$53
	dc.w	+$00,+$0A,+$53
	dc.w	+$0A,+$00,+$53
	dc.w	+$00,-$0E,+$6D
	dc.w	-$0E,+$00,+$6D
	dc.w	+$00,+$0E,+$6D
	dc.w	+$0E,+$00,+$6D
	dc.l	F_cylindre

P_cylindre115:	dc.w	27
	dc.w	+$00,-$10,-$1E
	dc.w	-$10,+$00,-$1E
	dc.w	+$00,+$10,-$1E
	dc.w	+$10,+$00,-$1E
	dc.w	+$00,-$12,-$19
	dc.w	-$12,+$00,-$19
	dc.w	+$00,+$12,-$19
	dc.w	+$12,+$00,-$19
	dc.w	+$00,-$15,-$11
	dc.w	-$15,+$00,-$11
	dc.w	+$00,+$15,-$11
	dc.w	+$15,+$00,-$11
	dc.w	+$00,-$1D,+$13
	dc.w	-$1D,+$00,+$13
	dc.w	+$00,+$1D,+$13
	dc.w	+$1D,+$00,+$13
	dc.w	+$00,-$12,+$36
	dc.w	-$12,+$00,+$36
	dc.w	+$00,+$12,+$36
	dc.w	+$12,+$00,+$36
	dc.w	+$00,-$0A,+$54
	dc.w	-$0A,+$00,+$54
	dc.w	+$00,+$0A,+$54
	dc.w	+$0A,+$00,+$54
	dc.w	+$00,-$0E,+$6D
	dc.w	-$0E,+$00,+$6D
	dc.w	+$00,+$0E,+$6D
	dc.w	+$0E,+$00,+$6D
	dc.l	F_cylindre

P_cylindre116:	dc.w	27
	dc.w	+$00,-$0F,-$20
	dc.w	-$0F,+$00,-$20
	dc.w	+$00,+$0F,-$20
	dc.w	+$0F,+$00,-$20
	dc.w	+$00,-$11,-$1C
	dc.w	-$11,+$00,-$1C
	dc.w	+$00,+$11,-$1C
	dc.w	+$11,+$00,-$1C
	dc.w	+$00,-$17,-$0E
	dc.w	-$17,+$00,-$0E
	dc.w	+$00,+$17,-$0E
	dc.w	+$17,+$00,-$0E
	dc.w	+$00,-$1D,+$16
	dc.w	-$1D,+$00,+$16
	dc.w	+$00,+$1D,+$16
	dc.w	+$1D,+$00,+$16
	dc.w	+$00,-$11,+$38
	dc.w	-$11,+$00,+$38
	dc.w	+$00,+$11,+$38
	dc.w	+$11,+$00,+$38
	dc.w	+$00,-$0A,+$55
	dc.w	-$0A,+$00,+$55
	dc.w	+$00,+$0A,+$55
	dc.w	+$0A,+$00,+$55
	dc.w	+$00,-$0F,+$6D
	dc.w	-$0F,+$00,+$6D
	dc.w	+$00,+$0F,+$6D
	dc.w	+$0F,+$00,+$6D
	dc.l	F_cylindre

P_cylindre117:	dc.w	27
	dc.w	+$00,-$0F,-$22
	dc.w	-$0F,+$00,-$22
	dc.w	+$00,+$0F,-$22
	dc.w	+$0F,+$00,-$22
	dc.w	+$00,-$11,-$1E
	dc.w	-$11,+$00,-$1E
	dc.w	+$00,+$11,-$1E
	dc.w	+$11,+$00,-$1E
	dc.w	+$00,-$18,-$0C
	dc.w	-$18,+$00,-$0C
	dc.w	+$00,+$18,-$0C
	dc.w	+$18,+$00,-$0C
	dc.w	+$00,-$1C,+$18
	dc.w	-$1C,+$00,+$18
	dc.w	+$00,+$1C,+$18
	dc.w	+$1C,+$00,+$18
	dc.w	+$00,-$10,+$39
	dc.w	-$10,+$00,+$39
	dc.w	+$00,+$10,+$39
	dc.w	+$10,+$00,+$39
	dc.w	+$00,-$0A,+$56
	dc.w	-$0A,+$00,+$56
	dc.w	+$00,+$0A,+$56
	dc.w	+$0A,+$00,+$56
	dc.w	+$00,-$0F,+$6D
	dc.w	-$0F,+$00,+$6D
	dc.w	+$00,+$0F,+$6D
	dc.w	+$0F,+$00,+$6D
	dc.l	F_cylindre

P_cylindre118:	dc.w	27
	dc.w	+$00,-$0F,-$24
	dc.w	-$0F,+$00,-$24
	dc.w	+$00,+$0F,-$24
	dc.w	+$0F,+$00,-$24
	dc.w	+$00,-$10,-$20
	dc.w	-$10,+$00,-$20
	dc.w	+$00,+$10,-$20
	dc.w	+$10,+$00,-$20
	dc.w	+$00,-$1A,-$09
	dc.w	-$1A,+$00,-$09
	dc.w	+$00,+$1A,-$09
	dc.w	+$1A,+$00,-$09
	dc.w	+$00,-$1B,+$1A
	dc.w	-$1B,+$00,+$1A
	dc.w	+$00,+$1B,+$1A
	dc.w	+$1B,+$00,+$1A
	dc.w	+$00,-$0F,+$3B
	dc.w	-$0F,+$00,+$3B
	dc.w	+$00,+$0F,+$3B
	dc.w	+$0F,+$00,+$3B
	dc.w	+$00,-$0A,+$57
	dc.w	-$0A,+$00,+$57
	dc.w	+$00,+$0A,+$57
	dc.w	+$0A,+$00,+$57
	dc.w	+$00,-$0F,+$6D
	dc.w	-$0F,+$00,+$6D
	dc.w	+$00,+$0F,+$6D
	dc.w	+$0F,+$00,+$6D
	dc.l	F_cylindre

P_cylindre119:	dc.w	27
	dc.w	+$00,-$0E,-$26
	dc.w	-$0E,+$00,-$26
	dc.w	+$00,+$0E,-$26
	dc.w	+$0E,+$00,-$26
	dc.w	+$00,-$10,-$23
	dc.w	-$10,+$00,-$23
	dc.w	+$00,+$10,-$23
	dc.w	+$10,+$00,-$23
	dc.w	+$00,-$1B,-$07
	dc.w	-$1B,+$00,-$07
	dc.w	+$00,+$1B,-$07
	dc.w	+$1B,+$00,-$07
	dc.w	+$00,-$1A,+$1C
	dc.w	-$1A,+$00,+$1C
	dc.w	+$00,+$1A,+$1C
	dc.w	+$1A,+$00,+$1C
	dc.w	+$00,-$0E,+$3C
	dc.w	-$0E,+$00,+$3C
	dc.w	+$00,+$0E,+$3C
	dc.w	+$0E,+$00,+$3C
	dc.w	+$00,-$0A,+$58
	dc.w	-$0A,+$00,+$58
	dc.w	+$00,+$0A,+$58
	dc.w	+$0A,+$00,+$58
	dc.w	+$00,-$10,+$6D
	dc.w	-$10,+$00,+$6D
	dc.w	+$00,+$10,+$6D
	dc.w	+$10,+$00,+$6D
	dc.l	F_cylindre

P_cylindre120:	dc.w	27
	dc.w	+$00,-$0E,-$28
	dc.w	-$0E,+$00,-$28
	dc.w	+$00,+$0E,-$28
	dc.w	+$0E,+$00,-$28
	dc.w	+$00,-$0F,-$25
	dc.w	-$0F,+$00,-$25
	dc.w	+$00,+$0F,-$25
	dc.w	+$0F,+$00,-$25
	dc.w	+$00,-$1C,-$04
	dc.w	-$1C,+$00,-$04
	dc.w	+$00,+$1C,-$04
	dc.w	+$1C,+$00,-$04
	dc.w	+$00,-$19,+$1E
	dc.w	-$19,+$00,+$1E
	dc.w	+$00,+$19,+$1E
	dc.w	+$19,+$00,+$1E
	dc.w	+$00,-$0D,+$3E
	dc.w	-$0D,+$00,+$3E
	dc.w	+$00,+$0D,+$3E
	dc.w	+$0D,+$00,+$3E
	dc.w	+$00,-$0A,+$58
	dc.w	-$0A,+$00,+$58
	dc.w	+$00,+$0A,+$58
	dc.w	+$0A,+$00,+$58
	dc.w	+$00,-$10,+$6D
	dc.w	-$10,+$00,+$6D
	dc.w	+$00,+$10,+$6D
	dc.w	+$10,+$00,+$6D
	dc.l	F_cylindre

P_cylindre121:	dc.w	27
	dc.w	+$00,-$0D,-$2B
	dc.w	-$0D,+$00,-$2B
	dc.w	+$00,+$0D,-$2B
	dc.w	+$0D,+$00,-$2B
	dc.w	+$00,-$0F,-$27
	dc.w	-$0F,+$00,-$27
	dc.w	+$00,+$0F,-$27
	dc.w	+$0F,+$00,-$27
	dc.w	+$00,-$1C,-$02
	dc.w	-$1C,+$00,-$02
	dc.w	+$00,+$1C,-$02
	dc.w	+$1C,+$00,-$02
	dc.w	+$00,-$18,+$20
	dc.w	-$18,+$00,+$20
	dc.w	+$00,+$18,+$20
	dc.w	+$18,+$00,+$20
	dc.w	+$00,-$0C,+$3F
	dc.w	-$0C,+$00,+$3F
	dc.w	+$00,+$0C,+$3F
	dc.w	+$0C,+$00,+$3F
	dc.w	+$00,-$0A,+$59
	dc.w	-$0A,+$00,+$59
	dc.w	+$00,+$0A,+$59
	dc.w	+$0A,+$00,+$59
	dc.w	+$00,-$11,+$6D
	dc.w	-$11,+$00,+$6D
	dc.w	+$00,+$11,+$6D
	dc.w	+$11,+$00,+$6D
	dc.l	F_cylindre

P_cylindre122:	dc.w	27
	dc.w	+$00,-$0D,-$2D
	dc.w	-$0D,+$00,-$2D
	dc.w	+$00,+$0D,-$2D
	dc.w	+$0D,+$00,-$2D
	dc.w	+$00,-$10,-$25
	dc.w	-$10,+$00,-$25
	dc.w	+$00,+$10,-$25
	dc.w	+$10,+$00,-$25
	dc.w	+$00,-$1D,+$00
	dc.w	-$1D,+$00,+$00
	dc.w	+$00,+$1D,+$00
	dc.w	+$1D,+$00,+$00
	dc.w	+$00,-$17,+$22
	dc.w	-$17,+$00,+$22
	dc.w	+$00,+$17,+$22
	dc.w	+$17,+$00,+$22
	dc.w	+$00,-$0B,+$40
	dc.w	-$0B,+$00,+$40
	dc.w	+$00,+$0B,+$40
	dc.w	+$0B,+$00,+$40
	dc.w	+$00,-$0B,+$59
	dc.w	-$0B,+$00,+$59
	dc.w	+$00,+$0B,+$59
	dc.w	+$0B,+$00,+$59
	dc.w	+$00,-$11,+$6C
	dc.w	-$11,+$00,+$6C
	dc.w	+$00,+$11,+$6C
	dc.w	+$11,+$00,+$6C
	dc.l	F_cylindre

P_cylindre123:	dc.w	27
	dc.w	+$00,-$0D,-$2F
	dc.w	-$0D,+$00,-$2F
	dc.w	+$00,+$0D,-$2F
	dc.w	+$0D,+$00,-$2F
	dc.w	+$00,-$12,-$22
	dc.w	-$12,+$00,-$22
	dc.w	+$00,+$12,-$22
	dc.w	+$12,+$00,-$22
	dc.w	+$00,-$1D,+$01
	dc.w	-$1D,+$00,+$01
	dc.w	+$00,+$1D,+$01
	dc.w	+$1D,+$00,+$01
	dc.w	+$00,-$16,+$23
	dc.w	-$16,+$00,+$23
	dc.w	+$00,+$16,+$23
	dc.w	+$16,+$00,+$23
	dc.w	+$00,-$0B,+$41
	dc.w	-$0B,+$00,+$41
	dc.w	+$00,+$0B,+$41
	dc.w	+$0B,+$00,+$41
	dc.w	+$00,-$0B,+$59
	dc.w	-$0B,+$00,+$59
	dc.w	+$00,+$0B,+$59
	dc.w	+$0B,+$00,+$59
	dc.w	+$00,-$11,+$6C
	dc.w	-$11,+$00,+$6C
	dc.w	+$00,+$11,+$6C
	dc.w	+$11,+$00,+$6C
	dc.l	F_cylindre

P_cylindre124:	dc.w	27
	dc.w	+$00,-$0C,-$32
	dc.w	-$0C,+$00,-$32
	dc.w	+$00,+$0C,-$32
	dc.w	+$0C,+$00,-$32
	dc.w	+$00,-$13,-$20
	dc.w	-$13,+$00,-$20
	dc.w	+$00,+$13,-$20
	dc.w	+$13,+$00,-$20
	dc.w	+$00,-$1D,+$04
	dc.w	-$1D,+$00,+$04
	dc.w	+$00,+$1D,+$04
	dc.w	+$1D,+$00,+$04
	dc.w	+$00,-$15,+$25
	dc.w	-$15,+$00,+$25
	dc.w	+$00,+$15,+$25
	dc.w	+$15,+$00,+$25
	dc.w	+$00,-$0A,+$42
	dc.w	-$0A,+$00,+$42
	dc.w	+$00,+$0A,+$42
	dc.w	+$0A,+$00,+$42
	dc.w	+$00,-$0B,+$59
	dc.w	-$0B,+$00,+$59
	dc.w	+$00,+$0B,+$59
	dc.w	+$0B,+$00,+$59
	dc.w	+$00,-$11,+$6B
	dc.w	-$11,+$00,+$6B
	dc.w	+$00,+$11,+$6B
	dc.w	+$11,+$00,+$6B
	dc.l	F_cylindre

P_cylindre125:	dc.w	27
	dc.w	+$00,-$0C,-$34
	dc.w	-$0C,+$00,-$34
	dc.w	+$00,+$0C,-$34
	dc.w	+$0C,+$00,-$34
	dc.w	+$00,-$15,-$1D
	dc.w	-$15,+$00,-$1D
	dc.w	+$00,+$15,-$1D
	dc.w	+$15,+$00,-$1D
	dc.w	+$00,-$1D,+$06
	dc.w	-$1D,+$00,+$06
	dc.w	+$00,+$1D,+$06
	dc.w	+$1D,+$00,+$06
	dc.w	+$00,-$14,+$27
	dc.w	-$14,+$00,+$27
	dc.w	+$00,+$14,+$27
	dc.w	+$14,+$00,+$27
	dc.w	+$00,-$0A,+$43
	dc.w	-$0A,+$00,+$43
	dc.w	+$00,+$0A,+$43
	dc.w	+$0A,+$00,+$43
	dc.w	+$00,-$0B,+$59
	dc.w	-$0B,+$00,+$59
	dc.w	+$00,+$0B,+$59
	dc.w	+$0B,+$00,+$59
	dc.w	+$00,-$11,+$6A
	dc.w	-$11,+$00,+$6A
	dc.w	+$00,+$11,+$6A
	dc.w	+$11,+$00,+$6A
	dc.l	F_cylindre

P_cylindre126:	dc.w	27
	dc.w	+$00,-$0C,-$37
	dc.w	-$0C,+$00,-$37
	dc.w	+$00,+$0C,-$37
	dc.w	+$0C,+$00,-$37
	dc.w	+$00,-$16,-$1B
	dc.w	-$16,+$00,-$1B
	dc.w	+$00,+$16,-$1B
	dc.w	+$16,+$00,-$1B
	dc.w	+$00,-$1D,+$08
	dc.w	-$1D,+$00,+$08
	dc.w	+$00,+$1D,+$08
	dc.w	+$1D,+$00,+$08
	dc.w	+$00,-$12,+$28
	dc.w	-$12,+$00,+$28
	dc.w	+$00,+$12,+$28
	dc.w	+$12,+$00,+$28
	dc.w	+$00,-$0A,+$44
	dc.w	-$0A,+$00,+$44
	dc.w	+$00,+$0A,+$44
	dc.w	+$0A,+$00,+$44
	dc.w	+$00,-$0C,+$59
	dc.w	-$0C,+$00,+$59
	dc.w	+$00,+$0C,+$59
	dc.w	+$0C,+$00,+$59
	dc.w	+$00,-$11,+$69
	dc.w	-$11,+$00,+$69
	dc.w	+$00,+$11,+$69
	dc.w	+$11,+$00,+$69
	dc.l	F_cylindre

P_cylindre127:	dc.w	27
	dc.w	+$00,-$0B,-$39
	dc.w	-$0B,+$00,-$39
	dc.w	+$00,+$0B,-$39
	dc.w	+$0B,+$00,-$39
	dc.w	+$00,-$18,-$19
	dc.w	-$18,+$00,-$19
	dc.w	+$00,+$18,-$19
	dc.w	+$18,+$00,-$19
	dc.w	+$00,-$1D,+$0A
	dc.w	-$1D,+$00,+$0A
	dc.w	+$00,+$1D,+$0A
	dc.w	+$1D,+$00,+$0A
	dc.w	+$00,-$11,+$2A
	dc.w	-$11,+$00,+$2A
	dc.w	+$00,+$11,+$2A
	dc.w	+$11,+$00,+$2A
	dc.w	+$00,-$0A,+$44
	dc.w	-$0A,+$00,+$44
	dc.w	+$00,+$0A,+$44
	dc.w	+$0A,+$00,+$44
	dc.w	+$00,-$0C,+$59
	dc.w	-$0C,+$00,+$59
	dc.w	+$00,+$0C,+$59
	dc.w	+$0C,+$00,+$59
	dc.w	+$00,-$11,+$68
	dc.w	-$11,+$00,+$68
	dc.w	+$00,+$11,+$68
	dc.w	+$11,+$00,+$68
	dc.l	F_cylindre

