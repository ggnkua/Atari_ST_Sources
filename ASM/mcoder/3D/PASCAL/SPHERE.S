	opt	l2
	XDEF	Sphere
	include	define.s

Sphere:	dc.l	.P_sphere
	dc.l	0
	dc.l	Sphere

.P_sphere:	dc.w	41
	dc.w	+$00,+$60,+$00
	dc.w	+$40,+$50,+$00
	dc.w	+$60,+$30,+$00
	dc.w	+$70,+$00,+$00
	dc.w	+$60,-$30,+$00
	dc.w	+$40,-$50,+$00
	dc.w	+$00,-$62,+$00
	dc.w	+$2d,+$50,+$2d
	dc.w	+$43,+$30,+$43
	dc.w	+$4f,+$00,+$4f
	dc.w	+$43,-$30,+$43
	dc.w	+$2d,-$50,+$2d
	dc.w	+$00,+$50,+$40
	dc.w	+$00,+$30,+$60
	dc.w	+$00,+$00,+$70
	dc.w	+$00,-$30,+$60
	dc.w	+$00,-$50,+$40
	dc.w	-$2e,+$50,+$2d
	dc.w	-$44,+$30,+$43
	dc.w	-$50,+$00,+$4f
	dc.w	-$44,-$30,+$43
	dc.w	-$2e,-$50,+$2d
	dc.w	-$40,+$50,+$00
	dc.w	-$60,+$30,+$00
	dc.w	-$70,+$00,+$00
	dc.w	-$60,-$30,+$00
	dc.w	-$40,-$50,+$00
	dc.w	-$2e,+$50,-$2e
	dc.w	-$44,+$30,-$44
	dc.w	-$50,+$00,-$50
	dc.w	-$44,-$30,-$44
	dc.w	-$2e,-$50,-$2e
	dc.w	+$00,+$50,-$40
	dc.w	+$00,+$30,-$60
	dc.w	+$00,+$00,-$70
	dc.w	+$00,-$30,-$60
	dc.w	+$00,-$50,-$40
	dc.w	+$2d,+$50,-$2e
	dc.w	+$43,+$30,-$44
	dc.w	+$4f,+$00,-$50
	dc.w	+$43,-$30,-$44
	dc.w	+$2d,-$50,-$2e
	dc.l	.F_sphere

.F_sphere:	;Interieur
	VERTICES	7,12,0,-1,-1,-1,-1,-1
	COLOR	10
	dc.l	0
	VERTICES	17,22,0,-1,-1,-1,-1,-1
	COLOR	10
	dc.l	0
	VERTICES	27,32,0,-1,-1,-1,-1,-1
	COLOR	10
	dc.l	0
	VERTICES	37,1,0,-1,-1,-1,-1,-1
	COLOR	10
	dc.l	0
	VERTICES	2,8,7,1,-1,-1,-1,-1
	COLOR	11
	dc.l	0
	VERTICES	13,18,17,12,-1,-1,-1,-1
	COLOR	11
	dc.l	0
	VERTICES	23,28,27,22,-1,-1,-1,-1
	COLOR	11
	dc.l	0
	VERTICES	33,38,37,32,-1,-1,-1,-1
	COLOR	11
	dc.l	0
	VERTICES	9,14,13,8,-1,-1,-1,-1
	COLOR	12
	dc.l	0
	VERTICES	19,24,23,18,-1,-1,-1,-1
	COLOR	12
	dc.l	0
	VERTICES	29,34,33,28,-1,-1,-1,-1
	COLOR	12
	dc.l	0
	VERTICES	39,3,2,38,-1,-1,-1,-1
	COLOR	12
	dc.l	0
	VERTICES	4,10,9,3,-1,-1,-1,-1
	COLOR	13
	dc.l	0
	VERTICES	15,20,19,14,-1,-1,-1,-1
	COLOR	13
	dc.l	0
	VERTICES	25,30,29,24,-1,-1,-1,-1
	COLOR	13
	dc.l	0
	VERTICES	35,40,39,34,-1,-1,-1,-1
	COLOR	13
	dc.l	0
	VERTICES	11,16,15,10,-1,-1,-1,-1
	COLOR	12
	dc.l	0
	VERTICES	21,26,25,20,-1,-1,-1,-1
	COLOR	12
	dc.l	0
	VERTICES	31,36,35,30,-1,-1,-1,-1
	COLOR	12
	dc.l	0
	VERTICES	41,5,4,40,-1,-1,-1,-1
	COLOR	12
	dc.l	0
	VERTICES	6,11,5,-1,-1,-1,-1,-1
	COLOR	11
	dc.l	0
	VERTICES	6,21,16,-1,-1,-1,-1,-1
	COLOR	11
	dc.l	0
	VERTICES	6,31,26,-1,-1,-1,-1,-1
	COLOR	11
	dc.l	0
	VERTICES	6,41,36,-1,-1,-1,-1,-1
	COLOR	11
	dc.l	0

	;Exterieur
	VERTICES	0,12,7,-1,-1,-1,-1,-1
	COLOR	6
	dc.l	0
	VERTICES	0,22,17,-1,-1,-1,-1,-1
	COLOR	6
	dc.l	0
	VERTICES	0,32,27,-1,-1,-1,-1,-1
	COLOR	6
	dc.l	0
	VERTICES	0,1,37,-1,-1,-1,-1,-1
	COLOR	6
	dc.l	0
	VERTICES	1,7,8,2,-1,-1,-1,-1
	COLOR	7
	dc.l	0
	VERTICES	12,17,18,13,-1,-1,-1,-1
	COLOR	7
	dc.l	0
	VERTICES	22,27,28,23,-1,-1,-1,-1
	COLOR	7
	dc.l	0
	VERTICES	32,37,38,33,-1,-1,-1,-1
	COLOR	7
	dc.l	0
	VERTICES	8,13,14,9,-1,-1,-1,-1
	COLOR	8
	dc.l	0
	VERTICES	18,23,24,19,-1,-1,-1,-1
	COLOR	8
	dc.l	0
	VERTICES	28,33,34,29,-1,-1,-1,-1
	COLOR	8
	dc.l	0
	VERTICES	38,2,3,39,-1,-1,-1,-1
	COLOR	8
	dc.l	0
	VERTICES	3,9,10,4,-1,-1,-1,-1
	COLOR	9
	dc.l	0
	VERTICES	14,19,20,15,-1,-1,-1,-1
	COLOR	9
	dc.l	0
	VERTICES	24,29,30,25,-1,-1,-1,-1
	COLOR	9
	dc.l	0
	VERTICES	34,39,40,35,-1,-1,-1,-1
	COLOR	9
	dc.l	0
	VERTICES	10,15,16,11,-1,-1,-1,-1
	COLOR	8
	dc.l	0
	VERTICES	20,25,26,21,-1,-1,-1,-1
	COLOR	8
	dc.l	0
	VERTICES	30,35,36,31,-1,-1,-1,-1
	COLOR	8
	dc.l	0
	VERTICES	40,4,5,41,-1,-1,-1,-1
	COLOR	8
	dc.l	0
	VERTICES	5,11,6,-1,-1,-1,-1,-1
	COLOR	7
	dc.l	0
	VERTICES	16,21,6,-1,-1,-1,-1,-1
	COLOR	7
	dc.l	0
	VERTICES	26,31,6,-1,-1,-1,-1,-1
	COLOR	7
	dc.l	0
	VERTICES	36,41,6,-1,-1,-1,-1,-1
	COLOR	7
	dc.l	0
	dc.w	-1

