WELCOME TO THE HIDDEN PART OF THIS DEMO !!!    
I DON'T KNOW HOW YOU FIND THIS MINI-DESIGNER BUT HERE ARE THE COMMANDS : 
1 TO 0 DISPLAY A NEW OBJECT, 
LEFT AND RIGHT ARROWS CHANGE X-ROT, 
DOWN AND UP ARROWS CHANGE Y-ROT, 
INSERT AND CLR-HOME CHANGE Z-ROT, 
HELP AND UNDO CHANGE THE ZOOM, 
BACKSPACE RESTORES THE VALUES. 
THE VALUES DISPLAYED AT THE TOP OF THE SCREEN ARE 1) THE NUMBER OF IMAGES 
COMPUTED AT THE MOMENT, 2) X-ROT, 3) Y-ROT, 4) Z-ROT, 5) ZOOM. 
I'VE NOTHING SPECIAL TO SAY IN THAT SCROLLING, SO LET'S WWWWWWRRRRRAAAAAPPPPPP.....................
