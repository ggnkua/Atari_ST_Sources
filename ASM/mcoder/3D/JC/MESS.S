
DO YOU LIKE 3D FILLED VECTORS ?          NO ? HUMM, IT DOESN'T MATTER...    
HERE IS ONE NEW TRY, BUT THIS TIME IT RUNS IN 1 VBL (FOR THE LAMERS : 
IT COULDN'T RUN FASTER).  THIS SCREEN -INSPIRATED FROM THE KEFRENS MEGADEMO 8- 
HAS BEEN HARD-CODED DURING 2 MONTHS BY MCODER. 
RUMOURS SAY THAT TCB ARE CODING A 3D VECTOR-FILLED SCREEN, AND 
I ONLY HOPE MY 3D ARE FASTER THAN THEIRS !!! 

NOW, LET'S START THE MOST AWAITED PART OF THIS DEMO : THE GREETINGS. 
THEY GO TO : TCB (PLEASE READ THE WHOLE SCROLLTEXT), 
ILLEGAL OF FALLEN ANGELS (EXCUSE ME AGAIN FOR THE PREVIOUS FUCKINGS, I WAS SO ANGRY), 
SKYRACE OF HEMOROIDS (IN SOME MONTHS, YOU'LL BE A GREAT CODER), 
ZIGGY STARDUST OF THE OVERLANDERS (GREAT CODER, GREAT DELIRIOUS 2, GREAT SCREENS, BUT SHITTY PROTECTION), 
TGN OF ZUUL (WHEN WILL YOU START TO CODE ?), 
STYX OF ZUUL (A LITTLE EFFORT, BOY...), 
BOXER 77 (VERY COOL GUY), 
GLUEV OF HMD (VERY COOL TOO), 
WEREWOLF FROM THE FALLEN ANGELS (SORRY I COULDN'T MEET YOU THESE LAST TIMES), 
DOM FROM THE REPLICANTS (WHAT ABOUT YOUR PROTECTION ?), 
TERMINATOR X (ARE YOU STILL ALIVE ?).    

I HOPE I DIDN'T FORGET ANYBODY BECAUSE NOW HERE ARE THE FUCKING GREETINGS. 
MEGA-FUCKS TO : 
ZORBA OF ZUUL (YOU ARE A BIG FAT LAMER WHO CAN'T KEEP A SECRET SECRET, 
BUT I DON'T BOTHER ANYMORE BECAUSE I'LL STOP TO TALK TO YOU), 
THE STARFIRES (DON'T SPREAD MY UNFINISHED SCREENS. I DON'T KNOW WHO DID THAT 
BUT MY REVENGE WILL BE BLOODY !!!), 
NEXT (LAMERS, I HOPE FOR YOU THAT YOU DIDN'T TRY TO ATTACK ME WHEN YOU FUCKED THE STARFIRES 
-DO THE REPLICANTS FUCK AS GOOD AS THEY PRETEND ?-), 
SMUGGLER (IF I LEARN THAT YOU TAKE MY PSEUDO ONE MORE TIME, I'LL KILL YOU). 
THE GROUPS I WON'T FUCK ARE : THE REPLICANTS (GREAT NEW INTROS), 
THE EMPIRE (V8,EQUINOX,FALLEN ANGELS...), 
ST CONNEXION (ALWAYS WAITING FOR YOUR MEGA-LATE-MEGADEMO, CRAZY REX IS VERY -ARGHHH- GOOD), 
THE OVERLANDERS (YOU HAVE ABILITIES TO MAKE GOOD DEMOS). 

I'VE SOMETHING IMPORTANT TO SAY : 
SOME GROUP(S) DOESN'T APPRECIATE THAT I WROTE 'TRY TO BEAT DIS TCB' 
BECAUSE IT SEEMED VERY PRETENTIOUS. BUT I'M NOT PRETENTIOUS, IT'S JUST 
BECAUSE TCB ALWAYS MENTION 'TRY TO BEAT DIS', AND I'VE BEEN IN CONTACT 
WITH NICK OF TCB (NICK, DO YOU REMEMBER 'DON'T DEBUG JEAN' ???) 
AND I KNOW THAT I'M VERY GOOD AT CODING (SURELY THE BEST OPTIMIZER IN FRANCE). 


PERSONAL MESSAGE TO NICK : I'VE DISASSEMBLED YOUR LATEST SPRITE ROUTINES 
IN LEAVIN'TERAMIS AND I HAVE A BETTER TECHNIQUE (!!!) WHICH 
USES LESS REGISTERS AND CAN BE USED IN A GENERAL SPRITE ROUTINE -LOOK 
FOR MY NEXT GAME-, IF YOU WANT TO CONTACT ME AGAIN, YOU HAVE MY ADDRESS !!! 
FOR OTHER GROUPS : IF YOU ORGANIZE A DEMO COMPETITION, TRY TO CONTACT ME (I'VE SOME 
GREAT SCREENS NOT YET FINISHED). 
