XRES			equ		640
