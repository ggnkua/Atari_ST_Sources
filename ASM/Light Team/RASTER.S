MFP	equ 	$fffa00		Base address to the MFP-chip

ISRA 	equ 	MFP+$0f		In Service Register A
DATA 	equ 	MFP+$21		Timer B data register...

BACKGR	equ	$ff8240		Address to color 0


start	jsr wait		Syncronize Timer B with VBL...
	move.l #inter,-(sp)	Interruptvector
	move.w #0,-(sp)		Start with 0...
	move.w #8,-(sp)		Event count mode
	move.w #1,-(sp)		Timer B - Horizontal blank counter
	move.w #31,-(sp)	Xbtimer
	trap #14		Call Xbios...
	add.l #12,sp		Correct stack!
	
	move.b #0,flag		begin with int1...

	move.w #0,-(sp)		Error Code #0
	move.l #1000,-(sp)	Save 1000 bytes...
	move.w #$31,-(sp) 	Keep PROCESS...
	trap #1

inter	addq.b #1,flag		Swap between ints...
	
test1	cmp.b #1,flag		int1 ?
	bne test2

int1	move.w #$00F,BACKGR	Change Background...
	move.b #50,DATA		Count 50 lines...
	jmp slut

test2	cmp.b #2,flag 		int2 ?
	bne int3 

int2	move.w #$FFF,BACKGR 	Change Background...
	move.b #50,DATA		Count 50 lines...
	jmp slut

int3	move.w #$F00,BACKGR 	Change Background...
	move.b #100,DATA	Count 100 lines...
	move.b #0,flag		Reset flag...
	jmp slut

slut	bclr #0,ISRA		Clear the TIMER-B In-Service bit...
	rte			End..

wait	move.w #37,-(sp)	Wait for VBL...
	trap #14
	addq.l #2,sp
	rts

flag	ds.b 0			Which interrupt...MFP	equ 	$fffa00		Base address to the MFP-chip

ISRA 	equ 	MFP+$0f		In Service Register A
DATA 	equ 	MFP+$21		Timer B data register...

BACKGR	equ	$ff8240		Address to color 0


start	jsr wait		Syncronize Timer B with VBL...
	move.l #inter,-(sp)	Interruptvector
	move.w #0,-(sp)		Start with 0...
	move.w #8,-(sp)		Event count mode
	move.w #1,-(sp)		Timer B - Horizontal blank counter
	move.w #31,-(sp)	Xbtimer
	trap #14		Call Xbios...
	add.l #12,sp		Correct stack!
	
	move.b #0,flag		begin with int1...

	move.w #0,-(sp)		Error Code #0
	move.l #1000,-(sp)	Save 1000 bytes...
	move.w #$31,-(sp) 	Keep PROCESS...
	trap #1

inter	addq.b #1,flag		Swap between ints...
	
test1	cmp.b #1,flag		int1 ?
	bne test2

int1	move.w #$00F,BACKGR	Change Background...
	move.b #50,DATA		Count 50 lines...
	jmp slut

test2	cmp.b #2,flag 		int2 ?
	bne int3 

int2	move.w #$FFF,BACKGR 	Change Background...
	move.b #50,DATA		Count 50 lines...
	jmp slut

int3	move.w #$F00,BACKGR 	Change Background...
	move.b #100,DATA	Count 100 lines...
	move.b #0,flag		Reset flag...
	jmp slut

slut	bclr #0,ISRA		Clear the TIMER-B In-Service bit...
	rte			End..

wait	move.w #37,-(sp)	Wait for VBL...
	trap #14
	addq.l #2,sp
	rts

flag	ds.b 0			Which interrupt...