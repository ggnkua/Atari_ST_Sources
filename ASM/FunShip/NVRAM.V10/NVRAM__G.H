/* Resource Datei Indizes f�r NVRAM__G */

#define FMAIN    0   /* Formular/Dialog */
#define KEYBOARD 2   /* BUTTON in Baum FMAIN */
#define LANGUAGE 3   /* BUTTON in Baum FMAIN */
#define FORMAT   9   /* BUTTON in Baum FMAIN */
#define C12H     12  /* USERDEF in Baum FMAIN */
#define C24H     13  /* USERDEF in Baum FMAIN */
#define PREFERENCE 18  /* BUTTON in Baum FMAIN */
#define CAR      22  /* FBOXTEXT in Baum FMAIN */
#define DELAY    23  /* FBOXTEXT in Baum FMAIN */
#define PAL      30  /* USERDEF in Baum FMAIN */
#define NTSC     31  /* USERDEF in Baum FMAIN */
#define VGA      34  /* USERDEF in Baum FMAIN */
#define RVB      35  /* USERDEF in Baum FMAIN */
#define COL40    38  /* USERDEF in Baum FMAIN */
#define COL80    39  /* USERDEF in Baum FMAIN */
#define COULEUR  43  /* BUTTON in Baum FMAIN */
#define INTERLEACE 44  /* USERDEF in Baum FMAIN */
#define MODEST   45  /* USERDEF in Baum FMAIN */
#define OVERSCAN 46  /* USERDEF in Baum FMAIN */
#define ABOUT    53  /* USERDEF in Baum FMAIN */
#define CANCEL   55  /* USERDEF in Baum FMAIN */
#define OK       57  /* USERDEF in Baum FMAIN */
#define RESET    59  /* USERDEF in Baum FMAIN */

#define FINFO    1   /* Formular/Dialog */
#define VERSION  4   /* FTEXT in Baum FINFO */
#define DATEVER  5   /* FTEXT in Baum FINFO */
#define FUNSHIP  7   /* IMAGE in Baum FINFO */
#define INFOK    10  /* BUTTON in Baum FINFO */

#define ISETUP   2   /* Formular/Dialog */

#define IINFO    3   /* Formular/Dialog */

#define IAPPLI   4   /* Formular/Dialog */

#define PCLAVIER 5   /* Formular/Dialog */
#define KBFR     1   /* STRING in Baum PCLAVIER */
#define KBD      2   /* STRING in Baum PCLAVIER */
#define KBGB     3   /* STRING in Baum PCLAVIER */
#define KBUSA    4   /* STRING in Baum PCLAVIER */
#define KBCHF    5   /* STRING in Baum PCLAVIER */
#define KBSP     6   /* STRING in Baum PCLAVIER */
#define KBCHD    7   /* STRING in Baum PCLAVIER */
#define KBI      8   /* STRING in Baum PCLAVIER */

#define PLANGUE  6   /* Formular/Dialog */
#define LGF      1   /* STRING in Baum PLANGUE */
#define LGD      2   /* STRING in Baum PLANGUE */
#define LGGB     3   /* STRING in Baum PLANGUE */
#define LGSP     4   /* STRING in Baum PLANGUE */
#define LGI      5   /* STRING in Baum PLANGUE */
#define LGUSA    6   /* STRING in Baum PLANGUE */
#define LGCHF    7   /* STRING in Baum PLANGUE */
#define LGCHD    8   /* STRING in Baum PLANGUE */

#define PFORMAT  7   /* Formular/Dialog */
#define FMT2     1   /* STRING in Baum PFORMAT */
#define FMT0     2   /* STRING in Baum PFORMAT */
#define FMT1     3   /* STRING in Baum PFORMAT */
#define FMT3     4   /* STRING in Baum PFORMAT */

#define PPREF    8   /* Formular/Dialog */
#define PREFUNIX 1   /* STRING in Baum PPREF */
#define PREFNONE 2   /* STRING in Baum PPREF */
#define PREFTOS  3   /* STRING in Baum PPREF */

#define PCOULEUR 9   /* Formular/Dialog */
#define COL16    1   /* STRING in Baum PCOULEUR */
#define COL2     2   /* STRING in Baum PCOULEUR */
#define COL4     3   /* STRING in Baum PCOULEUR */
#define COL256   4   /* STRING in Baum PCOULEUR */
#define COLNTC   5   /* STRING in Baum PCOULEUR */

#define MESSAGES 10  /* Formular/Dialog */
#define MSG1     1   /* STRING in Baum MESSAGES */
#define MSG2     2   /* STRING in Baum MESSAGES */
#define MSG3     3   /* STRING in Baum MESSAGES */
#define MSG4     4   /* STRING in Baum MESSAGES */
#define MSG5     5   /* STRING in Baum MESSAGES */
#define MSG6     6   /* STRING in Baum MESSAGES */
#define MSG7     7   /* STRING in Baum MESSAGES */
#define MSG8     8   /* STRING in Baum MESSAGES */
#define MSG9     9   /* STRING in Baum MESSAGES */
#define MSG10    10  /* STRING in Baum MESSAGES */
#define MSG11    11  /* STRING in Baum MESSAGES */
#define MSG12    12  /* STRING in Baum MESSAGES */
#define MSG13    13  /* STRING in Baum MESSAGES */
#define MSG14    14  /* STRING in Baum MESSAGES */
