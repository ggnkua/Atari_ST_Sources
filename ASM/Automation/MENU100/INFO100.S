	LEA	PAGE_1,A6
NEW_SCN	BSR	SET_SCN
	MOVE.W	4(A6),D5
	LEA	$FFFF8240.W,A5
	BSR.S	DO_COLS
	MOVE.W	2(A6),D5
	LEA	$FFFF8246.W,A5
	BSR.S	DO_COLS
	MOVE.W	2(A6),D5
	LEA	$FFFF825E.W,A5
	BSR.S	DO_COLS
	PEA	$16(A6)
	MOVE.W	#9,-(A7)
	TRAP	#1
	ADDQ.L	#6,A7
	MOVE.W	#2,-(A7)
	MOVE.W	#0,-(A7)
	MOVE.W	#$15,-(A7)
	TRAP	#14
	ADDQ.L	#6,A7
GET_KEY	MOVE.W	#8,-(A7)
	TRAP	#1
	ADDQ.L	#2,A7
	SWAP	D0
	ANDI.L	#$FF,D0
	SUBI.B	#$3B,D0
	BMI.S	GET_KEY
	CMP.B	#4,D0
	BPL.S	GET_KEY
	LSL.W	#2,D0
	MOVE.L	6(A6,D0.W),D6
	BEQ.S	GET_KEY
	MOVEA.L	D6,A6
	BRA.S	NEW_SCN

SET_SCN	MOVE.W	(A6),-(A7)
	MOVE.L	#$FFFFFFFF,-(A7)
	MOVE.L	#$FFFFFFFF,-(A7)
	MOVE.W	#5,-(A7)
	TRAP	#14
	ADDA.L	#$C,A7
	RTS
DO_COLS	CLR.L	-(A7)
	MOVE.W	#$20,-(A7)
	TRAP	#1
	ADDQ.L	#6,A7
	MOVE.L	D0,D4
	MOVE.W	D5,(A5)
	MOVE.L	D4,-(A7)
	MOVE.W	#$20,-(A7)
	TRAP	#1
	ADDQ.L	#6,A7
	RTS

PAGE_1	DC.W	0	;RESOLUTION
	DC.W	$777	;FOREGROUND COLOUR
	DC.W	$000	;BACKGROUND COLOUR
	DC.L	PAGE_2	;F1 PAGE ADDRESS
	DC.L	PAGE_8	;F2 PAGE ADDRESS
	DC.L	PAGE_19	;F3 PAGE ADDRESS
	DC.L	PAGE_21	;F4 PAGE ADDRESS
	DC.B	"       AUTOMATION DISK 100 INFO."
	DC.B	$0D,$0A,$0A,$0A
	DC.B	"               MAIN MENU"
	DC.B	$0D,$0A,$0A,$0A
	DC.B	"         F1   GENERAL INFO"
	DC.B	$0D,$0A,$0A
	DC.B	"         F2   A LIST OF OUR DISKS"
	DC.B	$0D,$0A,$0A
	DC.B	"         F3   LOADS OF CHEATS"
	DC.B	$0D,$0A,$0A
	DC.B	"         F4   MEGA GREETINGS"
	DC.B	$0D,$0A,$0A,$0A
	DC.B	"             SELECT OPTION"
	DC.B	$0D,$0A,$0A,$0A
	DC.B	"  AUTOMATION - 100 done - 100 TO COME!",$0D,$0A
	DC.B	"",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"PRESS RESET TO EXIT PROG AND REBOOT DISK"
	DC.B	0

PAGE_2	DC.W	0
	DC.W	$777
	DC.W	$700
	DC.L	PAGE_3
	DC.L	0
	DC.L	0
	DC.L	PAGE_1
	DC.B	"   General Info"
	DC.B	$0D,$0A,$0A
	DC.B	"DISK 100 IS HERE AT LAST !!!",$0D,$0A
	DC.B	$0D,$0A,$A
	dc.b	"",$0D,$0A
	DC.B	"YES FOLKS AT DISK 100, NOBODY IS ",$0D,$0A
	DC.B	"GIVING US ANY MAJOR COMPETITION.",$0D,$0A,$0A
	DC.B	"I HOPE YOU HAVE ALL READ THE ST/AMIGA",$0D,$0A
	DC.B	"FORMAT ARTICLE ABOUT PIRACY, MOST",$0D,$0A
	DC.B	"INTERESTING DON'T YOU THINK?",$0D,$0A,$0A
	DC.B	$0D,$0A
	DC.B	"OUR RECRUITMENT CAMPAIGN HAS BEEN",$0D,$0A
	DC.B	"PUT ON HOLD FOR THE TIME BEING, WHILE",$0D,$0A
	DC.B	"WE CONSOLIDATE OUR POSITION!",$0D,$0A,$a
	DC.B	"",$0D,$0A
	DC.B	$0A,$0A,$0A,$0A
	DC.B	"F1 - FORWARD, F4 - MAIN MENU",0

PAGE_3	DC.W	0
	DC.W	$000
	DC.W	$777
	DC.L	PAGE_4
	DC.L	PAGE_2
	DC.L	0
	DC.L	PAGE_1
	DC.B	"   General Info  cont."
	DC.B	$0D,$0A,$0A
	DC.B	"  WE HAVE RECENTLY BEEN TRYING TO TEST",$0D,$0A
	DC.B	"OUR MENU'S ON AS MANY MACHINES AS WE CAN",$0D,$0A
	dc.b	"BEFORE WE SPREAD THEM, BUT OCCASIONALLY",$0D,$0A
	DC.B	"THE ODD FAULT CREEPS THROUGH, IF A FAULT",$0D,$0A
	DC.B	"DOES APPEAR TELL US ABOUT IT! PLEASE NO",$0D,$0A
	DC.B	"COMPLAINTS ABOUT GAMES NOT WORKING ",$0D,$0A
	DC.B	"BECAUSE OF CHEAPO DISK ERRORS, BUY GOOD",$0D,$0A
	DC.B	"DISKS AND YOU WILL HAVE NO PROBLEMS!!!!",$0D,$0A
	DC.B	$0D,$0A
	DC.B	"OUR USE OF 10 SECTOR FORMATS IS GOING",$0D,$0A
	DC.B	"DOWN WELL, APART FROM THE CHEAPO DISK",$0D,$0A
	DC.B	"MERCHANTS, BUY GOOD DISKS AND HAVE NO",$0D,$0A
	DC.B	"PROBLEMS, BUY TURDS AND WATCH YOUR ",$0D,$0A
	DC.B	"DATA DIE A DEATH!",$0D,$0A
	DC.B	$0A,$0A,$0A,$0A,$0A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_4	DC.W	0
	DC.W	$777
	DC.W	$005
	DC.L	PAGE_5
	DC.L	PAGE_3
	DC.L	0
	DC.L	PAGE_1
	DC.B	"   General Info  cont.",$0D,$0A,$0A
	DC.B	"WELL THINGS ON THE COMPACTION SCENE",$0d,$0a
	DC.B	"ARE GETTING A LITTLE BIT MORE ACTIVE!",$0d,$0a,$0a
	DC.B	"THE POWER GENERATION AFTER PROMISING ",$0d,$0a
	DC.B	"LOTS AND TELLING EVERYBODY HOW GOOD",$0d,$0a
	DC.B	"THEY WERE, APPEAR TO HAVE FIZZLED OUT,",$0d,$0a
	DC.B	"WELL NO SURPRISE THERE, WE ALL KNEW",$0d,$0a
	DC.B	"THEY WERE NEVER GOING ANYWHERE!",$0d,$0a,$0a
	DC.B	"THE 'AUTOMATION SELL PIRATED GAMES' ",$0d,$0a
	DC.B	"LINE CROPS UP AGAIN, YET AGAIN I SAY",$0D,$0a
	DC.B	"WE DO NOT SELL GAMES NOR HAVE WE EVER",$0d,$0a
	dc.b	"DONE SO, WHEN WILL PEOPLE LEARN!",$D,$A,$A,$A
	DC.B	"   - AUTOMATION DO NOT SELL GAMES -",$D,$A,$A
	DC.B	"WE ARE INTO HACKING FOR FUN, NOT PROFIT",$D,$A,$A,$A,$A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_5	DC.W	0
	DC.W	$777
	DC.W	$303
	DC.L	PAGE_6
	DC.L	PAGE_4
	DC.L	0
	DC.L	PAGE_1
	DC.B	"   General Info  cont.",$0D,$0A,$0A
	DC.B	"  WE WILL HOPEFULLY BE GETTING OUR NEW",$0d,$0a
	DC.B	"P.O. BOX UP AND RUNNING SOON, BUT AT THE",$0d,$0a
	DC.B	"MOMENT WE HAVE NO POST ADDRESS, SO DON'T",$0d,$0a
	DC.B	"WRITE TO THE OLD ADDRESS, OR YOU WILL",$0d,$0a
	DC.B	"MOST CERTAINLY LOSE YOUR DISKS,NOT NICE!",$0d,$0a,$0a
	DC.B	"THE L.S.D. ARE NOW STARTING TO DO MORE ",$D,$A
	DC.B	"WORK ON THE AMIGA AGAIN, SO IF YOU HAVE",$D,$A
	DC.B	"AN AMIGA, WATCH OUT FOR THERE FAB WORK",$D,$A,$A,$A
	DC.B	"  REMEMBER :-",$0d,$0a,$0a,$A
	DC.B	"WE ARE ALWAYS ON THE LOOKOUT FOR NEW",$0d,$0a
	DC.B	"RECRUITS, SO IF YOU FIT THE BILL, GET IN",$0d,$0a
	DC.B	"TOUCH, NEW CONTACT ADDRESS SOON!",$0d,$0a
	DC.B	"YES INDEED FOLKS THERE WILL BE A NEW",$D,$A
	DC.B	"CONTACT ADDRESS, WATCH FUTURE PRODUCTS",$D,$A
	DC.B	"FROM AUTOMATION.",$D,$A,$A,$A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_6	DC.W	0
	DC.W	$777
	DC.W	$500
	DC.L	PAGE_7
	DC.L	PAGE_5
	DC.L	0
	DC.L	PAGE_1
	DC.B	"   General Info  cont.",$0d,$0a,$0a
	DC.B	"",$0d,$0a,$0a
	DC.B	" YOU MAY HAVE NOTICED THAT WE HAVE BEEN ",$0d,$0a
	DC.B	" DOING A LOT OF 1 MEG FILES RECENTLY,   ",$0D,$0a
	DC.B	" WELL WE WILL BE DOING A LOT MORE IN    ",$0d,$0a
	DC.B	" THE FUTURE, THE REASONS ?      ",$0D,$0a
	DC.B	" 1. Games can be taken off boot disks,  ",$0d,$0a
	DC.B	"    thus freeing valuable disks!        ",$0D,$0A,$0A
	DC.B	" 2. Games play faster, play R-TYPE on 1 ",$0d,$0a
	DC.B	"    Meg and see what I mean             ",$0d,$0a,$0a
	DC.B	" 3. Demand! People keep asking us to do ",$0d,$0a
	DC.B	"    them.                               ",$0d,$0a,$0a
	DC.B	" SO IF YOU DO NOT HAVE 1 MEG OF MEMORY, ",$0d,$0a
	DC.B	" I WOULD STRONGLY ADVISE YOU TO UPGRADE ",$0D,$0a
	DC.B	" OR YOU WILL HAVE TO LEARN TO HACK!     ",$D,$0a,$0a,$0a
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_7	DC.W	0
	DC.W	$777
	DC.W	$005
	DC.L	0
	DC.L	PAGE_6
	DC.L	0
	DC.L	PAGE_1
	DC.B	"   General Info  cont.",$0d,$0a,$0a
	DC.B	"  AS THE COMPACTION SCENE EXPANDS, YOU",$0D,$0a
	DC.B	"WILL START TO SEE MORE AND MORE 'TINPOT'",$0d,$0a
	DC.B	"COMPACTION PEOPLE CLAIMING TO BE BETTER",$D,$0a
	DC.B	"THAN AUTOMATION, WELL WE HAVE TO LAUGH",$0d,$0a
	DC.B	"AT SOME OF THE AMATEURISH ATTEMPTS MADE",$D,$0a
	DC.B	" TO 'BEAT' US, THESE PEOPLE USUALLY SAY",$0d,$0a
	DC.B	"THAT THEY HAVE COMPACTED DOZENS OF GAMES",$D,$0a
	DC.B	"BUT MYSTERIOUSLY CANNOT PRODUCE THEM, I",$0d,$0a
	DC.B	"WONDER WHY? (E.G. ABC MAN)",$D,$A,$A
	DC.B	"SO STICK WITH THE BEST, THE ULTIMATE SET",$0d,$0a
	DC.B	"OF COMPACTED DISKS FOR THE ATARI ST!",$0d,$0a
	DC.B	"     WE DELIVER GAMES, NOT BULLSHIT",$D,$0a
	DC.B	$0d,$0a,$0a
	DC.B	"      WOT BIRDY ONLY UPTO DISK 15!",$0d,$0a
	DC.B	$D,$0a,$0a
	DC.B	$0d,$0a,$0a,$0a,$0a
	DC.B	"F2 - BACK, F4 - MAIN MENU",0

PAGE_8	DC.W	1
	DC.W	$123
	DC.W	$777
	DC.L	PAGE_9
	DC.L	0
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  COMPACTED SOFTWARE LIST:  PAGE 1",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"DISK 1   -   ROBOTRON, SENTINEL, STAR RAIDERS, CRYSTAL CASTLES, NORTH STAR, ",$0d,$0a
	DC.B	"             EMPIRE STRIKES BACK, TRAILBLAZER 2.",$D,$A,$A,$A
	DC.B	"DISK 2   -   VIRUS, KNIGHTMARE, EXTENSOR, PLUTOS, INTO THE EAGLES NEST, ",$0d,$0a
	DC.B	"             JOE BLADE, TRANTOR, TRIFIDE 2.",$D,$A,$A,$A
	DC.B	"DISK 3   -   MERCENARY, SECOND CITY, REVENGE OF DOH, DELTA PATROL, ",$0d,$0a
	DC.B	"             FOOTBALL MANAGER, SUPER HUEY, ARCADE CLASSICS, ROLLING THUNDER.",$D,$A,$A,$A
	DC.B	"DISK 4   -   MISSION GENOCIDE, XEVIOUS, SCRABBLE DELUXE, MOON PATROL, ",$0d,$0a
	DC.B	"             AIRBALL, STARQUAKE, EDEN BLUES, MISSILE COMMAND(V1.0).",$D,$A,$A,$a
	DC.B	"DISK 5   -   TYPHOON THOMPSON, STREET GANG (MEG FILE), DEATH STRIKE. ",$0d,$0a,$0a
	DC.B	$0A,$0A
	DC.B	"F1 - FORWARD, F4 - MAIN MENU",0

PAGE_9	DC.W	1
	DC.W	$600
	DC.W	$566
	DC.L	PAGE_10
	DC.L	PAGE_8
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  COMPACTED SOFTWARE LIST:  page 2",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"DISK 6   -   BETTER DEAD THAN ALIEN, ARMY MOVES, ROCKFORD, PINBALL FACTORY, ",$0d,$0a
	DC.B	"             JOUST, THUNDERCATS, MISSILE COMMAND(V2.0).",$D,$A,$0a
	DC.B	"DISK 7   -   ASTEROIDS DELUXE, BATTLESHIPS, KARATE KID 2 (1 MEG), DIABLO, ",$0d,$0a
	DC.B	"             VAMPIRE EMPIRE, OVERLANDER.",$D,$A,$0a,$A
	DC.B	"DISK 8   -   BACKLASH, SUPER BREAKOUT, NINJA MISSION, MUTANT CAMELS, Q-BALL, ",$0d,$0a
	DC.B	"             GOLDRUNNER, MAJOR MOTION, SPOOK.",$D,$A,$0a,$A
	DC.B	"DISK 9   -   ENDURO RACER, CHUBBY GRISTLE, NEBULUS, ELIMINATOR.",$0d,$0a,$0a,$A,$a
	DC.B	"DISK 10  -   LEADERBOARD, TOURNAMENT DISK, VETERAN, BLACK LAMP, PENGY, ",$0d,$0a
	DC.B	"             WHIRLIGIG",$D,$A,$A
	DC.B	$0A,$0A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0


PAGE_10	DC.W	1
	DC.W	$000
	DC.W	$700
	DC.L	PAGE_11
	DC.L	PAGE_9
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  COMPACTED SOFTWARE LIST:  PAGE 3",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"DISK 11  -   CRICKET (MEG ONLY), SOCCER SUPREMO, MUDPIES, SUPER TENNIS, ",$0d,$0a
	DC.B	"             HOTSHOT, LANDS OF HAVOC, QUADRALIEN, THRUST.",$D,$A,$A,$0a
	DC.B	"DISK 12  -   BEYOND THE ICE PALACE, SHACKLED, TIME BANDIT, DEFLEKTOR, ",$0d,$0a
	DC.B	"             SPACE KILLER, SKYCHASE",$D,$A,$A,$0a
	DC.B	"DISK 13  -   SUPER HANG-ON(1 MEG), SUPER SPRINT, ST KARATE, ST POOL",$0d,$0a,$0a,$A,$A
	DC.B	"DISK 14  -   STAR GOOSE, ELITE, HELTER SKELTER, VIXEN.",$0D,$0A,$0A,$A,$A
	DC.B	"DISK 15  -   STAR RAY (1 MEG), RETURN TO GENESIS (1 MEG).",$0d,$0a,$0a
	DC.B	$0A,$0A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_11	DC.W	1
	DC.W	$777
	DC.W	$111
	DC.L	PAGE_12
	DC.L	PAGE_10
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  COMPACTED SOFTWARE LIST:  PAGE 4",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"DISK 16  -   FEDERATION OF FREE TRADERS, BOMBJACK, FOOTBALL MANAGER 2, ",$0d,$0a
	DC.B	"             SCREAMING WINGS, MOUSE TRAP.",$D,$A,$A,$0a
	DC.B	"DISK 17  -   MAGNETIC TANK, INDIANA JONES, TETRIS, SPY VS SPY, ",$0d,$0a
	DC.B	"             CYBERNOID, TETRA QUEST (1 MEG).",$D,$A,$A,$0a
	DC.B	"DISK 18  -   PHANTASM, ECO, WIZBALL, BUGGY BOY, FLOYD THE DROID.",$0d,$0a,$0a,$A,$A
	DC.B	"DISK 19  -   WHERE TIME STOOD STILL, BATTLE PROBE , SORCERY +, XOR.",$0D,$0A,$0A,$A,$A
	DC.B	"DISK 20  -   ARTURA, GARFIELD, MOONBASE, 3D GALAX.",$0d,$0a,$0a
	DC.B	$0A,$0A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_12	DC.W	1
	DC.W	$700
	DC.W	$077
	DC.L	PAGE_13
	DC.L	PAGE_11
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  COMPACTED SOFTWARE LIST:  PAGE 5",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"DISK 21  -   NIGEL MANSELL, FERNANDEZ MUST DIE, URIDIUM, ALTAIR, ",$0d,$0a
	DC.B	"             BATTLEZONE, ENFORCER.",$D,$A,$A,$0a
	DC.B	"DISK 22  -   1943, CAPTAIN AMERICA, RAMPAGE, SLAPFIGHT, LEATHERNECKS.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 23  -   TURBO CUP, FLYING SHARK, SNAFUX.",$0d,$0a,$0a,$A,$A
	DC.B	"DISK 24  -   RETURN OF THE JEDI, OFFSHORE WARRIOR, BANK BUSTERS, 2 GAME.",$0D,$0A,$0A,$A,$A
	DC.B	"DISK 25  -   PAC-MANIA, METROCROSS, SOLOMONS KEY, HELLFIRE, MAD MIX, ",$0d,$0a
	DC.B	"             INTERNATIONAL KARATE +, HARRIER STRIKE MISSION.",$d,$0a
	DC.B	$0A,$0A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_13	DC.W	1
	DC.W	$700
	DC.W	$000
	DC.L	PAGE_14
	DC.L	PAGE_12
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  COMPACTED SOFTWARE LIST:  PAGE 6",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"DISK 26  -   MILLIPEDE, DRILLER, MACH 3, TRUCK.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 27  -   LIVE + LET DIE, FOUNDATIONS WASTE, ST PROTECTOR, PANDORA.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 28  -   FIREBLASTER, STORMBRINGER, NETHERWORLD, FROSTBYTE, XENON.",$0d,$0a,$0a,$A,$A
	DC.B	"DISK 29  -   ALIEN SYNDROME, SPACE STATION, BARBARIAN, FUZZBALL.",$0D,$0A,$0A,$A,$A
	DC.B	"DISK 30  -   HAUNTED HOUSE, CRACKED, SPEEDBALL, TIMEBLAST, EXOLON, ATAX.",$0d,$0a,$A
	DC.B	$0A,$0A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_14	DC.W	1
	DC.W	$070
	DC.W	$207
	DC.L	PAGE_15
	DC.L	PAGE_13
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  COMPACTED SOFTWARE LIST:  PAGE 7",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"DISK 31  -   DALEY THOMPSONS OLYMPIC CHALLENGE (MEG FILE), GROWTH.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 32  -   STAR BATTLE, SDI(Cinemaware), BIONIC COMMANDO.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 33  -   PREDATOR, BOUNCEOUT, CHUCKIE EGG, SOLDIER OF LIGHT.",$0d,$0a,$0a,$A,$A
	DC.B	"DISK 34  -   BUBBLE BOBBLE, HYPERDOME, HELLBENT, G.L.SOCCER, MONEY.",$0D,$0A,$0A,$A,$A
	DC.B	"DISK 35  -   FALCON, BOMBUZAL.",$0d,$0a,$A
	DC.B	$0A,$0A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_15	DC.W	1
	DC.W	$700
	DC.W	$270
	DC.L	PAGE_16
	DC.L	PAGE_14
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  COMPACTED SOFTWARE LIST:  PAGE 8",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"DISK 36  -   JOE BLADE 2, POOL, FLIPSIDE, WANTED.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 37  -   OPERATION WOLF, TOP GUN.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 38  -   MISSION ELEVATOR, IKARI WARRIORS, FLINTSTONES, MUNSTERS, ",$0d,$0a
	DC.B	"             CHECKERS.",$D,$0a,$A,$A
	DC.B	"DISK 39  -   TERRAMEX, METROPOLIS, SUPER SKI, POKER ROYALE.",$0D,$0A,$0A,$A,$A
	DC.B	"DISK 40  -   IRON TRACKERS, VICTORY ROAD, MEGAROIDS.",$0d,$0a,$A
	DC.B	$0A,$0A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_16	DC.W	1
	DC.W	$700
	DC.W	$001
	DC.L	PAGE_17
	DC.L	PAGE_15
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  COMPACTED SOFTWARE LIST:  PAGE 9",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"DISK 41  -   STREET FIGHTER, SPACE RACER, RIPCORD.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 42  -   GALACTIC CONQUEROR, TRAUMA, CHOPPER X, MONKEY BUSINESS.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 43  -   THUNDERBLADE (1 MEG), SPIDERTRONIC, BOULDERDASH.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 44  -   SDI (Activision) (1 MEG), DESOLATOR (1 MEG).",$0D,$0A,$0A,$A,$A
	DC.B	"DISK 45  -   VECTORBALL, DOUBLE DRAGON (MEG FILE).",$0d,$0a,$A
	DC.B	$0A,$0A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_17	DC.W	1
	DC.W	$700
	DC.W	$100
	DC.L	PAGE_17a
	DC.L	PAGE_16
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  COMPACTED SOFTWARE LIST:  PAGE 10",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"DISK 46  -   R-TYPE (1 MEG), MENACE (1 MEG).",$0d,$0a,$A,$A,$A
	DC.B	"DISK 47  -   RAMBO 3, TRANSPUTOR, FREE CLIMBING, YAHTZEE, ZXYM.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 48  -   CAPTAIN FIZZ, TRACKSUIT MANAGER, RUGBY SIMULATOR, ",$0d,$0a
	DC.B	"             ELF, PYRAMINO.",$D,$A,$A,$A
	DC.B	"DISK 49  -   CRAZY CARS 2 (1 MEG), BAAL (1 MEG).",$0D,$0A,$0A,$A,$A
	DC.B	"DISK 50  -   BATMAN A + B, BREAKANOID, ADDICTABALL, WARHAWK, BRIKYARD.",$0d,$0a,$A
	DC.B	$0A,$0A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_17a	DC.W	1
	DC.W	$007
	DC.W	$700
	DC.L	PAGE_17b
	DC.L	PAGE_17
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  COMPACTED SOFTWARE LIST:  PAGE 11",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"DISK 51  -   PETER BEARDSLEYS FOOTBALL, IMPACT, PROHIBITION, TAU CETI.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 52  -   ZANY GOLF, KARATEKA.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 53  -   QUESTION OF SPORT, SPACE BALLER, TURBO GT. SKYRIDER, EREBUS.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 54  -   LED STORM, THUNDERWING, CHASE, MAFDET, HADES NEBULA.",$0D,$0A,$0A,$A,$A
	DC.B	"DISK 55  -   CUSTODIAN, ANDES ATTACK, BRATTACUS, SIDEARMS.",$0d,$0a,$A
	DC.B	$0A,$0A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_17b	DC.W	1
	DC.W	$304
	DC.W	$060
	DC.L	PAGE_17c
	DC.L	PAGE_17a
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  COMPACTED SOFTWARE LIST:  PAGE 12",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"DISK 56  -   BERMUDA PROJECT, TRAP.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 57  -   I LUDICRUS, LUXOR, HUSTLER.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 58  -   WIZARD ROYALE, CARDS, DAME.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 59  -   GOLDEN PATH, ROADWARS.",$0D,$0A,$0A,$A,$A
	DC.B	"DISK 60  -   LIVINGSTONE, STARGLIDER, BLAST, LABYRINTH, MISSION.",$0d,$0a,$A
	DC.B	$0A,$0A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_17c	DC.W	1
	DC.W	$070
	DC.W	$007
	DC.L	PAGE_17d
	DC.L	PAGE_17b
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  COMPACTED SOFTWARE LIST:  PAGE 13",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"DISK 61  -   CATCH 23, TENTH FRAME, ROADRUNNER.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 62  -   TECHNOCOP(1 MEG), POWERDROME(1 MEG).",$0d,$0a,$A,$A,$A
	DC.B	"DISK 63  -   STONEBREAKER, STRIP BREAKOUT, ARKANOID, BMX SIMULATOR, HACKER 2.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 64  -   BARBARIAN(PSYGNOSIS - 1 MEG), OUTRUN(1 MEG).",$0D,$0A,$0A,$A,$A
	DC.B	"DISK 65  -   GALDREGONS DOMAIN.",$0d,$0a,$A
	DC.B	$0A,$0A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_17d	DC.W	1
	DC.W	$700
	DC.W	$007
	DC.L	PAGE_17e
	DC.L	PAGE_17c
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  COMPACTED SOFTWARE LIST:  PAGE 14",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"DISK 66  -   INCREDIBLE SHRINKING SPHERE, MAD FLUNKY, BOMB FUSION, TERRA NOVA.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 67  -   FIRE AND FORGET, CRAFTON + XUNK, EYE, HUNT FOR THE RED OCTOBER.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 68  -   RAFFLES, TERRESTIAL ENCOUNTER, RINGSIDE.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 69a -   PRESIDENT ELECT, STELLAR CRUSADE, WINTER GAMES, ULTIMA III.",$0D,$0A,$0A
	DC.B	"DISK 69b -   BARBARIAN 2, LAST DUEL.",$D,$A,$A
	DC.B	"DISK 70  -   BALLISTIX, REAL GHOSTBUSTERS, WARLOCKS QUEST.",$0d,$0a,$A
	DC.B	$0A,$0A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_17e	DC.W	1
	DC.W	$777
	DC.W	$000
	DC.L	PAGE_17f
	DC.L	PAGE_17d
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  COMPACTED SOFTWARE LIST:  PAGE 15",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"DISK 71  -   TEENAGE QUEEN, KARTING GRAND PRIX, SAM AND ED, KNICKER BOCKER.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 72  -   PROHIBITION 2, SECONDS OUT, SCRUPLES, FOOTBALL DIRECTOR.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 73  -   GAUNTLET(1 MEG), ARCTIC FOX(1 MEG), WIZARD WARZ(1 MEG).",$0d,$0a,$A,$A,$A
	DC.B	"DISK 74  -   MINI-GOLF PT 1, BILLIARDS SIMULATOR, BORODINO, HANG-MAN.",$0D,$0A,$0A,$A,$A
	DC.B	"DISK 75  -   MINI-GOLF PT 2, MARIA'S XMAS BOX, GAME OVER 2(1 MEG), PAC-MAN.",$0d,$0a,$A
	DC.B	$0A,$0A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_17f	DC.W	1
	DC.W	$000
	DC.W	$777
	DC.L	PAGE_17g
	DC.L	PAGE_17e
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  COMPACTED SOFTWARE LIST:  PAGE 16",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"DISK 76  -   KICK OFF, NO EXCUSES, GREAT BATTLES, RUGBY LEAGUE BOSS.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 77  -   CAPTAIN BLOOD, ARKANOID 3, T.N.T.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 78  -   TRIVIAL PURSUIT + A NEW BEGINNING, ROADWAR EUROPA.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 79  -   PACLAND, ZYNAPS, SAPIENS, ROGUE.",$0D,$0A,$0A,$A,$A
	DC.B	"DISK 80  -   BLASTEROIDS, GRIDRUNNER, WRANGLER, MANIACS DIARY, SKWEEK.",$0d,$0a,$A
	DC.B	$0A,$0A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_17g	DC.W	1
	DC.W	$000
	DC.W	$777
	DC.L	PAGE_17h
	DC.L	PAGE_17f
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  COMPACTED SOFTWARE LIST:  PAGE 17",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"DISK 81  -   POPULOUS, STAR WARS, WALL STREET.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 82  -   DEFENDER OF THE CROWN, PINK PANTHER.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 83  -   KRYPTON EGG, CHUCKIE EGG 2, SKULLDIGGERY, ILLUSIONS.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 84  -   DRAGONSCAPE, H.K.M. , ROADBLASTERS, LAST TROOPER.",$0D,$0A,$0A,$A,$A
	DC.B	"DISK 85  -   WINTER EDITION, CYBERNOID 2, ACADEMY.",$0d,$0a,$A
	DC.B	$0A,$0A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_17h	DC.W	1
	DC.W	$000
	DC.W	$777
	DC.L	PAGE_17i
	DC.L	PAGE_17g
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  COMPACTED SOFTWARE LIST:  PAGE 18",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"DISK 86  -   STEVE DAVIS SNOOKER, BOBO.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 87  -   TIGER ROAD, MOTOR MASSACRE.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 88  -   VOYAGER, ACTION FIGHTER, WARZONE, SKYFOX, TRIVIA CHALLENGE.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 89  -   STAR TREK, LIBERATOR, ALPINE GAMES, SORCEROR LORD.",$0D,$0A,$0A,$A,$A
	DC.B	"DISK 90  -   HE-MAN, EPYX KARATE, FINAL LEGACY.",$0d,$0a,$A
	DC.B	$0A,$0A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_17i	DC.W	1
	DC.W	$000
	DC.W	$777
	DC.L	PAGE_17j
	DC.L	PAGE_17h
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  COMPACTED SOFTWARE LIST:  PAGE 19",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"DISK 91  -   CLEVER + SMART, VINDICATORS.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 92  -   SUPERMAN, DUGGER, DRAGON FORCE.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 93  -   SPACEBALL, A320.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 94  -   CARRIER COMMAND, MATAHARI, OPERATION HORMUZ.",$0D,$0A,$0A,$A,$A
	DC.B	"DISK 95  -   COSMIC PIRATES, HOSTAGES.",$0d,$0a,$A
	DC.B	$0A,$0A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_17j	DC.W	1
	DC.W	$000
	DC.W	$777
	DC.L	PAGE_18
	DC.L	PAGE_17i
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  COMPACTED SOFTWARE LIST:  PAGE 20",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"DISK 96  -   ROBOCOP, SHANGHAI, RENEGADE.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 97  -   DUNGEON MASTER, OIDS, 3D POOL.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 98  -   F-15 STRIKE EAGLE, ALPHAMAX, MILENIUM 2.2, SHUTTLE 2.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 99  -   JOAN OF ARC, MARBLE MADNESS.",$0D,$0A,$0A,$A,$A
	DC.B	"DISK 100 -   CHICAGO 30, PUFFY'S SAGA, SAVAGE (INTRO + 1,2,3).",$0d,$0a,$A
	DC.B	$0A,$0A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_18	DC.W	0
	DC.W	$000
	DC.W	$777
	DC.L	PAGE_18A
	DC.L	PAGE_17
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  COMPACTED SOFTWARE LIST:  SUMMARY",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"WELL THAT CONCLUDES THE LIST FOR NOW!  ",$0d,$0a,$A
	DC.B	"HERE IS A LIST OF WHAT MAY OR MAY NOT  ",$D,$A
	DC.B	"APPEAR IN THE FUTURE :-",$D,$A,$A,$A
	DC.B	"BUMPY, STORMTROOPER, ",$0d,$0a
	DC.B	"COBRA 2, ARCHIPELAGOS, SPHERICAL,",$D,$A
	DC.B	" OBLITERATOR,",$0d,$0a
	DC.B	"GHOSTS AND GOBLINS, WINTER OLYMPIAD,",$D,$A
	DC.B	"",$D,$A
	DC.B	"POTHOLE PETE, J.U.G.,",$D,$A
	DC.B	"SKYRIDER, ARTIFICIAL DREAMS, ",$0D,$0A
	DC.B	"PRISON,  DREAM ZONE, ",$D,$A
	DC.B	" KENNEDY APPROACH",$D,$0A
	DC.B	"ALL THE ABOVE ARE READY AND WAITING!",$0d,$0a,$A
	DC.B	$0A,$0A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_18A	DC.W	0
	DC.W	$000
	DC.W	$427
	DC.L	0
	DC.L	PAGE_18
	DC.L	0
	DC.L	PAGE_1
	DC.B	"FOR THOSE OF YOU WITH NON-BRITISH      ",$0D,$0A
	DC.B	"MACHINES WHO ARE CONFRONTED BY THE     ",$0d,$0a
	DC.B	"MESSAGE 'CAN'T RUN THIS TOS VERSION'   ",$D,$A
	DC.B	"OR WORDS TO THAT EFFECT WHEN ATTEMPTING",$D,$A
	DC.B	"TO LOAD THE ODD GAME ON SOME OF OUR    ",$0d,$0a
	DC.B	"EARLY MENUS - FOLLOW THESE INSTRUCTIONS",$D,$A
	DC.B	"1. DELETE GEM1FILE/STARTGEM.PRG AND    ",$0d,$0a
	DC.B	"   STARTGEM.LSD FROM THE DISK.         ",$D,$A
	DC.B	"2. RENAME THE ?.LSD/WAS FILE WHICH THE ",$D,$A
	DC.B	"   ABOVE PROGRAMS WERE TRYING TO LOAD  ",$D,$A
	DC.B	"   TO A ?.TOS FILE.",$0D,$0A
	DC.B	"3. CREATE A DESKTOP.INF FILE TO DISPLAY",$D,$A
	DC.B	"   THIS PARTICULAR ?.TOS FILE AND      ",$D,$0A
	DC.B	"   VOILA! IT CAN NOW BE RUN FROM THE   ",$0d,$0a
	DC.B	"   DESKTOP ON EXITING THE MENU.  WOW!  ",$0d,$0A,$A
	DC.B	"F2 - BACK, F4 - MAIN MENU",0

PAGE_19	DC.W	0
	DC.W	$000
	DC.W	$777
	DC.L	PAGE_20
	DC.L	0
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  CHEAT LIST ",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"IN SOME OF THE GAMES THAT WE HAVE PUT  ",$0d,$0a
	DC.B	"ON THE EARLIER MENU'S, WE HAVE BUILT IN",$D,$A
	DC.B	"ADDITIONAL CHEATS TO ANY ALREADY THERE.",$D,$A,$A,$A,$A
	DC.B	"ON THE NEXT FEW PAGES YOU WILL FIND A",$0d,$0a
	DC.B	"LIST OF MOST OF THEM, THOUGH NOT ALL OF",$D,$A
	DC.B	"THEM, AS THAT WOULD BE TOO EASY, FOR",$0d,$0a
	DC.B	"YOU ALL, SO IF YOU EXPERIMENT YOU MAY",$D,$A
	DC.B	"FIND SOME MORE",$D,$A
	DC.B	"",$D,$A
	DC.B	"",$0D,$0A
	DC.B	"",$D,$0A,$A,$A
	DC.B	"",$0d,$0a,$A
	DC.B	$0A,$0A
	DC.B	"F1 - FORWARD, F4 - MAIN MENU",0

PAGE_20	DC.W	0
	DC.W	$777
	DC.W	$000
	DC.L	PAGE_20A
	DC.L	PAGE_19
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  CHEAT LIST  cont.",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"IN THE FOLLOWING GAMES HIT F1 OR HELP",$0d,$0a
	DC.B	"WHEN THE GAME SAYS PRESS A KEY, IT WILL",$D,$A
	DC.B	"BE ONE OR THE OTHER, OK!",$D,$A,$A
	DC.B	"ROCKFORD",$D,$A
	DC.B	"JOE BLADE",$D,$A
	DC.B	"REVENGE OF DOH",$0d,$0a
	DC.B	"ARMY MOVES",$D,$A
	DC.B	"CHUBBY GRISTLE",$0d,$0a
	DC.B	"NORTH STAR(later versions of disk 1)",$D,$A
	DC.B	"BEYOND THE ICE PALACE",$D,$A
	DC.B	"SLAPFIGHT",$D,$A
	DC.B	"SOLOMONS KEY",$0D,$0A
	DC.B	"HELLFIRE",$D,$0A
	DC.B	"FIREBLASTER",$D,$A
	DC.B	"HYPERDOME",$D,$A
	DC.B	"DEATHSTRIKE",$0d,$0a
	DC.B	"TERRAMEX",$D,$A
	DC.B	"METROPOLIS",$D,$0A,$0A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_20A	DC.W	0
	DC.W	$777
	DC.W	$000
	DC.L	PAGE_20b
	DC.L	PAGE_20
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  CHEAT LIST  cont.",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"STREETFIGHTER (PRESS C)",$D,$A
	DC.B	"R-TYPE (PRESS F4,F5,F6,F7,F8,F9)",$D,$A
	DC.B	"MENACE (TYPE XR3ITURBONUTTERBASTARD)",$D,$A
	DC.B	"SUPER HANG ON (TYPE 207L ON SCORE SHEET,",$D,$A
	DC.B	"  WAIT, THEN PRESS CTRL,ALT,Z AND T, ",$D,$A
	DC.B	"  WAIT, NOW LET GO OF T.",$D,$A
	DC.B	"NEBULUS (TYPE HELLIOAMJMP)",$D,$A
	DC.B	"SORCERY+ (GAS MASK WHEELER WANTS CHEAT)",$D,$A
	DC.B	"D.T.O.C (TYPE HINGSEN-J) - = KEY-PAD",$D,$A
	DC.B	"    THEN USE FUNCTION KEYS.",$D,$A
	DC.B	"CYBERNOID (TYPE RAISTLIN)",$D,$A
	DC.B	"FERNANDEZ MUST DIE (TYPE SPINYNORMAN)",$D,$A
	DC.B	"SKYRIDER (SCORE 50000+ POINTS THEN",$D,$A
	DC.B	"   TYPE SHEFFIELD",$D,$A,$A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_20b	DC.W	0
	DC.W	$000
	DC.W	$777
	DC.L	0
	DC.L	PAGE_20A
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  CHEAT LIST  cont.",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"SOME MORE RECENT CHEATS!!",$D,$A,$A
	DC.B	"ON THE FOLLOWING GAMES HIT THE '*'",$D,$A
	DC.B	"KEY ON THE KEYPAD WHEN IT WANTS A KEY!",$D,$A
	DC.B	"   BLASTEROIDS (MENU 80)",$D,$A
	DC.B	"   HKM (MENU 84!)",$D,$A
	DC.B	"   ROADBLASTERS (MENU 84)",$D,$A
	DC.B	"   TIGER ROAD (MENU ??)",$D,$A,$A
	DC.B	"REAL GHOSTBUSTERS - HOLD '*' WHILE",$D,$A
	DC.B	"                    IT LOADS!",$D,$A,$A
	DC.B	"PLUS MORE HIDDEN ONES! - GET GUESSING!",$D,$A,$A,$A
	DC.B	"F2 - BACK, F4 - MAIN MENU",0

PAGE_21	DC.W	0
	DC.W	$777
	DC.W	$700
	DC.L	PAGE_22
	DC.L	0
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  GREETINGS LIST",$0D,$0A
	DC.B	$0A
	DC.B	"WE AT AUTOMATION, MUST BID A BIG AND",$0d,$0a
	DC.B	"INDEED HEARTY HELLO TO THE FOLLOWING",$D,$A
	DC.B	"FRIENDS AND CONTACTS :-",$D,$A,$A
	DC.B	"PIRASOFT/ACU, SERVO, A-HA, KAM, CLIMAX,",$D,$A
	DC.B	"THE ELITE SQUAD, SPECIAL FX, PHALANX,",$D,$A
	DC.B	"TURNIP, HAL, EDITMAN, SEWER SOFTWARE,",$0d,$0a
	DC.B	"TEX(CUTE GAME), THE REPLICANTS,",$D,$A
	DC.B	"777 TEAM FINLAND, SWINTON CLUB (RIP),",$0d,$0a
	DC.B	"SUB HUMANS IN TURKEY, MEDWAY BOYS.",$D,$A,$A
	DC.B	"A MESSAGE TO ALL ST OWNERS AT BRADFORD",$D,$A
	DC.B	"MICRO CLUB  -  FAST ARE COMING FOR YOU!",$0D,$0A,$0A,$A,$A,$0a
	DC.B	$A,$0A,$0A
	DC.B	"F1 - FORWARD, F4 - MAIN MENU",0

PAGE_22	DC.W	0
	DC.W	$000
	DC.W	$700
	DC.L	PAGE_22A
	DC.L	PAGE_21
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  GREETINGS LIST  cont.",$0D,$0A
	DC.B	$0A
	DC.B	"SO REMEMBER GUYS, COLLECT OUR DISKS",$0d,$0a
	DC.B	"AND YOU WILL HAVE THE BEST COMPACTED",$D,$A
	DC.B	"COLLECTION AVAILABLE ON THE ST!",$D,$A,$A
	DC.B	"I MEAN, HOW CAN YOU GO WRONG WITH THE",$D,$A
	DC.B	"COMBINED MIGHT OF WAS(NOT WAS), L.S.D,",$D,$A
	DC.B	"IAN.C, SHARAZ JEK, THE UN-NAMEABLES",$0d,$0a
	DC.B	"AND COR BLIMEY WORKING TOGETHER!",$D,$A,$0a
	DC.B	"WE DON'T BULLSHIT AND SAY WE HAVE DONE",$D,$A
	DC.B	"THIS AND THIS, BUT THEY ARE AT HOME OR",$D,$A
	DC.B	"WE ACCIDENTALLY FORMATTED THEM ALL!!",$0D,$0A
	DC.B	"SOME PEOPLE DO SAY STUFF LIKE THAT!",$D,$a,$0A
	DC.B	"  COMPETITION - WHAT COMPETITION?????",$D,$A
	DC.B	$D,$A,$0a,$0A,$0A,$0A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_22A	DC.W	0
	DC.W	$000
	DC.W	$700
	DC.L	0
	DC.L	PAGE_22
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  GREETINGS LIST  cont.",$0D,$0A
	DC.B	$0A
	DC.B	"IF YOU KNOW ANYTHING ABOUT ANY LAMERS",$D,$A
	DC.B	"WHO TAMPER WITH OUR MENUS, LET US KNOW",$D,$A
	DC.B	"ABOUT THEM SO WE CAN EXPOSE THEM ON",$D,$A
	DC.B	"FUTURE INFO FILES, AND WE DON'T MEAN IT",$D,$A
	DC.B	"AS A CHEAP THRILL FOR THE LADIES.",$D,$A,$A
	DC.B	"COME ON GUYS THERE MUST BE SOMEONE OUT",$D,$A
	DC.B	"THERE WHO CAN DO SOME MUSIC FOR US, ",$D,$A
	DC.B	"IF NOT, WHY NOT.",$D,$A,$A
	DC.B	"MESSAGE TO PROBE SOFTWARE,STICK TO THE",$D,$A
	DC.B	"SPECTRUM,YOUR METHOD OF STOPPING PIRACY ",$D,$A
	DC.B	"IS TO MAKE A GAME SO BAD, NO PIRATE ",$D,$A
	DC.B	"WOULD WANT IT IN HIS COLLECTION.",$D,$A,$A
	DC.B	$D,$A,$A,$A,$A,$A,$A
	DC.B	"F2 - BACK, F4 - MAIN MENU",0
