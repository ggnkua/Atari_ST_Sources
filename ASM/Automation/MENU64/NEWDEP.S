		opt c+,d-

;SET TABS TO 10 FOR DISASSEMBLY

	
main	MOVEA.L	4(A7),A5
	MOVEA.L	$10(A5),A1
	LEA	DATA(PC),A2
	MOVE.L	A1,(A2)
	MOVEA.L	8(A5),A1
	LEA	PROG(PC),A2
	MOVE.L	A1,(A2)
	ADDA.L	#$400,A1
	LEA	DEP1(PC),A2
	MOVE.L	A1,(A2)
	MOVE.W	#$2,-(A7)
	TRAP	#14
	ADDQ.L	#2,A7
	LEA	SCRN(PC),A1
	MOVE.L	D0,(A1)
	MOVE.L	D0,A2
	MOVE.W	#$17D,D1
LOOP1	CLR.L	(A2)+
	DBF	D1,LOOP1
	MOVE.W	#4,-(A7)
	TRAP	#14
	ADDQ.L	#2,A7
	CMP.B	#0,D0
	BEQ.S	LOWREZ
	LEA	REZBIT(PC),A1
	MOVE.B	#$39,(A1)
LOWREZ	LEA	TITLE(PC),A1
	MOVE.L	A1,-(A7)
	MOVE.W	#$9,-(A7)
	TRAP	#$01
	ADDQ.L	#6,A7
	CLR.L	-(A7)
	MOVE.W	#$20,-(A7)
	TRAP	#$01
	ADDQ.L	#6,A7
	LEA	SUPERLNG(PC),A6
	MOVE.L	D0,(A6)
	MOVE.W	$FF8240,d7
	
	
	LEA	L_020(PC),A0
	ADDA.L	#$8,A0
	LEA	SIZE(PC),A2
	MOVE.L	(A0),(A2)
	LEA	DEP1(PC),A2
	MOVE.L	(A2),A1
	BSR	depack
	MOVE.W	d7,$FF8240
	MOVE.L	SUPERLNG(PC),-(A7)
	MOVE.W	#$20,-(A7)
	TRAP	#$01
	ADDQ.L	#6,A7
	MOVE.L	PROG(PC),A5
	SUBA.L	#$100,A5
	MOVE.L	DEP1(PC),A3
	MOVEA.L	2(A3),A0
	ADDA.L	6(A3),A0
	ADDA.L	#$1C,A0
	ADDA.L	A3,A0
	MOVE.L	8(A5),D0
	MOVE.L	DEP1(PC),A1
	ADDA.L	#$1C,A1
	TST.L	(A0)
	BEQ	LAB_1
	ADDA.L	(A0)+,A1
LAB_4	ADD.L	D0,(A1)
LAB_3	CLR.L	D1
	MOVE.B	(A0)+,D1
	TST.W	D1
	BEQ.S	LAB_1
	CMP.B	#1,D1
	BNE.S	LAB_2
	ADDA.L	#$FE,A1
	BRA.S	LAB_3
LAB_2	ADDA.L	D1,A1
	BRA.S	LAB_4
LAB_1	MOVE.L	DEP1(PC),A3
	MOVE.L	2(A3),$C(A5)
	MOVE.L	6(A3),$14(A5)
	MOVE.L	$A(A3),$1C(A5)
	MOVE.L	8(A5),D0
	MOVE.L	$C(A5),D1
	ADD.L	D0,D1
	MOVE.L	D1,$10(A5)
	MOVE.L	$14(A5),D0
	ADD.L	D0,D1
	MOVE.L	D1,$18(A5)
	MOVE.L	SCRN(PC),D0
	ADD.L	#$7F00,D0
	MOVEA.L	D0,A2
	MOVEA.L	D0,A5
	MOVE.L	#$30,D2
	LEA	COPYUP(PC),A1
CLOOP1	MOVE.B	(A1)+,(A2)+
	DBF	D2,CLOOP1
	MOVE.L	DEP1(PC),A1
	MOVEA.L	A1,A4
	ADDA.L	#$1C,A1
	MOVE.L	SIZE(PC),D2
	MOVE.L	PROG(PC),A4
	MOVE.L	A4,A3
	JMP	(A5)

COPYUP	MOVE.B	(A1)+,(A3)+
	DBF	D2,COPYUP
	SUB.L	#$10000,D2
	BPL.S	COPYUP
	MOVE.L	A4,A1
	SUB.L	#$100,A1
	CLR.L	D1
	MOVE.L	A1,4(A7)
	JMP	(A4)

PROG	DC.L	0
DEP1	DC.L	0
SIZE	DC.L	0
SCRN	DC.L	0
DATA	DC.L	0
SUPERLNG	DC.L	0
TITLE	DC.B	$1B,$59,$20
REZBIT	DC.B	$25
	DC.B	"    AUTOMATION PACKER V2.0",0

	even	

crunpos	dc.l	0


depack		MOVE.L	A0,crunpos
		MOVE.L	(A0)+,D5
		ADDA.L	D5,A1
		ADDA.L	(A0),A0
		SUBA.L	#4,A0
		TST.W	-(A0)
		BPL.S	L_1
		SUBQ.L	#1,A0
L_1		MOVE.B	-(A0),D0
L_2		LSL.B	#1,D0
		BNE.S	L_3
		MOVE.B	-(A0),D0
		ROXL.B	#1,D0
L_3		BCC.S	L_10
		CLR.W	D1
		LSL.B	#1,D0
		BNE.S	L_4
		MOVE.B	-(A0),D0
		ROXL.B	#1,D0
L_4		BCC.S	L_9
		LEA	NUMS(PC),A3
		MOVEQ	#3,D3
L_5		CLR.W	D1
		MOVE.B	0(A3,D3.W),D2
		EXT.W	D2
		MOVEQ	#-1,D4
		LSL.W	D2,D4
		NOT.W	D4
		SUBQ.W	#1,D2
L_6		LSL.B	#1,D0
		BNE.S	L_7
		MOVE.B	-(A0),D0
		ROXL.B	#1,D0
L_7		ROXL.W	#1,D1
		DBF	D2,L_6
		TST.W	D3
		BEQ.S	L_8
		CMP.W	D1,D4
		DBNE	D3,L_5
L_8		MOVE.B	4(A3,D3.W),D2
		EXT.W	D2
		ADD.W	D2,D1
		BRA	L_9

NUMS		DC.B	$0A,$03,$02,$02,$0E,$07,$04,$01

L_9		MOVE.B	-(A0),-(A1)
		MOVE.W	A0,$FFFF8240
		DBF	D1,L_9
L_10		MOVE.L	crunpos,A3
		ADDQ.L	#$8,A3
		CMPA.L	A3,A0
		BLE	BYENOW
		LEA	NUMS2(PC),A3
		MOVEQ	#3,D2
L_11		LSL.B	#1,D0
		BNE.S	L_12
		MOVE.B	-(A0),D0
		ROXL.B	#1,D0
L_12		BCC.S	L_13
		DBF	D2,L_11
L_13		CLR.W	D1
		ADDQ.W	#1,D2
		MOVE.B	0(A3,D2.W),D3
		BEQ.S	L_16
		EXT.W	D3
		SUBQ.W	#1,D3
L_14		LSL.B	#1,D0
		BNE.S	L_15
		MOVE.B	-(A0),D0
		ROXL.B	#1,D0
L_15		ROXL.W	#1,D1
		DBF	D3,L_14
L_16		MOVE.B	5(A3,D2.W),D3
		EXT.W	D3
		ADD.W	D3,D1
		BRA	L_161

NUMS2		DC.B	$0A,$02,$01,$00,$00,$0A,$06,$04,$03,$02

L_161		CMPI.W	#2,D1
		BEQ.S	L_22
		LEA	NUMS3(PC),A3
		MOVEQ	#1,D3
L_17		LSL.B	#1,D0
		BNE.S	L_18
		MOVE.B	-(A0),D0
		ROXL.B	#1,D0
L_18		BCC.S	L_19
		DBF	D3,L_17
L_19		ADDQ.W	#1,D3
		CLR.W	D2
		MOVE.B	0(A3,D3.W),D4
		EXT.W	D4
L_20		LSL.B	#1,D0
		BNE.S	L_21
		MOVE.B	-(A0),D0
		ROXL.B	#1,D0
L_21		ROXL.W	#1,D2
		DBF	D4,L_20
		LSL.W	#1,D3
		ADD.W	4(A3,D3.W),D2
		BRA.S	L_26

NUMS3		DC.B	$0B,$04,$07,$00,$01,$20,$00,$00
		DC.B	$00,$20,$00,$00

L_22		CLR.W	D2
		MOVEQ	#5,D3
		CLR.W	D4
		LSL.b	#1,D0
		BNE.S	L_23
		MOVE.B	-(A0),D0
		ROXL.B	#1,D0
L_23		BCC.S	L_24
		MOVEQ	#8,D3
		MOVEQ	#$40,D4
L_24		LSL.B	#1,D0
		BNE.S	L_25
		MOVE.B	-(A0),D0
		ROXL.B	#1,D0
L_25		ROXL.W	#1,D2
		DBF	D3,L_24
		ADD.W	D4,D2
L_26		LEA	0(A1,D2.W),A2
		EXT.L	D1
		ADDA.L	D1,A2
		SUBQ.W	#1,D1
L_27		MOVE.B	-(A2),-(A1)
		DBF	D1,L_27
		BRA	L_2
BYENOW		RTS

L_020		INCBIN	"A:\NEWPAC.DAT"