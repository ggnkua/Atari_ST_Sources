	LEA	PAGE_1,A6
NEW_SCN	BSR	SET_SCN
	MOVE.W	4(A6),D5
	LEA	$FFFF8240.W,A5
	BSR.S	DO_COLS
	MOVE.W	2(A6),D5
	LEA	$FFFF8246.W,A5
	BSR.S	DO_COLS
	MOVE.W	2(A6),D5
	LEA	$FFFF825E.W,A5
	BSR.S	DO_COLS
	PEA	$16(A6)
	MOVE.W	#9,-(A7)
	TRAP	#1
	ADDQ.L	#6,A7
	MOVE.W	#2,-(A7)
	MOVE.W	#0,-(A7)
	MOVE.W	#$15,-(A7)
	TRAP	#14
	ADDQ.L	#6,A7
GET_KEY	MOVE.W	#8,-(A7)
	TRAP	#1
	ADDQ.L	#2,A7
	SWAP	D0
	ANDI.L	#$FF,D0
	SUBI.B	#$3B,D0
	BMI.S	GET_KEY
	CMP.B	#4,D0
	BPL.S	GET_KEY
	LSL.W	#2,D0
	MOVE.L	6(A6,D0.W),D6
	BEQ.S	GET_KEY
	MOVEA.L	D6,A6
	BRA.S	NEW_SCN

SET_SCN	MOVE.W	(A6),-(A7)
	MOVE.L	#$FFFFFFFF,-(A7)
	MOVE.L	#$FFFFFFFF,-(A7)
	MOVE.W	#5,-(A7)
	TRAP	#14
	ADDA.L	#$C,A7
	RTS
DO_COLS	CLR.L	-(A7)
	MOVE.W	#$20,-(A7)
	TRAP	#1
	ADDQ.L	#6,A7
	MOVE.L	D0,D4
	MOVE.W	D5,(A5)
	MOVE.L	D4,-(A7)
	MOVE.W	#$20,-(A7)
	TRAP	#1
	ADDQ.L	#6,A7
	RTS

PAGE_1	DC.W	0	;RESOLUTION
	DC.W	$777	;FOREGROUND COLOUR
	DC.W	$000	;BACKGROUND COLOUR
	DC.L	PAGE_2	;F1 PAGE ADDRESS
	DC.L	PAGE_8	;F2 PAGE ADDRESS
	DC.L	PAGE_19	;F3 PAGE ADDRESS
	DC.L	PAGE_21	;F4 PAGE ADDRESS
	DC.B	"     LSD/WAS(NOT WAS) DISK 50 INFO."
	DC.B	$0D,$0A,$0A,$0A
	DC.B	"               MAIN MENU"
	DC.B	$0D,$0A,$0A,$0A
	DC.B	"         F1   GENERAL INFO"
	DC.B	$0D,$0A,$0A
	DC.B	"         F2   A LIST OF OUR DISKS"
	DC.B	$0D,$0A,$0A
	DC.B	"         F3   LOADS OF CHEATS"
	DC.B	$0D,$0A,$0A
	DC.B	"         F4   MEGA GREETINGS"
	DC.B	$0D,$0A,$0A,$0A
	DC.B	"             SELECT OPTION"
	DC.B	$0D,$0A,$0A,$0A
	DC.B	"        BEWARE OF THE A.B.C.MAN",$0D,$0A
	DC.B	"    FOR HE WILL SURELY RIP YOU OFF!",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"PRESS RESET TO EXIT PROG AND REBOOT DISK"
	DC.B	0

PAGE_2	DC.W	0
	DC.W	$777
	DC.W	$700
	DC.L	PAGE_3
	DC.L	0
	DC.L	0
	DC.L	PAGE_1
	DC.B	"   General Info"
	DC.B	$0D,$0A,$0A
	DC.B	"WELL AS YOU MIGHT HAVE GATHERED DISK 50",$0D,$0A
	DC.B	"IS TO BE THE LAST LSD/WAS(NOT WAS) DISK!",$0D,$0A,$A
	dc.b	"WHAT ARE WE GOING TO DO NEXT?",$0D,$0A,$0A
	DC.B	"HINT: WATCH FOR THE NAME 'AUTOMATION'",$0D,$0A
	DC.B	"  ",$0D,$0A
	DC.B	" IT IS ONLY 6 MONTHS SINCE WE BEGAN THE",$0D,$0A
	DC.B	" COMPACTED DISK CRAZE, AND WE HAVE NOW",$0D,$0A
	DC.B	" REACHED No.50, 228 GAMES, UMPTEEN HOURS",$0D,$0A
	DC.B	" OF HARD HACKING AND CRUNCHING. WE THINK",$0D,$0A
	DC.B	" IT HAS ALL BEEN WORTH WHILE,IT HAS ONLY",$0D,$0A
	DC.B	" BEEN SPOILT BY SOME 'SCUM' RIPPING OUR",$0D,$0A
	DC.B	" STUFF OFF, THEY CAN'T HACK, BUT LIKE",$0D,$0A
	DC.B	" THEIR NAME ON EVERYTHING THEY TOUCH, SO",$0D,$0A
	DC.B	" THEY CAN IMPRESS THEIR FRIENDS. WE KNOW",$0D,$0A
	DC.B	" WHO YOU ARE, I WON'T MENTION NAMES, OK, ",$0D,$0A
	DC.B	" I WILL THEN, A.B.C.MAN, HEARD OF HIM?,",$0D,$0A,$0A
	DC.B	"    IF NOT YOU SHOULD FEEL BLESSED.",$0D,$0A,$0A
	DC.B	"F1 - FORWARD, F4 - MAIN MENU",0

PAGE_3	DC.W	0
	DC.W	$000
	DC.W	$777
	DC.L	PAGE_4
	DC.L	PAGE_2
	DC.L	0
	DC.L	PAGE_1
	DC.B	"   General Info  cont."
	DC.B	$0D,$0A,$0A
	DC.B	"ABC MAN  WILL PUT HIS NAME ON ANYTHING.",$0D,$0A
	DC.B	"HE EVEN CLAIMED TO HAVE CRACKED A GAME",$0D,$0A
	dc.b	"WITHOUT PROTECTION 'RETURN OF THE JEDI'!",$0D,$0A,$A
	DC.B	"IT IS GOOD TO SEE OTHER PEOPLE STARTING",$0D,$0A
	DC.B	"TO TAKE UP OUR CHALLENGE, WE WISH YOU ",$0D,$0A
	DC.B	"ALL LUCK, YOU MAY WELL NEED IT. SOME OF",$0D,$0A
	DC.B	"THE WORK WE HAVE SEEN THAT LOOKS PRETTY",$0D,$0A
	DC.B	"GOOD, HAS COME FROM THE FOLLOWING PEOPLE",$0D,$0A
	DC.B	"THE UN-NAMABLES AND THE MEDWAY BOYS, ",$0D,$0A
	DC.B	"YOUR MAIN PROBLEM GUYS IS THAT YOU ARE ",$0D,$0A
	DC.B	"LETTING DUMB FORMATS APPEAR, YOUR DISKS",$0D,$0A
	DC.B	"WILL NEVER SPREAD IF YOU DO THINGS LIKE",$0D,$0A
	DC.B	"THAT(LOADS OF ERRORS), SO TRY TO KEEP",$0D,$0A
	DC.B	"TO NORMAL FORMATS OR DON'T BOTHER, OK?",$0D,$0A
	DC.B	$0A,$0A,$0A,$0A,$0A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_4	DC.W	0
	DC.W	$777
	DC.W	$005
	DC.L	PAGE_5
	DC.L	PAGE_3
	DC.L	0
	DC.L	PAGE_1
	DC.B	"   General Info  cont.",$0D,$0A,$0A
	DC.B	"WE HAVE BEEN GETTING A LARGE AMOUNT OF",$0d,$0a
	DC.B	"FEEDBACK ON THE DISKS, GENERALLY IT IS",$0d,$0a
	DC.B	"GOOD, BUT ALAS WE HAVE BEEN HEARING SOME",$0d,$0a
	DC.B	"REAL HORROR STORIES!   E.G. ONE GUY TOLD",$0d,$0a
	DC.B	"US THAT HE HAD RECEIVED A DISK WITH ONLY",$0d,$0a
	DC.B	"2 GAMES ON IT. THE REASON? WELL IT SEEMS",$0d,$0a
	DC.B	"AS THE DISK HAD SPREAD, IT HAD COLLECTED",$0d,$0a
	DC.B	"ERRORS AND SOME SMART BOD HAD MERELY",$0d,$0a
	DC.B	"DELETED THE CORRUPT FILES AND TAKEN THEM",$0d,$0a
	DC.B	"OFF THE MENU. WHAT A BRIGHT GUY!",$0d,$0a,$0a,$0a,$0a
	DC.B	"IF YOU DO GET ERRORS - GET ANOTHER COPY,",$0d,$0a
	dc.b	"UNLESS THAT IS TOO COMPLICATED FOR YOU!",$D,$A,$A,$A,$A,$A,$A,$A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_5	DC.W	0
	DC.W	$777
	DC.W	$303
	DC.L	PAGE_6
	DC.L	PAGE_4
	DC.L	0
	DC.L	PAGE_1
	DC.B	"   General Info  cont.",$0D,$0A,$0A
	DC.B	" ONE IMPORTANT BIT OF NEWS REGARDS A NEW",$0d,$0a
	DC.B	" RECRUIT TO OUR COMPACTION CIRCLE,",$0d,$0a
	DC.B	" HIS NAME IS SHARAZ JEK, AND HE IS BASED",$0d,$0a
	DC.B	" IN AUSTRALIA, WATCH OUT FOR HIS WORK.",$0d,$0a
	DC.B	"",$0d,$0a,$0a,$A,$A,$A,$A,$A
	DC.B	"  REMEMBER :-",$0d,$0a,$0a,$A
	DC.B	"WE ARE ALWAYS ON THE LOOKOUT FOR NEW",$0d,$0a
	DC.B	"RECRUITS, SO IF YOU FIT THE BILL, GET IN",$0d,$0a
	DC.B	"TOUCH, NEW CONTACT ADDRESS SOON!",$0d,$0a
	DC.B	"YES INDEED FOLKS THERE WILL BE A NEW",$D,$A
	DC.B	"CONTACT ADDRESS, WATCH FUTURE PRODUCTS",$D,$A
	DC.B	"FROM AUTOMATION.",$D,$A,$A,$A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_6	DC.W	0
	DC.W	$777
	DC.W	$500
	DC.L	PAGE_7
	DC.L	PAGE_5
	DC.L	0
	DC.L	PAGE_1
	DC.B	"   General Info  cont.",$0d,$0a,$0a
	DC.B	"",$0d,$0a,$0a
	DC.B	" YOU MAY HAVE NOTICED THAT WE HAVE BEEN ",$0d,$0a
	DC.B	" DOING A LOT OF 1 MEG FILES RECENTLY,   ",$0D,$0a
	DC.B	" WELL WE WILL BE DOING A LOT MORE IN    ",$0d,$0a
	DC.B	" THE FUTURE, THE REASONS ?      ",$0D,$0a
	DC.B	" 1. Games can be taken off boot disks,  ",$0d,$0a
	DC.B	"    thus freeing valuable disks!        ",$0D,$0A,$0A
	DC.B	" 2. Games play faster, play R-TYPE on 1 ",$0d,$0a
	DC.B	"    Meg and see what I mean             ",$0d,$0a,$0a
	DC.B	" 3. Demand! People keep asking us to do ",$0d,$0a
	DC.B	"    them.                               ",$0d,$0a,$0a
	DC.B	" SO IF YOU DO NOT HAVE 1 MEG OF MEMORY, ",$0d,$0a
	DC.B	" I WOULD STRONGLY ADVISE YOU TO UPGRADE ",$0D,$0a
	DC.B	" OR YOU WILL HAVE TO LEARN TO HACK!     ",$D,$0a,$0a,$0a
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_7	DC.W	0
	DC.W	$777
	DC.W	$005
	DC.L	0
	DC.L	PAGE_6
	DC.L	0
	DC.L	PAGE_1
	DC.B	"   General Info  cont.",$0d,$0a,$0a
	DC.B	"WE HAVE RECEIVED SEVERAL OTHER PEOPLES  ",$0D,$0a
	DC.B	"COMPACTIONS. IT APPEARS THAT PEOPLE HAVE",$0d,$0a
	DC.B	"LEARNED FROM OUR 'WOT NO TITLE PICTURES'",$D,$0a
	DC.B	"JIBES TO A CERTAIN OTHER WELL KNOWN GUY.",$0d,$0a
	DC.B	"UNFORTUNATELY, THEY MESSED UP BY PUTTING",$D,$0a
	DC.B	"A STUPID FORMAT ON THEIR DISKS, COME ON ",$0d,$0a
	DC.B	"GUYS, STOP USING STUPID FORMATS, IT MAY ",$D,$0a
	DC.B	"LOOK CLEVER(LOTS ON A DISK), BUT IT WILL",$0d,$0a
	DC.B	"MEAN ERRORS!!!!!",$D,$A,$A
	DC.B	"ANYWAY, THAT WILL DO FOR NOW, SO I WILL",$0d,$0a
	DC.B	"BID YOU FAREWELL AND REMEMBER THESE NEW",$0d,$0a
	DC.B	"AND IMPORTANT WORDS :-",$D,$0a
	DC.B	"       - BEWARE OF A.B.C.MAN - ",$0d,$0a,$0a
	DC.B	"YOU HAVE BEEN WARNED, IGNORE IT AT YOUR",$0d,$0a
	DC.B	"OWN PERIL, OK!",$D,$0a,$0a
	DC.B	"BYE - OZZWALD - L.S.D. - 'AUTOMATION 89'",$0d,$0a,$0a,$0a,$0a
	DC.B	"F2 - BACK, F4 - MAIN MENU",0

PAGE_8	DC.W	1
	DC.W	$123
	DC.W	$777
	DC.L	PAGE_9
	DC.L	0
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  COMPACTED SOFTWARE LIST:  PAGE 1",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"DISK 1   -   ROBOTRON, SENTINEL, STAR RAIDERS, CRYSTAL CASTLES, NORTH STAR, ",$0d,$0a
	DC.B	"             EMPIRE STRIKES BACK, TRAILBLAZER 2.",$D,$A,$A,$A
	DC.B	"DISK 2   -   VIRUS, KNIGHTMARE, EXTENSOR, PLUTOS, INTO THE EAGLES NEST, ",$0d,$0a
	DC.B	"             JOE BLADE, TRANTOR, TRIFIDE 2.",$D,$A,$A,$A
	DC.B	"DISK 3   -   MERCENARY, SECOND CITY, REVENGE OF DOH, DELTA PATROL, ",$0d,$0a
	DC.B	"             FOOTBALL MANAGER, SUPER HUEY, ARCADE CLASSICS, ROLLING THUNDER.",$D,$A,$A,$A
	DC.B	"DISK 4   -   MISSION GENOCIDE, XEVIOUS, SCRABBLE DELUXE, MOON PATROL, ",$0d,$0a
	DC.B	"             AIRBALL, STARQUAKE, EDEN BLUES, MISSILE COMMAND(V1.0).",$D,$A,$A,$a
	DC.B	"DISK 5   -   TYPHOON THOMPSON, STREET GANG (MEG FILE), DEATH STRIKE. ",$0d,$0a,$0a
	DC.B	$0A,$0A
	DC.B	"F1 - FORWARD, F4 - MAIN MENU",0

PAGE_9	DC.W	1
	DC.W	$600
	DC.W	$566
	DC.L	PAGE_10
	DC.L	PAGE_8
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  COMPACTED SOFTWARE LIST:  page 2",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"DISK 6   -   BETTER DEAD THAN ALIEN, ARMY MOVES, ROCKFORD, PINBALL FACTORY, ",$0d,$0a
	DC.B	"             JOUST, THUNDERCATS, MISSILE COMMAND(V2.0).",$D,$A,$0a
	DC.B	"DISK 7   -   ASTEROIDS DELUXE, BATTLESHIPS, KARATE KID 2 (1 MEG), DIABLO, ",$0d,$0a
	DC.B	"             VAMPIRE EMPIRE, OVERLANDER.",$D,$A,$0a,$A
	DC.B	"DISK 8   -   BACKLASH, SUPER BREAKOUT, NINJA MISSION, MUTANT CAMELS, Q-BALL, ",$0d,$0a
	DC.B	"             GOLDRUNNER, MAJOR MOTION, SPOOK.",$D,$A,$0a,$A
	DC.B	"DISK 9   -   ENDURO RACER, CHUBBY GRISTLE, NEBULUS, ELIMINATOR.",$0d,$0a,$0a,$A,$a
	DC.B	"DISK 10  -   LEADERBOARD, TOURNAMENT DISK, VETERAN, BLACK LAMP, PENGY, ",$0d,$0a
	DC.B	"             WHIRLIGIG",$D,$A,$A
	DC.B	$0A,$0A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0


PAGE_10	DC.W	1
	DC.W	$000
	DC.W	$700
	DC.L	PAGE_11
	DC.L	PAGE_9
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  COMPACTED SOFTWARE LIST:  PAGE 3",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"DISK 11  -   CRICKET (MEG ONLY), SOCCER SUPREMO, MUDPIES, SUPER TENNIS, ",$0d,$0a
	DC.B	"             HOTSHOT, LANDS OF HAVOC, QUADRALIEN, THRUST.",$D,$A,$A,$0a
	DC.B	"DISK 12  -   BEYOND THE ICE PALACE, SHACKLED, TIME BANDIT, DEFLEKTOR, ",$0d,$0a
	DC.B	"             SPACE KILLER, SKYCHASE",$D,$A,$A,$0a
	DC.B	"DISK 13  -   SUPER HANG-ON(1 MEG), SUPER SPRINT, ST KARATE, ST POOL",$0d,$0a,$0a,$A,$A
	DC.B	"DISK 14  -   STAR GOOSE, ELITE, HELTER SKELTER, VIXEN.",$0D,$0A,$0A,$A,$A
	DC.B	"DISK 15  -   STAR RAY (1 MEG), RETURN TO GENESIS (1 MEG).",$0d,$0a,$0a
	DC.B	$0A,$0A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_11	DC.W	1
	DC.W	$777
	DC.W	$111
	DC.L	PAGE_12
	DC.L	PAGE_10
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  COMPACTED SOFTWARE LIST:  PAGE 4",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"DISK 16  -   FEDERATION OF FREE TRADERS, BOMBJACK, FOOTBALL MANAGER 2, ",$0d,$0a
	DC.B	"             SCREAMING WINGS, MOUSE TRAP.",$D,$A,$A,$0a
	DC.B	"DISK 17  -   MAGNETIC TANK, INDIANA JONES, TETRIS, SPY VS SPY, ",$0d,$0a
	DC.B	"             CYBERNOID, TETRA QUEST (1 MEG).",$D,$A,$A,$0a
	DC.B	"DISK 18  -   PHANTASM, ECO, WIZBALL, BUGGY BOY, FLOYD THE DROID.",$0d,$0a,$0a,$A,$A
	DC.B	"DISK 19  -   WHERE TIME STOOD STILL, BATTLE PROBE , SORCERY +, XOR.",$0D,$0A,$0A,$A,$A
	DC.B	"DISK 20  -   ARTURA, GARFIELD, MOONBASE, 3D GALAX.",$0d,$0a,$0a
	DC.B	$0A,$0A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_12	DC.W	1
	DC.W	$700
	DC.W	$077
	DC.L	PAGE_13
	DC.L	PAGE_11
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  COMPACTED SOFTWARE LIST:  PAGE 5",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"DISK 21  -   NIGEL MANSELL, FERNANDEZ MUST DIE, URIDIUM, ALTAIR, ",$0d,$0a
	DC.B	"             BATTLEZONE, ENFORCER.",$D,$A,$A,$0a
	DC.B	"DISK 22  -   1943, CAPTAIN AMERICA, RAMPAGE, SLAPFIGHT, LEATHERNECKS.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 23  -   TURBO CUP, FLYING SHARK, SNAFUX.",$0d,$0a,$0a,$A,$A
	DC.B	"DISK 24  -   RETURN OF THE JEDI, OFFSHORE WARRIOR, BANK BUSTERS, 2 GAME.",$0D,$0A,$0A,$A,$A
	DC.B	"DISK 25  -   PAC-MANIA, METROCROSS, SOLOMONS KEY, HELLFIRE, MAD MIX, ",$0d,$0a
	DC.B	"             INTERNATIONAL KARATE +, HARRIER STRIKE MISSION.",$d,$0a
	DC.B	$0A,$0A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_13	DC.W	1
	DC.W	$700
	DC.W	$000
	DC.L	PAGE_14
	DC.L	PAGE_12
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  COMPACTED SOFTWARE LIST:  PAGE 6",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"DISK 26  -   MILLIPEDE, DRILLER, MACH 3, TRUCK.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 27  -   LIVE + LET DIE, FOUNDATIONS WASTE, ST PROTECTOR, PANDORA.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 28  -   FIREBLASTER, STORMBRINGER, NETHERWORLD, FROSTBYTE, XENON.",$0d,$0a,$0a,$A,$A
	DC.B	"DISK 29  -   ALIEN SYNDROME, SPACE STATION, BARBARIAN, FUZZBALL.",$0D,$0A,$0A,$A,$A
	DC.B	"DISK 30  -   HAUNTED HOUSE, CRACKED, SPEEDBALL, TIMEBLAST, EXOLON, ATAX.",$0d,$0a,$A
	DC.B	$0A,$0A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_14	DC.W	1
	DC.W	$070
	DC.W	$207
	DC.L	PAGE_15
	DC.L	PAGE_13
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  COMPACTED SOFTWARE LIST:  PAGE 7",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"DISK 31  -   DALEY THOMPSONS OLYMPIC CHALLENGE (MEG FILE), GROWTH.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 32  -   STAR BATTLE, SDI(Cinemaware), BIONIC COMMANDO.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 33  -   PREDATOR, BOUNCEOUT, CHUCKIE EGG, SOLDIER OF LIGHT.",$0d,$0a,$0a,$A,$A
	DC.B	"DISK 34  -   BUBBLE BOBBLE, HYPERDOME, HELLBENT, G.L.SOCCER, MONEY.",$0D,$0A,$0A,$A,$A
	DC.B	"DISK 35  -   FALCON, BOMBUZAL.",$0d,$0a,$A
	DC.B	$0A,$0A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_15	DC.W	1
	DC.W	$700
	DC.W	$270
	DC.L	PAGE_16
	DC.L	PAGE_14
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  COMPACTED SOFTWARE LIST:  PAGE 8",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"DISK 36  -   JOE BLADE 2, POOL, FLIPSIDE, WANTED.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 37  -   OPERATION WOLF, TOP GUN.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 38  -   MISSION ELEVATOR, IKARI WARRIORS, FLINTSTONES, MUNSTERS, ",$0d,$0a
	DC.B	"             CHECKERS.",$D,$0a,$A,$A
	DC.B	"DISK 39  -   TERRAMEX, METROPOLIS, SUPER SKI, POKER ROYALE.",$0D,$0A,$0A,$A,$A
	DC.B	"DISK 40  -   IRON TRACKERS, VICTORY ROAD, MEGAROIDS.",$0d,$0a,$A
	DC.B	$0A,$0A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_16	DC.W	1
	DC.W	$700
	DC.W	$001
	DC.L	PAGE_17
	DC.L	PAGE_15
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  COMPACTED SOFTWARE LIST:  PAGE 9",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"DISK 41  -   STREET FIGHTER, SPACE RACER, RIPCORD.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 42  -   GALACTIC CONQUEROR, TRAUMA, CHOPPER X, MONKEY BUSINESS.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 43  -   THUNDERBLADE (1 MEG), SPIDERTRONIC, BOULDERDASH.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 44  -   SDI (Activision) (1 MEG), DESOLATOR (1 MEG).",$0D,$0A,$0A,$A,$A
	DC.B	"DISK 45  -   VECTORBALL, DOUBLE DRAGON (MEG FILE).",$0d,$0a,$A
	DC.B	$0A,$0A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_17	DC.W	1
	DC.W	$700
	DC.W	$100
	DC.L	PAGE_18
	DC.L	PAGE_16
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  COMPACTED SOFTWARE LIST:  PAGE 10",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"DISK 46  -   R-TYPE (1 MEG), MENACE (1 MEG).",$0d,$0a,$A,$A,$A
	DC.B	"DISK 47  -   RAMBO 3, TRANSPUTOR, FREE CLIMBING, YAHTZEE, ZXYM.",$0d,$0a,$A,$A,$A
	DC.B	"DISK 48  -   CAPTAIN FIZZ, TRACKSUIT MANAGER, RUGBY SIMULATOR, ",$0d,$0a
	DC.B	"             ELF, PYRAMINO.",$D,$A,$A,$A
	DC.B	"DISK 49  -   CRAZY CARS 2 (1 MEG), BAAL (1 MEG).",$0D,$0A,$0A,$A,$A
	DC.B	"DISK 50  -   BATMAN A + B, BREAKANOID, ADDICTABALL, WARHAWK, BRIKYARD.",$0d,$0a,$A
	DC.B	$0A,$0A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_18	DC.W	0
	DC.W	$000
	DC.W	$777
	DC.L	PAGE_18A
	DC.L	PAGE_17
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  COMPACTED SOFTWARE LIST:  SUMMARY",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"WELL THAT CONCLUDES THE LIST FOR NOW!  ",$0d,$0a,$A
	DC.B	"HERE IS A LIST OF WHAT MAY OR MAY NOT  ",$D,$A
	DC.B	"APPEAR IN THE FUTURE :-",$D,$A,$A,$A
	DC.B	"PETER BEARDSLEYS FOOTBALL, IMPACT, ",$0d,$0a
	DC.B	"PROHIBITION, TAU CETI, HUSTLER, CARDS,",$D,$A
	DC.B	"DAME, SPACE BALLER, HADES NEBULA, ",$0d,$0a
	DC.B	"LIVINGSTONE, STARGLIDER, ZANY GOLF,",$D,$A
	DC.B	"KARATEKA, BERMUDA PROJECT, TRAP",$D,$A
	DC.B	"POTHOLE PETE, QUESTION OF SPORT, ",$D,$A
	DC.B	"SKYRIDER, ARTIFICIAL DREAMS, ",$0D,$0A
	DC.B	"GOLDEN PATH, DREAM ZONE, ",$D,$A
	DC.B	"I LUDICRUS, DUGGER, KENNEDY APPROACH.",$D,$0A
	DC.B	"ALL THE ABOVE ARE READY AND WAITING!",$0d,$0a,$A
	DC.B	$0A,$0A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_18A	DC.W	0
	DC.W	$000
	DC.W	$427
	DC.L	0
	DC.L	PAGE_18
	DC.L	0
	DC.L	PAGE_1
	DC.B	"FOR THOSE OF YOU WITH NON-BRITISH      ",$0D,$0A
	DC.B	"MACHINES WHO ARE CONFRONTED BY THE     ",$0d,$0a
	DC.B	"MESSAGE 'CAN'T RUN THIS TOS VERSION'   ",$D,$A
	DC.B	"OR WORDS TO THAT EFFECT WHEN ATTEMPTING",$D,$A
	DC.B	"TO LOAD THE ODD GAME ON SOME OF OUR    ",$0d,$0a
	DC.B	"EARLY MENUS - FOLLOW THESE INSTRUCTIONS",$D,$A
	DC.B	"1. DELETE GEM1FILE/STARTGEM.PRG AND    ",$0d,$0a
	DC.B	"   STARTGEM.LSD FROM THE DISK.         ",$D,$A
	DC.B	"2. RENAME THE ?.LSD/WAS FILE WHICH THE ",$D,$A
	DC.B	"   ABOVE PROGRAMS WERE TRYING TO LOAD  ",$D,$A
	DC.B	"   TO A ?.TOS FILE.",$0D,$0A
	DC.B	"3. CREATE A DESKTOP.INF FILE TO DISPLAY",$D,$A
	DC.B	"   THIS PARTICULAR ?.TOS FILE AND      ",$D,$0A
	DC.B	"   VOILA! IT CAN NOW BE RUN FROM THE   ",$0d,$0a
	DC.B	"   DESKTOP ON EXITING THE MENU.  WOW!  ",$0d,$0A,$A
	DC.B	"F2 - BACK, F4 - MAIN MENU",0

PAGE_19	DC.W	0
	DC.W	$000
	DC.W	$777
	DC.L	PAGE_20
	DC.L	0
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  CHEAT LIST ",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"IN SOME OF THE GAMES THAT WE HAVE PUT  ",$0d,$0a
	DC.B	"ON THE EARLIER MENU'S, WE HAVE BUILT IN",$D,$A
	DC.B	"ADDITIONAL CHEATS TO ANY ALREADY THERE.",$D,$A,$A,$A,$A
	DC.B	"ON THE NEXT FEW PAGES YOU WILL FIND A",$0d,$0a
	DC.B	"LIST OF MOST OF THEM, THOUGH NOT ALL OF",$D,$A
	DC.B	"THEM, AS THAT WOULD BE TOO EASY, FOR",$0d,$0a
	DC.B	"YOU ALL, SO IF YOU EXPERIMENT YOU MAY",$D,$A
	DC.B	"FIND SOME MORE",$D,$A
	DC.B	"",$D,$A
	DC.B	"",$0D,$0A
	DC.B	"",$D,$0A,$A,$A
	DC.B	"",$0d,$0a,$A
	DC.B	$0A,$0A
	DC.B	"F1 - FORWARD, F4 - MAIN MENU",0

PAGE_20	DC.W	0
	DC.W	$777
	DC.W	$000
	DC.L	PAGE_20A
	DC.L	PAGE_19
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  CHEAT LIST  cont.",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"IN THE FOLLOWING GAMES HIT F1 OR HELP",$0d,$0a
	DC.B	"WHEN THE GAME SAYS PRESS A KEY, IT WILL",$D,$A
	DC.B	"BE ONE OR THE OTHER, OK!",$D,$A,$A
	DC.B	"ROCKFORD",$D,$A
	DC.B	"JOE BLADE",$D,$A
	DC.B	"REVENGE OF DOH",$0d,$0a
	DC.B	"ARMY MOVES",$D,$A
	DC.B	"CHUBBY GRISTLE",$0d,$0a
	DC.B	"NORTH STAR(later versions of disk 1)",$D,$A
	DC.B	"BEYOND THE ICE PALACE",$D,$A
	DC.B	"SLAPFIGHT",$D,$A
	DC.B	"SOLOMONS KEY",$0D,$0A
	DC.B	"HELLFIRE",$D,$0A
	DC.B	"FIREBLASTER",$D,$A
	DC.B	"HYPERDOME",$D,$A
	DC.B	"DEATHSTRIKE",$0d,$0a
	DC.B	"TERRAMEX",$D,$A
	DC.B	"METROPOLIS",$D,$0A,$0A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_20A	DC.W	0
	DC.W	$777
	DC.W	$000
	DC.L	0
	DC.L	PAGE_20
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  CHEAT LIST  cont.",$0D,$0A
	DC.B	$0A,$0A
	DC.B	"STREETFIGHTER (PRESS C)",$D,$A
	DC.B	"R-TYPE (PRESS F4,F5,F6,F7,F8,F9)",$D,$A
	DC.B	"MENACE (TYPE XR3ITURBONUTTERBASTARD)",$D,$A
	DC.B	"SUPER HANG ON (TYPE 207L ON SCORE SHEET,",$D,$A
	DC.B	"  WAIT, THEN PRESS CTRL,ALT,Z AND T, ",$D,$A
	DC.B	"  WAIT, NOW LET GO OF T.",$D,$A
	DC.B	"NEBULUS (TYPE HELLIOAMJMP)",$D,$A
	DC.B	"SORCERY+ (GAS MASK WHEELER WANTS CHEAT)",$D,$A
	DC.B	"D.T.O.C (TYPE HINGSEN-J) - = KEY-PAD",$D,$A
	DC.B	"    THEN USE FUNCTION KEYS.",$D,$A
	DC.B	"CYBERNOID (TYPE RAISTLIN)",$D,$A
	DC.B	"FERNANDEZ MUST DIE (TYPE SPINYNORMAN)",$D,$A
	DC.B	"SKYRIDER (SCORE 50000+ POINTS THEN",$D,$A
	DC.B	"   TYPE SHEFFIELD",$D,$A,$A
	DC.B	"F2 - BACK, F4 - MAIN MENU",0

PAGE_21	DC.W	0
	DC.W	$777
	DC.W	$700
	DC.L	PAGE_22
	DC.L	0
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  GREETINGS LIST",$0D,$0A
	DC.B	$0A
	DC.B	"WE AT AUTOMATION, MUST BID A BIG AND",$0d,$0a
	DC.B	"INDEED HEARTY HELLO TO THE FOLLOWING",$D,$A
	DC.B	"FRIENDS AND CONTACTS :-",$D,$A,$A
	DC.B	"PIRASOFT/ACU, SERVO, A-HA, KAM, CLIMAX,",$D,$A
	DC.B	"THE ELITE SQUAD,SPECIAL FX,UN-NAMABLES,",$D,$A
	DC.B	"THUNDER THIGHS, THE UNION(NICE DEMO), ",$0d,$0a
	DC.B	"TEX(CUTE GAME), NEIL OF COR BLIMEY, ",$D,$A
	DC.B	"THE ANGELS OF MERCY (LSD SAY VISIT US!),",$0d,$0a
	DC.B	"SUB HUMANS IN TURKEY, MEDWAY BOYS.",$D,$A,$A
	DC.B	"A MESSAGE TO ALL ST OWNERS AT BRADFORD",$D,$A
	DC.B	"MICRO CLUB  -  YOU GUYS ARE DUMB ENOUGH",$0D,$0A
	DC.B	"TO BELIEVE ALL THAT ABC MAN AND HIS PAL",$D,$0A
	DC.B	"NEILBULUS SAY, THESE TWO ARE LYING SCUM,",$D,$A
	DC.B	"SO GET OFF YOUR BEHINDS AND TELL THEM",$D,$A
	DC.B	"WHERE TO GO!",$0d,$0a
	DC.B	"",$D,$A
	DC.B	"MICK IN BASILDON WANTS HIS DISKS BACK,",$D,$0A
	DC.B	"DID YOU READ THAT ABC MAN(UNCLE PERVO)",$D,$0A
	DC.B	"F1 - FORWARD, F4 - MAIN MENU",0

PAGE_22	DC.W	0
	DC.W	$000
	DC.W	$700
	DC.L	PAGE_22A
	DC.L	PAGE_21
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  GREETINGS LIST  cont.",$0D,$0A
	DC.B	$0A
	DC.B	"SO REMEMBER GUYS, COLLECT OUR DISKS",$0d,$0a
	DC.B	"AND YOU WILL HAVE THE BEST COMPACTED",$D,$A
	DC.B	"COLLECTION AVAILABLE ON THE ST!",$D,$A,$A
	DC.B	"I MEAN, HOW CAN YOU GO WRONG WITH THE",$D,$A
	DC.B	"COMBINED MIGHT OF WAS(NOT WAS), L.S.D,",$D,$A
	DC.B	"IAN.C, SHARAZ JEK AND BOB.M ALL WORKING",$0d,$0a
	DC.B	"TOGETHER, WE ARE UNSTOPPABLE, JUST ",$D,$A
	DC.B	"REMEMBER TO TELL ALL THE BULLSHITTERS",$0d,$0a
	DC.B	"WHERE TO GO, ALL THEY WILL GIVE YOU IS",$D,$A
	DC.B	"EARACHE(TELLING YOU HOW GOOD THEY ARE).",$D,$A
	DC.B	"",$0D,$0A,$a
	DC.B	"BEFORE I GO, I MUST SAY HI TO ALL AT THE",$D,$0A
	DC.B	"SWINTON CLUB, HOW'S IT HANGING GUYS!!",$D,$A
	DC.B	"",$D,$A
	DC.B	"",$0d,$0a
	DC.B	"",$D,$A
	DC.B	"",$D,$0A
	DC.B	"",$D,$0A
	DC.B	"F1 - FORWARD, F2 - BACK, F4 - MAIN MENU",0

PAGE_22A	DC.W	0
	DC.W	$000
	DC.W	$700
	DC.L	0
	DC.L	PAGE_22
	DC.L	0
	DC.L	PAGE_1
	DC.B	"  GREETINGS LIST  cont.",$0D,$0A
	DC.B	$0A
	DC.B	"IF YOU KNOW ANYTHING ABOUT ANY LAMERS",$D,$A
	DC.B	"WHO TAMPER WITH OUR MENUS, LET US KNOW",$D,$A
	DC.B	"ABOUT THEM SO WE CAN EXPOSE THEM ON",$D,$A
	DC.B	"FUTURE INFO FILES, AND WE DON'T MEAN IT",$D,$A
	DC.B	"AS A CHEAP THRILL FOR THE LADIES.",$D,$A,$A
	DC.B	"HEY PERVO! STAY AWAY FROM SWINTON COS I",$D,$A
	DC.B	"JUST FEEL LIKE BUSSING UP YA FACE AFTER",$D,$A
	DC.B	"15 PINTS!",$D,$A,$A
	DC.B	"TO THE HARROGATE LAMERS . . . WHAT'S",$D,$A
	DC.B	"THIS CRAP I HEAR THROUGH THE GRAPEVINE?",$D,$A,$A
	DC.B	"GET IN TOUCH GOLIATH . . . I LOST YOUR",$D,$A
	DC.B	"ADDRESS.",$D,$A,$A
	DC.B	"NEXT ISSUE WE SHALL EXPOSE SOME SOFTWARE",$D,$A
	DC.B	"HOUSES THAT RIP-OFF ARTISTS/PROGRAMMERS",$D,$A
	DC.B	"AND PAY MAGS TO WRITE GREAT REVIEWS OF",$D,$A
	DC.B	"THEIR OWN CRAP GAMES.",$D,$A,$A,$A
	DC.B	"F2 - BACK, F4 - MAIN MENU",0
