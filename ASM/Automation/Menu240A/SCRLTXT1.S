scrolltext
	dc.b	'THE BBC PROUDLY PRESENTS AUTOMATION DISK 240. THIS DISK '
	dc.b	'HAS BEEN RELEASED IN TWO PARTS FOR TWO REASONS. FIRSTLY'
	dc.b	', WE HAD THE WHOLE GAME PACKED ONTO ONE DISK BUT WHEN WE GOT TO LEVEL 3 WE'
	dc.b	' FOUND IT CRASHED, THIS WAS BECAUSE OF A DUFF TRACK '
	dc.b	'ON THE ORIGINAL DISK. WE RERIPPED THE FILE FROM ANOTHER DISK BUT AS THIS WAS'
	dc.b	' FULL OF DATA INSTEAD OF SPACE IT DIDN''T PACK ANYWHERE NEAR AS WELL.'
	dc.b	' THIS IS BLOODY ANNOYING BUT WE DECIDED IT DIDN''T MATTER TOO MUCH AS WE HAD'
	dc.b	' A NUMBER OF OTHER TITLES READY FOR RELEASE, SO WE HAVE PUT THEM ALL ON.'
	dc.b	' THANX GOTO THE MEDWAY BOYS FOR THE CHEATS. THUNDERBOLT DOCUMENT'
	dc.b	' IS USED WITH KIND PERMISSION OF DES OF THE POMPEY PIRATES. IF THIS SCROLLER'
	dc.b	' ENDS UP ON THE MENU I (THE PILOT...) DESIGNED THEN IT HOULD BE READABLE AND NOT'
	dc.b	' AT ALL STRENUOUS ON THE EYES, BUT THEN ANDY THE ARFLING IS SURE TO DO SOMETHING ABOUT THAT,'
	dc.b	' LIKE ''OH I HAD LOADS OF TIME LEFT SO I JUST ADDED A COUPLE OF BITS'
	dc.b	', NOT TOO IMPOSSIBLE TO READ IS IT ? ''   CREDITS ON THESE DISKS GO TO'
	dc.b	' ANDY THE ARFLING : MENU CODING, THUNDERBOLT CRACK + OTHER WORK, BRICKBUSTA PACK '
	dc.b	'AND WORK ON ROTOR. THE PILOT... : BLACK TIGER CRACK AND PACK, WORK ON THUNDERBOLT,'
	dc.b	' CRACK AND OTHER WORK ON ROTOR AND MENU DESIGN. CHRISPY NOODLE : MENU MUSAX.'
	dc.b	' PLEASE NOTE THAT ONLY THUNDERBOLT REQUIRES YOU TO SWAP DISKS. WE WERE'
	dc.b	' GOING TO PUT THRUST ON THIS DISK BUT DIDN''T WANT THE SAME GAME TWICE.'
	dc.b	' NOW, REGARDING SLAGGING BETWEEN AUTOMATION AND OTHER GROUPS. UNLESS ITS REALLY JUSTIFIED'
	dc.b	' THEN STOP THE CHILDISH BICKERING GUYS. THIS MESSAGE WAS AIMED AT MEMBERS OF AUTOMATION AS'
	dc.b	' WELL, JUST IN CASE YOU THOUGHT I WAS ON A HOLIER THAN THOU JAUNT. RIGHT THEN, ONLY'
	dc.b	' ONE MAJOR SLAGGING FROM US, 100 PERCENT JUSTIFIED AS WELL - DIRTY FUCKING DEAD CATS'
	dc.b	' TO THE SHAOLIN MASTERS, YOU ARE A BUNCH OF LAMERS, YOU RIP OFF OTHER PEOPLES CRACKS'
	dc.b	' AND CHANGE TEXT TO SAY YOU CRACKED IT. PROOF ? DISK 10 HAS WICKED ON IT, SUPPOSEDLY'
	dc.b	' CRACKED BY SOME LAMER CALLED GANDELF, THIS IS ANDY THE ARFLINGS CRACK FROM BBC 10'
	dc.b	' YOU HAVEN''T EVEN EDITED THE TEXT VERY WELL YOU SHITHEADS. IF YOU SHOW YOUR FACE AT'
	dc.b	' A SHOW YOU ARE DEAD FUCKING MEAT.'
	dc.b '       -    OK,THIS IS ANDY HERE NOW,INTERRUPTING THE PILOT''S RANTINGS WITH A FEW THOUGHTS OF MY OWN.'
	dc.b	'I WOULD JUST LIKE TO SAY A QUICK ''CUNTS'' TO THE SHAOLIN LAMERS,HOW THE FUCK CAN THEY SLAG AUTOMATION '
	dc.b	'AND THEN USE OUR FILES? OK,NEXT SLAG COMING UP,THIS IS DIRECTED TO A GUY WHO''S REALLY PISSING ME OFF AT '
	dc.b	'THE MOMENT,HE CAN ONLY JUST CRACK (BIRDY IS BETTER - PROOF : SPORTING TRIANGLES),HE CAN HARDLY PACK TO SAVE '
	dc.b	'HIS WORTHLESS LITTLE LIFE,HE STICKS RAW DATA ON SIDE 2 OF HIS DISKS THEN BOASTS ABOUT A HALF MEG VERSION (WHICH '
	dc.b	'HAD BEEN PACKED PROPERLY ON AUTOMATION 232 FOR OVER A WEEK) HE GOES ON ABOUT HIS WONDERFUL CODE THEN COPIES A FOFT INTRO,IN SHORT, '
	dc.b	' THE GUY IS A FUCKING DICKHEAD.  HIS NAME?  THE ALIEN.  I HEAR THAT THE REST OF THE GROUP ARE QUITE NICE GUYS,SO WHY THE FUCK DO '
	dc.b	'THEY PUT UP WITH THIS CUNT?  MY THEORY IS THAT IF YOU CAN''T DO ANYTHING USEFUL,THEN SLAG OTHER PEOPLE (ESPECIALLY AUTOMATION) '
	dc.b	'TO GET YOURSELF NOTICED. SO ALIEN,NEXT TIME YOU WRITE A SCROLL MESSAGE,EITHER SAY SOMTHING NICE ABOUT AUTOMATION,OR SAY NOTHING AT ALL,'
	dc.b	'YOU''RE NOT EVEN IN OUR LEAGUE!!!!      OK,THAT''S ENOUGH FOR NOW,I''LL LEAVE YOU ALL IN PEACE WITH... THE PILOT   -   '    
	dc.b	' SORRY ABOUT THE LANGUAGE, NO MORE LIKE THAT IN THE'
	dc.b	' REST OF THE SCROLLER. IN CASE IT HAS ESCAPED YOUR NOTICE I HAVE STARTED PACKING STUFF'
	dc.b	' AS WELL AS JUST CRACKING IT. ANDY WAS RIGHT WHEN HE SAID THAT CRACKING IS EASY COMPARED'
	dc.b	' TO PACKING. FORTUNATELY I FOUND A COUPLE OF EASY PACKS TO START ON AND I AM NOW WORKING'
	dc.b	' ON SOME HARDER STUFF. HOWEVER, IF I GET STUCK I CAN ALWAYS CALL ON ANDY. OUR NEXT INTRO'
	dc.b	' SHOULD HAVE SOME FUNKY GUITARS FROM CHRISPY, WHICH I PERSONALLY LOOK FORWARD TO, EVEN THOUGH'
	dc.b	' I''M A HOUSE, ACID, HIP HOP FREAK I DO APPRECIATE A GOOD BIT OF JAMMIN. NOW THEN THERE STILL'
	dc.b	' SEEMS TO BE SOME CONFUSION AS TO WHO THE MEMBERS OF THE BBC ARE. WE ARE ANDY THE ARFLING,'
	dc.b	' THE PILOT...(TM) AND CHRISPY NOODLE. WE HAVE A GROUP OF HANGERS ON CALLED THE SUPER-HANGERS ON.'
	dc.b	' THESE ARE ELTRON, BEGINNER AND LEARNER, WHO GET BITS AND BOBS FOR US TO PACK, OR HUNT DOWN THOSE'
	dc.b	' ELUSIVE 100 PERCENT COPIES OF AUTOMATION DISKS (WHY CAN''T SOME ASSHOLES COPY DISKS ? COPYING'
	dc.b	' VOLUME WILL LEAD TO ERRORS BUT ONE-OFFS FROM SOME PEOPLE ARE ALWAYS WRITE-OFFS !). UM, WELL'
	dc.b	', GREETINGS I SUPPOSE. PLATINUM LIGHT REGARDS TO (NO ORDER) : MOST OF AUTOMATION, POMPEY PIRATES'
	dc.b	' (SPECIAL YO TO DES), MEDWAY BOYS (YO CLOG, SORRY I HAVEN''T SENT YOU MUCH BUT I THINK YOU GET IT'
	dc.b	' AS FAST AS ME ANYWAY), STAN THE MAN (HEY ACID PARTY HAPPENING AT YOURS ? BRING LSD AND AUTOMATIONS'
	dc.b	'), DEREK MD OF WHATEVER GROUP HE HAS JUST STARTED (AGAIN), THE EMPIRE - NICE CRACKS, THE UNION'
	dc.b	' - NICE DEMOS, THALION - NICE GAMES, THUNDERBIRD PUPPET - NICE BODY, TLB - NICE MINDBOMB SCREENS,'
	dc.b	' YO MANIKIN HAVE YOU OILED YOUR BEDSPRINGS YET ? , JAZZIE - WHOEVER YOU ARE, I WANT YOU BODY AS WELL.'
	dc.b	' WHY DOES ELTRON GET PREFERENTIAL TREATMENT ? , PAC AND DAWN, MEGA MIKE - NICE HAIRCUT, WHEN DO YOU'
	dc.b	' PAY THE OTHER INSTALMENT ? AND A TAGNUT TO YOUNG JOE. SUB-SONIC PLASTIC REGARDS TO : BIRDY - THE MIGHTY BATMAN THIEF,'
	dc.b	' THE ACE-HACKER HAL - SORRY ABOUT THE TONE OF THE LETTER I SENT YOU, I''LL PUT YOU IN THE PLATINUM LIGHT REGARDS'
	dc.b	' NEXT TIME, ALIEN - DIDN''T LIKE THE WAY YOU SLAGGED AUTOMATION IN GENERAL BUT DES SAYS THAT YOU''RE'
	dc.b	' ALRIGHT REALLY JUST YOUR EGO NEEDS TAMING, I''LL TAKE A LOT OF CONVINCING AFTER'
	dc.b	' READING PP27. SEEMS LIKE YOU''RE JUST A BIGHEADED LAMER WITH IDEAS ABOVE YOUR STATION.'
	dc.b	' MUCH MORE CRAP LIKE THAT AND YOU''LL ALIENATE YOURSELF.  '
	dc.b	' AND A BIG CONCRETE OVERCOAT TO THE SHAOLIN LAMERS'
	dc.b	'.    THIS WAS THE PILOT...   NOTE ... NO PRISONERS, NO MESSING AND NO CHEQUES - W R A P...................  '

 