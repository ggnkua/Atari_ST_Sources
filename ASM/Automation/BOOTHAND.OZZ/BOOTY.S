	OPT	o+

	PEA	TITLE(PC)
	BSR	PRINT
chk1	CMP.L	#$FC0000,$472
	BPL.S	chk2
	MOVE.W	#$30,-(A7)
	TRAP	#$01
	ADDQ.L	#2,A7
	CMP.W	#$1300,D0
	BNE.S	EIGHT
	MOVE.L	#$FC0FCA,$472
	BRA.S	FLUSH
EIGHT	MOVE.L	#$FC0DE6,$472
FLUSH	MOVE.L	$4C6,A0
	ADD.L	#$600,A0
	MOVE.W	#$100,D0
LOOP	MOVE.B	#$0,(A0)+
	DBF	D0,LOOP
	PEA	FOUND(PC)
	BSR.S	PRINT
	BRA.S	PAL
chk2	cmp.l	#$31415926,$426
	bne.s	NOVIR
	move.l	#$0,$426
	move.l	#$0,$42a
	PEA	VIRBOOT(PC)
	BSR.S	PRINT
	BRA.S	PAL
NOVIR	PEA	NOVIRI(PC)
	BSR.S	PRINT
PAL	MOVE.W	#$FFFF,D0
LOOP1	DBF	D1,LOOP1
	RTS

PRINT	MOVE.L	(A7)+,A6
	MOVE.W	#$9,-(A7)
	TRAP	#$01
	ADDQ.L	#6,A7
	JMP	(A6)
	

TITLE	DC.B	$09," L.S.D. VIRUS KILLER 1.1",$0D,$0A
	DC.B	$09," ------ ----- ------ ---",$0D,$0A,$0A,$0A,$0
FOUND	DC.B	$09,"VIRUS 1 DETECTED + KILLED",$D,$A,$A,$0
VIRBOOT	DC.B	$09," !RESET CHECKSUM HAD BEEN",$D,$A
	DC.B	$09,"   CHANGED, NOW CLEARED!",$D,$A,$0
NOVIRI	DC.B	$09,"  NO VIRUS IN MEMORY!",$D,$A,$A,$0
