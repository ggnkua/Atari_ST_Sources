	OPT	o+

	PEA	TITLE(PC)
	BSR	PRINT
	BCLR.B	#0,$484
	CMP.B	#$04,$424
	BEQ.S	ALLFIVE
	PEA	FIVEST(PC)
	BSR.S	PRINT
	BSR.S	GETKEY
	BEQ.S	FIVEDO
	PEA	MOREMEM(PC)
	BSR.S	PRINT
	BRA.S	ALLMEM
FIVEDO	MOVE.B	#4,$424
	MOVE.L	#$80000,$42E
	MOVE.L	#$38600,$432
	MOVE.L	#$78000,$436
	JMP	$FC0020
ALLFIVE	PEA	FIVEDONE(PC)
	BSR.S	PRINT
ALLMEM	PEA	SCAN(PC)
	BSR.S	PRINT
	BSR.S	GETKEY
	BNE.S	PAL
	MOVE.B	#$00,$FF820A
PAL	PEA	BOOTING(PC)
	BSR.S	PRINT
	RTS

PRINT	MOVE.L	(A7)+,A6
	MOVE.W	#$9,-(A7)
	TRAP	#$01
	ADDQ.L	#6,A7
	JMP	(A6)
	
GETKEY	MOVE.W	#$8,-(A7)
	TRAP	#$01
	ADDQ.L	#2,A7
	ORI.W	#32,D0
	CMP.B	#$79,D0
	RTS

TITLE	DC.B	$09,"L.S.D. BOOT SECTOR +",$0D,$0A
	DC.B	$09,"------ ---- ------ -",$0D,$0A,$0A,$0A,$0
SCAN	DC.B	$09,"  60hz  MODE (Y/N)? ",$D,$0
FIVEST	DC.B	$09,"  512k  MODE (Y/N)? ",$D,$0
FIVEDONE	DC.B	$09,"512K MEMORY AVAILABLE",$0D,$0A,$0A,$0
MOREMEM	DC.B	$09,"FULL MEMORY AVAILABLE",$0D,$0A,$0A,$0
BOOTING	DC.B	$09,"CONTINUING WITH BOOT!",$0
