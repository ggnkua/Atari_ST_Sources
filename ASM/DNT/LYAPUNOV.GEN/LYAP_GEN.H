#define TREE1 0  	/* TREE */
#define YCENT 4  	/* OBJECT in TREE #0 */
#define XCENT 2  	/* OBJECT in TREE #0 */
#define VSIZE 5  	/* OBJECT in TREE #0 */
#define HSIZE 3  	/* OBJECT in TREE #0 */
#define CALC 11  	/* OBJECT in TREE #0 */
#define SHOW 12  	/* OBJECT in TREE #0 */
#define LOADLYS 13  	/* OBJECT in TREE #0 */
#define COLOR1 9  	/* OBJECT in TREE #0 */
#define CPREC 6  	/* OBJECT in TREE #0 */
#define GPREC 8  	/* OBJECT in TREE #0 */
#define SEQUENCE 7  	/* OBJECT in TREE #0 */
#define TREE2 1  	/* TREE */
#define WINFO 3  	/* OBJECT in TREE #1 */
#define COLOR2 10  	/* OBJECT in TREE #0 */
#define SAVEPI1 15  	/* OBJECT in TREE #0 */
#define SAVELYS 14  	/* OBJECT in TREE #0 */
#define QUIT 16  	/* OBJECT in TREE #0 */
