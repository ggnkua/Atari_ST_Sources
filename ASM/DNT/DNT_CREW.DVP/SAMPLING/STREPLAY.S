;Le label __SR_SGN vaut 0 si on veut une table pour samples non sign‚s,
;ou 1 pour des samples sign‚s.Il est … d‚finir dans votre source.
;Si vous ne le d‚finissez pas, alors par d‚faut la tableau sera une
;table non-sign‚e.

	IFND	__SR_SIGN
__SR_SIGN	equ	0
	ENDC
	
	IFNE	__SR_SIGN
ST_REPLAY

	DC.W	$080C,$090B,$0A0A,$0909,$080C,$090B,$0A0A,$0909
	DC.W	$080D,$0908,$0A0A,$0808,$080B,$090B,$0A0A,$0B0B
	DC.W	$080D,$0909,$0A0A,$0505,$080C,$090B,$0A0A,$0808
	DC.W	$080D,$0909,$0A0A,$0202,$080D,$0908,$0A0A,$0606
	DC.W	$080C,$090B,$0A0A,$0707,$080D,$0907,$0A0A,$0707
	DC.W	$080C,$090B,$0A0A,$0606,$080C,$090A,$0A0A,$0909
	DC.W	$080B,$090B,$0A0A,$0A0A,$080C,$090B,$0A0A,$0202
	DC.W	$080C,$090B,$0A0A,$0000,$080C,$090A,$0A0A,$0808
	DC.W	$080D,$0906,$0A0A,$0404,$080D,$0905,$0A0A,$0505
	DC.W	$080D,$0905,$0A0A,$0404,$080C,$0909,$0A0A,$0909
	DC.W	$080D,$0904,$0A0A,$0303,$080B,$090B,$0A0A,$0909
	DC.W	$080C,$090A,$0A0A,$0505,$080B,$090A,$0A0A,$0A0A
	DC.W	$080C,$0909,$0A0A,$0808,$080B,$090B,$0A0A,$0808
	DC.W	$080C,$090A,$0A0A,$0000,$080C,$090A,$0A0A,$0000
	DC.W	$080C,$0909,$0A0A,$0707,$080B,$090B,$0A0A,$0707
	DC.W	$080C,$0909,$0A0A,$0606,$080B,$090B,$0A0A,$0606
	DC.W	$080B,$090A,$0A0A,$0909,$080B,$090B,$0A0A,$0505
	DC.W	$080A,$090A,$0A0A,$0A0A,$080B,$090B,$0A0A,$0202
	DC.W	$080B,$090A,$0A0A,$0808,$080C,$0907,$0A0A,$0707
	DC.W	$080C,$0908,$0A0A,$0404,$080C,$0907,$0A0A,$0606
	DC.W	$080B,$0909,$0A0A,$0909,$080C,$0906,$0A0A,$0606
	DC.W	$080A,$090A,$0A0A,$0909,$080C,$0907,$0A0A,$0303
	DC.W	$080B,$090A,$0A0A,$0505,$080B,$0909,$0A0A,$0808
	DC.W	$080B,$090A,$0A0A,$0303,$080A,$090A,$0A0A,$0808
	DC.W	$080B,$090A,$0A0A,$0000,$080B,$0909,$0A0A,$0707
	DC.W	$080B,$0908,$0A0A,$0808,$080A,$090A,$0A0A,$0707
	DC.W	$080A,$0909,$0A0A,$0909,$080C,$0901,$0A0A,$0101
	DC.W	$080A,$090A,$0A0A,$0606,$080B,$0908,$0A0A,$0707
	DC.W	$080A,$090A,$0A0A,$0505,$080A,$0909,$0A0A,$0808
	DC.W	$080A,$090A,$0A0A,$0202,$080A,$090A,$0A0A,$0101
	DC.W	$080A,$090A,$0A0A,$0000,$0809,$0909,$0A0A,$0909
	DC.W	$080A,$0908,$0A0A,$0808,$080B,$0908,$0A0A,$0101
	DC.W	$080A,$0909,$0A0A,$0606,$080B,$0907,$0A0A,$0404
	DC.W	$080A,$0909,$0A0A,$0505,$0809,$0909,$0A0A,$0808
	DC.W	$080A,$0909,$0A0A,$0303,$080A,$0908,$0A0A,$0606
	DC.W	$080A,$0909,$0A0A,$0000,$0809,$0909,$0A0A,$0707
	DC.W	$0809,$0908,$0A0A,$0808,$080A,$0908,$0A0A,$0404
	DC.W	$0809,$0909,$0A0A,$0606,$080A,$0908,$0A0A,$0101
	DC.W	$0809,$0909,$0A0A,$0505,$0809,$0908,$0A0A,$0707
	DC.W	$0808,$0908,$0A0A,$0808,$0809,$0909,$0A0A,$0202
	DC.W	$0809,$0908,$0A0A,$0606,$0809,$0909,$0A0A,$0000
	DC.W	$0809,$0907,$0A0A,$0707,$0808,$0908,$0A0A,$0707
	DC.W	$0809,$0907,$0A0A,$0606,$0809,$0908,$0A0A,$0202
	DC.W	$0808,$0908,$0A0A,$0606,$0809,$0906,$0A0A,$0606
	DC.W	$0808,$0907,$0A0A,$0707,$0808,$0908,$0A0A,$0404
	DC.W	$0808,$0907,$0A0A,$0606,$0808,$0908,$0A0A,$0202
	DC.W	$0807,$0907,$0A0A,$0707,$0808,$0906,$0A0A,$0606
	DC.W	$0808,$0907,$0A0A,$0404,$0807,$0907,$0A0A,$0606
	DC.W	$0808,$0906,$0A0A,$0505,$0808,$0906,$0A0A,$0404
	DC.W	$0807,$0906,$0A0A,$0606,$0807,$0907,$0A0A,$0404
	DC.W	$0808,$0905,$0A0A,$0404,$0806,$0906,$0A0A,$0606
	DC.W	$0807,$0906,$0A0A,$0404,$0807,$0905,$0A0A,$0505
	DC.W	$0806,$0906,$0A0A,$0505,$0806,$0906,$0A0A,$0404
	DC.W	$0806,$0905,$0A0A,$0505,$0806,$0906,$0A0A,$0202
	DC.W	$0806,$0905,$0A0A,$0404,$0805,$0905,$0A0A,$0505
	DC.W	$0806,$0905,$0A0A,$0202,$0805,$0905,$0A0A,$0404
	DC.W	$0805,$0904,$0A0A,$0404,$0805,$0905,$0A0A,$0202
	DC.W	$0804,$0904,$0A0A,$0404,$0804,$0904,$0A0A,$0303
	DC.W	$0804,$0904,$0A0A,$0202,$0804,$0903,$0A0A,$0303
	DC.W	$0803,$0903,$0A0A,$0303,$0803,$0903,$0A0A,$0202
	DC.W	$0803,$0902,$0A0A,$0202,$0802,$0902,$0A0A,$0202
	DC.W	$0802,$0902,$0A0A,$0101,$0801,$0901,$0A0A,$0101
	DC.W	$0802,$0901,$0A0A,$0000,$0801,$0901,$0A0A,$0000
	DC.W	$0801,$0900,$0A0A,$0000,$0800,$0900,$0A0A,$0000

	DC.W	$080E,$090D,$0A0A,$0C0C,$080F,$0903,$0A0A,$0000
	DC.W	$080F,$0903,$0A0A,$0000,$080F,$0903,$0A0A,$0000
	DC.W	$080F,$0903,$0A0A,$0000,$080F,$0903,$0A0A,$0000
	DC.W	$080F,$0903,$0A0A,$0000,$080E,$090D,$0A0A,$0B0B
	DC.W	$080E,$090D,$0A0A,$0B0B,$080E,$090D,$0A0A,$0B0B
	DC.W	$080E,$090D,$0A0A,$0B0B,$080E,$090D,$0A0A,$0B0B
	DC.W	$080E,$090D,$0A0A,$0B0B,$080E,$090D,$0A0A,$0B0B
	DC.W	$080E,$090D,$0A0A,$0A0A,$080E,$090D,$0A0A,$0A0A
	DC.W	$080E,$090D,$0A0A,$0A0A,$080E,$090D,$0A0A,$0A0A
	DC.W	$080E,$090C,$0A0A,$0C0C,$080E,$090D,$0A0A,$0000
	DC.W	$080D,$090D,$0A0A,$0D0D,$080D,$090D,$0A0A,$0D0D
	DC.W	$080D,$090D,$0A0A,$0D0D,$080D,$090D,$0A0A,$0D0D
	DC.W	$080D,$090D,$0A0A,$0D0D,$080D,$090D,$0A0A,$0D0D
	DC.W	$080E,$090C,$0A0A,$0B0B,$080E,$090C,$0A0A,$0B0B
	DC.W	$080E,$090C,$0A0A,$0B0B,$080E,$090C,$0A0A,$0B0B
	DC.W	$080E,$090C,$0A0A,$0B0B,$080E,$090C,$0A0A,$0B0B
	DC.W	$080E,$090C,$0A0A,$0B0B,$080E,$090C,$0A0A,$0B0B
	DC.W	$080E,$090C,$0A0A,$0A0A,$080E,$090C,$0A0A,$0A0A
	DC.W	$080E,$090C,$0A0A,$0A0A,$080E,$090C,$0A0A,$0A0A
	DC.W	$080D,$090D,$0A0A,$0C0C,$080D,$090D,$0A0A,$0C0C
	DC.W	$080E,$090C,$0A0A,$0909,$080E,$090C,$0A0A,$0909
	DC.W	$080E,$090C,$0A0A,$0505,$080E,$090C,$0A0A,$0000
	DC.W	$080E,$090C,$0A0A,$0000,$080E,$090B,$0A0A,$0B0B
	DC.W	$080E,$090B,$0A0A,$0B0B,$080E,$090B,$0A0A,$0B0B
	DC.W	$080E,$090B,$0A0A,$0B0B,$080E,$090B,$0A0A,$0A0A
	DC.W	$080E,$090B,$0A0A,$0A0A,$080E,$090B,$0A0A,$0A0A
	DC.W	$080D,$090D,$0A0A,$0B0B,$080D,$090D,$0A0A,$0B0B
	DC.W	$080D,$090D,$0A0A,$0B0B,$080E,$090B,$0A0A,$0909
	DC.W	$080E,$090B,$0A0A,$0909,$080E,$090B,$0A0A,$0909
	DC.W	$080D,$090C,$0A0A,$0C0C,$080D,$090D,$0A0A,$0A0A
	DC.W	$080E,$090B,$0A0A,$0707,$080E,$090B,$0A0A,$0000
	DC.W	$080E,$090B,$0A0A,$0000,$080D,$090D,$0A0A,$0909
	DC.W	$080D,$090D,$0A0A,$0909,$080E,$090A,$0A0A,$0909
	DC.W	$080D,$090D,$0A0A,$0808,$080D,$090D,$0A0A,$0707
	DC.W	$080D,$090D,$0A0A,$0404,$080D,$090D,$0A0A,$0000
	DC.W	$080E,$090A,$0A0A,$0404,$080E,$0909,$0A0A,$0909
	DC.W	$080E,$0909,$0A0A,$0909,$080D,$090C,$0A0A,$0B0B
	DC.W	$080E,$0909,$0A0A,$0808,$080E,$0909,$0A0A,$0808
	DC.W	$080E,$0909,$0A0A,$0707,$080E,$0908,$0A0A,$0808
	DC.W	$080E,$0909,$0A0A,$0101,$080C,$090C,$0A0A,$0C0C
	DC.W	$080D,$090C,$0A0A,$0A0A,$080E,$0908,$0A0A,$0606
	DC.W	$080E,$0907,$0A0A,$0707,$080E,$0908,$0A0A,$0000
	DC.W	$080E,$0907,$0A0A,$0505,$080E,$0906,$0A0A,$0606
	DC.W	$080D,$090C,$0A0A,$0909,$080E,$0905,$0A0A,$0505
	DC.W	$080E,$0904,$0A0A,$0404,$080D,$090C,$0A0A,$0808
	DC.W	$080D,$090B,$0A0A,$0B0B,$080E,$0900,$0A0A,$0000
	DC.W	$080D,$090C,$0A0A,$0606,$080D,$090C,$0A0A,$0505
	DC.W	$080D,$090C,$0A0A,$0202,$080C,$090C,$0A0A,$0B0B
	DC.W	$080C,$090C,$0A0A,$0B0B,$080D,$090B,$0A0A,$0A0A
	DC.W	$080D,$090B,$0A0A,$0A0A,$080D,$090B,$0A0A,$0A0A
	DC.W	$080D,$090B,$0A0A,$0A0A,$080C,$090C,$0A0A,$0A0A
	DC.W	$080C,$090C,$0A0A,$0A0A,$080C,$090C,$0A0A,$0A0A
	DC.W	$080D,$090B,$0A0A,$0909,$080D,$090B,$0A0A,$0909
	DC.W	$080D,$090A,$0A0A,$0A0A,$080D,$090A,$0A0A,$0A0A
	DC.W	$080D,$090A,$0A0A,$0A0A,$080C,$090C,$0A0A,$0909
	DC.W	$080C,$090C,$0A0A,$0909,$080C,$090C,$0A0A,$0909
	DC.W	$080D,$090B,$0A0A,$0606,$080C,$090B,$0A0A,$0B0B
	DC.W	$080C,$090C,$0A0A,$0808,$080D,$090B,$0A0A,$0000
	DC.W	$080D,$090B,$0A0A,$0000,$080C,$090C,$0A0A,$0707
	DC.W	$080C,$090C,$0A0A,$0606,$080C,$090C,$0A0A,$0505
	DC.W	$080C,$090C,$0A0A,$0303,$080C,$090C,$0A0A,$0101
	DC.W	$080C,$090B,$0A0A,$0A0A,$080D,$090A,$0A0A,$0505
	DC.W	$080D,$090A,$0A0A,$0404,$080D,$090A,$0A0A,$0202
	DC.W	$080D,$0909,$0A0A,$0808,$080D,$0909,$0A0A,$0808

	ELSE

ST_REPLAY
	DC.W	$080E,$090D,$0A0A,$0C0C,$080F,$0903,$0A0A,$0000
	DC.W	$080F,$0903,$0A0A,$0000,$080F,$0903,$0A0A,$0000
	DC.W	$080F,$0903,$0A0A,$0000,$080F,$0903,$0A0A,$0000
	DC.W	$080F,$0903,$0A0A,$0000,$080E,$090D,$0A0A,$0B0B
	DC.W	$080E,$090D,$0A0A,$0B0B,$080E,$090D,$0A0A,$0B0B
	DC.W	$080E,$090D,$0A0A,$0B0B,$080E,$090D,$0A0A,$0B0B
	DC.W	$080E,$090D,$0A0A,$0B0B,$080E,$090D,$0A0A,$0B0B
	DC.W	$080E,$090D,$0A0A,$0A0A,$080E,$090D,$0A0A,$0A0A
	DC.W	$080E,$090D,$0A0A,$0A0A,$080E,$090D,$0A0A,$0A0A
	DC.W	$080E,$090C,$0A0A,$0C0C,$080E,$090D,$0A0A,$0000
	DC.W	$080D,$090D,$0A0A,$0D0D,$080D,$090D,$0A0A,$0D0D
	DC.W	$080D,$090D,$0A0A,$0D0D,$080D,$090D,$0A0A,$0D0D
	DC.W	$080D,$090D,$0A0A,$0D0D,$080D,$090D,$0A0A,$0D0D
	DC.W	$080E,$090C,$0A0A,$0B0B,$080E,$090C,$0A0A,$0B0B
	DC.W	$080E,$090C,$0A0A,$0B0B,$080E,$090C,$0A0A,$0B0B
	DC.W	$080E,$090C,$0A0A,$0B0B,$080E,$090C,$0A0A,$0B0B
	DC.W	$080E,$090C,$0A0A,$0B0B,$080E,$090C,$0A0A,$0B0B
	DC.W	$080E,$090C,$0A0A,$0A0A,$080E,$090C,$0A0A,$0A0A
	DC.W	$080E,$090C,$0A0A,$0A0A,$080E,$090C,$0A0A,$0A0A
	DC.W	$080D,$090D,$0A0A,$0C0C,$080D,$090D,$0A0A,$0C0C
	DC.W	$080E,$090C,$0A0A,$0909,$080E,$090C,$0A0A,$0909
	DC.W	$080E,$090C,$0A0A,$0505,$080E,$090C,$0A0A,$0000
	DC.W	$080E,$090C,$0A0A,$0000,$080E,$090B,$0A0A,$0B0B
	DC.W	$080E,$090B,$0A0A,$0B0B,$080E,$090B,$0A0A,$0B0B
	DC.W	$080E,$090B,$0A0A,$0B0B,$080E,$090B,$0A0A,$0A0A
	DC.W	$080E,$090B,$0A0A,$0A0A,$080E,$090B,$0A0A,$0A0A
	DC.W	$080D,$090D,$0A0A,$0B0B,$080D,$090D,$0A0A,$0B0B
	DC.W	$080D,$090D,$0A0A,$0B0B,$080E,$090B,$0A0A,$0909
	DC.W	$080E,$090B,$0A0A,$0909,$080E,$090B,$0A0A,$0909
	DC.W	$080D,$090C,$0A0A,$0C0C,$080D,$090D,$0A0A,$0A0A
	DC.W	$080E,$090B,$0A0A,$0707,$080E,$090B,$0A0A,$0000
	DC.W	$080E,$090B,$0A0A,$0000,$080D,$090D,$0A0A,$0909
	DC.W	$080D,$090D,$0A0A,$0909,$080E,$090A,$0A0A,$0909
	DC.W	$080D,$090D,$0A0A,$0808,$080D,$090D,$0A0A,$0707
	DC.W	$080D,$090D,$0A0A,$0404,$080D,$090D,$0A0A,$0000
	DC.W	$080E,$090A,$0A0A,$0404,$080E,$0909,$0A0A,$0909
	DC.W	$080E,$0909,$0A0A,$0909,$080D,$090C,$0A0A,$0B0B
	DC.W	$080E,$0909,$0A0A,$0808,$080E,$0909,$0A0A,$0808
	DC.W	$080E,$0909,$0A0A,$0707,$080E,$0908,$0A0A,$0808
	DC.W	$080E,$0909,$0A0A,$0101,$080C,$090C,$0A0A,$0C0C
	DC.W	$080D,$090C,$0A0A,$0A0A,$080E,$0908,$0A0A,$0606
	DC.W	$080E,$0907,$0A0A,$0707,$080E,$0908,$0A0A,$0000
	DC.W	$080E,$0907,$0A0A,$0505,$080E,$0906,$0A0A,$0606
	DC.W	$080D,$090C,$0A0A,$0909,$080E,$0905,$0A0A,$0505
	DC.W	$080E,$0904,$0A0A,$0404,$080D,$090C,$0A0A,$0808
	DC.W	$080D,$090B,$0A0A,$0B0B,$080E,$0900,$0A0A,$0000
	DC.W	$080D,$090C,$0A0A,$0606,$080D,$090C,$0A0A,$0505
	DC.W	$080D,$090C,$0A0A,$0202,$080C,$090C,$0A0A,$0B0B
	DC.W	$080C,$090C,$0A0A,$0B0B,$080D,$090B,$0A0A,$0A0A
	DC.W	$080D,$090B,$0A0A,$0A0A,$080D,$090B,$0A0A,$0A0A
	DC.W	$080D,$090B,$0A0A,$0A0A,$080C,$090C,$0A0A,$0A0A
	DC.W	$080C,$090C,$0A0A,$0A0A,$080C,$090C,$0A0A,$0A0A
	DC.W	$080D,$090B,$0A0A,$0909,$080D,$090B,$0A0A,$0909
	DC.W	$080D,$090A,$0A0A,$0A0A,$080D,$090A,$0A0A,$0A0A
	DC.W	$080D,$090A,$0A0A,$0A0A,$080C,$090C,$0A0A,$0909
	DC.W	$080C,$090C,$0A0A,$0909,$080C,$090C,$0A0A,$0909
	DC.W	$080D,$090B,$0A0A,$0606,$080C,$090B,$0A0A,$0B0B
	DC.W	$080C,$090C,$0A0A,$0808,$080D,$090B,$0A0A,$0000
	DC.W	$080D,$090B,$0A0A,$0000,$080C,$090C,$0A0A,$0707
	DC.W	$080C,$090C,$0A0A,$0606,$080C,$090C,$0A0A,$0505
	DC.W	$080C,$090C,$0A0A,$0303,$080C,$090C,$0A0A,$0101
	DC.W	$080C,$090B,$0A0A,$0A0A,$080D,$090A,$0A0A,$0505
	DC.W	$080D,$090A,$0A0A,$0404,$080D,$090A,$0A0A,$0202
	DC.W	$080D,$0909,$0A0A,$0808,$080D,$0909,$0A0A,$0808

	DC.W	$080C,$090B,$0A0A,$0909,$080C,$090B,$0A0A,$0909
	DC.W	$080D,$0908,$0A0A,$0808,$080B,$090B,$0A0A,$0B0B
	DC.W	$080D,$0909,$0A0A,$0505,$080C,$090B,$0A0A,$0808
	DC.W	$080D,$0909,$0A0A,$0202,$080D,$0908,$0A0A,$0606
	DC.W	$080C,$090B,$0A0A,$0707,$080D,$0907,$0A0A,$0707
	DC.W	$080C,$090B,$0A0A,$0606,$080C,$090A,$0A0A,$0909
	DC.W	$080B,$090B,$0A0A,$0A0A,$080C,$090B,$0A0A,$0202
	DC.W	$080C,$090B,$0A0A,$0000,$080C,$090A,$0A0A,$0808
	DC.W	$080D,$0906,$0A0A,$0404,$080D,$0905,$0A0A,$0505
	DC.W	$080D,$0905,$0A0A,$0404,$080C,$0909,$0A0A,$0909
	DC.W	$080D,$0904,$0A0A,$0303,$080B,$090B,$0A0A,$0909
	DC.W	$080C,$090A,$0A0A,$0505,$080B,$090A,$0A0A,$0A0A
	DC.W	$080C,$0909,$0A0A,$0808,$080B,$090B,$0A0A,$0808
	DC.W	$080C,$090A,$0A0A,$0000,$080C,$090A,$0A0A,$0000
	DC.W	$080C,$0909,$0A0A,$0707,$080B,$090B,$0A0A,$0707
	DC.W	$080C,$0909,$0A0A,$0606,$080B,$090B,$0A0A,$0606
	DC.W	$080B,$090A,$0A0A,$0909,$080B,$090B,$0A0A,$0505
	DC.W	$080A,$090A,$0A0A,$0A0A,$080B,$090B,$0A0A,$0202
	DC.W	$080B,$090A,$0A0A,$0808,$080C,$0907,$0A0A,$0707
	DC.W	$080C,$0908,$0A0A,$0404,$080C,$0907,$0A0A,$0606
	DC.W	$080B,$0909,$0A0A,$0909,$080C,$0906,$0A0A,$0606
	DC.W	$080A,$090A,$0A0A,$0909,$080C,$0907,$0A0A,$0303
	DC.W	$080B,$090A,$0A0A,$0505,$080B,$0909,$0A0A,$0808
	DC.W	$080B,$090A,$0A0A,$0303,$080A,$090A,$0A0A,$0808
	DC.W	$080B,$090A,$0A0A,$0000,$080B,$0909,$0A0A,$0707
	DC.W	$080B,$0908,$0A0A,$0808,$080A,$090A,$0A0A,$0707
	DC.W	$080A,$0909,$0A0A,$0909,$080C,$0901,$0A0A,$0101
	DC.W	$080A,$090A,$0A0A,$0606,$080B,$0908,$0A0A,$0707
	DC.W	$080A,$090A,$0A0A,$0505,$080A,$0909,$0A0A,$0808
	DC.W	$080A,$090A,$0A0A,$0202,$080A,$090A,$0A0A,$0101
	DC.W	$080A,$090A,$0A0A,$0000,$0809,$0909,$0A0A,$0909
	DC.W	$080A,$0908,$0A0A,$0808,$080B,$0908,$0A0A,$0101
	DC.W	$080A,$0909,$0A0A,$0606,$080B,$0907,$0A0A,$0404
	DC.W	$080A,$0909,$0A0A,$0505,$0809,$0909,$0A0A,$0808
	DC.W	$080A,$0909,$0A0A,$0303,$080A,$0908,$0A0A,$0606
	DC.W	$080A,$0909,$0A0A,$0000,$0809,$0909,$0A0A,$0707
	DC.W	$0809,$0908,$0A0A,$0808,$080A,$0908,$0A0A,$0404
	DC.W	$0809,$0909,$0A0A,$0606,$080A,$0908,$0A0A,$0101
	DC.W	$0809,$0909,$0A0A,$0505,$0809,$0908,$0A0A,$0707
	DC.W	$0808,$0908,$0A0A,$0808,$0809,$0909,$0A0A,$0202
	DC.W	$0809,$0908,$0A0A,$0606,$0809,$0909,$0A0A,$0000
	DC.W	$0809,$0907,$0A0A,$0707,$0808,$0908,$0A0A,$0707
	DC.W	$0809,$0907,$0A0A,$0606,$0809,$0908,$0A0A,$0202
	DC.W	$0808,$0908,$0A0A,$0606,$0809,$0906,$0A0A,$0606
	DC.W	$0808,$0907,$0A0A,$0707,$0808,$0908,$0A0A,$0404
	DC.W	$0808,$0907,$0A0A,$0606,$0808,$0908,$0A0A,$0202
	DC.W	$0807,$0907,$0A0A,$0707,$0808,$0906,$0A0A,$0606
	DC.W	$0808,$0907,$0A0A,$0404,$0807,$0907,$0A0A,$0606
	DC.W	$0808,$0906,$0A0A,$0505,$0808,$0906,$0A0A,$0404
	DC.W	$0807,$0906,$0A0A,$0606,$0807,$0907,$0A0A,$0404
	DC.W	$0808,$0905,$0A0A,$0404,$0806,$0906,$0A0A,$0606
	DC.W	$0807,$0906,$0A0A,$0404,$0807,$0905,$0A0A,$0505
	DC.W	$0806,$0906,$0A0A,$0505,$0806,$0906,$0A0A,$0404
	DC.W	$0806,$0905,$0A0A,$0505,$0806,$0906,$0A0A,$0202
	DC.W	$0806,$0905,$0A0A,$0404,$0805,$0905,$0A0A,$0505
	DC.W	$0806,$0905,$0A0A,$0202,$0805,$0905,$0A0A,$0404
	DC.W	$0805,$0904,$0A0A,$0404,$0805,$0905,$0A0A,$0202
	DC.W	$0804,$0904,$0A0A,$0404,$0804,$0904,$0A0A,$0303
	DC.W	$0804,$0904,$0A0A,$0202,$0804,$0903,$0A0A,$0303
	DC.W	$0803,$0903,$0A0A,$0303,$0803,$0903,$0A0A,$0202
	DC.W	$0803,$0902,$0A0A,$0202,$0802,$0902,$0A0A,$0202
	DC.W	$0802,$0902,$0A0A,$0101,$0801,$0901,$0A0A,$0101
	DC.W	$0802,$0901,$0A0A,$0000,$0801,$0901,$0A0A,$0000
	DC.W	$0801,$0900,$0A0A,$0000,$0800,$0900,$0A0A,$0000

	ENDC