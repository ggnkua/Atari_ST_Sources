* resource set indicies for PRG_400 *

TESTTUBE EQU	0	/* menu tree */
DESK400  EQU	3	/* TITLE in tree TESTTUBE */
FILES400 EQU	4	/* TITLE in tree TESTTUBE */
ABOUT400 EQU	7	/* STRING in tree TESTTUBE */
QUIT400  EQU	17	/* STRING in tree TESTTUBE */
