* resource set indicies for ACC_500 */

TUBE       EQU   0	/* form/dialog */
CADTUBE    EQU   0	/* BOX in tree TUBE */
TUBE1      EQU   4	/* BUTTON in tree TUBE */
TUBE2      EQU   5	/* BUTTON in tree TUBE */
TUBE3      EQU   6	/* BUTTON in tree TUBE */
TUBE4      EQU   7	/* BUTTON in tree TUBE */
TUBE5      EQU   8	/* BUTTON in tree TUBE */
ANNUTUBE   EQU   9	/* BUTTON in tree TUBE */
NEXTTUBE   EQU   10	/* BUTTON in tree TUBE */
