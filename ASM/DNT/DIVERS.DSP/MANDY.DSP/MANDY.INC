;Parametres du calcul de Mandelbrot fait par mandy.asm
;
centrx	equ	-0.7882861+.1+.2/10
centry	equ	0.4365374+.2/8
size_x	equ	0.1
size_y	equ	size_x
resolx	equ	128*8
resoly	equ	128*8
prof	equ	51
startx	equ	centrx-size_x/2
starty	equ	centry-size_y/2
