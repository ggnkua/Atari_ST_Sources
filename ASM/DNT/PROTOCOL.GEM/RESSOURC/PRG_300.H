* resource set indicies for TESTTUBE *

TESTTUBE EQU	0	/* menu tree */
ABOUT    EQU	7	/* STRING in tree TESTTUBE */
LOAD1    EQU	16	/* STRING in tree TESTTUBE */
LOAD2    EQU	17	/* STRING in tree TESTTUBE */
SEND     EQU	18	/* STRING in tree TESTTUBE */
QUIT     EQU	20	/* STRING in tree TESTTUBE */

TUBE     EQU	1	/* form/dialog */
CADTUBE  EQU	0	/* BOX in tree TUBE */
TUBE1    EQU	4	/* BUTTON in tree TUBE */
TUBE2    EQU	5	/* BUTTON in tree TUBE */
TUBE3    EQU	6	/* BUTTON in tree TUBE */
TUBE4    EQU	7	/* BUTTON in tree TUBE */
TUBE5    EQU	8	/* BUTTON in tree TUBE */
ANNUTUBE EQU	9	/* BUTTON in tree TUBE */
NEXTTUBE EQU	10	/* BUTTON in tree TUBE */
