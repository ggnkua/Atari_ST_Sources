; generated line speeds
rastercolors:
	 dc.l $577 
	 dc.l $245 
	 dc.l $012 
	 dc.l $023 
	 dc.l $134 
	 dc.l $134 
	 dc.l $366 
	 dc.l $012 
	 dc.l $023 
	 dc.l $245 
	 dc.l $023 
	 dc.l $134 
	 dc.l $023 
	 dc.l $577 
	 dc.l $366 
	 dc.l $012 
	 dc.l $134 
	 dc.l $023 
	 dc.l $245 
	 dc.l $366 
	 dc.l $366 
	 dc.l $012 
	 dc.l $245 
	 dc.l $012 
	 dc.l $577 
	 dc.l $577 
	 dc.l $023 
	 dc.l $245 
	 dc.l $577 
	 dc.l $577 
	 dc.l $577 
	 dc.l $134 
	 dc.l $245 
	 dc.l $577 
	 dc.l $366 
	 dc.l $245 
	 dc.l $577 
	 dc.l $012 
	 dc.l $134 
	 dc.l $012 
	 dc.l $245 
	 dc.l $245 
	 dc.l $245 
	 dc.l $366 
	 dc.l $012 
	 dc.l $577 
	 dc.l $134 
	 dc.l $023 
	 dc.l $023 
	 dc.l $366 
	 dc.l $577 
	 dc.l $245 
	 dc.l $366 
	 dc.l $134 
	 dc.l $023 
	 dc.l $245 
	 dc.l $577 
	 dc.l $134 
	 dc.l $366 
	 dc.l $366 
	 dc.l $134 
	 dc.l $245 
	 dc.l $366 
	 dc.l $245 
	 dc.l $012 
	 dc.l $134 
	 dc.l $366 
	 dc.l $012 
	 dc.l $023 
	 dc.l $366 
	 dc.l $366 
	 dc.l $366 
	 dc.l $134 
	 dc.l $577 
	 dc.l $023 
	 dc.l $134 
	 dc.l $577 
	 dc.l $023 
	 dc.l $245 
	 dc.l $366 
	 dc.l $577 
	 dc.l $012 
	 dc.l $023 
	 dc.l $245 
	 dc.l $134 
	 dc.l $023 
	 dc.l $366 
	 dc.l $577 
	 dc.l $245 
	 dc.l $023 
	 dc.l $023 
	 dc.l $245 
	 dc.l $134 
	 dc.l $012 
	 dc.l $366 
	 dc.l $245 
	 dc.l $012 
	 dc.l $023 
	 dc.l $023 
	 dc.l $023 
	 dc.l $577 
	 dc.l $577 
	 dc.l $366 
	 dc.l $577 
	 dc.l $577 
	 dc.l $245 
	 dc.l $134 
	 dc.l $134 
	 dc.l $366 
	 dc.l $245 
	 dc.l $366 
	 dc.l $134 
	 dc.l $134 
	 dc.l $245 
	 dc.l $245 
	 dc.l $134 
	 dc.l $366 
	 dc.l $134 
	 dc.l $134 
	 dc.l $134 
	 dc.l $023 
	 dc.l $245 
	 dc.l $245 
	 dc.l $245 
	 dc.l $245 
	 dc.l $134 
	 dc.l $012 
	 dc.l $366 
	 dc.l $023 
	 dc.l $023 
	 dc.l $245 
	 dc.l $012 
	 dc.l $577 
	 dc.l $577 
	 dc.l $012 
	 dc.l $134 
	 dc.l $134 
	 dc.l $012 
	 dc.l $366 
	 dc.l $577 
	 dc.l $023 
	 dc.l $134 
	 dc.l $577 
	 dc.l $245 
	 dc.l $577 
	 dc.l $134 
	 dc.l $012 
	 dc.l $134 
	 dc.l $134 
	 dc.l $012 
	 dc.l $366 
	 dc.l $245 
	 dc.l $245 
	 dc.l $577 
	 dc.l $577 
	 dc.l $023 
	 dc.l $577 
	 dc.l $245 
	 dc.l $245 
	 dc.l $012 
	 dc.l $577 
	 dc.l $366 
	 dc.l $577 
	 dc.l $134 
	 dc.l $366 
	 dc.l $245 
	 dc.l $366 
	 dc.l $366 
	 dc.l $245 
	 dc.l $012 
	 dc.l $023 
	 dc.l $134 
	 dc.l $012 
	 dc.l $012 
	 dc.l $366 
	 dc.l $245 
	 dc.l $245 
	 dc.l $134 
	 dc.l $577 
	 dc.l $577 
	 dc.l $134 
	 dc.l $023 
	 dc.l $023 
	 dc.l $577 
	 dc.l $023 
	 dc.l $012 
	 dc.l $366 
	 dc.l $012 
	 dc.l $245 
	 dc.l $577 
	 dc.l $577 
	 dc.l $012 
	 dc.l $366 
	 dc.l $366 
	 dc.l $134 
	 dc.l $012 
	 dc.l $023 
	 dc.l $366 
	 dc.l $366 
	 dc.l $366 	 

; generated number of stars  1000
starlist:
	dc.w 305,12800,5
	dc.w 75,13760,2
	dc.w 181,14080,6
	dc.w 44,17920,3
	dc.w 24,8320,4
	dc.w 272,12960,6
	dc.w 230,160,6
	dc.w 267,14720,4
	dc.w 234,12800,5
	dc.w 292,2560,1
	dc.w 217,8000,5
	dc.w 284,3520,1
	dc.w 316,9440,5
	dc.w 271,16960,4
	dc.w 280,7200,1
	dc.w 5,4160,6
	dc.w 175,2240,6
	dc.w 76,14080,6
	dc.w 269,14560,2
	dc.w 200,14400,2
	dc.w 252,15200,5
	dc.w 308,2880,2
	dc.w 233,16480,5
	dc.w 23,3840,1
	dc.w 125,7520,3
	dc.w 302,16480,5
	dc.w 271,18240,4
	dc.w 183,9120,6
	dc.w 174,1760,2
	dc.w 18,6400,1
	dc.w 56,2400,5
	dc.w 299,9280,3
	dc.w 109,8960,4
	dc.w 59,160,6
	dc.w 284,16960,4
	dc.w 141,6880,4
	dc.w 201,1120,5
	dc.w 62,8000,5
	dc.w 284,7680,2
	dc.w 161,8640,3
	dc.w 298,17120,3
	dc.w 120,10880,1
	dc.w 309,6720,4
	dc.w 96,6400,1
	dc.w 227,7680,2
	dc.w 304,16320,6
	dc.w 35,3680,4
	dc.w 94,13760,2
	dc.w 129,9280,3
	dc.w 311,13920,5
	dc.w 309,6080,1
	dc.w 101,1440,2
	dc.w 269,10880,1
	dc.w 204,3840,1
	dc.w 146,1600,4
	dc.w 12,14080,6
	dc.w 196,16480,5
	dc.w 273,14560,2
	dc.w 116,6720,4
	dc.w 247,11840,6
	dc.w 170,14080,6
	dc.w 313,4960,6
	dc.w 306,14080,6
	dc.w 138,8160,6
	dc.w 30,10240,4
	dc.w 109,12480,2
	dc.w 268,4480,4
	dc.w 1,2560,1
	dc.w 271,3680,4
	dc.w 243,14400,2
	dc.w 257,17600,4
	dc.w 120,1760,2
	dc.w 176,15200,5
	dc.w 218,17600,4
	dc.w 130,17600,4
	dc.w 213,15520,1
	dc.w 277,800,3
	dc.w 294,9760,3
	dc.w 296,16800,6
	dc.w 278,0,4
	dc.w 248,1600,4
	dc.w 136,3680,4
	dc.w 68,6720,4
	dc.w 205,1920,3
	dc.w 29,11360,5
	dc.w 15,12000,2
	dc.w 173,6400,1
	dc.w 318,4800,6
	dc.w 215,10400,1
	dc.w 111,2880,2
	dc.w 262,13600,3
	dc.w 223,2720,3
	dc.w 111,16480,5
	dc.w 273,8160,6
	dc.w 316,9440,5
	dc.w 312,2080,2
	dc.w 90,960,3
	dc.w 231,14720,4
	dc.w 272,9600,5
	dc.w 75,14400,2
	dc.w 36,13120,1
	dc.w 166,9120,6
	dc.w 231,1920,3
	dc.w 29,480,1
	dc.w 69,16640,6
	dc.w 158,640,2
	dc.w 152,640,2
	dc.w 129,4960,6
	dc.w 49,13440,4
	dc.w 248,10720,5
	dc.w 106,1600,4
	dc.w 80,11520,5
	dc.w 269,16000,2
	dc.w 252,7680,2
	dc.w 218,4640,6
	dc.w 102,7040,5
	dc.w 104,9120,6
	dc.w 43,15200,5
	dc.w 119,10240,4
	dc.w 148,2400,5
	dc.w 218,16480,5
	dc.w 309,17440,5
	dc.w 49,5280,4
	dc.w 103,14400,2
	dc.w 312,14560,2
	dc.w 41,640,2
	dc.w 64,18080,3
	dc.w 192,16160,6
	dc.w 118,160,6
	dc.w 25,1600,4
	dc.w 139,6400,1
	dc.w 170,480,1
	dc.w 184,6240,3
	dc.w 156,5600,5
	dc.w 74,11520,5
	dc.w 282,5120,3
	dc.w 291,9760,3
	dc.w 133,6720,4
	dc.w 289,5440,6
	dc.w 124,12640,4
	dc.w 270,7840,2
	dc.w 170,15040,1
	dc.w 183,5760,4
	dc.w 137,480,1
	dc.w 174,15360,4
	dc.w 216,8320,4
	dc.w 79,10720,5
	dc.w 26,17600,4
	dc.w 280,4640,6
	dc.w 145,13760,2
	dc.w 275,11360,5
	dc.w 118,5760,4
	dc.w 278,3040,4
	dc.w 165,16480,5
	dc.w 277,12480,2
	dc.w 1,7360,6
	dc.w 243,2880,2
	dc.w 140,6560,4
	dc.w 112,16480,5
	dc.w 306,12160,3
	dc.w 18,9280,3
	dc.w 70,15520,1
	dc.w 60,9600,5
	dc.w 257,17280,3
	dc.w 176,16800,6
	dc.w 165,10720,5
	dc.w 89,11520,5
	dc.w 66,11040,2
	dc.w 5,8000,5
	dc.w 86,3360,5
	dc.w 99,0,4
	dc.w 300,2560,1
	dc.w 155,13440,4
	dc.w 28,10400,1
	dc.w 296,15040,1
	dc.w 133,3840,1
	dc.w 116,4640,6
	dc.w 200,4960,6
	dc.w 197,12800,5
	dc.w 305,7520,3
	dc.w 119,13760,2
	dc.w 85,960,3
	dc.w 13,14880,3
	dc.w 154,1600,4
	dc.w 172,1280,1
	dc.w 198,5120,3
	dc.w 116,13440,4
	dc.w 193,1760,2
	dc.w 197,16800,6
	dc.w 10,0,4
	dc.w 134,12320,6
	dc.w 169,15520,1
	dc.w 135,3360,5
	dc.w 4,10240,4
	dc.w 297,3040,4
	dc.w 285,6240,3
	dc.w 250,16160,6
	dc.w 95,5120,3
	dc.w 310,15520,1
	dc.w 179,15680,2
	dc.w 68,9280,3
	dc.w 14,15680,2
	dc.w 26,8640,3
	dc.w 246,12640,4
	dc.w 217,7200,1
	dc.w 79,17760,5
	dc.w 296,15360,4
	dc.w 287,16640,6
	dc.w 196,14080,6
	dc.w 131,12640,4
	dc.w 282,6240,3
	dc.w 169,14240,4
	dc.w 256,3840,1
	dc.w 55,15200,5
	dc.w 92,5120,3
	dc.w 98,16480,5
	dc.w 293,12000,2
	dc.w 135,160,6
	dc.w 216,8640,3
	dc.w 14,7680,2
	dc.w 215,4320,2
	dc.w 44,15520,1
	dc.w 28,640,2
	dc.w 309,17440,5
	dc.w 93,960,3
	dc.w 188,12320,6
	dc.w 219,9440,5
	dc.w 166,9920,4
	dc.w 200,7680,2
	dc.w 302,14240,4
	dc.w 246,16320,6
	dc.w 134,6080,1
	dc.w 90,5920,6
	dc.w 118,11840,6
	dc.w 120,16480,5
	dc.w 209,10560,3
	dc.w 123,6720,4
	dc.w 213,960,3
	dc.w 163,160,6
	dc.w 165,3840,1
	dc.w 115,8960,4
	dc.w 101,5760,4
	dc.w 289,4320,2
	dc.w 69,13280,2
	dc.w 67,2400,5
	dc.w 144,3680,4
	dc.w 30,1440,2
	dc.w 112,9920,4
	dc.w 126,13600,3
	dc.w 215,2240,6
	dc.w 44,3040,4
	dc.w 160,11520,5
	dc.w 256,17920,3
	dc.w 107,16000,2
	dc.w 47,9920,4
	dc.w 145,16640,6
	dc.w 205,14880,3
	dc.w 75,160,6
	dc.w 200,18400,4
	dc.w 27,10240,4
	dc.w 94,2880,2
	dc.w 51,1280,1
	dc.w 135,2880,2
	dc.w 34,9280,3
	dc.w 182,12000,2
	dc.w 189,7040,5
	dc.w 144,3520,1
	dc.w 290,3840,1
	dc.w 300,11360,5
	dc.w 290,0,4
	dc.w 249,17440,5
	dc.w 299,3040,4
	dc.w 49,18080,3
	dc.w 310,12000,2
	dc.w 308,15520,1
	dc.w 306,17920,3
	dc.w 194,14080,6
	dc.w 207,1760,2
	dc.w 98,9440,5
	dc.w 272,12320,6
	dc.w 69,2880,2
	dc.w 296,15520,1
	dc.w 69,960,3
	dc.w 84,6880,4
	dc.w 135,16960,4
	dc.w 188,13760,2
	dc.w 178,2400,5
	dc.w 308,8480,5
	dc.w 13,320,4
	dc.w 266,17600,4
	dc.w 215,2080,2
	dc.w 193,13280,2
	dc.w 188,16320,6
	dc.w 210,13280,2
	dc.w 220,6240,3
	dc.w 36,9120,6
	dc.w 203,6720,4
	dc.w 291,14400,2
	dc.w 70,3200,5
	dc.w 220,17600,4
	dc.w 10,8320,4
	dc.w 168,14880,3
	dc.w 155,11200,5
	dc.w 312,11680,3
	dc.w 246,4320,2
	dc.w 67,7680,2
	dc.w 90,7840,2
	dc.w 131,2720,3
	dc.w 238,16160,6
	dc.w 34,11680,3
	dc.w 82,2080,2
	dc.w 6,11840,6
	dc.w 192,4640,6
	dc.w 244,14080,6
	dc.w 252,8000,5
	dc.w 257,8160,6
	dc.w 132,7680,2
	dc.w 28,7520,3
	dc.w 263,6720,4
	dc.w 141,10720,5
	dc.w 70,10080,5
	dc.w 231,15040,1
	dc.w 257,960,3
	dc.w 17,3680,4
	dc.w 281,12800,5
	dc.w 213,1120,5
	dc.w 230,15200,5
	dc.w 227,2720,3
	dc.w 95,18400,4
	dc.w 155,9120,6
	dc.w 194,10240,4
	dc.w 79,4480,4
	dc.w 307,1920,3
	dc.w 191,15840,2
	dc.w 26,11360,5
	dc.w 21,160,6
	dc.w 10,6560,4
	dc.w 153,18240,4
	dc.w 192,12000,2
	dc.w 22,4800,6
	dc.w 11,17760,5
	dc.w 203,160,6
	dc.w 32,16480,5
	dc.w 242,15840,2
	dc.w 160,17280,3
	dc.w 264,5760,4
	dc.w 172,2720,3
	dc.w 151,5920,6
	dc.w 137,2560,1
	dc.w 310,12160,3
	dc.w 253,11200,5
	dc.w 156,13120,1
	dc.w 161,6560,4
	dc.w 109,4160,6
	dc.w 58,15040,1
	dc.w 85,5120,3
	dc.w 52,13600,3
	dc.w 208,8960,4
	dc.w 189,7040,5
	dc.w 2,8160,6
	dc.w 318,8800,2
	dc.w 282,12320,6
	dc.w 188,4480,4
	dc.w 230,15040,1
	dc.w 36,2880,2
	dc.w 278,17120,3
	dc.w 22,17280,3
	dc.w 131,10720,5
	dc.w 4,6080,1
	dc.w 6,4000,6
	dc.w 269,4000,6
	dc.w 29,14400,2
	dc.w 276,14720,4
	dc.w 196,8160,6
	dc.w 157,8480,5
	dc.w 74,6560,4
	dc.w 42,10560,3
	dc.w 118,9120,6
	dc.w 260,0,4
	dc.w 27,18240,4
	dc.w 39,10400,1
	dc.w 164,14400,2
	dc.w 318,10080,5
	dc.w 244,13120,1
	dc.w 6,1600,4
	dc.w 282,16320,6
	dc.w 238,8000,5
	dc.w 68,3360,5
	dc.w 18,14400,2
	dc.w 131,3520,1
	dc.w 251,9600,5
	dc.w 121,480,1
	dc.w 31,9120,6
	dc.w 313,14240,4
	dc.w 165,11360,5
	dc.w 58,9440,5
	dc.w 224,12320,6
	dc.w 54,11200,5
	dc.w 307,10560,3
	dc.w 232,17600,4
	dc.w 18,3360,5
	dc.w 59,16480,5
	dc.w 295,6400,1
	dc.w 241,12960,6
	dc.w 72,13120,1
	dc.w 277,4000,6
	dc.w 47,6880,4
	dc.w 87,1920,3
	dc.w 5,11680,3
	dc.w 159,4160,6
	dc.w 0,10400,1
	dc.w 164,6720,4
	dc.w 18,16480,5
	dc.w 133,4320,2
	dc.w 306,2720,3
	dc.w 109,18240,4
	dc.w 241,16320,6
	dc.w 159,14880,3
	dc.w 85,17600,4
	dc.w 108,5280,4
	dc.w 242,6080,1
	dc.w 59,12480,2
	dc.w 44,12800,5
	dc.w 265,7840,2
	dc.w 124,10880,1
	dc.w 9,10560,3
	dc.w 9,3360,5
	dc.w 245,4480,4
	dc.w 182,14240,4
	dc.w 142,7200,1
	dc.w 106,11040,2
	dc.w 72,3360,5
	dc.w 317,4640,6
	dc.w 143,12000,2
	dc.w 102,6560,4
	dc.w 245,13440,4
	dc.w 108,6880,4
	dc.w 104,4480,4
	dc.w 239,2080,2
	dc.w 98,5920,6
	dc.w 53,2080,2
	dc.w 66,14560,2
	dc.w 179,12800,5
	dc.w 198,5440,6
	dc.w 161,6880,4
	dc.w 108,5600,5
	dc.w 170,1120,5
	dc.w 193,7040,5
	dc.w 94,6240,3
	dc.w 256,8160,6
	dc.w 167,15360,4
	dc.w 11,5600,5
	dc.w 276,8000,5
	dc.w 113,2400,5
	dc.w 63,1280,1
	dc.w 139,3360,5
	dc.w 216,4960,6
	dc.w 76,7520,3
	dc.w 306,14720,4
	dc.w 226,5120,3
	dc.w 193,7200,1
	dc.w 205,1280,1
	dc.w 197,16000,2
	dc.w 218,12800,5
	dc.w 102,5120,3
	dc.w 65,15200,5
	dc.w 128,3040,4
	dc.w 122,3040,4
	dc.w 301,9760,3
	dc.w 179,1280,1
	dc.w 236,12480,2
	dc.w 167,12000,2
	dc.w 102,1760,2
	dc.w 318,14240,4
	dc.w 95,12800,5
	dc.w 27,17120,3
	dc.w 30,9280,3
	dc.w 231,7200,1
	dc.w 208,5600,5
	dc.w 96,8000,5
	dc.w 183,2720,3
	dc.w 261,11360,5
	dc.w 239,4480,4
	dc.w 294,15520,1
	dc.w 197,1440,2
	dc.w 271,3040,4
	dc.w 262,480,1
	dc.w 145,11840,6
	dc.w 151,13760,2
	dc.w 242,16320,6
	dc.w 158,5920,6
	dc.w 6,7040,5
	dc.w 290,13440,4
	dc.w 205,960,3
	dc.w 264,14560,2
	dc.w 172,10080,5
	dc.w 253,12320,6
	dc.w 18,3200,5
	dc.w 76,17440,5
	dc.w 80,10080,5
	dc.w 256,14400,2
	dc.w 285,12000,2
	dc.w 152,8480,5
	dc.w 33,14720,4
	dc.w 44,10240,4
	dc.w 20,9280,3
	dc.w 15,7520,3
	dc.w 181,11680,3
	dc.w 268,10720,5
	dc.w 274,480,1
	dc.w 158,1760,2
	dc.w 240,4160,6
	dc.w 31,12160,3
	dc.w 162,11200,5
	dc.w 41,6240,3
	dc.w 278,9120,6
	dc.w 64,14720,4
	dc.w 74,16000,2
	dc.w 253,6560,4
	dc.w 97,5920,6
	dc.w 279,3680,4
	dc.w 182,14560,2
	dc.w 41,11680,3
	dc.w 70,12480,2
	dc.w 219,17920,3
	dc.w 102,8160,6
	dc.w 261,3680,4
	dc.w 48,12960,6
	dc.w 70,1280,1
	dc.w 296,7200,1
	dc.w 242,7200,1
	dc.w 305,7200,1
	dc.w 187,17600,4
	dc.w 311,5440,6
	dc.w 64,13120,1
	dc.w 100,4000,6
	dc.w 105,6720,4
	dc.w 108,9440,5
	dc.w 223,4000,6
	dc.w 245,1280,1
	dc.w 101,13760,2
	dc.w 80,2240,6
	dc.w 159,1920,3
	dc.w 124,12320,6
	dc.w 128,960,3
	dc.w 27,7040,5
	dc.w 254,14880,3
	dc.w 255,8960,4
	dc.w 290,16480,5
	dc.w 33,1120,5
	dc.w 235,6080,1
	dc.w 169,8000,5
	dc.w 313,2560,1
	dc.w 275,10240,4
	dc.w 34,18400,4
	dc.w 238,7680,2
	dc.w 19,18400,4
	dc.w 286,8800,2
	dc.w 128,5280,4
	dc.w 306,2560,1
	dc.w 300,2240,6
	dc.w 205,13280,2
	dc.w 136,4160,6
	dc.w 255,11360,5
	dc.w 179,16960,4
	dc.w 252,10560,3
	dc.w 0,15040,1
	dc.w 116,16320,6
	dc.w 276,16160,6
	dc.w 108,3200,5
	dc.w 63,17120,3
	dc.w 234,8640,3
	dc.w 135,18240,4
	dc.w 159,17600,4
	dc.w 292,160,6
	dc.w 98,10080,5
	dc.w 268,11360,5
	dc.w 196,17120,3
	dc.w 126,7200,1
	dc.w 91,16320,6
	dc.w 210,2560,1
	dc.w 81,9120,6
	dc.w 131,7040,5
	dc.w 101,14080,6
	dc.w 59,13600,3
	dc.w 80,960,3
	dc.w 134,8480,5
	dc.w 313,9440,5
	dc.w 197,5920,6
	dc.w 111,12000,2
	dc.w 88,10240,4
	dc.w 22,6080,1
	dc.w 302,7040,5
	dc.w 21,17440,5
	dc.w 140,12000,2
	dc.w 204,17600,4
	dc.w 33,2560,1
	dc.w 138,12320,6
	dc.w 61,13760,2
	dc.w 41,14560,2
	dc.w 134,5440,6
	dc.w 31,0,4
	dc.w 225,4160,6
	dc.w 117,1280,1
	dc.w 287,16640,6
	dc.w 278,13760,2
	dc.w 16,14400,2
	dc.w 203,9120,6
	dc.w 97,3360,5
	dc.w 216,13440,4
	dc.w 125,2240,6
	dc.w 165,10080,5
	dc.w 176,800,3
	dc.w 219,13440,4
	dc.w 228,9120,6
	dc.w 146,2400,5
	dc.w 171,5120,3
	dc.w 102,6400,1
	dc.w 311,10560,3
	dc.w 185,16960,4
	dc.w 25,18400,4
	dc.w 18,15840,2
	dc.w 234,12160,3
	dc.w 148,14720,4
	dc.w 126,12000,2
	dc.w 147,11040,2
	dc.w 255,3680,4
	dc.w 306,16640,6
	dc.w 194,3840,1
	dc.w 246,16640,6
	dc.w 255,1120,5
	dc.w 256,7840,2
	dc.w 40,320,4
	dc.w 292,13120,1
	dc.w 155,800,3
	dc.w 101,18240,4
	dc.w 92,5120,3
	dc.w 11,13760,2
	dc.w 129,2240,6
	dc.w 236,11680,3
	dc.w 313,1120,5
	dc.w 192,7520,3
	dc.w 167,5440,6
	dc.w 151,5440,6
	dc.w 174,16000,2
	dc.w 43,2560,1
	dc.w 49,1440,2
	dc.w 115,3680,4
	dc.w 235,3680,4
	dc.w 19,10080,5
	dc.w 144,9920,4
	dc.w 149,5280,4
	dc.w 29,5760,4
	dc.w 141,10080,5
	dc.w 216,9280,3
	dc.w 100,1280,1
	dc.w 231,4960,6
	dc.w 250,11360,5
	dc.w 261,11840,6
	dc.w 19,0,4
	dc.w 58,17920,3
	dc.w 124,6720,4
	dc.w 151,10560,3
	dc.w 94,160,6
	dc.w 118,8800,2
	dc.w 36,160,6
	dc.w 23,1760,2
	dc.w 288,11680,3
	dc.w 242,3680,4
	dc.w 215,12960,6
	dc.w 168,4000,6
	dc.w 31,2400,5
	dc.w 289,3200,5
	dc.w 165,18400,4
	dc.w 153,10880,1
	dc.w 136,4640,6
	dc.w 36,0,4
	dc.w 216,10080,5
	dc.w 182,2080,2
	dc.w 151,4960,6
	dc.w 213,800,3
	dc.w 32,8640,3
	dc.w 269,9440,5
	dc.w 293,7520,3
	dc.w 111,2560,1
	dc.w 13,6400,1
	dc.w 186,16320,6
	dc.w 47,14400,2
	dc.w 115,1440,2
	dc.w 176,13760,2
	dc.w 186,11680,3
	dc.w 165,3040,4
	dc.w 44,10080,5
	dc.w 306,2400,5
	dc.w 271,2240,6
	dc.w 104,1920,3
	dc.w 223,11200,5
	dc.w 299,3200,5
	dc.w 246,9920,4
	dc.w 155,14080,6
	dc.w 41,12960,6
	dc.w 215,17920,3
	dc.w 1,9440,5
	dc.w 281,8000,5
	dc.w 264,7040,5
	dc.w 70,2400,5
	dc.w 30,640,2
	dc.w 142,10560,3
	dc.w 88,16000,2
	dc.w 197,1760,2
	dc.w 164,480,1
	dc.w 313,320,4
	dc.w 15,13120,1
	dc.w 139,13920,5
	dc.w 145,14560,2
	dc.w 197,15840,2
	dc.w 251,10240,4
	dc.w 203,17120,3
	dc.w 145,8000,5
	dc.w 266,8480,5
	dc.w 94,7360,6
	dc.w 10,13920,5
	dc.w 253,15040,1
	dc.w 95,17440,5
	dc.w 70,17600,4
	dc.w 170,9600,5
	dc.w 171,3200,5
	dc.w 200,11200,5
	dc.w 247,12480,2
	dc.w 237,2400,5
	dc.w 103,13760,2
	dc.w 49,13600,3
	dc.w 316,12480,2
	dc.w 76,2880,2
	dc.w 207,16320,6
	dc.w 129,14400,2
	dc.w 149,3680,4
	dc.w 3,13280,2
	dc.w 80,14400,2
	dc.w 214,10080,5
	dc.w 287,10400,1
	dc.w 174,12960,6
	dc.w 19,7520,3
	dc.w 115,10240,4
	dc.w 291,9920,4
	dc.w 129,7360,6
	dc.w 148,8640,3
	dc.w 218,8000,5
	dc.w 220,13280,2
	dc.w 185,2080,2
	dc.w 215,2560,1
	dc.w 307,15200,5
	dc.w 243,6560,4
	dc.w 25,4000,6
	dc.w 306,18400,4
	dc.w 52,16000,2
	dc.w 94,11680,3
	dc.w 203,2880,2
	dc.w 178,13760,2
	dc.w 277,800,3
	dc.w 32,4800,6
	dc.w 14,8960,4
	dc.w 163,9280,3
	dc.w 222,14880,3
	dc.w 104,8160,6
	dc.w 70,12640,4
	dc.w 300,13920,5
	dc.w 50,16000,2
	dc.w 157,16800,6
	dc.w 233,3200,5
	dc.w 104,13120,1
	dc.w 208,7200,1
	dc.w 300,10080,5
	dc.w 209,5600,5
	dc.w 91,3520,1
	dc.w 98,9120,6
	dc.w 44,13280,2
	dc.w 308,800,3
	dc.w 133,15200,5
	dc.w 61,4320,2
	dc.w 197,11680,3
	dc.w 243,13280,2
	dc.w 297,5280,4
	dc.w 299,6560,4
	dc.w 51,10880,1
	dc.w 177,320,4
	dc.w 288,9280,3
	dc.w 251,9280,3
	dc.w 55,16640,6
	dc.w 7,3520,1
	dc.w 205,1600,4
	dc.w 166,7520,3
	dc.w 115,10880,1
	dc.w 247,15200,5
	dc.w 156,1600,4
	dc.w 64,8800,2
	dc.w 229,15520,1
	dc.w 109,640,2
	dc.w 72,12960,6
	dc.w 240,4480,4
	dc.w 199,15840,2
	dc.w 175,8320,4
	dc.w 273,12480,2
	dc.w 16,4960,6
	dc.w 37,12960,6
	dc.w 53,11040,2
	dc.w 25,1440,2
	dc.w 282,8480,5
	dc.w 272,4480,4
	dc.w 286,17440,5
	dc.w 96,3680,4
	dc.w 40,960,3
	dc.w 236,9920,4
	dc.w 3,2880,2
	dc.w 27,6400,1
	dc.w 220,7200,1
	dc.w 131,11040,2
	dc.w 292,7840,2
	dc.w 292,12160,3
	dc.w 312,14400,2
	dc.w 120,2720,3
	dc.w 151,160,6
	dc.w 163,4320,2
	dc.w 75,14080,6
	dc.w 221,11360,5
	dc.w 15,13600,3
	dc.w 182,18240,4
	dc.w 113,15840,2
	dc.w 205,12640,4
	dc.w 197,12800,5
	dc.w 256,5120,3
	dc.w 146,1760,2
	dc.w 72,14400,2
	dc.w 52,2720,3
	dc.w 109,2560,1
	dc.w 273,13440,4
	dc.w 199,2880,2
	dc.w 164,7040,5
	dc.w 8,1280,1
	dc.w 269,13440,4
	dc.w 282,12960,6
	dc.w 227,9280,3
	dc.w 21,2080,2
	dc.w 34,2560,1
	dc.w 34,4480,4
	dc.w 146,14080,6
	dc.w 226,14240,4
	dc.w 149,6080,1
	dc.w 92,4320,2
	dc.w 134,16960,4
	dc.w 35,4800,6
	dc.w 220,9600,5
	dc.w 301,4480,4
	dc.w 67,11040,2
	dc.w 94,16640,6
	dc.w 8,17280,3
	dc.w 302,13120,1
	dc.w 100,4000,6
	dc.w 262,12160,3
	dc.w 236,10240,4
	dc.w 154,800,3
	dc.w 57,5280,4
	dc.w 36,480,1
	dc.w 42,5440,6
	dc.w 196,17600,4
	dc.w 227,9120,6
	dc.w 161,14560,2
	dc.w 147,8960,4
	dc.w 91,14400,2
	dc.w 30,6400,1
	dc.w 129,6080,1
	dc.w 32,2720,3
	dc.w 170,12000,2
	dc.w 13,12160,3
	dc.w 56,12160,3
	dc.w 199,0,4
	dc.w 313,8480,5
	dc.w 62,8320,4
	dc.w 252,15360,4
	dc.w 57,11360,5
	dc.w 177,16320,6
	dc.w 150,15680,2
	dc.w 310,18400,4
	dc.w 270,13120,1
	dc.w 89,6240,3
	dc.w 267,7040,5
	dc.w 127,4960,6
	dc.w 119,9120,6
	dc.w 11,15360,4
	dc.w 308,1440,2
	dc.w 172,5600,5
	dc.w 67,2080,2
	dc.w 22,5440,6
	dc.w 202,800,3
	dc.w 130,3040,4
	dc.w 193,15360,4
	dc.w 122,13120,1
	dc.w 223,13440,4
	dc.w 110,17280,3
	dc.w 195,7360,6
	dc.w 52,7680,2
	dc.w 315,13440,4
	dc.w 21,4480,4
	dc.w 163,9760,3
	dc.w 37,4480,4
	dc.w 208,8960,4
	dc.w 237,11520,5
	dc.w 62,3040,4
	dc.w 302,17760,5
	dc.w 112,18080,3
	dc.w 102,15040,1
	dc.w 318,3360,5
	dc.w 226,6400,1
	dc.w 126,1440,2
	dc.w 83,3680,4
	dc.w 113,6400,1
	dc.w 42,3520,1
	dc.w 1,4320,2
	dc.w 14,3040,4
	dc.w 312,6880,4
	dc.w 213,4320,2
	dc.w 158,15040,1
	dc.w 266,6080,1
	dc.w 287,10720,5
	dc.w 62,3520,1
	dc.w 259,7680,2
	dc.w 174,4160,6
	dc.w 177,7040,5
	dc.w 59,5440,6
	dc.w 314,12160,3
	dc.w 202,16160,6
	dc.w 174,800,3
	dc.w 7,17440,5
	dc.w 314,6720,4
	dc.w 236,16640,6
	dc.w 289,6880,4
	dc.w 298,9920,4
	dc.w 50,14720,4
	dc.w 245,3040,4
	dc.w 72,2720,3
	dc.w 207,15840,2
	dc.w 261,4160,6
	dc.w 60,17760,5
	dc.w 41,9760,3
	dc.w 1,0,4
	dc.w 158,12640,4
	dc.w 43,800,3
	dc.w 26,17280,3
	dc.w 86,17280,3
	dc.w 288,480,1
	dc.w 118,18080,3
	dc.w 134,15520,1
	dc.w 175,9600,5
	dc.w 239,6880,4
	dc.w 311,17280,3
	dc.w 197,16800,6
	dc.w 4,16320,6
	dc.w 160,13600,3
	dc.w 156,12320,6
	dc.w 80,1920,3
	dc.w 135,5600,5
	dc.w 257,9920,4
	dc.w 41,8320,4
	dc.w 18,6400,1
	dc.w 94,11840,6
	dc.w 238,1440,2
	dc.w 245,13120,1
	dc.w 98,960,3
	dc.w 27,7520,3
	dc.w 310,15680,2
	dc.w 118,14880,3
	dc.w 224,18400,4
	dc.w 225,15040,1
	dc.w 84,9920,4
	dc.w 164,17120,3
	dc.w 8,1440,2
	dc.w 84,4000,6
	dc.w 267,9440,5
	dc.w 19,17760,5
	dc.w 149,16960,4
	dc.w 61,1760,2
	dc.w 115,1280,1
	dc.w 122,14400,2
	dc.w 304,17920,3
	dc.w 129,8800,2
	dc.w 174,7200,1
	dc.w 61,8000,5
	dc.w 160,16640,6
	dc.w 253,1920,3
	dc.w 245,11040,2
	dc.w 198,16000,2
	dc.w 186,2240,6
	dc.w 97,2880,2
	dc.w 305,12640,4
	dc.w 208,7840,2
	dc.w 127,9280,3
	dc.w 205,9760,3
	dc.w 153,4640,6
	dc.w 35,11520,5
	dc.w 163,7680,2

	