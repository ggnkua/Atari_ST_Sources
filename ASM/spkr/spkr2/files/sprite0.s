*
*  NEOchrome V2.24 cut buffer contents (left justified):
*  by Chaos, Inc. of the Delta Force (member of The Union)
*
*    pixels/scanline    = $0020 (bytes/scanline: $0010)
*  # scanlines (height) = $0010
*
*  Hardware color pallet  (color 0 to 15):
*
spritepallete:
      	dc.w	  $0000,$0000,$0210,$0210,$0420,$0420,$0641,$0641
		dc.w      $0752,$0752,$0763,$0763,$0774,$0774,$0776,$0776
*
*
sprite0_0:
		dc.w	$0000,$0660,$0180,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$15D8,$0C60,$0380,$0000,$0000,$0000,$0000
		dc.w	$0000,$27EC,$1030,$0FC0,$0000,$0000,$0000,$0000
		dc.w	$0000,$4876,$2798,$1FE0,$0000,$0000,$0000,$0000
		dc.w	$0000,$172A,$4FCC,$3FF0,$0000,$0000,$0000,$0000
		dc.w	$0000,$EF49,$5FAE,$3FF0,$0000,$0000,$0000,$0000
		dc.w	$0000,$AEB3,$1F54,$7FE8,$0000,$0000,$0000,$0000
		dc.w	$0000,$6D69,$9EAE,$7FD0,$0000,$0000,$0000,$0000
		dc.w	$0000,$62D3,$9D5C,$7FA0,$0000,$0000,$0000,$0000
		dc.w	$0000,$F5AD,$4ABA,$3F40,$0000,$0000,$0000,$0000
		dc.w	$0000,$BB5A,$6574,$1E80,$0000,$0000,$0000,$0000
		dc.w	$0000,$52B6,$32E8,$0D00,$0000,$0000,$0000,$0000
		dc.w	$0000,$6D6C,$1DD0,$0200,$0000,$0000,$0000,$0000
		dc.w	$0000,$3058,$0FA0,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$1AB0,$0540,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$07C0,$0000,$0000,$0000,$0000,$0000,$0000
				
sprite1_0:
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0080,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0520,$0340,$0080,$0000,$0000,$0000,$0000
		dc.w	$0000,$0C10,$0420,$03C0,$0000,$0000,$0000,$0000
		dc.w	$0000,$1B88,$0810,$07E0,$0000,$0000,$0000,$0000
		dc.w	$0000,$3454,$1398,$0FE0,$0000,$0000,$0000,$0000
		dc.w	$0000,$18B4,$3718,$0FE0,$0000,$0000,$0000,$0000
		dc.w	$0000,$094E,$2618,$1FE0,$0000,$0000,$0000,$0000
		dc.w	$0000,$4ADC,$2470,$1F80,$0000,$0000,$0000,$0000
		dc.w	$0000,$25B2,$00E8,$1F00,$0000,$0000,$0000,$0000
		dc.w	$0000,$2264,$10D0,$0F00,$0000,$0000,$0000,$0000
		dc.w	$0000,$16C8,$0FA0,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0990,$0740,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$07A0,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0140,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		
sprite2_0:
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0400,$0380,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$04A0,$0CC0,$0300,$0000,$0000,$0000,$0000
		dc.w	$0000,$0A50,$1860,$0780,$0000,$0000,$0000,$0000
		dc.w	$0000,$3710,$1060,$0F80,$0000,$0000,$0000,$0000
		dc.w	$0000,$0EB0,$20C0,$1F00,$0000,$0000,$0000,$0000
		dc.w	$0000,$0570,$2180,$1E00,$0000,$0000,$0000,$0000
		dc.w	$0000,$12A0,$3340,$0C00,$0000,$0000,$0000,$0000
		dc.w	$0000,$0950,$1E80,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$13A0,$0C00,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0F40,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000		
		
sprite_mask0:
		dc.w	$F81F,$F81F,$F81F,$F81F,$FFFF,$FFFF,$FFFF,$FFFF
		dc.w	$E007,$E007,$E007,$E007,$FFFF,$FFFF,$FFFF,$FFFF
		dc.w	$C003,$C003,$C003,$C003,$FFFF,$FFFF,$FFFF,$FFFF
		dc.w	$8001,$8001,$8001,$8001,$FFFF,$FFFF,$FFFF,$FFFF
		dc.w	$8001,$8001,$8001,$8001,$FFFF,$FFFF,$FFFF,$FFFF
		dc.w	$0000,$0000,$0000,$0000,$FFFF,$FFFF,$FFFF,$FFFF
		dc.w	$0000,$0000,$0000,$0000,$FFFF,$FFFF,$FFFF,$FFFF
		dc.w	$0000,$0000,$0000,$0000,$FFFF,$FFFF,$FFFF,$FFFF
		dc.w	$0000,$0000,$0000,$0000,$FFFF,$FFFF,$FFFF,$FFFF
		dc.w	$0000,$0000,$0000,$0000,$FFFF,$FFFF,$FFFF,$FFFF
		dc.w	$0001,$0001,$0001,$0001,$FFFF,$FFFF,$FFFF,$FFFF
		dc.w	$8001,$8001,$8001,$8001,$FFFF,$FFFF,$FFFF,$FFFF
		dc.w	$8003,$8003,$8003,$8003,$FFFF,$FFFF,$FFFF,$FFFF
		dc.w	$C007,$C007,$C007,$C007,$FFFF,$FFFF,$FFFF,$FFFF
		dc.w	$E00F,$E00F,$E00F,$E00F,$FFFF,$FFFF,$FFFF,$FFFF
		dc.w	$F83F,$F83F,$F83F,$F83F,$FFFF,$FFFF,$FFFF,$FFFF