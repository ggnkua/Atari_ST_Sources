----------------------------------------
|				       |
|				       |
|				       |
|				       |
|	A	DDDDDD	  RRRRRR       |
|      A A	 D    D   R     R      |
|     A   A	 D    D   R     R      |
|    A     A	 D    D   RRRRRR       |
|    AAAAAAA	 D    D   R   R	       |
|    A     A	 D    D   R    R       |
|    A     A	DDDDDD    R     R      |
|				       |
|				       |
|	     333333  555555	       |
|		 3   5		       |
|		3    5		       |
|		 3    5555	       |
|		  3	  5	       |
|	     33333   55555	       |
|				       |
|				       |
|				       |
|				       |
|				       |
|				       |
|				       |
----------------------------------------^



----------------------------------------
|    WELCOME TO ADRENALIN UK DISK 35   |
----------------------------------------

		CREDITS:

	     MENU CODED BY:

	     SPACEMAN SPIFF


	       MUSIC BY:

	      MUSIC MAKER

----------------------------------------^


----------------------------------------
		1: GAME 1

		2: TITLE 2

		3: ANOTHER TITLE

		4: TITLE NUMBER 4

		5: NUMBER 5 HERE

		6: WOT NUMBER 6?

		7: SEVEN IS ALIVE!

		8: THIS MUST BE A FILLER

		9: COPIER?
----------------------------------------^
THIS TEXT SHOULD BE HIGHER CASE AND CAN
INCLUDE TAB. THE ONLY THING YOU SHOULD
REMEMBER IS THAT THE PAGE OF TEXT MUST
END IN A 'TO THE SIGN OF' CHARACTER (THE
ONE ON SHIFT 6!

YOU CAN HAVE 28 LINES PER PAGE AND AS
MANY PAGES AS MEMORY WILL ALLOW.

YOU CAN ALTER THE TIME THE TEXT STAYS ON
SCREEN BY CHANGING AN EQUATE AT THE
START OF THE CODE.

       ....   ...  .   .   ..
       .   . .   . .   .   ..
       .   . .   . .   .   ..
       ....  .   . .   .   ..
       .     .   .  . .
       .      ...    .     ..
----------------------------------------^






----------------------------------------
	     CONTACT ADR AT:

	       ADRENALIN UK
		THE STREET
		 THE TOWN
		  COUNTY
		 POST CODE
		 ENGLAND

----------------------------------------^
WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP
WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP
WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP
WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP
WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP
WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP
WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP
WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP
WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP
WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP
WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP
WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP
WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP
WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP
WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP
WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP
WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP
WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP
WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP
WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP
WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP
WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP
WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP
WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP
WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP
WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP
WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP
WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP,WRAP!
----------------------------------------^
