[\\\\\\\\\\\\\\\\\\]
}                  &
}  SPACEMAN SPIFF  &
}                  &
}     PRESENTS     &
}                  &
}   ADRENALIN UK   &
}                  &
}     DISC 40      &
}                  &
}                  &
{``````````````````_^
[\\\\\\\\\\\\\\\\\\]
}      4    0000   &
}     44   0	0  &
}    4 4   0	0  &
}   4  4   0    0  &
}  444444  0    0  &
}      4    0000   &
}		   &
}		   &
}		   &
}		   &
{``````````````````_^
[\\\\\\\\\\\\\\\\\\]
}  ADR UK DISK 40  &
{``````````````````_

      CREDITS:

   MENU CODED BY:

   SPACEMAN SPIFF


dddddddddddddddddddd^
     1: GAME 1

     2: TITLE 2

  3: ANOTHER TITLE

  4: TITLE NUMBER 4

  5: NUMBER 5 HERE

  6: WOT NUMBER 6?
    7: COPIER?^


THIS TEXT CAN BE
HIGHER OR LOWER CASE
AND INCLUDE TAB. THE
   ONLY THING TO
REMEMBER IS THAT THE
PAGE OF TEXT MUST
END IN A 'TO THE
SIGN OF' CHARACTER
(THE ONE ON SHIFT 6!^
  YOU CAN HAVE 12
LINES PER PAGE AND
AS MANY PAGES AS
MEMORY WILL ALLOW.

YOU CAN ALTER THE
TIME THE TEXT STAYS
   ON SCREEN BY
CHANGING AN EQUATE
AT THE START OF THE
CODE.
````````````````````^


\\\\\\\\\\\\\\\\\\\\
   CONTACT ADR AT:

    ADRENALIN UK
     THE STREET
      THE TOWN
       COUNTY
      POST CODE
       ENGLAND
````````````````````^
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,^
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP!
^
