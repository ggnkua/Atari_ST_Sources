[\\\\\\\\\\\\\\\\\\]
}                  &
}  SPACEMAN SPIFF  &
}                  &
}     PRESENTS     &
}                  &
}   ADRENALIN UK   &
}                  &
}     DISC 35      &
}                  &
}                  &
}                  &
}                  &
}                  &
}                  &
}                  &
{``````````````````_^
[\\\\\\\\\\\\\\\\\\]
}  333333  555555  &
}      3   5	   &
}     3    5	   &
}      3    5555   &
}       3       5  &
}  33333   55555   &
}		   &
}		   &
}		   &
}		   &
}		   &
}		   &
}		   &
{``````````````````_^

[\\\\\\\\\\\\\\\\\\]
}  ADR UK DISK 35  &
{``````````````````_

      CREDITS:

   MENU CODED BY:

   SPACEMAN SPIFF


      MUSIC BY:

     Donald Fakk^
     1: GAME 1

     2: TITLE 2

  3: ANOTHER TITLE

  4: TITLE NUMBER 4

  5: NUMBER 5 HERE

  6: WOT NUMBER 6?

  7: SEVEN IS ALIVE!

8: MUST BE A FILLER

    9: COPIER?^


THIS TEXT CAN BE
HIGHER OR LOWER CASE
AND INCLUDE TAB. THE
   ONLY THING TO
REMEMBER IS THAT THE
PAGE OF TEXT MUST
END IN A 'TO THE
SIGN OF' CHARACTER
(THE ONE ON SHIFT 6!^


  YOU CAN HAVE 17
LINES PER PAGE AND
AS MANY PAGES AS
MEMORY WILL ALLOW.

YOU CAN ALTER THE
TIME THE TEXT STAYS
   ON SCREEN BY
CHANGING AN EQUATE
AT THE START OF THE
CODE.

````````````````````^


\\\\\\\\\\\\\\\\\\\\
   CONTACT ADR AT:

    ADRENALIN UK
     THE STREET
      THE TOWN
       COUNTY
      POST CODE
       ENGLAND
````````````````````^
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,^

WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP,
WRAP,WRAP,WRAP,WRAP!
^
