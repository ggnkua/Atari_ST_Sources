; This source code is generated!
; It's the blitter fullscreen rendering part of a 4KiB Atari STE intro
; ( https://www.pouet.net/prod.php?which=97530 )
; It's also part of a blog post "Graphics Tricks from Boomers"
; ( https://arnaud-carre.github.io/ ) 


; Raster line 0 [0]
; -------------- Clear mask buffer -----------
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#$00e0,$ffff8a30.w	; [16 cycle]
	move.w	#$0001,$ffff8a36.w	; [16 cycle]
	move.w	#$0200,$ffff8a3a.w	; [16 cycle]
	move.w	m_maskBuffer(a6),$ffff8a32.w	; [20 cycle]
	move.w	m_currentClearOffset(a6),d1	; [12 cycle]
	; bitplan #0
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#61,(a2)	; set blitter line count to 61	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [260 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#3,(a2)	; set blitter line count to 3	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [28 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#3,(a2)	; set blitter line count to 3	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [28 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 1 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#61,(a2)	; set blitter line count to 61	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [260 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#12,(a2)	; set blitter line count to 12	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [64 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#21,(a2)	; set blitter line count to 21	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 2 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#31,(a2)	; set blitter line count to 31	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [140 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#42,(a2)	; set blitter line count to 42	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [184 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#21,(a2)	; set blitter line count to 21	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 3 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#1,(a2)	; set blitter line count to 1	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [20 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#64,(a2)	; set blitter line count to 64	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [272 cycle]
; -------------- Draw N-1 sprites in mask buffer -----------
	move.w	m_preshiftedMasks(a6),$ffff8a24.w	; [20 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#$0207,$ffff8a3a.w	; [16 cycle]
	move.w	(a0)+,d1		; dst	; [8 cycle]
	move.w	(a0)+,d0		; src	; [8 cycle]
	move.w	#$000a,$ffff8a22.w	; [16 cycle]
	moveq	#-8,d2	; [4 cycle]
	; bitplan #0
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#29,(a2)	; set blitter line count to 29	; [12 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
; Raster line 4 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	d7,(a3)	; run blitter	; [364 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 5 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#4,(a2)	; set blitter line count to 4	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [64 cycle]
	nop	; [4 cycle]
; Raster line 6 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 7 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#27,(a2)	; set blitter line count to 27	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [340 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
; Raster line 8 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 9 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#24,(a2)	; set blitter line count to 24	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [304 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#6,(a2)	; set blitter line count to 6	; [12 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	d7,(a3)	; run blitter	; [88 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 10 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 11 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#23,(a2)	; set blitter line count to 23	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [292 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#8,(a2)	; set blitter line count to 8	; [12 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	d7,(a3)	; run blitter	; [112 cycle]
; Raster line 12 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 13 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#23,(a2)	; set blitter line count to 23	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [292 cycle]
	move.w	(a0)+,d1		; dst	; [8 cycle]
	move.w	(a0)+,d0		; src	; [8 cycle]
	; bitplan #0
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#8,(a2)	; set blitter line count to 8	; [12 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	d7,(a3)	; run blitter	; [112 cycle]
; Raster line 14 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 15 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#21,(a2)	; set blitter line count to 21	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [268 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#2,(a2)	; set blitter line count to 2	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [40 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 16 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 17 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#22,(a2)	; set blitter line count to 22	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [280 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#1,(a2)	; set blitter line count to 1	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [28 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 18 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 19 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#23,(a2)	; set blitter line count to 23	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [292 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#8,(a2)	; set blitter line count to 8	; [12 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	d7,(a3)	; run blitter	; [112 cycle]
; Raster line 20 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 21 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#21,(a2)	; set blitter line count to 21	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [268 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#2,(a2)	; set blitter line count to 2	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [40 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 22 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 23 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#22,(a2)	; set blitter line count to 22	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [280 cycle]
	move.w	(a0)+,d1		; dst	; [8 cycle]
	move.w	(a0)+,d0		; src	; [8 cycle]
	; bitplan #0
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#8,(a2)	; set blitter line count to 8	; [12 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	d7,(a3)	; run blitter	; [112 cycle]
; Raster line 24 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 25 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#23,(a2)	; set blitter line count to 23	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [292 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#8,(a2)	; set blitter line count to 8	; [12 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	d7,(a3)	; run blitter	; [112 cycle]
; Raster line 26 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 27 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#21,(a2)	; set blitter line count to 21	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [268 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#2,(a2)	; set blitter line count to 2	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [40 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 28 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 29 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#22,(a2)	; set blitter line count to 22	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [280 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#1,(a2)	; set blitter line count to 1	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [28 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 30 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 31 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#23,(a2)	; set blitter line count to 23	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [292 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#8,(a2)	; set blitter line count to 8	; [12 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	d7,(a3)	; run blitter	; [112 cycle]
; Raster line 32 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 33 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#21,(a2)	; set blitter line count to 21	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [268 cycle]
	move.w	(a0)+,d1		; dst	; [8 cycle]
	move.w	(a0)+,d0		; src	; [8 cycle]
	; bitplan #0
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#1,(a2)	; set blitter line count to 1	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [28 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 34 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 35 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#23,(a2)	; set blitter line count to 23	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [292 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#8,(a2)	; set blitter line count to 8	; [12 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	d7,(a3)	; run blitter	; [112 cycle]
; Raster line 36 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 37 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#23,(a2)	; set blitter line count to 23	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [292 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#8,(a2)	; set blitter line count to 8	; [12 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	d7,(a3)	; run blitter	; [112 cycle]
; Raster line 38 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 39 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#21,(a2)	; set blitter line count to 21	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [268 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#2,(a2)	; set blitter line count to 2	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [40 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 40 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 41 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#22,(a2)	; set blitter line count to 22	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [280 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#1,(a2)	; set blitter line count to 1	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [28 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 42 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 43 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#23,(a2)	; set blitter line count to 23	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [292 cycle]
	move.w	(a0)+,d1		; dst	; [8 cycle]
	move.w	(a0)+,d0		; src	; [8 cycle]
	; bitplan #0
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#8,(a2)	; set blitter line count to 8	; [12 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	d7,(a3)	; run blitter	; [112 cycle]
; Raster line 44 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 45 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#21,(a2)	; set blitter line count to 21	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [268 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#2,(a2)	; set blitter line count to 2	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [40 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 46 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 47 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#22,(a2)	; set blitter line count to 22	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [280 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#1,(a2)	; set blitter line count to 1	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [28 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 48 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 49 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#23,(a2)	; set blitter line count to 23	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [292 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#8,(a2)	; set blitter line count to 8	; [12 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	d7,(a3)	; run blitter	; [112 cycle]
; Raster line 50 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 51 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#21,(a2)	; set blitter line count to 21	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [268 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#2,(a2)	; set blitter line count to 2	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [40 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 52 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 53 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#22,(a2)	; set blitter line count to 22	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [280 cycle]
	move.w	(a0)+,d1		; dst	; [8 cycle]
	move.w	(a0)+,d0		; src	; [8 cycle]
	; bitplan #0
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#8,(a2)	; set blitter line count to 8	; [12 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	d7,(a3)	; run blitter	; [112 cycle]
; Raster line 54 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 55 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#23,(a2)	; set blitter line count to 23	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [292 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#8,(a2)	; set blitter line count to 8	; [12 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	d7,(a3)	; run blitter	; [112 cycle]
; Raster line 56 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 57 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#21,(a2)	; set blitter line count to 21	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [268 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#2,(a2)	; set blitter line count to 2	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [40 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 58 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 59 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#22,(a2)	; set blitter line count to 22	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [280 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#1,(a2)	; set blitter line count to 1	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [28 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 60 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 61 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#23,(a2)	; set blitter line count to 23	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [292 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#8,(a2)	; set blitter line count to 8	; [12 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	d7,(a3)	; run blitter	; [112 cycle]
; Raster line 62 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 63 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#21,(a2)	; set blitter line count to 21	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [268 cycle]
	move.w	(a0)+,d1		; dst	; [8 cycle]
	move.w	(a0)+,d0		; src	; [8 cycle]
	; bitplan #0
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#1,(a2)	; set blitter line count to 1	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [28 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 64 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 65 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#23,(a2)	; set blitter line count to 23	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [292 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#8,(a2)	; set blitter line count to 8	; [12 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	d7,(a3)	; run blitter	; [112 cycle]
; Raster line 66 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 67 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#23,(a2)	; set blitter line count to 23	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [292 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#8,(a2)	; set blitter line count to 8	; [12 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	d7,(a3)	; run blitter	; [112 cycle]
; Raster line 68 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 69 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#21,(a2)	; set blitter line count to 21	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [268 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#2,(a2)	; set blitter line count to 2	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [40 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 70 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 71 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#22,(a2)	; set blitter line count to 22	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [280 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#1,(a2)	; set blitter line count to 1	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [28 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 72 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 73 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#23,(a2)	; set blitter line count to 23	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [292 cycle]
	move.w	(a0)+,d1		; dst	; [8 cycle]
	move.w	(a0)+,d0		; src	; [8 cycle]
	; bitplan #0
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#8,(a2)	; set blitter line count to 8	; [12 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	d7,(a3)	; run blitter	; [112 cycle]
; Raster line 74 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 75 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#21,(a2)	; set blitter line count to 21	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [268 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#2,(a2)	; set blitter line count to 2	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [40 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 76 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 77 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#22,(a2)	; set blitter line count to 22	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [280 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#1,(a2)	; set blitter line count to 1	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [28 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 78 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 79 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#23,(a2)	; set blitter line count to 23	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [292 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#8,(a2)	; set blitter line count to 8	; [12 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	d7,(a3)	; run blitter	; [112 cycle]
; Raster line 80 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 81 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#21,(a2)	; set blitter line count to 21	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [268 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#2,(a2)	; set blitter line count to 2	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [40 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 82 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 83 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#22,(a2)	; set blitter line count to 22	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [280 cycle]
	move.w	(a0)+,d1		; dst	; [8 cycle]
	move.w	(a0)+,d0		; src	; [8 cycle]
	; bitplan #0
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#8,(a2)	; set blitter line count to 8	; [12 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	d7,(a3)	; run blitter	; [112 cycle]
; Raster line 84 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 85 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#23,(a2)	; set blitter line count to 23	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [292 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#8,(a2)	; set blitter line count to 8	; [12 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	d7,(a3)	; run blitter	; [112 cycle]
; Raster line 86 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 87 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#21,(a2)	; set blitter line count to 21	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [268 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#2,(a2)	; set blitter line count to 2	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [40 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 88 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 89 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#22,(a2)	; set blitter line count to 22	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [280 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#1,(a2)	; set blitter line count to 1	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [28 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 90 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 91 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#23,(a2)	; set blitter line count to 23	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [292 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#8,(a2)	; set blitter line count to 8	; [12 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	d7,(a3)	; run blitter	; [112 cycle]
; Raster line 92 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 93 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#21,(a2)	; set blitter line count to 21	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [268 cycle]
	move.w	(a0)+,d1		; dst	; [8 cycle]
	move.w	(a0)+,d0		; src	; [8 cycle]
	; bitplan #0
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#1,(a2)	; set blitter line count to 1	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [28 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 94 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 95 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#23,(a2)	; set blitter line count to 23	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [292 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#8,(a2)	; set blitter line count to 8	; [12 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	d7,(a3)	; run blitter	; [112 cycle]
; Raster line 96 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 97 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#23,(a2)	; set blitter line count to 23	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [292 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#8,(a2)	; set blitter line count to 8	; [12 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	d7,(a3)	; run blitter	; [112 cycle]
; Raster line 98 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 99 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#21,(a2)	; set blitter line count to 21	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [268 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#2,(a2)	; set blitter line count to 2	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [40 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 100 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 101 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#22,(a2)	; set blitter line count to 22	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [280 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#1,(a2)	; set blitter line count to 1	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [28 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 102 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 103 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#23,(a2)	; set blitter line count to 23	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [292 cycle]
	move.w	(a0)+,d1		; dst	; [8 cycle]
	move.w	(a0)+,d0		; src	; [8 cycle]
	; bitplan #0
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#8,(a2)	; set blitter line count to 8	; [12 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	d7,(a3)	; run blitter	; [112 cycle]
; Raster line 104 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 105 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#21,(a2)	; set blitter line count to 21	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [268 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#2,(a2)	; set blitter line count to 2	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [40 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 106 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 107 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#22,(a2)	; set blitter line count to 22	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [280 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#1,(a2)	; set blitter line count to 1	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [28 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 108 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 109 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#23,(a2)	; set blitter line count to 23	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [292 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#8,(a2)	; set blitter line count to 8	; [12 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	d7,(a3)	; run blitter	; [112 cycle]
; Raster line 110 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 111 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#21,(a2)	; set blitter line count to 21	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [268 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#2,(a2)	; set blitter line count to 2	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [40 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 112 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 113 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#22,(a2)	; set blitter line count to 22	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [280 cycle]
	move.w	(a0)+,d1		; dst	; [8 cycle]
	move.w	(a0)+,d0		; src	; [8 cycle]
	; bitplan #0
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#8,(a2)	; set blitter line count to 8	; [12 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	d7,(a3)	; run blitter	; [112 cycle]
; Raster line 114 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 115 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#23,(a2)	; set blitter line count to 23	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [292 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#8,(a2)	; set blitter line count to 8	; [12 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	d7,(a3)	; run blitter	; [112 cycle]
; Raster line 116 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 117 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#21,(a2)	; set blitter line count to 21	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [268 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#2,(a2)	; set blitter line count to 2	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [40 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 118 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 119 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#22,(a2)	; set blitter line count to 22	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [280 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#1,(a2)	; set blitter line count to 1	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [28 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 120 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 121 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#23,(a2)	; set blitter line count to 23	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [292 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#8,(a2)	; set blitter line count to 8	; [12 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	d7,(a3)	; run blitter	; [112 cycle]
; Raster line 122 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 123 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#21,(a2)	; set blitter line count to 21	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [268 cycle]
	move.w	(a0)+,d1		; dst	; [8 cycle]
	move.w	(a0)+,d0		; src	; [8 cycle]
	; bitplan #0
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#1,(a2)	; set blitter line count to 1	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [28 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 124 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 125 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#23,(a2)	; set blitter line count to 23	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [292 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#8,(a2)	; set blitter line count to 8	; [12 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	d7,(a3)	; run blitter	; [112 cycle]
; Raster line 126 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 127 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#23,(a2)	; set blitter line count to 23	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [292 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#8,(a2)	; set blitter line count to 8	; [12 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	d7,(a3)	; run blitter	; [112 cycle]
; Raster line 128 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 129 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#21,(a2)	; set blitter line count to 21	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [268 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#2,(a2)	; set blitter line count to 2	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [40 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 130 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 131 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#22,(a2)	; set blitter line count to 22	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [280 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#1,(a2)	; set blitter line count to 1	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [28 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 132 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 133 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#23,(a2)	; set blitter line count to 23	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [292 cycle]
	move.w	(a0)+,d1		; dst	; [8 cycle]
	move.w	(a0)+,d0		; src	; [8 cycle]
	; bitplan #0
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#8,(a2)	; set blitter line count to 8	; [12 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	d7,(a3)	; run blitter	; [112 cycle]
; Raster line 134 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 135 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#21,(a2)	; set blitter line count to 21	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [268 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#2,(a2)	; set blitter line count to 2	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [40 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 136 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 137 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#20,(a2)	; set blitter line count to 20	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [256 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#3,(a2)	; set blitter line count to 3	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [52 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 138 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 139 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#21,(a2)	; set blitter line count to 21	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [268 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#2,(a2)	; set blitter line count to 2	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [40 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 140 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 141 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#20,(a2)	; set blitter line count to 20	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [256 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#3,(a2)	; set blitter line count to 3	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [52 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 142 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 143 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#21,(a2)	; set blitter line count to 21	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [268 cycle]
	move.w	(a0)+,d1		; dst	; [8 cycle]
	move.w	(a0)+,d0		; src	; [8 cycle]
	; bitplan #0
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#1,(a2)	; set blitter line count to 1	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [28 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 144 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 145 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#21,(a2)	; set blitter line count to 21	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [268 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#2,(a2)	; set blitter line count to 2	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [40 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 146 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 147 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#20,(a2)	; set blitter line count to 20	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [256 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#3,(a2)	; set blitter line count to 3	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [52 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 148 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 149 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#19,(a2)	; set blitter line count to 19	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [244 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#4,(a2)	; set blitter line count to 4	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [64 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 150 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 151 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#20,(a2)	; set blitter line count to 20	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [256 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#3,(a2)	; set blitter line count to 3	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [52 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 152 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 153 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#19,(a2)	; set blitter line count to 19	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [244 cycle]
; -------------- clear last sprite on screen -----------
	move.w	m_maskBuffer(a6),$ffff8a24.w	; [20 cycle]
	move.w	m_currentClearOffset(a6),d0	; [12 cycle]
	move.w	m_currentScreen(a6),$ffff8a32.w	; [20 cycle]
	move.w	d0,d1	; [4 cycle]
	move.w	#$0201,$ffff8a3a.w	; [16 cycle]
	move.w	#$00e0,$ffff8a22.w	; [16 cycle]
	moveq	#-32,d2	; [4 cycle]
	; bitplan #0
	move.w	d0,$ffff8a26.w	; [12 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#4,(a2)	; set blitter line count to 4	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [64 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 154 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 155 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#25,(a2)	; set blitter line count to 25	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [316 cycle]
	addq.w	#8,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 156 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 157 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#22,(a2)	; set blitter line count to 22	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [280 cycle]
	addq.w	#8,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#1,(a2)	; set blitter line count to 1	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [28 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 158 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 159 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#21,(a2)	; set blitter line count to 21	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [268 cycle]
	addq.w	#8,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#2,(a2)	; set blitter line count to 2	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [40 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 160 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 161 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#20,(a2)	; set blitter line count to 20	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [256 cycle]
	addq.w	#8,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#3,(a2)	; set blitter line count to 3	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [52 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 162 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 163 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#19,(a2)	; set blitter line count to 19	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [244 cycle]
	add.w	d2,d0	; [4 cycle]
	add.w	#-(5-1)*8+2,d1	; [8 cycle]
	; bitplan #1
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#3,(a2)	; set blitter line count to 3	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [52 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 164 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 165 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#19,(a2)	; set blitter line count to 19	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [244 cycle]
	addq.w	#8,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#4,(a2)	; set blitter line count to 4	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [64 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 166 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 167 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#20,(a2)	; set blitter line count to 20	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [256 cycle]
	addq.w	#8,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#3,(a2)	; set blitter line count to 3	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [52 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 168 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 169 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#21,(a2)	; set blitter line count to 21	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [268 cycle]
	addq.w	#8,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#2,(a2)	; set blitter line count to 2	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [40 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 170 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 171 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#20,(a2)	; set blitter line count to 20	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [256 cycle]
	addq.w	#8,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#3,(a2)	; set blitter line count to 3	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [52 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 172 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 173 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#19,(a2)	; set blitter line count to 19	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [244 cycle]
	add.w	d2,d0	; [4 cycle]
	add.w	#-(5-1)*8+2,d1	; [8 cycle]
	; bitplan #2
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#3,(a2)	; set blitter line count to 3	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [52 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 174 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 175 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#19,(a2)	; set blitter line count to 19	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [244 cycle]
	addq.w	#8,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#4,(a2)	; set blitter line count to 4	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [64 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 176 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 177 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#18,(a2)	; set blitter line count to 18	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [232 cycle]
	addq.w	#8,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 178 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 179 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#17,(a2)	; set blitter line count to 17	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [220 cycle]
	addq.w	#8,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#6,(a2)	; set blitter line count to 6	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [88 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 180 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 181 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#16,(a2)	; set blitter line count to 16	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [208 cycle]
	addq.w	#8,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 182 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 183 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#15,(a2)	; set blitter line count to 15	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [196 cycle]
	add.w	d2,d0	; [4 cycle]
	add.w	#-(5-1)*8+2,d1	; [8 cycle]
	; bitplan #3
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 184 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 185 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#17,(a2)	; set blitter line count to 17	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [220 cycle]
	addq.w	#8,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#6,(a2)	; set blitter line count to 6	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [88 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 186 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 187 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#18,(a2)	; set blitter line count to 18	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [232 cycle]
	addq.w	#8,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 188 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 189 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#17,(a2)	; set blitter line count to 17	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [220 cycle]
	addq.w	#8,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#6,(a2)	; set blitter line count to 6	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [88 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 190 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 191 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#16,(a2)	; set blitter line count to 16	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [208 cycle]
	addq.w	#8,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 192 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 193 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#15,(a2)	; set blitter line count to 15	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [196 cycle]
; -------------- mask sprite on screen -----------
	move.w	m_preshiftedMasks(a6),$ffff8a24.w	; [20 cycle]
	move.w	m_currentBobMask(a6),d0	; [12 cycle]
	move.w	m_currentScrOffset(a6),d1	; [12 cycle]
	move.w	#$0204,$ffff8a3a.w	; [16 cycle]
	move.w	#$000a,$ffff8a22.w	; [16 cycle]
	moveq	#-8,d2	; [4 cycle]
	; bitplan #0
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#2,(a2)	; set blitter line count to 2	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [40 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 194 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 195 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#20,(a2)	; set blitter line count to 20	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [256 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#3,(a2)	; set blitter line count to 3	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [52 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 196 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 197 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#19,(a2)	; set blitter line count to 19	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [244 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#4,(a2)	; set blitter line count to 4	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [64 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 198 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 199 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#18,(a2)	; set blitter line count to 18	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [232 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 200 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 201 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#17,(a2)	; set blitter line count to 17	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [220 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#6,(a2)	; set blitter line count to 6	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [88 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 202 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 203 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#16,(a2)	; set blitter line count to 16	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [208 cycle]
	add.w	d2,d0	; [4 cycle]
	add.w	#-(5-1)*8+2,d1	; [8 cycle]
	; bitplan #1
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#6,(a2)	; set blitter line count to 6	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [88 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 204 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 205 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#18,(a2)	; set blitter line count to 18	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [232 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 206 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 207 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#17,(a2)	; set blitter line count to 17	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [220 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#6,(a2)	; set blitter line count to 6	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [88 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 208 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 209 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#18,(a2)	; set blitter line count to 18	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [232 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 210 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 211 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#17,(a2)	; set blitter line count to 17	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [220 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#6,(a2)	; set blitter line count to 6	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [88 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 212 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 213 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#16,(a2)	; set blitter line count to 16	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [208 cycle]
	add.w	d2,d0	; [4 cycle]
	add.w	#-(5-1)*8+2,d1	; [8 cycle]
	; bitplan #2
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#6,(a2)	; set blitter line count to 6	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [88 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 214 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 215 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#16,(a2)	; set blitter line count to 16	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [208 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 216 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 217 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#15,(a2)	; set blitter line count to 15	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [196 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#8,(a2)	; set blitter line count to 8	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [112 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 218 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 219 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#14,(a2)	; set blitter line count to 14	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [184 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#9,(a2)	; set blitter line count to 9	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [124 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 220 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 221 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#13,(a2)	; set blitter line count to 13	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [172 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#10,(a2)	; set blitter line count to 10	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [136 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 222 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 223 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#12,(a2)	; set blitter line count to 12	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [160 cycle]
	add.w	d2,d0	; [4 cycle]
	add.w	#-(5-1)*8+2,d1	; [8 cycle]
	; bitplan #3
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#10,(a2)	; set blitter line count to 10	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [136 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 224 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 225 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#12,(a2)	; set blitter line count to 12	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [160 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#11,(a2)	; set blitter line count to 11	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [148 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 226 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 227 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#11,(a2)	; set blitter line count to 11	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [148 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#12,(a2)	; set blitter line count to 12	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [160 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#3,(a2)	; set blitter line count to 3	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [52 cycle]
	move.b	d6,(a5)	;Open lower border	; [8 cycle]
	move.w	#1,(a2)	; set blitter line count to 1	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [28 cycle]
; Raster line 228 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#27,(a2)	; set blitter line count to 27	; [12 cycle]
	move.w	a5,(a5)	; End lower border switch	; [8 cycle]
	move.w	d7,(a3)	; run blitter	; [340 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 229 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#14,(a2)	; set blitter line count to 14	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [184 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#9,(a2)	; set blitter line count to 9	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [124 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 230 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 231 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#13,(a2)	; set blitter line count to 13	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [172 cycle]
	addq.w	#2,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#10,(a2)	; set blitter line count to 10	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [136 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 232 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 233 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#14,(a2)	; set blitter line count to 14	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [184 cycle]
; -------------- OR sprite on screen -----------
	move.w	m_preshiftedMasks(a6),$ffff8a24.w	; on purpose mask instead of Sprite (64k aligned)	; [20 cycle]
	move.w	m_currentBobOr(a6),d0	; [12 cycle]
	move.w	m_currentScrOffset(a6),d1	; [12 cycle]
	move.w	#$0207,$ffff8a3a.w	; [16 cycle]
	move.w	#$0028,$ffff8a22.w	; [16 cycle]
	moveq	#-30,d2	; [4 cycle]
	; bitplan #0
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#3,(a2)	; set blitter line count to 3	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [52 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 234 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 235 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#21,(a2)	; set blitter line count to 21	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [268 cycle]
	addq.w	#8,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#2,(a2)	; set blitter line count to 2	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [40 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 236 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 237 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#20,(a2)	; set blitter line count to 20	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [256 cycle]
	addq.w	#8,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#3,(a2)	; set blitter line count to 3	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [52 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 238 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 239 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#19,(a2)	; set blitter line count to 19	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [244 cycle]
	addq.w	#8,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#4,(a2)	; set blitter line count to 4	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [64 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 240 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 241 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#18,(a2)	; set blitter line count to 18	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [232 cycle]
	addq.w	#8,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 242 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 243 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#17,(a2)	; set blitter line count to 17	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [220 cycle]
	add.w	d2,d0	; [4 cycle]
	add.w	#-(5-1)*8+2,d1	; [8 cycle]
	; bitplan #1
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 244 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 245 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#17,(a2)	; set blitter line count to 17	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [220 cycle]
	addq.w	#8,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#6,(a2)	; set blitter line count to 6	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [88 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 246 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 247 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#16,(a2)	; set blitter line count to 16	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [208 cycle]
	addq.w	#8,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 248 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 249 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#15,(a2)	; set blitter line count to 15	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [196 cycle]
	addq.w	#8,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#8,(a2)	; set blitter line count to 8	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [112 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 250 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 251 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#14,(a2)	; set blitter line count to 14	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [184 cycle]
	addq.w	#8,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#9,(a2)	; set blitter line count to 9	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [124 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 252 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 253 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#13,(a2)	; set blitter line count to 13	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [172 cycle]
	add.w	d2,d0	; [4 cycle]
	add.w	#-(5-1)*8+2,d1	; [8 cycle]
	; bitplan #2
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#9,(a2)	; set blitter line count to 9	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [124 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 254 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 255 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#13,(a2)	; set blitter line count to 13	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [172 cycle]
	addq.w	#8,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#10,(a2)	; set blitter line count to 10	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [136 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 256 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 257 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#12,(a2)	; set blitter line count to 12	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [160 cycle]
	addq.w	#8,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#11,(a2)	; set blitter line count to 11	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [148 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 258 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 259 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#11,(a2)	; set blitter line count to 11	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [148 cycle]
	addq.w	#8,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#12,(a2)	; set blitter line count to 12	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [160 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 260 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 261 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#10,(a2)	; set blitter line count to 10	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [136 cycle]
	addq.w	#8,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#13,(a2)	; set blitter line count to 13	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [172 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 262 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 263 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#11,(a2)	; set blitter line count to 11	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [148 cycle]
	add.w	d2,d0	; [4 cycle]
	add.w	#-(5-1)*8+2,d1	; [8 cycle]
	; bitplan #3
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#11,(a2)	; set blitter line count to 11	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [148 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 264 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#5,(a2)	; set blitter line count to 5	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [76 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.w	(a1)+,$ffff8240.w	; change background color	; [16 cycle]
; Raster line 265 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#13,(a2)	; set blitter line count to 13	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [172 cycle]
	addq.w	#8,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#10,(a2)	; set blitter line count to 10	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [136 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 266 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 267 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#12,(a2)	; set blitter line count to 12	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [160 cycle]
	addq.w	#8,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#11,(a2)	; set blitter line count to 11	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [148 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 268 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 269 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#11,(a2)	; set blitter line count to 11	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [148 cycle]
	addq.w	#8,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#12,(a2)	; set blitter line count to 12	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [160 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 270 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 271 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#10,(a2)	; set blitter line count to 10	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [136 cycle]
	addq.w	#8,d0	; [4 cycle]
	addq.w	#8,d1	; [4 cycle]
	move.w	d0,$ffff8a26.w	; [12 cycle]
	move.w	d1,$ffff8a34.w	; [12 cycle]
	move.w	#13,(a2)	; set blitter line count to 13	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [172 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 272 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#28,(a2)	; set blitter line count to 28	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [352 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
	move.w	#7,(a2)	; set blitter line count to 7	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [100 cycle]
; Raster line 273 [0]
	move.w	a4,(a4)	; cycle 0: set high res, open left border	; [8 cycle]
	nop	; [4 cycle]
	move.b	d6,(a4)	; back to low res	; [8 cycle]
	move.w	#9,(a2)	; set blitter line count to 9	; [12 cycle]
	move.w	d7,(a3)	; run blitter	; [124 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	nop	; [4 cycle]
	move.b	d6,(a5)	; cycle 376, set 60hz to open right border	; [8 cycle]
	move.w	a5,(a5)	; back to 50hz	; [8 cycle]
