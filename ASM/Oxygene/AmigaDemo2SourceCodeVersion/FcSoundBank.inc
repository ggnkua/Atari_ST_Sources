	dc.w	$0000,$0000,$0592,$0000,$0001,0,0,0
	dc.w	$0000,$0b24,$054e,$0000,$0001,0,0,0
	dc.w	$0000,$15c0,$07eb,$0000,$0001,0,0,0
	dc.w	$0000,$2596,$0010,$0000,$0010,0,0,0
	dc.w	$0000,$25b6,$0010,$0000,$0010,0,0,0
	dc.w	$0000,$25d6,$0010,$0000,$0010,0,0,0
	dc.w	$0000,$25f6,$0010,$0000,$0010,0,0,0
	dc.w	$0000,$2616,$0008,$0000,$0008,0,0,0
	dc.w	$0000,$2626,$0c1c,$0000,$0001,0,0,0
	dc.w	$0000,$3e5e,$05dc,$0000,$0001,0,0,0
	dc.w	$0000,$4a16,$0010,$0000,$0010,0,0,0
	dc.w	$0000,$4a36,$0010,$0000,$0010,0,0,0
	dc.w	$0000,$4a56,$0010,$0000,$0010,0,0,0
	dc.w	$0000,$4a76,$0010,$0000,$0010,0,0,0
	dc.w	$0000,$4a96,$0010,$0000,$0010,0,0,0
	dc.w	$0000,$4ab6,$0010,$0000,$0010,0,0,0
	dc.w	$0000,$4ad6,$0010,$0000,$0010,0,0,0
	dc.w	$0000,$4af6,$0010,$0000,$0010,0,0,0
	dc.w	$0000,$4b16,$0010,$0000,$0010,0,0,0
	dc.w	$0000,$4b36,$0010,$0000,$0010,0,0,0
	dc.w	$0000,$4b56,$0010,$0000,$0010,0,0,0
	dc.w	$0000,$4b76,$0010,$0000,$0010,0,0,0
	dc.w	$0000,$4b96,$0010,$0000,$0010,0,0,0
	dc.w	$0000,$4bb6,$0010,$0000,$0010,0,0,0
	dc.w	$0000,$4bd6,$0010,$0000,$0010,0,0,0
	dc.w	$0000,$4bf6,$0010,$0000,$0010,0,0,0
	dc.w	$0000,$4c16,$0010,$0000,$0010,0,0,0
	dc.w	$0000,$4c36,$0008,$0000,$0008,0,0,0
	dc.w	$0000,$4c46,$0008,$0000,$0008,0,0,0
	dc.w	$0000,$4c56,$0008,$0000,$0008,0,0,0
	dc.w	$0000,$4c66,$0008,$0000,$0008,0,0,0
	dc.w	$0000,$4c76,$0008,$0000,$0008,0,0,0
	dc.w	$0000,$4c86,$0448,$0000,$0001,0,0,0
	dc.w	$0000,$5516,$049a,$0000,$0001,0,0,0
	dc.w	$0000,$5e4a,$0008,$0000,$0008,0,0,0
	dc.w	$0000,$5e5a,$0008,$0000,$0008,0,0,0
	dc.w	$0000,$5e6a,$0008,$0000,$0008,0,0,0
	dc.w	$0000,$5e7a,$0010,$0000,$0010,0,0,0
	dc.w	$0000,$5e9a,$0010,$0000,$0010,0,0,0
	dc.w	$0000,$5eba,$0010,$0000,$0010,0,0,0
	dc.w	$0000,$5eda,$0010,$0000,$0010,0,0,0
	dc.w	$0000,$5efa,$0010,$0000,$0010,0,0,0
	dc.w	$0000,$5f1a,$0010,$0000,$0010,0,0,0
	dc.w	$0000,$5f3a,$0010,$0000,$0010,0,0,0
	dc.w	$0000,$5f5a,$0010,$0000,$0010,0,0,0
	dc.w	$0000,$5f7a,$07f1,$0000,$0001,0,0,0
	dc.w	$0000,$6f5c,$05e6,$0000,$0001,0,0,0
	dc.w	$0000,$7b28,$0ad1,$0000,$0001,0,0,0
	dc.w	$0000,$90ca,$0240,$0380,$0080,0,0,0
	dc.w	$0000,$954a,$0010,$0000,$0010,0,0,0
	dc.w	$0000,$956a,$0010,$0000,$0010,0,0,0
	dc.w	$0000,$958a,$0010,$0000,$0010,0,0,0
	dc.w	$0000,$95aa,$0010,$0000,$0010,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0
