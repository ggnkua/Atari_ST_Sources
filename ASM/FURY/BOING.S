	dc.w	1920
	dc.w	1760
	dc.w	1600
	dc.w	1440
	dc.w	1280
	dc.w	1120
	dc.w	1120
	dc.w	960
	dc.w	800
	dc.w	640
	dc.w	640
	dc.w	480
	dc.w	480
	dc.w	320
	dc.w	320
	dc.w	160
	dc.w	160
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	160
	dc.w	160
	dc.w	320
	dc.w	320
	dc.w	480
	dc.w	480
	dc.w	640
	dc.w	640
	dc.w	800
	dc.w	960
	dc.w	1120
	dc.w	1120
	dc.w	1280
	dc.w	1440
	dc.w	1600
	dc.w	1760
	dc.w	1920
