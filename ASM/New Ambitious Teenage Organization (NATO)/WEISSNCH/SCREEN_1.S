000000
                DC.W %1111111110000000,%1111111110000000
                DC.W %1111111100000000,%1111111100000000
                DC.W %1111111000000000,%1111111000000000
                DC.W %1111110000000000,%1111110000000000
                DC.W %1111100000000000,%1111000000000000
                DC.W %111111111111,%11111111111111
                DC.W %111111111111111,%111111111111111
                DC.W %1111111111111111,%1111111000000000
                DC.W %1111110000000000,%1111111000000000
                DC.W %111111111111111,%111111111111111
                DC.W %111111111111111,%1111111111111111
                DC.W %1111111000000000,%1111110000000000
                DC.W %1111111000000000,%1111111111111111
                DC.W %111111111111111,%111111111111111
                DC.W %11111111111111,%111111111111
                DC.W %1111111100000000,%1111111111000000
                DC.W %1111111111100000,%1111111111100000
                DC.W %1111111111110000,%11111110000
                DC.W %1111110000,%11111110000
                DC.W %1111111111100000,%1111111111100000
                DC.W %1111111111100000,%1111111111110000
                DC.W %11111110000,%1111110000
                DC.W %11111110000,%1111111111110000
                DC.W %1111111111100000,%1111111111100000
                DC.W %1111111111000000,%1111111100000000
                DC.W %111111111111,%11111111111111
                DC.W %111111111111111,%111111111111111
                DC.W %1111111111111111,%1111111000000000
                DC.W %1111111000000000,%1111111111111111
                DC.W %111111111111111,%111111111111111
                DC.W %11111111111111,%111111111111
                DC.W %0,%111111000000000
                DC.W %1111111100000000,%1111111111111111
                DC.W %1111111111111111,%111111111111111
                DC.W %11111111111111,%111111111111
                DC.W %1111111100000000,%1111111111000000
                DC.W %1111111111100000,%1111111111100000
                DC.W %1111111111110000,%111111110000
                DC.W %111111110000,%1111111111110000
                DC.W %1111111111110000,%1111111111110000
                DC.W %1111111111110000,%1111111111110000
                DC.W %11111110000,%11111110000
                DC.W %111111110000,%1111111111100000
                DC.W %1111111111100000,%1111111111000000
                DC.W %1111111110000000,%1111111000000000
                DC.W %11111111111,%1111111111111
                DC.W %11111111111111,%111111111111111
                DC.W %111111111111111,%1111111111111111
                DC.W %1111111100000000,%1111111000000001
                DC.W %1111111000000111,%1111111000011111
                DC.W %1111111001111111,%1111111011111110
                DC.W %1111111011111000,%1111111100000000
                DC.W %1111111111111111,%111111111111111
                DC.W %111111111111111,%11111111111111
                DC.W %1111111111111,%11111111111
                DC.W %1111111000000000,%1111111110000000
                DC.W %1111111111000000,%1111111111100000
                DC.W %1111111111100000,%1111111111110000
                DC.W %111111110000,%1111011111110000
                DC.W %1111011111110000,%1110011111110000
                DC.W %1000011111110000,%11111110000
                DC.W %11111110000,%111111110000
                DC.W %1111111111110000,%1111111111100000
                DC.W %1111111111100000,%1111111111000000
                DC.W %1111111110000000,%1111111000000000
L000F:          DC.B 'Nq'
                END
������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������������*****************************
* Code for the 1st Screen   *
* in the Weissnich-Demo.    *
* Made by Charon and        *
* Blowtorch.                *
*                           *
* Here is a bug, too:       *
* The program doesn't       *
* accept the key, so You're *
* not able to leave the     *
* screen...                 *
*****************************

                clr.l   -(SP)           ; Supervisor on
                move.w  #$20,-(SP)
                trap    #1
                addq.l  #6,SP
                moveq   #0,D0

                move.b  #2,$0484.w
                move.b  #2,$FFFF820A.w  ; 50 Hz

                movea.l #$FFFF8240,A0
                moveq   #16,D0
luuhp:          move.w  #0,(A0)+
                dbra    D0,luuhp

                move.b  #$12,$FFFFFC02.w ; No Mouse...

                move.w  #0,-(SP)
                pea     datei
                move.w  #$3D,-(SP)
                trap    #1
                addq.l  #8,SP
                move.w  D0,handle1

                pea     $030600         ; Read Grafix
                move.l  #32000,-(SP)
                move.w  handle1,-(SP)
                move.w  #$3F,-(SP)
                trap    #1
                adda.l  #12,SP

                move.w  handle,-(SP)
                move.w  #$3E,-(SP)
                trap    #1
                addq.l  #4,-(SP)

                movea.l #gfx,A0         ; Move additional grafix to right
                movea.l #$07DDC0,A1     ; addresse.
                move.l  #1999,D0
luuup:          move.l  (A0)+,(A1)+
                dbra    D0,luuup

                movea.l #$030600,A1     ; Copying Screen
                movea.l #$038300,A2
                move.w  #7999,D0
luhp:           move.l  (A1)+,(A2)+
                dbra    D0,luhp

                movea.l #$07DDC0,A1     ; Copying Rest Gfx
                movea.l #$075DC0,A2
                move.w  #1999,D0
luup:           move.l  (A1)+,(A2)+
                dbra    D0,luup

                move.l  #cols,$045A     ; Set new colors
                move.l  #newvbl,$04D2   ; Vertical-scroller in  VBL-Queue

                moveq   #1,D0           ; Mad Max Music
                jsr     muzak
                move.l  #muzak+8,$04D6

****************************************************************************
                move.w  #7,lettercounter
                move.l  #$05FF00,saver

                move.l  #routine,$04DA  ; Scrolline in VBL-Queue

wait:           move.w  #7,-(SP)        ; Wait for key
                trap    #1
                addq.l  #6,SP

                move.l  #0,$04D2        ; All routs off
                move.l  #0,$04D6
                move.l  #0,$04DA

                move.l  #$0777,$FFFF8240 ; Make new colors for Desktop
                move.l  #$70,$FFFF8246
                move.l  #$0F8000,$045E  ; Set screen-addresse

                clr.w   -(SP)           ; Bye...
                trap    #1
routine:
                cmpi.w  #0,pause
                bne     time_kill

                movea.l saver,A3

                sub.l   D0,D0
                addi.w  #1,lettercounter
                cmpi.w  #8,lettercounter
                bne     same_letter
                clr.w   lettercounter
next:           movea.l #text,A0
                move.l  offset,D1
                addi.l  #1,offset
                move.b  0(A0,D1.w),D0
                cmp.b   #$FE,D0
                bne     no_stand
                move.w  #200,pause
                move.w  #7,lettercounter
                bra     routine
no_stand:       cmp.b   #$FF,D0
                bne     okay2
                clr.l   offset
                bra     next
okay2:          mulu    #80,D0
                add.l   #table,D0
                move.l  D0,zeiger

same_letter:    move.w  #19,D1
y_zeile:        move.l  (A3),D0
                cmpi.w  #2,counter
                ble     roll_it
                swap    D0
                movea.l zeiger,A0
                move.w  (A0)+,D0
                move.l  A0,zeiger
                swap    D0
                rol.l   #4,D0
                move.l  D0,(A3)+

                dbra    D1,y_zeile

                clr.w   counter
                bra     ready

roll_it:        rol.l   #4,D0
                move.l  D0,(A3)+
                dbra    D1,y_zeile

                addi.w  #1,counter

ready:          move.l  base1,sav_puffer
                move.l  base2,base1
                move.l  base3,base2
                move.l  base4,base3
                move.l  sav_puffer,base4

                movea.l base2,A0

                movea.l saver,A3

                move.w  #19,D2
y_loop:
                move.w  8(A0),(A0)
                move.w  16(A0),8(A0)
                move.w  24(A0),16(A0)
                move.w  32(A0),24(A0)
                move.w  40(A0),32(A0)
                move.w  48(A0),40(A0)
                move.w  56(A0),48(A0)
                move.w  64(A0),56(A0)
                move.w  72(A0),64(A0)
                move.w  80(A0),72(A0)
                move.w  88(A0),80(A0)
                move.w  96(A0),88(A0)
                move.w  104(A0),96(A0)
                move.w  112(A0),104(A0)
                move.w  120(A0),112(A0)
                move.w  128(A0),120(A0)
                move.w  136(A0),128(A0)
                move.w  144(A0),136(A0)
                move.w  152(A0),144(A0)

                move.l  (A3)+,D0
                move.w  D0,152(A0)

                adda.l  #160,A0

                dbra    D2,y_loop

                bra     after_pause

time_kill:      subq.w  #1,pause

after_pause:    movea.l screen2,A6      ;**********
                move.l  screen1,screen2 ;**********
                move.l  A6,screen1      ;**********
                movea.l base2,A0
                movea.l screen2,A1
                adda.l  #160*175,A1
                move.w  #19,D0

copy:           move.w  (A0),(A1)
                move.w  8(A0),8(A1)
                move.w  16(A0),16(A1)
                move.w  24(A0),24(A1)
                move.w  32(A0),32(A1)
                move.w  40(A0),40(A1)
                move.w  48(A0),48(A1)
                move.w  56(A0),56(A1)
                move.w  64(A0),64(A1)
                move.w  72(A0),72(A1)
                move.w  80(A0),80(A1)
                move.w  88(A0),88(A1)
                move.w  96(A0),96(A1)
                move.w  104(A0),104(A1)
                move.w  112(A0),112(A1)
                move.w  120(A0),120(A1)
                move.w  128(A0),128(A1)
                move.w  136(A0),136(A1)
                move.w  144(A0),144(A1)
                move.w  152(A0),152(A1)

                adda.l  #160,A0
                adda.l  #160,A1

                dbra    D0,copy


                rts

****************************************************************************
newvbl:
                lea     sintab,A5       ; Read Sine Wave
                move.w  teiger,D0
                move.w  0(A5,D0.w),D1   ; A4=actual Wave-#
                addq.w  #2,teiger       ; Next Position

                cmpi.w  #$FFFF,D1       ; End of Sine-Tab ?
                beq     newsin          ; Yeah...

go_on:
                movea.l aim1,A3         ; Swapping the adresses
                move.l  aim2,aim1
                move.l  A3,aim2

                move.l  aim2,$045E      ; New Screen-Adresse
                movea.l aim1,A6         ; Screen-adresse => A6
                lea     $030600,A5      ; Gfx-Source-adresse => A5
                adda.w  D1,A5           ; Add Sine-Wave

loop:                                   ; Of course no DBRA...
                movem.l 0(A5),D0-A4
                movem.l D0-A4,0(A6)
                movem.l 48(A5),D0-A4
                movem.l D0-A4,48(A6)
                movem.l 96(A5),D0-A4
                movem.l D0-A4,96(A6)
                movem.l 144(A5),D0-A4
                movem.l D0-A4,144(A6)
                movem.l 192(A5),D0-A4
                movem.l D0-A4,192(A6)
                movem.l 240(A5),D0-A4
                movem.l D0-A4,240(A6)
                movem.l 288(A5),D0-A4
                movem.l D0-A4,288(A6)
                movem.l 336(A5),D0-A4
                movem.l D0-A4,336(A6)
                movem.l 384(A5),D0-A4
                movem.l D0-A4,384(A6)
                movem.l 432(A5),D0-A4
                movem.l D0-A4,432(A6)
                movem.l 480(A5),D0-A4
                movem.l D0-A4,480(A6)
                movem.l 528(A5),D0-A4
                movem.l D0-A4,528(A6)
                movem.l 576(A5),D0-A4
                movem.l D0-A4,576(A6)
                movem.l 624(A5),D0-A4
                movem.l D0-A4,624(A6)
                movem.l 672(A5),D0-A4
                movem.l D0-A4,672(A6)
                movem.l 720(A5),D0-A4
                movem.l D0-A4,720(A6)
                movem.l 768(A5),D0-A4
                movem.l D0-A4,768(A6)
                movem.l 816(A5),D0-A4
                movem.l D0-A4,816(A6)
                movem.l 864(A5),D0-A4
                movem.l D0-A4,864(A6)
                movem.l 912(A5),D0-A4
                movem.l D0-A4,912(A6)
                movem.l 960(A5),D0-A4
                movem.l D0-A4,960(A6)
                movem.l 1008(A5),D0-A4
                movem.l D0-A4,1008(A6)
                movem.l 1056(A5),D0-A4
                movem.l D0-A4,1056(A6)
                movem.l 1104(A5),D0-A4
                movem.l D0-A4,1104(A6)
                movem.l 1152(A5),D0-A4
                movem.l D0-A4,1152(A6)
                movem.l 1200(A5),D0-A4
                movem.l D0-A4,1200(A6)
                movem.l 1248(A5),D0-A4
                movem.l D0-A4,1248(A6)
                movem.l 1296(A5),D0-A4
                movem.l D0-A4,1296(A6)
                movem.l 1344(A5),D0-A4
                movem.l D0-A4,1344(A6)
                movem.l 1392(A5),D0-A4
                movem.l D0-A4,1392(A6)
                movem.l 1440(A5),D0-A4
                movem.l D0-A4,1440(A6)
                movem.l 1488(A5),D0-A4
                movem.l D0-A4,1488(A6)
                movem.l 1536(A5),D0-A4
                movem.l D0-A4,1536(A6)
                movem.l 1584(A5),D0-A4
                movem.l D0-A4,1584(A6)
                movem.l 1632(A5),D0-A4
                movem.l D0-A4,1632(A6)
                movem.l 1680(A5),D0-A4
                movem.l D0-A4,1680(A6)
                movem.l 1728(A5),D0-A4
                movem.l D0-A4,1728(A6)
                movem.l 1776(A5),D0-A4
                movem.l D0-A4,1776(A6)
                movem.l 1824(A5),D0-A4
                movem.l D0-A4,1824(A6)
                movem.l 1872(A5),D0-A4
                movem.l D0-A4,1872(A6)
                movem.l 1920(A5),D0-A4
                movem.l D0-A4,1920(A6)
                movem.l 1968(A5),D0-A4
                movem.l D0-A4,1968(A6)
                movem.l 2016(A5),D0-A4
                movem.l D0-A4,2016(A6)
                movem.l 2064(A5),D0-A4
                movem.l D0-A4,2064(A6)
                movem.l 2112(A5),D0-A4
                movem.l D0-A4,2112(A6)
                movem.l 2160(A5),D0-A4
                movem.l D0-A4,2160(A6)
                movem.l 2208(A5),D0-A4
                movem.l D0-A4,2208(A6)
                movem.l 2256(A5),D0-A4
                movem.l D0-A4,2256(A6)
                movem.l 2304(A5),D0-A4
                movem.l D0-A4,2304(A6)
                movem.l 2352(A5),D0-A4
                movem.l D0-A4,2352(A6)
                movem.l 2400(A5),D0-A4
                movem.l D0-A4,2400(A6)
                movem.l 2448(A5),D0-A4
                movem.l D0-A4,2448(A6)
                movem.l 2496(A5),D0-A4
                movem.l D0-A4,2496(A6)
                movem.l 2544(A5),D0-A4
                movem.l D0-A4,2544(A6)
                movem.l 2592(A5),D0-A4
                movem.l D0-A4,2592(A6)
                movem.l 2640(A5),D0-A4
                movem.l D0-A4,2640(A6)
                movem.l 2688(A5),D0-A4
                movem.l D0-A4,2688(A6)
                movem.l 2736(A5),D0-A4
                movem.l D0-A4,2736(A6)
                movem.l 2784(A5),D0-A4
                movem.l D0-A4,2784(A6)
                movem.l 2832(A5),D0-A4
                movem.l D0-A4,2832(A6)
                movem.l 2880(A5),D0-A4
                movem.l D0-A4,2880(A6)
                movem.l 2928(A5),D0-A4
                movem.l D0-A4,2928(A6)
                movem.l 2976(A5),D0-A4
                movem.l D0-A4,2976(A6)
                movem.l 3024(A5),D0-A4
                movem.l D0-A4,3024(A6)
                movem.l 3072(A5),D0-A4
                movem.l D0-A4,3072(A6)
                movem.l 3120(A5),D0-A4
                movem.l D0-A4,3120(A6)
                movem.l 3168(A5),D0-A4
                movem.l D0-A4,3168(A6)
                movem.l 3216(A5),D0-A4
                movem.l D0-A4,3216(A6)
                movem.l 3264(A5),D0-A4
                movem.l D0-A4,3264(A6)
                movem.l 3312(A5),D0-A4
                movem.l D0-A4,3312(A6)
                movem.l 3360(A5),D0-A4
                movem.l D0-A4,3360(A6)
                movem.l 3408(A5),D0-A4
                movem.l D0-A4,3408(A6)
                movem.l 3456(A5),D0-A4
                movem.l D0-A4,3456(A6)
                movem.l 3504(A5),D0-A4
                movem.l D0-A4,3504(A6)
                movem.l 3552(A5),D0-A4
                movem.l D0-A4,3552(A6)
                movem.l 3600(A5),D0-A4
                movem.l D0-A4,3600(A6)
                movem.l 3648(A5),D0-A4
                movem.l D0-A4,3648(A6)
                movem.l 3696(A5),D0-A4
                movem.l D0-A4,3696(A6)
                movem.l 3744(A5),D0-A4
                movem.l D0-A4,3744(A6)
                movem.l 3792(A5),D0-A4
                movem.l D0-A4,3792(A6)
                movem.l 3840(A5),D0-A4
                movem.l D0-A4,3840(A6)
                movem.l 3888(A5),D0-A4
                movem.l D0-A4,3888(A6)
                movem.l 3936(A5),D0-A4
                movem.l D0-A4,3936(A6)
                movem.l 3984(A5),D0-A4
                movem.l D0-A4,3984(A6)
                movem.l 4032(A5),D0-A4
                movem.l D0-A4,4032(A6)
                movem.l 4080(A5),D0-A4
                movem.l D0-A4,4080(A6)
                movem.l 4128(A5),D0-A4
                movem.l D0-A4,4128(A6)
                movem.l 4176(A5),D0-A4
                movem.l D0-A4,4176(A6)
                movem.l 4224(A5),D0-A4
                movem.l D0-A4,4224(A6)
                movem.l 4272(A5),D0-A4
                movem.l D0-A4,4272(A6)
                movem.l 4320(A5),D0-A4
                movem.l D0-A4,4320(A6)
                movem.l 4368(A5),D0-A4
                movem.l D0-A4,4368(A6)
                movem.l 4416(A5),D0-A4
                movem.l D0-A4,4416(A6)
                movem.l 4464(A5),D0-A4
                movem.l D0-A4,4464(A6)
                movem.l 4512(A5),D0-A4
                movem.l D0-A4,4512(A6)
                movem.l 4560(A5),D0-A4
                movem.l D0-A4,4560(A6)
                movem.l 4608(A5),D0-A4
                movem.l D0-A4,4608(A6)
                movem.l 4656(A5),D0-A4
                movem.l D0-A4,4656(A6)
                movem.l 4704(A5),D0-A4
                movem.l D0-A4,4704(A6)
                movem.l 4752(A5),D0-A4
                movem.l D0-A4,4752(A6)
                movem.l 4800(A5),D0-A4
                movem.l D0-A4,4800(A6)
                movem.l 4848(A5),D0-A4
                movem.l D0-A4,4848(A6)
                movem.l 4896(A5),D0-A4
                movem.l D0-A4,4896(A6)
                movem.l 4944(A5),D0-A4
                movem.l D0-A4,4944(A6)
                movem.l 4992(A5),D0-A4
                movem.l D0-A4,4992(A6)
                movem.l 5040(A5),D0-A4
                movem.l D0-A4,5040(A6)
                movem.l 5088(A5),D0-A4
                movem.l D0-A4,5088(A6)
                movem.l 5136(A5),D0-A4
                movem.l D0-A4,5136(A6)
                movem.l 5184(A5),D0-A4
                movem.l D0-A4,5184(A6)
                movem.l 5232(A5),D0-A4
                movem.l D0-A4,5232(A6)
                movem.l 5280(A5),D0-A4
                movem.l D0-A4,5280(A6)
                movem.l 5328(A5),D0-A4
                movem.l D0-A4,5328(A6)
                movem.l 5376(A5),D0-A4
                movem.l D0-A4,5376(A6)
                movem.l 5424(A5),D0-A4
                movem.l D0-A4,5424(A6)
                movem.l 5472(A5),D0-A4
                movem.l D0-A4,5472(A6)
                movem.l 5520(A5),D0-A4
                movem.l D0-A4,5520(A6)
                movem.l 5568(A5),D0-A4
                movem.l D0-A4,5568(A6)
                movem.l 5616(A5),D0-A4
                movem.l D0-A4,5616(A6)
                movem.l 5664(A5),D0-A4
                movem.l D0-A4,5664(A6)
                movem.l 5712(A5),D0-A4
                movem.l D0-A4,5712(A6)
                movem.l 5760(A5),D0-A4
                movem.l D0-A4,5760(A6)
                movem.l 5808(A5),D0-A4
                movem.l D0-A4,5808(A6)
                movem.l 5856(A5),D0-A4
                movem.l D0-A4,5856(A6)
                movem.l 5904(A5),D0-A4
                movem.l D0-A4,5904(A6)
                movem.l 5952(A5),D0-A4
                movem.l D0-A4,5952(A6)
                movem.l 6000(A5),D0-A4
                movem.l D0-A4,6000(A6)
                movem.l 6048(A5),D0-A4
                movem.l D0-A4,6048(A6)
                movem.l 6096(A5),D0-A4
                movem.l D0-A4,6096(A6)
                movem.l 6144(A5),D0-A4
                movem.l D0-A4,6144(A6)
                movem.l 6192(A5),D0-A4
                movem.l D0-A4,6192(A6)
                movem.l 6240(A5),D0-A4
                movem.l D0-A4,6240(A6)
                movem.l 6288(A5),D0-A4
                movem.l D0-A4,6288(A6)
                movem.l 6336(A5),D0-A4
                movem.l D0-A4,6336(A6)
                movem.l 6384(A5),D0-A4
                movem.l D0-A4,6384(A6)
                movem.l 6432(A5),D0-A4
                movem.l D0-A4,6432(A6)
                movem.l 6480(A5),D0-A4
                movem.l D0-A4,6480(A6)
                movem.l 6528(A5),D0-A4
                movem.l D0-A4,6528(A6)
                movem.l 6576(A5),D0-A4
                movem.l D0-A4,6576(A6)
                movem.l 6624(A5),D0-A4
                movem.l D0-A4,6624(A6)
                movem.l 6672(A5),D0-A4
                movem.l D0-A4,6672(A6)
                movem.l 6720(A5),D0-A4
                movem.l D0-A4,6720(A6)
                movem.l 6768(A5),D0-A4
                movem.l D0-A4,6768(A6)
                movem.l 6816(A5),D0-A4
                movem.l D0-A4,6816(A6)
                movem.l 6864(A5),D0-A4
                movem.l D0-A4,6864(A6)
                movem.l 6912(A5),D0-A4
                movem.l D0-A4,6912(A6)
                movem.l 6960(A5),D0-A4
                movem.l D0-A4,6960(A6)
                movem.l 7008(A5),D0-A4
                movem.l D0-A4,7008(A6)
                movem.l 7056(A5),D0-A4
                movem.l D0-A4,7056(A6)
                movem.l 7104(A5),D0-A4
                movem.l D0-A4,7104(A6)
                movem.l 7152(A5),D0-A4
                movem.l D0-A4,7152(A6)
                movem.l 7200(A5),D0-A4
                movem.l D0-A4,7200(A6)
                movem.l 7248(A5),D0-A4
                movem.l D0-A4,7248(A6)
                movem.l 7296(A5),D0-A4
                movem.l D0-A4,7296(A6)
                movem.l 7344(A5),D0-A4
                movem.l D0-A4,7344(A6)
                movem.l 7392(A5),D0-A4
                movem.l D0-A4,7392(A6)
                movem.l 7440(A5),D0-A4
                movem.l D0-A4,7440(A6)
                movem.l 7488(A5),D0-A4
                movem.l D0-A4,7488(A6)
                movem.l 7536(A5),D0-A4
                movem.l D0-A4,7536(A6)
                movem.l 7584(A5),D0-A4
                movem.l D0-A4,7584(A6)
                movem.l 7632(A5),D0-A4
                movem.l D0-A4,7632(A6)
                movem.l 7680(A5),D0-A4
                movem.l D0-A4,7680(A6)
                movem.l 7728(A5),D0-A4
                movem.l D0-A4,7728(A6)
                movem.l 7776(A5),D0-A4
                movem.l D0-A4,7776(A6)
                movem.l 7824(A5),D0-A4
                movem.l D0-A4,7824(A6)
                movem.l 7872(A5),D0-A4
                movem.l D0-A4,7872(A6)
                movem.l 7920(A5),D0-A4
                movem.l D0-A4,7920(A6)
                movem.l 7968(A5),D0-A4
                movem.l D0-A4,7968(A6)
                movem.l 8016(A5),D0-A4
                movem.l D0-A4,8016(A6)
                movem.l 8064(A5),D0-A4
                movem.l D0-A4,8064(A6)
                movem.l 8112(A5),D0-A4
                movem.l D0-A4,8112(A6)
                movem.l 8160(A5),D0-A4
                movem.l D0-A4,8160(A6)
                movem.l 8208(A5),D0-A4
                movem.l D0-A4,8208(A6)
                movem.l 8256(A5),D0-A4
                movem.l D0-A4,8256(A6)
                movem.l 8304(A5),D0-A4
                movem.l D0-A4,8304(A6)
                movem.l 8352(A5),D0-A4
                movem.l D0-A4,8352(A6)
                movem.l 8400(A5),D0-A4
                movem.l D0-A4,8400(A6)
                movem.l 8448(A5),D0-A4
                movem.l D0-A4,8448(A6)
                movem.l 8496(A5),D0-A4
                movem.l D0-A4,8496(A6)
                movem.l 8544(A5),D0-A4
                movem.l D0-A4,8544(A6)
                movem.l 8592(A5),D0-A4
                movem.l D0-A4,8592(A6)
                movem.l 8640(A5),D0-A4
                movem.l D0-A4,8640(A6)
                movem.l 8688(A5),D0-A4
                movem.l D0-A4,8688(A6)
                movem.l 8736(A5),D0-A4
                movem.l D0-A4,8736(A6)
                movem.l 8784(A5),D0-A4
                movem.l D0-A4,8784(A6)
                movem.l 8832(A5),D0-A4
                movem.l D0-A4,8832(A6)
                movem.l 8880(A5),D0-A4
                movem.l D0-A4,8880(A6)
                movem.l 8928(A5),D0-A4
                movem.l D0-A4,8928(A6)
                movem.l 8976(A5),D0-A4
                movem.l D0-A4,8976(A6)
                movem.l 9024(A5),D0-A4
                movem.l D0-A4,9024(A6)
                movem.l 9072(A5),D0-A4
                movem.l D0-A4,9072(A6)
                movem.l 9120(A5),D0-A4
                movem.l D0-A4,9120(A6)
                movem.l 9168(A5),D0-A4
                movem.l D0-A4,9168(A6)
                movem.l 9216(A5),D0-A4
                movem.l D0-A4,9216(A6)
                movem.l 9264(A5),D0-A4
                movem.l D0-A4,9264(A6)
                movem.l 9312(A5),D0-A4
                movem.l D0-A4,9312(A6)
                movem.l 9360(A5),D0-A4
                movem.l D0-A4,9360(A6)
                movem.l 9408(A5),D0-A4
                movem.l D0-A4,9408(A6)
                movem.l 9456(A5),D0-A4
                movem.l D0-A4,9456(A6)
                movem.l 9504(A5),D0-A4
                movem.l D0-A4,9504(A6)
                movem.l 9552(A5),D0-A4
                movem.l D0-A4,9552(A6)
                movem.l 9600(A5),D0-A4
                movem.l D0-A4,9600(A6)
                movem.l 9648(A5),D0-A4
                movem.l D0-A4,9648(A6)
                movem.l 9696(A5),D0-A4
                movem.l D0-A4,9696(A6)
                movem.l 9744(A5),D0-A4
                movem.l D0-A4,9744(A6)
                movem.l 9792(A5),D0-A4
                movem.l D0-A4,9792(A6)
                movem.l 9840(A5),D0-A4
                movem.l D0-A4,9840(A6)
                movem.l 9888(A5),D0-A4
                movem.l D0-A4,9888(A6)
                movem.l 9936(A5),D0-A4
                movem.l D0-A4,9936(A6)
                movem.l 9984(A5),D0-A4
                movem.l D0-A4,9984(A6)
                movem.l 10032(A5),D0-A4
                movem.l D0-A4,10032(A6)
                movem.l 10080(A5),D0-A4
                movem.l D0-A4,10080(A6)
                movem.l 10128(A5),D0-A4
                movem.l D0-A4,10128(A6)
                movem.l 10176(A5),D0-A4
                movem.l D0-A4,10176(A6)
                movem.l 10224(A5),D0-A4
                movem.l D0-A4,10224(A6)
                movem.l 10272(A5),D0-A4
                movem.l D0-A4,10272(A6)
                movem.l 10320(A5),D0-A4
                movem.l D0-A4,10320(A6)
                movem.l 10368(A5),D0-A4
                movem.l D0-A4,10368(A6)
                movem.l 10416(A5),D0-A4
                movem.l D0-A4,10416(A6)
                movem.l 10464(A5),D0-A4
                movem.l D0-A4,10464(A6)
                movem.l 10512(A5),D0-A4
                movem.l D0-A4,10512(A6)
                movem.l 10560(A5),D0-A4
                movem.l D0-A4,10560(A6)
                movem.l 10608(A5),D0-A4
                movem.l D0-A4,10608(A6)
                movem.l 10656(A5),D0-A4
                movem.l D0-A4,10656(A6)
                movem.l 10704(A5),D0-A4
                movem.l D0-A4,10704(A6)
                movem.l 10752(A5),D0-A4
                movem.l D0-A4,10752(A6)
                movem.l 10800(A5),D0-A4
                movem.l D0-A4,10800(A6)
                movem.l 10848(A5),D0-A4
                movem.l D0-A4,10848(A6)
                movem.l 10896(A5),D0-A4
                movem.l D0-A4,10896(A6)
                movem.l 10944(A5),D0-A4
                movem.l D0-A4,10944(A6)
                movem.l 10992(A5),D0-A4
                movem.l D0-A4,10992(A6)
                movem.l 11040(A5),D0-A4
                movem.l D0-A4,11040(A6)
                movem.l 11088(A5),D0-A4
                movem.l D0-A4,11088(A6)
                movem.l 11136(A5),D0-A4
                movem.l D0-A4,11136(A6)
                movem.l 11184(A5),D0-A4
                movem.l D0-A4,11184(A6)
                movem.l 11232(A5),D0-A4
                movem.l D0-A4,11232(A6)
                movem.l 11280(A5),D0-A4
                movem.l D0-A4,11280(A6)
                movem.l 11328(A5),D0-A4
                movem.l D0-A4,11328(A6)
                movem.l 11376(A5),D0-A4
                movem.l D0-A4,11376(A6)
                movem.l 11424(A5),D0-A4
                movem.l D0-A4,11424(A6)
                movem.l 11472(A5),D0-A4
                movem.l D0-A4,11472(A6)
                movem.l 11520(A5),D0-A4
                movem.l D0-A4,11520(A6)
                movem.l 11568(A5),D0-A4
                movem.l D0-A4,11568(A6)
                movem.l 11616(A5),D0-A4
                movem.l D0-A4,11616(A6)
                movem.l 11664(A5),D0-A4
                movem.l D0-A4,11664(A6)
                movem.l 11712(A5),D0-A4
                movem.l D0-A4,11712(A6)
                movem.l 11760(A5),D0-A4
                movem.l D0-A4,11760(A6)
                movem.l 11808(A5),D0-A4
                movem.l D0-A4,11808(A6)
                movem.l 11856(A5),D0-A4
                movem.l D0-A4,11856(A6)
                movem.l 11904(A5),D0-A4
                movem.l D0-A4,11904(A6)
                movem.l 11952(A5),D0-A4
                movem.l D0-A4,11952(A6)
                movem.l 12000(A5),D0-A4
                movem.l D0-A4,12000(A6)
                movem.l 12048(A5),D0-A4
                movem.l D0-A4,12048(A6)
                movem.l 12096(A5),D0-A4
                movem.l D0-A4,12096(A6)
                movem.l 12144(A5),D0-A4
                movem.l D0-A4,12144(A6)
                movem.l 12192(A5),D0-A4
                movem.l D0-A4,12192(A6)
                movem.l 12240(A5),D0-A4
                movem.l D0-A4,12240(A6)
                movem.l 12288(A5),D0-A4
                movem.l D0-A4,12288(A6)
                movem.l 12336(A5),D0-A4
                movem.l D0-A4,12336(A6)
                movem.l 12384(A5),D0-A4
                movem.l D0-A4,12384(A6)
                movem.l 12432(A5),D0-A4
                movem.l D0-A4,12432(A6)
                movem.l 12480(A5),D0-A4
                movem.l D0-A4,12480(A6)
                movem.l 12528(A5),D0-A4
                movem.l D0-A4,12528(A6)
                movem.l 12576(A5),D0-A4
                movem.l D0-A4,12576(A6)
                movem.l 12624(A5),D0-A4
                movem.l D0-A4,12624(A6)
                movem.l 12672(A5),D0-A4
                movem.l D0-A4,12672(A6)
                movem.l 12720(A5),D0-A4
                movem.l D0-A4,12720(A6)
                movem.l 12768(A5),D0-A4
                movem.l D0-A4,12768(A6)
                movem.l 12816(A5),D0-A4
                movem.l D0-A4,12816(A6)
                movem.l 12864(A5),D0-A4
                movem.l D0-A4,12864(A6)
                movem.l 12912(A5),D0-A4
                movem.l D0-A4,12912(A6)
                movem.l 12960(A5),D0-A4
                movem.l D0-A4,12960(A6)
                movem.l 13008(A5),D0-A4
                movem.l D0-A4,13008(A6)
                movem.l 13056(A5),D0-A4
                movem.l D0-A4,13056(A6)
                movem.l 13104(A5),D0-A4
                movem.l D0-A4,13104(A6)
                movem.l 13152(A5),D0-A4
                movem.l D0-A4,13152(A6)
                movem.l 13200(A5),D0-A4
                movem.l D0-A4,13200(A6)
                movem.l 13248(A5),D0-A4
                movem.l D0-A4,13248(A6)
                movem.l 13296(A5),D0-A4
                movem.l D0-A4,13296(A6)
                movem.l 13344(A5),D0-A4
                movem.l D0-A4,13344(A6)
                movem.l 13392(A5),D0-A4
                movem.l D0-A4,13392(A6)
                movem.l 13440(A5),D0-A4
                movem.l D0-A4,13440(A6)
                movem.l 13488(A5),D0-A4
                movem.l D0-A4,13488(A6)
                movem.l 13536(A5),D0-A4
                movem.l D0-A4,13536(A6)
                movem.l 13584(A5),D0-A4
                movem.l D0-A4,13584(A6)
                movem.l 13632(A5),D0-A4
                movem.l D0-A4,13632(A6)
                movem.l 13680(A5),D0-A4
                movem.l D0-A4,13680(A6)
                movem.l 13728(A5),D0-A4
                movem.l D0-A4,13728(A6)
                movem.l 13776(A5),D0-A4
                movem.l D0-A4,13776(A6)
                movem.l 13824(A5),D0-A4
                movem.l D0-A4,13824(A6)
                movem.l 13872(A5),D0-A4
                movem.l D0-A4,13872(A6)
                movem.l 13920(A5),D0-A4
                movem.l D0-A4,13920(A6)
                movem.l 13968(A5),D0-A4
                movem.l D0-A4,13968(A6)
                movem.l 14016(A5),D0-A4
                movem.l D0-A4,14016(A6)
                movem.l 14064(A5),D0-A4
                movem.l D0-A4,14064(A6)
                movem.l 14112(A5),D0-A4
                movem.l D0-A4,14112(A6)
                movem.l 14160(A5),D0-A4
                movem.l D0-A4,14160(A6)
                movem.l 14208(A5),D0-A4
                movem.l D0-A4,14208(A6)
                movem.l 14256(A5),D0-A4
                movem.l D0-A4,14256(A6)
                movem.l 14304(A5),D0-A4
                movem.l D0-A4,14304(A6)
                movem.l 14352(A5),D0-A4
                movem.l D0-A4,14352(A6)
                movem.l 14400(A5),D0-A4
                movem.l D0-A4,14400(A6)
                movem.l 14448(A5),D0-A4
                movem.l D0-A4,14448(A6)
                movem.l 14496(A5),D0-A4
                movem.l D0-A4,14496(A6)
                movem.l 14544(A5),D0-A4
                movem.l D0-A4,14544(A6)
                movem.l 14592(A5),D0-A4
                movem.l D0-A4,14592(A6)
                movem.l 14640(A5),D0-A4
                movem.l D0-A4,14640(A6)
                movem.l 14688(A5),D0-A4
                movem.l D0-A4,14688(A6)
                movem.l 14736(A5),D0-A4
                movem.l D0-A4,14736(A6)
                movem.l 14784(A5),D0-A4
                movem.l D0-A4,14784(A6)
                movem.l 14832(A5),D0-A4
                movem.l D0-A4,14832(A6)
                movem.l 14880(A5),D0-A4
                movem.l D0-A4,14880(A6)
                movem.l 14928(A5),D0-A4
                movem.l D0-A4,14928(A6)
                movem.l 14976(A5),D0-A4
                movem.l D0-A4,14976(A6)
                movem.l 15024(A5),D0-A4
                movem.l D0-A4,15024(A6)
                movem.l 15072(A5),D0-A4
                movem.l D0-A4,15072(A6)
                movem.l 15120(A5),D0-A4
                movem.l D0-A4,15120(A6)
                movem.l 15168(A5),D0-A4
                movem.l D0-A4,15168(A6)
                movem.l 15216(A5),D0-A4
                movem.l D0-A4,15216(A6)
                movem.l 15264(A5),D0-A4
                movem.l D0-A4,15264(A6)
                movem.l 15312(A5),D0-A4
                movem.l D0-A4,15312(A6)
                movem.l 15360(A5),D0-A4
                movem.l D0-A4,15360(A6)
                movem.l 15408(A5),D0-A4
                movem.l D0-A4,15408(A6)
                movem.l 15456(A5),D0-A4
                movem.l D0-A4,15456(A6)
                movem.l 15504(A5),D0-A4
                movem.l D0-A4,15504(A6)
                movem.l 15552(A5),D0-A4
                movem.l D0-A4,15552(A6)
                movem.l 15600(A5),D0-A4
                movem.l D0-A4,15600(A6)
                movem.l 15648(A5),D0-A4
                movem.l D0-A4,15648(A6)
                movem.l 15696(A5),D0-A4
                movem.l D0-A4,15696(A6)
                movem.l 15744(A5),D0-A4
                movem.l D0-A4,15744(A6)
                movem.l 15792(A5),D0-A4
                movem.l D0-A4,15792(A6)
                movem.l 15840(A5),D0-A4
                movem.l D0-A4,15840(A6)
                movem.l 15888(A5),D0-A4
                movem.l D0-A4,15888(A6)
                movem.l 15936(A5),D0-A4
                movem.l D0-A4,15936(A6)
                movem.l 15984(A5),D0-A4
                movem.l D0-A4,15984(A6)
                movem.l 16032(A5),D0-A4
                movem.l D0-A4,16032(A6)
                movem.l 16080(A5),D0-A4
                movem.l D0-A4,16080(A6)
                movem.l 16128(A5),D0-A4
                movem.l D0-A4,16128(A6)
                movem.l 16176(A5),D0-A4
                movem.l D0-A4,16176(A6)
                movem.l 16224(A5),D0-A4
                movem.l D0-A4,16224(A6)
                movem.l 16272(A5),D0-A4
                movem.l D0-A4,16272(A6)
                movem.l 16320(A5),D0-A4
                movem.l D0-A4,16320(A6)
                movem.l 16368(A5),D0-A4
                movem.l D0-A4,16368(A6)
                movem.l 16416(A5),D0-A4
                movem.l D0-A4,16416(A6)
                movem.l 16464(A5),D0-A4
                movem.l D0-A4,16464(A6)
                movem.l 16512(A5),D0-A4
                movem.l D0-A4,16512(A6)
                movem.l 16560(A5),D0-A4
                movem.l D0-A4,16560(A6)
                movem.l 16608(A5),D0-A4
                movem.l D0-A4,16608(A6)
                movem.l 16656(A5),D0-A4
                movem.l D0-A4,16656(A6)
                movem.l 16704(A5),D0-A4
                movem.l D0-A4,16704(A6)
                movem.l 16752(A5),D0-A4
                movem.l D0-A4,16752(A6)
                movem.l 16800(A5),D0-A4
                movem.l D0-A4,16800(A6)
                movem.l 16848(A5),D0-A4
                movem.l D0-A4,16848(A6)
                movem.l 16896(A5),D0-A4
                movem.l D0-A4,16896(A6)
                movem.l 16944(A5),D0-A4
                movem.l D0-A4,16944(A6)
                movem.l 16992(A5),D0-A4
                movem.l D0-A4,16992(A6)
                movem.l 17040(A5),D0-A4
                movem.l D0-A4,17040(A6)
                movem.l 17088(A5),D0-A4
                movem.l D0-A4,17088(A6)
                movem.l 17136(A5),D0-A4
                movem.l D0-A4,17136(A6)
                movem.l 17184(A5),D0-A4
                movem.l D0-A4,17184(A6)
                movem.l 17232(A5),D0-A4
                movem.l D0-A4,17232(A6)
                movem.l 17280(A5),D0-A4
                movem.l D0-A4,17280(A6)
                movem.l 17328(A5),D0-A4
                movem.l D0-A4,17328(A6)
                movem.l 17376(A5),D0-A4
                movem.l D0-A4,17376(A6)
                movem.l 17424(A5),D0-A4
                movem.l D0-A4,17424(A6)
                movem.l 17472(A5),D0-A4
                movem.l D0-A4,17472(A6)
                movem.l 17520(A5),D0-A4
                movem.l D0-A4,17520(A6)
                movem.l 17568(A5),D0-A4
                movem.l D0-A4,17568(A6)
                movem.l 17616(A5),D0-A4
                movem.l D0-A4,17616(A6)
                movem.l 17664(A5),D0-A4
                movem.l D0-A4,17664(A6)
                movem.l 17712(A5),D0-A4
                movem.l D0-A4,17712(A6)
                movem.l 17760(A5),D0-A4
                movem.l D0-A4,17760(A6)
                movem.l 17808(A5),D0-A4
                movem.l D0-A4,17808(A6)
                movem.l 17856(A5),D0-A4
                movem.l D0-A4,17856(A6)
                movem.l 17904(A5),D0-A4
                movem.l D0-A4,17904(A6)
                movem.l 17952(A5),D0-A4
                movem.l D0-A4,17952(A6)
                movem.l 18000(A5),D0-A4
                movem.l D0-A4,18000(A6)
                movem.l 18048(A5),D0-A4
                movem.l D0-A4,18048(A6)
                movem.l 18096(A5),D0-A4
                movem.l D0-A4,18096(A6)
                movem.l 18144(A5),D0-A4
                movem.l D0-A4,18144(A6)
                movem.l 18192(A5),D0-A4
                movem.l D0-A4,18192(A6)
                movem.l 18240(A5),D0-A4
                movem.l D0-A4,18240(A6)
                movem.l 18288(A5),D0-A4
                movem.l D0-A4,18288(A6)
                movem.l 18336(A5),D0-A4
                movem.l D0-A4,18336(A6)
                movem.l 18384(A5),D0-A4
                movem.l D0-A4,18384(A6)
                movem.l 18432(A5),D0-A4
                movem.l D0-A4,18432(A6)
                movem.l 18480(A5),D0-A4
                movem.l D0-A4,18480(A6)
                movem.l 18528(A5),D0-A4
                movem.l D0-A4,18528(A6)
                movem.l 18576(A5),D0-A4
                movem.l D0-A4,18576(A6)
                movem.l 18624(A5),D0-A4
                movem.l D0-A4,18624(A6)
                movem.l 18672(A5),D0-A4
                movem.l D0-A4,18672(A6)
                movem.l 18720(A5),D0-A4
                movem.l D0-A4,18720(A6)
                movem.l 18768(A5),D0-A4
                movem.l D0-A4,18768(A6)
                movem.l 18816(A5),D0-A4
                movem.l D0-A4,18816(A6)
                movem.l 18864(A5),D0-A4
                movem.l D0-A4,18864(A6)
                movem.l 18912(A5),D0-A4
                movem.l D0-A4,18912(A6)
                movem.l 18960(A5),D0-A4
                movem.l D0-A4,18960(A6)
                movem.l 19008(A5),D0-A4
                movem.l D0-A4,19008(A6)
                movem.l 19056(A5),D0-A4
                movem.l D0-A4,19056(A6)
                movem.l 19104(A5),D0-A4
                movem.l D0-A4,19104(A6)
                movem.l 19152(A5),D0-A4
                movem.l D0-A4,19152(A6)
                movem.l 19200(A5),D0-A4
                movem.l D0-A4,19200(A6)
                movem.l 19248(A5),D0-A4
                movem.l D0-A4,19248(A6)
                movem.l 19296(A5),D0-A4
                movem.l D0-A4,19296(A6)
                movem.l 19344(A5),D0-A4
                movem.l D0-A4,19344(A6)
                movem.l 19392(A5),D0-A4
                movem.l D0-A4,19392(A6)
                movem.l 19440(A5),D0-A4
                movem.l D0-A4,19440(A6)
                movem.l 19488(A5),D0-A4
                movem.l D0-A4,19488(A6)
                movem.l 19536(A5),D0-A4
                movem.l D0-A4,19536(A6)
                movem.l 19584(A5),D0-A4
                movem.l D0-A4,19584(A6)
                movem.l 19632(A5),D0-A4
                movem.l D0-A4,19632(A6)
                movem.l 19680(A5),D0-A4
                movem.l D0-A4,19680(A6)
                movem.l 19728(A5),D0-A4
                movem.l D0-A4,19728(A6)
                movem.l 19776(A5),D0-A4
                movem.l D0-A4,19776(A6)
                movem.l 19824(A5),D0-A4
                movem.l D0-A4,19824(A6)
                movem.l 19872(A5),D0-A4
                movem.l D0-A4,19872(A6)
                movem.l 19920(A5),D0-A4
                movem.l D0-A4,19920(A6)
                movem.l 19968(A5),D0-A4
                movem.l D0-A4,19968(A6)
                movem.l 20016(A5),D0-A4
                movem.l D0-A4,20016(A6)
                movem.l 20064(A5),D0-A4
                movem.l D0-A4,20064(A6)
                movem.l 20112(A5),D0-A4
                movem.l D0-A4,20112(A6)
                movem.l 20160(A5),D0-A4
                movem.l D0-A4,20160(A6)
                movem.l 20208(A5),D0-A4
                movem.l D0-A4,20208(A6)
                movem.l 20256(A5),D0-A4
                movem.l D0-A4,20256(A6)
                movem.l 20304(A5),D0-A4
                movem.l D0-A4,20304(A6)
                movem.l 20352(A5),D0-A4
                movem.l D0-A4,20352(A6)
                movem.l 20400(A5),D0-A4
                movem.l D0-A4,20400(A6)
                movem.l 20448(A5),D0-A4
                movem.l D0-A4,20448(A6)
                movem.l 20496(A5),D0-A4
                movem.l D0-A4,20496(A6)
                movem.l 20544(A5),D0-A4
                movem.l D0-A4,20544(A6)
                movem.l 20592(A5),D0-A4
                movem.l D0-A4,20592(A6)
                movem.l 20640(A5),D0-A4
                movem.l D0-A4,20640(A6)
                movem.l 20688(A5),D0-A4
                movem.l D0-A4,20688(A6)
                movem.l 20736(A5),D0-A4
                movem.l D0-A4,20736(A6)
                movem.l 20784(A5),D0-A4
                movem.l D0-A4,20784(A6)
                movem.l 20832(A5),D0-A4
                movem.l D0-A4,20832(A6)
                movem.l 20880(A5),D0-A4
                movem.l D0-A4,20880(A6)
                movem.l 20928(A5),D0-A4
                movem.l D0-A4,20928(A6)
                movem.l 20976(A5),D0-A4
                movem.l D0-A4,20976(A6)
                movem.l 21024(A5),D0-A4
                movem.l D0-A4,21024(A6)
                movem.l 21072(A5),D0-A4
                movem.l D0-A4,21072(A6)
                movem.l 21120(A5),D0-A4
                movem.l D0-A4,21120(A6)
                movem.l 21168(A5),D0-A4
                movem.l D0-A4,21168(A6)
                movem.l 21216(A5),D0-A4
                movem.l D0-A4,21216(A6)
                movem.l 21264(A5),D0-A4
                movem.l D0-A4,21264(A6)
                movem.l 21312(A5),D0-A4
                movem.l D0-A4,21312(A6)
                movem.l 21360(A5),D0-A4
                movem.l D0-A4,21360(A6)
                movem.l 21408(A5),D0-A4
                movem.l D0-A4,21408(A6)
                movem.l 21456(A5),D0-A4
                movem.l D0-A4,21456(A6)
                movem.l 21504(A5),D0-A4
                movem.l D0-A4,21504(A6)
                movem.l 21552(A5),D0-A4
                movem.l D0-A4,21552(A6)
                movem.l 21600(A5),D0-A4
                movem.l D0-A4,21600(A6)
                movem.l 21648(A5),D0-A4
                movem.l D0-A4,21648(A6)
                movem.l 21696(A5),D0-A4
                movem.l D0-A4,21696(A6)
                movem.l 21744(A5),D0-A4
                movem.l D0-A4,21744(A6)
                movem.l 21792(A5),D0-A4
                movem.l D0-A4,21792(A6)
                movem.l 21840(A5),D0-A4
                movem.l D0-A4,21840(A6)
                movem.l 21888(A5),D0-A4
                movem.l D0-A4,21888(A6)
                movem.l 21936(A5),D0-A4
                movem.l D0-A4,21936(A6)
                movem.l 21984(A5),D0-A4
                movem.l D0-A4,21984(A6)
                movem.l 22032(A5),D0-A4
                movem.l D0-A4,22032(A6)
                movem.l 22080(A5),D0-A4
                movem.l D0-A4,22080(A6)
                movem.l 22128(A5),D0-A4
                movem.l D0-A4,22128(A6)
                movem.l 22176(A5),D0-A4
                movem.l D0-A4,22176(A6)
                movem.l 22224(A5),D0-A4
                movem.l D0-A4,22224(A6)
                movem.l 22272(A5),D0-A4
                movem.l D0-A4,22272(A6)
                movem.l 22320(A5),D0-A4
                movem.l D0-A4,22320(A6)
                movem.l 22368(A5),D0-A4
                movem.l D0-A4,22368(A6)
                movem.l 22416(A5),D0-A4
                movem.l D0-A4,22416(A6)
                movem.l 22464(A5),D0-A4
                movem.l D0-A4,22464(A6)
                movem.l 22512(A5),D0-A4
                movem.l D0-A4,22512(A6)
                movem.l 22560(A5),D0-A4
                movem.l D0-A4,22560(A6)
                movem.l 22608(A5),D0-A4
                movem.l D0-A4,22608(A6)
                movem.l 22656(A5),D0-A4
                movem.l D0-A4,22656(A6)
                movem.l 22704(A5),D0-A4
                movem.l D0-A4,22704(A6)
                movem.l 22752(A5),D0-A4
                movem.l D0-A4,22752(A6)
                movem.l 22800(A5),D0-A4
                movem.l D0-A4,22800(A6)
                movem.l 22848(A5),D0-A4
                movem.l D0-A4,22848(A6)
                movem.l 22896(A5),D0-A4
                movem.l D0-A4,22896(A6)
                movem.l 22944(A5),D0-A4
                movem.l D0-A4,22944(A6)
                movem.l 22992(A5),D0-A4
                movem.l D0-A4,22992(A6)
                movem.l 23040(A5),D0-A4
                movem.l D0-A4,23040(A6)
                movem.l 23088(A5),D0-A4
                movem.l D0-A4,23088(A6)
                movem.l 23136(A5),D0-A4
                movem.l D0-A4,23136(A6)
                movem.l 23184(A5),D0-A4
                movem.l D0-A4,23184(A6)
                movem.l 23232(A5),D0-A4
                movem.l D0-A4,23232(A6)
                movem.l 23280(A5),D0-A4
                movem.l D0-A4,23280(A6)
                movem.l 23328(A5),D0-A4
                movem.l D0-A4,23328(A6)
                movem.l 23376(A5),D0-A4
                movem.l D0-A4,23376(A6)
                movem.l 23424(A5),D0-A4
                movem.l D0-A4,23424(A6)
                movem.l 23472(A5),D0-A4
                movem.l D0-A4,23472(A6)
                movem.l 23520(A5),D0-A4
                movem.l D0-A4,23520(A6)
                movem.l 23568(A5),D0-A4
                movem.l D0-A4,23568(A6)
                movem.l 23616(A5),D0-A4
                movem.l D0-A4,23616(A6)
                movem.l 23664(A5),D0-A4
                movem.l D0-A4,23664(A6)
                movem.l 23712(A5),D0-A4
                movem.l D0-A4,23712(A6)
                movem.l 23760(A5),D0-A4
                movem.l D0-A4,23760(A6)
                movem.l 23808(A5),D0-A4
                movem.l D0-A4,23808(A6)
                movem.l 23856(A5),D0-A4
                movem.l D0-A4,23856(A6)
                movem.l 23904(A5),D0-A4
                movem.l D0-A4,23904(A6)
                movem.l 23952(A5),D0-A3
                movem.l D0-A3,23952(A6)


                rts

newsin:         move.w  #0,teiger       ; Clear Sine-Tab.
                moveq   #0,D1
                bra     go_on

muzak:          IBYTES 'FETZ2.IMG'

                DATA
aim1:           DC.L $078000
aim2:           DC.L $070000
teiger:         DC.W 0
flag:           DC.W 0
handle1:        DC.W 0
datei:          DC.B "WEISNICH.DOO",0
                EVEN
gfx:            IBYTES 'GFX.IMG'
sintab:
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 160
                DC.W 160
                DC.W 480
                DC.W 640
                DC.W 960
                DC.W 1120
                DC.W 1440
                DC.W 1920
                DC.W 2240
                DC.W 2720
                DC.W 3200
                DC.W 3680
                DC.W 4160
                DC.W 4800
                DC.W 5440
                DC.W 5920
                DC.W 6560
                DC.W 7200
                DC.W 8000
                DC.W 8640
                DC.W 9440
                DC.W 10080
                DC.W 10880
                DC.W 11680
                DC.W 12480
                DC.W 13280
                DC.W 13920
                DC.W 14720
                DC.W 15520
                DC.W 16320
                DC.W 17120
                DC.W 17920
                DC.W 18720
                DC.W 19520
                DC.W 20320
                DC.W 21120
                DC.W 21920
                DC.W 22560
                DC.W 23360
                DC.W 24000
                DC.W 24640
                DC.W 25280
                DC.W 25920
                DC.W 26560
                DC.W 27200
                DC.W 27680
                DC.W 28320
                DC.W 28800
                DC.W 29280
                DC.W 29600
                DC.W 30080
                DC.W 30400
                DC.W 30720
                DC.W 31040
                DC.W 31200
                DC.W 31520
                DC.W 31680
                DC.W 31680
                DC.W 31840
                DC.W 31840
                DC.W 31840
                DC.W 31840
                DC.W 31840
                DC.W 31680
                DC.W 31520
                DC.W 31360
                DC.W 31200
                DC.W 30880
                DC.W 30560
                DC.W 30240
                DC.W 29920
                DC.W 29440
                DC.W 29120
                DC.W 28640
                DC.W 28000
                DC.W 27520
                DC.W 27040
                DC.W 26400
                DC.W 25760
                DC.W 25120
                DC.W 24480
                DC.W 23840
                DC.W 23040
                DC.W 22400
                DC.W 21600
                DC.W 20800
                DC.W 20000
                DC.W 19360
                DC.W 18560
                DC.W 17760
                DC.W 16960
                DC.W 16160
                DC.W 15360
                DC.W 14560
                DC.W 13760
                DC.W 12960
                DC.W 12160
                DC.W 11360
                DC.W 10560
                DC.W 9920
                DC.W 9120
                DC.W 8480
                DC.W 7680
                DC.W 7040
                DC.W 6400
                DC.W 5760
                DC.W 5120
                DC.W 4640
                DC.W 4000
                DC.W 3520
                DC.W 3040
                DC.W 2560
                DC.W 2080
                DC.W 1760
                DC.W 1440
                DC.W 1120
                DC.W 800
                DC.W 480
                DC.W 320
                DC.W 160
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 160
                DC.W 320
                DC.W 480
                DC.W 640
                DC.W 960
                DC.W 1280
                DC.W 1600
                DC.W 2080
                DC.W 2400
                DC.W 2880
                DC.W 3360
                DC.W 3840
                DC.W 4320
                DC.W 4960
                DC.W 5600
                DC.W 6240
                DC.W 6880
                DC.W 7520
                DC.W 8160
                DC.W 8960
                DC.W 9600
                DC.W 10400
                DC.W 11200
                DC.W 11840
                DC.W 12640
                DC.W 13440
                DC.W 14240
                DC.W 15040
                DC.W 15840
                DC.W 16640
                DC.W 17440
                DC.W 18240
                DC.W 19040
                DC.W 19840
                DC.W 20640
                DC.W 21280
                DC.W 22080
                DC.W 22880
                DC.W 23520
                DC.W 24160
                DC.W 24960
                DC.W 25600
                DC.W 26240
                DC.W 26720
                DC.W 27360
                DC.W 27840
                DC.W 28480
                DC.W 28960
                DC.W 29280
                DC.W 29760
                DC.W 30080
                DC.W 30560
                DC.W 30880
                DC.W 31040
                DC.W 31360
                DC.W 31520
                DC.W 31680
                DC.W 31840
                DC.W 31840
                DC.W 31840
                DC.W 31840
                DC.W 31840
                DC.W 31840
                DC.W 31680
                DC.W 31520
                DC.W 31360
                DC.W 31040
                DC.W 30880
                DC.W 30560
                DC.W 30080
                DC.W 29760
                DC.W 29280
                DC.W 28960
                DC.W 28480
                DC.W 27840
                DC.W 27360
                DC.W 26720
                DC.W 26240
                DC.W 25600
                DC.W 24960
                DC.W 24160
                DC.W 23520
                DC.W 22880
                DC.W 22080
                DC.W 21280
                DC.W 20640
                DC.W 19840
                DC.W 19040
                DC.W 18240
                DC.W 17440
                DC.W 16640
                DC.W 15840
                DC.W 15040
                DC.W 14240
                DC.W 13440
                DC.W 12640
                DC.W 11840
                DC.W 11200
                DC.W 10400
                DC.W 9600
                DC.W 8960
                DC.W 8160
                DC.W 7520
                DC.W 6880
                DC.W 6240
                DC.W 5600
                DC.W 4960
                DC.W 4320
                DC.W 3840
                DC.W 3360
                DC.W 2880
                DC.W 2400
                DC.W 2080
                DC.W 1600
                DC.W 1280
                DC.W 960
                DC.W 640
                DC.W 480
                DC.W 320
                DC.W 160
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 160
                DC.W 320
                DC.W 480
                DC.W 800
                DC.W 1120
                DC.W 1440
                DC.W 1760
                DC.W 2080
                DC.W 2560
                DC.W 3040
                DC.W 3520
                DC.W 4000
                DC.W 4640
                DC.W 5120
                DC.W 5760
                DC.W 6400
                DC.W 7040
                DC.W 7680
                DC.W 8480
                DC.W 9120
                DC.W 9920
                DC.W 10560
                DC.W 11360
                DC.W 12160
                DC.W 12960
                DC.W 13760
                DC.W 14560
                DC.W 15360
                DC.W 16160
                DC.W 16960
                DC.W 17760
                DC.W 18560
                DC.W 19360
                DC.W 20000
                DC.W 20800
                DC.W 21600
                DC.W 22400
                DC.W 23040
                DC.W 23840
                DC.W 24480
                DC.W 25120
                DC.W 25760
                DC.W 26400
                DC.W 27040
                DC.W 27520
                DC.W 28000
                DC.W 28640
                DC.W 29120
                DC.W 29440
                DC.W 29920
                DC.W 30240
                DC.W 30560
                DC.W 30880
                DC.W 31200
                DC.W 31360
                DC.W 31520
                DC.W 31680
                DC.W 31840
                DC.W 31840
                DC.W 31840
                DC.W 31840
                DC.W 31840
                DC.W 31680
                DC.W 31680
                DC.W 31520
                DC.W 31200
                DC.W 31040
                DC.W 30720
                DC.W 30400
                DC.W 30080
                DC.W 29600
                DC.W 29120
                DC.W 28800
                DC.W 28160
                DC.W 27680
                DC.W 27200
                DC.W 26560
                DC.W 25920
                DC.W 25280
                DC.W 24640
                DC.W 24000
                DC.W 23360
                DC.W 22560
                DC.W 21760
                DC.W 21120
                DC.W 20320
                DC.W 19520
                DC.W 18720
                DC.W 17920
                DC.W 17120
                DC.W 16320
                DC.W 15520
                DC.W 14720
                DC.W 13920
                DC.W 13120
                DC.W 12480
                DC.W 11680
                DC.W 10880
                DC.W 10080
                DC.W 9440
                DC.W 8640
                DC.W 8000
                DC.W 7200
                DC.W 6560
                DC.W 5920
                DC.W 5280
                DC.W 4800
                DC.W 4160
                DC.W 3680
                DC.W 3200
                DC.W 2720
                DC.W 2240
                DC.W 1920
                DC.W 1440
                DC.W 1120
                DC.W 960
                DC.W 640
                DC.W 480
                DC.W 160
                DC.W 160
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 160
                DC.W 320
                DC.W 480
                DC.W 640
                DC.W 960
                DC.W 1120
                DC.W 1440
                DC.W 1920
                DC.W 2240
                DC.W 2720
                DC.W 3200
                DC.W 3680
                DC.W 4160
                DC.W 4800
                DC.W 5440
                DC.W 5920
                DC.W 6560
                DC.W 7360
                DC.W 8000
                DC.W 8640
                DC.W 9440
                DC.W 10080
                DC.W 10880
                DC.W 11680
                DC.W 12480
                DC.W 13280
                DC.W 13920
                DC.W 14720
                DC.W 15520
                DC.W 16320
                DC.W 17120
                DC.W 17920
                DC.W 18720
                DC.W 19520
                DC.W 20320
                DC.W 21120
                DC.W 21920
                DC.W 22560
                DC.W 23360
                DC.W 24000
                DC.W 24640
                DC.W 25280
                DC.W 25920
                DC.W 26560
                DC.W 27200
                DC.W 27680
                DC.W 28320
                DC.W 28800
                DC.W 29280
                DC.W 29600
                DC.W 30080
                DC.W 30400
                DC.W 30720
                DC.W 31040
                DC.W 31200
                DC.W 31520
                DC.W 31680
                DC.W 31840
                DC.W 31840
                DC.W 31840
                DC.W 31840
                DC.W 31840
                DC.W 31840
                DC.W 31680
                DC.W 31520
                DC.W 31360
                DC.W 31200
                DC.W 30880
                DC.W 30560
                DC.W 30240
                DC.W 29920
                DC.W 29440
                DC.W 29120
                DC.W 28640
                DC.W 28000
                DC.W 27520
                DC.W 27040
                DC.W 26400
                DC.W 25760
                DC.W 25120
                DC.W 24480
                DC.W 23680
                DC.W 23040
                DC.W 22400
                DC.W 21600
                DC.W 20800
                DC.W 20000
                DC.W 19360
                DC.W 18560
                DC.W 17760
                DC.W 16960
                DC.W 16160
                DC.W 15360
                DC.W 14560
                DC.W 13760
                DC.W 12960
                DC.W 12160
                DC.W 11360
                DC.W 10560
                DC.W 9920
                DC.W 9120
                DC.W 8480
                DC.W 7680
                DC.W 7040
                DC.W 6400
                DC.W 5760
                DC.W 5120
                DC.W 4640
                DC.W 4000
                DC.W 3520
                DC.W 3040
                DC.W 2560
                DC.W 2080
                DC.W 1760
                DC.W 1440
                DC.W 1120
                DC.W 800
                DC.W 480
                DC.W 320
                DC.W 160
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 160
                DC.W 320
                DC.W 480
                DC.W 640
                DC.W 960
                DC.W 1280
                DC.W 1600
                DC.W 2080
                DC.W 2400
                DC.W 2880
                DC.W 3360
                DC.W 3840
                DC.W 4480
                DC.W 4960
                DC.W 5600
                DC.W 6240
                DC.W 6880
                DC.W 7520
                DC.W 8160
                DC.W 8960
                DC.W 9600
                DC.W 10400
                DC.W 11200
                DC.W 11840
                DC.W 12640
                DC.W 13440
                DC.W 14240
                DC.W 15040
                DC.W 15840
                DC.W 16640
                DC.W 17440
                DC.W 18240
                DC.W 19040
                DC.W 19840
                DC.W 20640
                DC.W 21280
                DC.W 22080
                DC.W 22880
                DC.W 23520
                DC.W 24160
                DC.W 24960
                DC.W 25600
                DC.W 26240
                DC.W 26720
                DC.W 27360
                DC.W 27840
                DC.W 28480
                DC.W 28960
                DC.W 29280
                DC.W 29760
                DC.W 30080
                DC.W 30560
                DC.W 30880
                DC.W 31040
                DC.W 31360
                DC.W 31520
                DC.W 31680
                DC.W 31840
                DC.W 31840
                DC.W 31840
                DC.W 31840
                DC.W 31840
                DC.W 31840
                DC.W 31680
                DC.W 31520
                DC.W 31360
                DC.W 31040
                DC.W 30880
                DC.W 30560
                DC.W 30080
                DC.W 29760
                DC.W 29280
                DC.W 28960
                DC.W 28480
                DC.W 27840
                DC.W 27360
                DC.W 26720
                DC.W 26240
                DC.W 25600
                DC.W 24960
                DC.W 24160
                DC.W 23520
                DC.W 22880
                DC.W 22080
                DC.W 21280
                DC.W 20640
                DC.W 19840
                DC.W 19040
                DC.W 18240
                DC.W 17440
                DC.W 16640
                DC.W 15840
                DC.W 15040
                DC.W 14240
                DC.W 13440
                DC.W 12640
                DC.W 11840
                DC.W 11040
                DC.W 10400
                DC.W 9600
                DC.W 8960
                DC.W 8160
                DC.W 7520
                DC.W 6880
                DC.W 6240
                DC.W 5600
                DC.W 4960
                DC.W 4320
                DC.W 3840
                DC.W 3360
                DC.W 2880
                DC.W 2400
                DC.W 2080
                DC.W 1600
                DC.W 1280
                DC.W 960
                DC.W 640
                DC.W 480
                DC.W 320
                DC.W 160
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 160
                DC.W 320
                DC.W 640
                DC.W 800
                DC.W 1120
                DC.W 1440
                DC.W 1760
                DC.W 2080
                DC.W 2560
                DC.W 3040
                DC.W 3520
                DC.W 4000
                DC.W 4640
                DC.W 5120
                DC.W 5760
                DC.W 6400
                DC.W 7040
                DC.W 7680
                DC.W 8480
                DC.W 9120
                DC.W 9920
                DC.W 10560
                DC.W 11360
                DC.W 12160
                DC.W 12960
                DC.W 13760
                DC.W 14560
                DC.W 15360
                DC.W 16160
                DC.W 16960
                DC.W 17760
                DC.W 18560
                DC.W 19360
                DC.W 20160
                DC.W 20800
                DC.W 21600
                DC.W 22400
                DC.W 23040
                DC.W 23840
                DC.W 24480
                DC.W 25120
                DC.W 25760
                DC.W 26400
                DC.W 27040
                DC.W 27520
                DC.W 28000
                DC.W 28640
                DC.W 29120
                DC.W 29440
                DC.W 29920
                DC.W 30240
                DC.W 30560
                DC.W 30880
                DC.W 31200
                DC.W 31360
                DC.W 31520
                DC.W 31680
                DC.W 31840
                DC.W 31840
                DC.W 31840
                DC.W 31840
                DC.W 31840
                DC.W 31680
                DC.W 31680
                DC.W 31520
                DC.W 31200
                DC.W 31040
                DC.W 30720
                DC.W 30400
                DC.W 30080
                DC.W 29600
                DC.W 29120
                DC.W 28800
                DC.W 28160
                DC.W 27680
                DC.W 27200
                DC.W 26560
                DC.W 25920
                DC.W 25280
                DC.W 24640
                DC.W 24000
                DC.W 23360
                DC.W 22560
                DC.W 21760
                DC.W 21120
                DC.W 20320
                DC.W 19520
                DC.W 18720
                DC.W 17920
                DC.W 17120
                DC.W 16320
                DC.W 15520
                DC.W 14720
                DC.W 13920
                DC.W 13120
                DC.W 12480
                DC.W 11680
                DC.W 10880
                DC.W 10080
                DC.W 9440
                DC.W 8640
                DC.W 8000
                DC.W 7200
                DC.W 6560
                DC.W 5920
                DC.W 5280
                DC.W 4800
                DC.W 4160
                DC.W 3680
                DC.W 3200
                DC.W 2720
                DC.W 2240
                DC.W 1920
                DC.W 1440
                DC.W 1120
                DC.W 960
                DC.W 640
                DC.W 480
                DC.W 160
                DC.W 160
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 160
                DC.W 320
                DC.W 480
                DC.W 640
                DC.W 960
                DC.W 1120
                DC.W 1440
                DC.W 1920
                DC.W 2240
                DC.W 2720
                DC.W 3200
                DC.W 3680
                DC.W 4160
                DC.W 4800
                DC.W 5440
                DC.W 5920
                DC.W 6560
                DC.W 7360
                DC.W 8000
                DC.W 8640
                DC.W 9440
                DC.W 10080
                DC.W 10880
                DC.W 11680
                DC.W 12480
                DC.W 13280
                DC.W 14080
                DC.W 14880
                DC.W 15680
                DC.W 16480
                DC.W 17280
                DC.W 17920
                DC.W 18720
                DC.W 19520
                DC.W 20320
                DC.W 21120
                DC.W 21920
                DC.W 22560
                DC.W 23360
                DC.W 24000
                DC.W 24640
                DC.W 25280
                DC.W 25920
                DC.W 26560
                DC.W 27200
                DC.W 27680
                DC.W 28320
                DC.W 28800
                DC.W 29280
                DC.W 29600
                DC.W 30080
                DC.W 30400
                DC.W 30720
                DC.W 31040
                DC.W 31200
                DC.W 31520
                DC.W 31680
                DC.W 31840
                DC.W 31840
                DC.W 31840
                DC.W 31840
                DC.W 31840
                DC.W 31840
                DC.W 31680
                DC.W 31520
                DC.W 31360
                DC.W 31200
                DC.W 30880
                DC.W 30560
                DC.W 30240
                DC.W 29920
                DC.W 29440
                DC.W 29120
                DC.W 28640
                DC.W 28000
                DC.W 27520
                DC.W 27040
                DC.W 26400
                DC.W 25760
                DC.W 25120
                DC.W 24480
                DC.W 23680
                DC.W 23040
                DC.W 22240
                DC.W 21600
                DC.W 20800
                DC.W 20000
                DC.W 19200
                DC.W 18560
                DC.W 17760
                DC.W 16960
                DC.W 16160
                DC.W 15360
                DC.W 14560
                DC.W 13760
                DC.W 12960
                DC.W 12160
                DC.W 11360
                DC.W 10560
                DC.W 9920
                DC.W 9120
                DC.W 8480
                DC.W 7680
                DC.W 7040
                DC.W 6400
                DC.W 5760
                DC.W 5120
                DC.W 4640
                DC.W 4000
                DC.W 3520
                DC.W 3040
                DC.W 2560
                DC.W 2080
                DC.W 1760
                DC.W 1440
                DC.W 1120
                DC.W 800
                DC.W 480
                DC.W 320
                DC.W 160
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 0
                DC.W 1120
                DC.W 2400
                DC.W 3680
                DC.W 4960
                DC.W 6240
                DC.W 7520
                DC.W 8640
                DC.W 9920
                DC.W 11200
                DC.W 12320
                DC.W 13440
                DC.W 14560
                DC.W 15680
                DC.W 16800
                DC.W 17920
                DC.W 18880
                DC.W 20000
                DC.W 20960
                DC.W 21920
                DC.W 22720
                DC.W 23680
                DC.W 24480
                DC.W 25280
                DC.W 26080
                DC.W 26720
                DC.W 27360
                DC.W 28000
                DC.W 28640
                DC.W 29120
                DC.W 29600
                DC.W 30080
                DC.W 30400
                DC.W 30720
                DC.W 31040
                DC.W 31360
                DC.W 31520
                DC.W 31680
                DC.W 31680
                DC.W 31680
                DC.W 31680
                DC.W 31680
                DC.W 31520
                DC.W 31360
                DC.W 31200
                DC.W 30880
                DC.W 30560
                DC.W 30240
                DC.W 29760
                DC.W 29440
                DC.W 28800
                DC.W 28320
                DC.W 27680
                DC.W 27040
                DC.W 26400
                DC.W 25600
                DC.W 24960
                DC.W 24160
                DC.W 23200
                DC.W 22400
                DC.W 21440
                DC.W 20480
                DC.W 19520
                DC.W 18400
                DC.W 17440
                DC.W 16320
                DC.W 15200
                DC.W 14080
                DC.W 12960
                DC.W 11840
                DC.W 10560
                DC.W 9440
                DC.W 8160
                DC.W 6880
                DC.W 5600
                DC.W 4480
                DC.W 3200
                DC.W 1920
                DC.W 640
                DC.W 0
                DC.W 1120
                DC.W 2400
                DC.W 3520
                DC.W 4800
                DC.W 5920
                DC.W 7200
                DC.W 8320
                DC.W 9440
                DC.W 10560
                DC.W 11680
                DC.W 12800
                DC.W 13760
                DC.W 14720
                DC.W 15680
                DC.W 16640
                DC.W 17600
                DC.W 18400
                DC.W 19200
                DC.W 20000
                DC.W 20800
                DC.W 21440
                DC.W 22080
                DC.W 22720
                DC.W 23200
                DC.W 23680
                DC.W 24160
                DC.W 24480
                DC.W 24800
                DC.W 25120
                DC.W 25280
                DC.W 25440
                DC.W 25440
                DC.W 25440
                DC.W 25440
                DC.W 25440
                DC.W 25280
                DC.W 25120
                DC.W 24800
                DC.W 24480
                DC.W 24160
                DC.W 23680
                DC.W 23200
                DC.W 22720
                DC.W 22080
                DC.W 21440
                DC.W 20800
                DC.W 20000
                DC.W 19200
                DC.W 18400
                DC.W 17600
                DC.W 16640
                DC.W 15680
                DC.W 14720
                DC.W 13760
                DC.W 12640
                DC.W 11680
                DC.W 10560
                DC.W 9440
                DC.W 8320
                DC.W 7040
                DC.W 5920
                DC.W 4800
                DC.W 3520
                DC.W 2400
                DC.W 1120
                DC.W 0
                DC.W 1120
                DC.W 2240
                DC.W 3360
                DC.W 4480
                DC.W 5600
                DC.W 6560
                DC.W 7680
                DC.W 8640
                DC.W 9760
                DC.W 10720
                DC.W 11520
                DC.W 12480
                DC.W 13280
                DC.W 14080
                DC.W 14880
                DC.W 15520
                DC.W 16160
                DC.W 16800
                DC.W 17280
                DC.W 17760
                DC.W 18240
                DC.W 18560
                DC.W 18880
                DC.W 19040
                DC.W 19200
                DC.W 19200
                DC.W 19200
                DC.W 19200
                DC.W 19040
                DC.W 18880
                DC.W 18720
                DC.W 18400
                DC.W 17920
                DC.W 17600
                DC.W 16960
                DC.W 16480
                DC.W 15840
                DC.W 15200
                DC.W 14400
                DC.W 13600
                DC.W 12800
                DC.W 12000
                DC.W 11040
                DC.W 10080
                DC.W 9120
                DC.W 8160
                DC.W 7040
                DC.W 5920
                DC.W 4960
                DC.W 3840
                DC.W 2720
                DC.W 1600
                DC.W 320
                DC.W 0
                DC.W 960
                DC.W 1920
                DC.W 2880
                DC.W 3840
                DC.W 4800
                DC.W 5760
                DC.W 6720
                DC.W 7520
                DC.W 8320
                DC.W 9120
                DC.W 9760
                DC.W 10400
                DC.W 11040
                DC.W 11520
                DC.W 11840
                DC.W 12320
                DC.W 12640
                DC.W 12800
                DC.W 12960
                DC.W 12960
                DC.W 12960
                DC.W 12960
                DC.W 12800
                DC.W 12480
                DC.W 12160
                DC.W 11840
                DC.W 11360
                DC.W 10880
                DC.W 10240
                DC.W 9600
                DC.W 8960
                DC.W 8160
                DC.W 7360
                DC.W 6560
                DC.W 5600
                DC.W 4640
                DC.W 3680
                DC.W 2720
                DC.W 1760
                DC.W 800
                DC.W 0
                DC.W 640
                DC.W 1440
                DC.W 2240
                DC.W 2880
                DC.W 3520
                DC.W 4160
                DC.W 4800
                DC.W 5280
                DC.W 5760
                DC.W 6080
                DC.W 6400
                DC.W 6560
                DC.W 6720
                DC.W 6720
                DC.W 6720
                DC.W 6720
                DC.W 6400
                DC.W 6240
                DC.W 5760
                DC.W 5440
                DC.W 4960
                DC.W 4320
                DC.W 3680
                DC.W 3040
                DC.W 2400
                DC.W 1600
                DC.W 960
                DC.W 160
                DC.W 0
                DC.W 0
                DC.W 160
                DC.W 320
                DC.W 320
                DC.W 480
                DC.W 480
                DC.W 480
                DC.W 480
                DC.W 480
                DC.W 480
                DC.W 480
                DC.W 320
                DC.W 320
                DC.W 160
                DC.W 0
                DC.W 0
                DC.W 320
                DC.W 640
                DC.W 960
                DC.W 1280
                DC.W 1600
                DC.W 1920
                DC.W 2240
                DC.W 2560
                DC.W 2880
                DC.W 3200
                DC.W 3520
                DC.W 3840
                DC.W 4160
                DC.W 4480
                DC.W 4800
                DC.W 5120
                DC.W 5440
                DC.W 5760
                DC.W 6080
                DC.W 6400
                DC.W 6720
                DC.W 7040
                DC.W 7360
                DC.W 7680
                DC.W 8000
                DC.W 8320
                DC.W 8640
                DC.W 8960
                DC.W 9280
                DC.W 9600
                DC.W 9920
                DC.W 10240
                DC.W 10560
                DC.W 10880
                DC.W 11200
                DC.W 11520
                DC.W 11840
                DC.W 12160
                DC.W 12480
                DC.W 12800
                DC.W 13120
                DC.W 13440
                DC.W 13760
                DC.W 14080
                DC.W 14400
                DC.W 14720
                DC.W 15040
                DC.W 15360
                DC.W 15680
                DC.W 16000
                DC.W 16320
                DC.W 16640
                DC.W 16960
                DC.W 17280
                DC.W 17600
                DC.W 17920
                DC.W 18240
                DC.W 18560
                DC.W 18880
                DC.W 19200
                DC.W 19520
                DC.W 19840
                DC.W 20160
                DC.W 20480
                DC.W 20800
                DC.W 21120
                DC.W 21440
                DC.W 21760
                DC.W 22080
                DC.W 22400
                DC.W 22720
                DC.W 23040
                DC.W 23360
                DC.W 23680
                DC.W 24000
                DC.W 24320
                DC.W 24640
                DC.W 24960
                DC.W 25280
                DC.W 25600
                DC.W 25920
                DC.W 26240
                DC.W 26560
                DC.W 26880
                DC.W 27200
                DC.W 27520
                DC.W 27840
                DC.W 28160
                DC.W 28480
                DC.W 28800
                DC.W 29120
                DC.W 29440
                DC.W 29760
                DC.W 30080
                DC.W 30400
                DC.W 30720
                DC.W 31040
                DC.W 31360
                DC.W 31680
                DC.W 0
                DC.W 320
                DC.W 640
                DC.W 960
                DC.W 1280
                DC.W 1600
                DC.W 1920
                DC.W 2240
                DC.W 2560
                DC.W 2880
                DC.W 3200
                DC.W 3520
                DC.W 3840
                DC.W 4160
                DC.W 4480
                DC.W 4800
                DC.W 5120
                DC.W 5440
                DC.W 5760
                DC.W 6080
                DC.W 6400
                DC.W 6720
                DC.W 7040
                DC.W 7360
                DC.W 7680
                DC.W 8000
                DC.W 8320
                DC.W 8640
                DC.W 8960
                DC.W 9280
                DC.W 9600
                DC.W 9920
                DC.W 10240
                DC.W 10560
                DC.W 10880
                DC.W 11200
                DC.W 11520
                DC.W 11840
                DC.W 12160
                DC.W 12480
                DC.W 12800
                DC.W 13120
                DC.W 13440
                DC.W 13760
                DC.W 14080
                DC.W 14400
                DC.W 14720
                DC.W 15040
                DC.W 15360
                DC.W 15680
                DC.W 16000
                DC.W 16320
                DC.W 16640
                DC.W 16960
                DC.W 17280
                DC.W 17600
                DC.W 17920
                DC.W 18240
                DC.W 18560
                DC.W 18880
                DC.W 19200
                DC.W 19520
                DC.W 19840
                DC.W 20160
                DC.W 20480
                DC.W 20800
                DC.W 21120
                DC.W 21440
                DC.W 21760
                DC.W 22080
                DC.W 22400
                DC.W 22720
                DC.W 23040
                DC.W 23360
                DC.W 23680
                DC.W 24000
                DC.W 24320
                DC.W 24640
                DC.W 24960
                DC.W 25280
                DC.W 25600
                DC.W 25920
                DC.W 26240
                DC.W 26560
                DC.W 26880
                DC.W 27200
                DC.W 27520
                DC.W 27840
                DC.W 28160
                DC.W 28480
                DC.W 28800
                DC.W 29120
                DC.W 29440
                DC.W 29760
                DC.W 30080
                DC.W 30400
                DC.W 30720
                DC.W 31040
                DC.W 31360
                DC.W 31680
                DC.W 0
                DC.W 320
                DC.W 640
                DC.W 960
                DC.W 1280
                DC.W 1600
                DC.W 1920
                DC.W 2240
                DC.W 2560
                DC.W 2880
                DC.W 3200
                DC.W 3520
                DC.W 3840
                DC.W 4160
                DC.W 4480
                DC.W 4800
                DC.W 5120
                DC.W 5440
                DC.W 5760
                DC.W 6080
                DC.W 6400
                DC.W 6720
                DC.W 7040
                DC.W 7360
                DC.W 7680
                DC.W 8000
                DC.W 8320
                DC.W 8640
                DC.W 8960
                DC.W 9280
                DC.W 9600
                DC.W 9920
                DC.W 10240
                DC.W 10560
                DC.W 10880
                DC.W 11200
                DC.W 11520
                DC.W 11840
                DC.W 12160
                DC.W 12480
                DC.W 12800
                DC.W 13120
                DC.W 13440
                DC.W 13760
                DC.W 14080
                DC.W 14400
                DC.W 14720
                DC.W 15040
                DC.W 15360
                DC.W 15680
                DC.W 16000
                DC.W 16320
                DC.W 16640
                DC.W 16960
                DC.W 17280
                DC.W 17600
                DC.W 17920
                DC.W 18240
                DC.W 18560
                DC.W 18880
                DC.W 19200
                DC.W 19520
                DC.W 19840
                DC.W 20160
                DC.W 20480
                DC.W 20800
                DC.W 21120
                DC.W 21440
                DC.W 21760
                DC.W 22080
                DC.W 22400
                DC.W 22720
                DC.W 23040
                DC.W 23360
                DC.W 23680
                DC.W 24000
                DC.W 24320
                DC.W 24640
                DC.W 24960
                DC.W 25280
                DC.W 25600
                DC.W 25920
                DC.W 26240
                DC.W 26560
                DC.W 26880
                DC.W 27200
                DC.W 27520
                DC.W 27840
                DC.W 28160
                DC.W 28480
                DC.W 28800
                DC.W 29120
                DC.W 29440
                DC.W 29760
                DC.W 30080
                DC.W 30400
                DC.W 30720
                DC.W 31040
                DC.W 31360
                DC.W 31680
                DC.W 0
                DC.W 8
                DC.W 16
                DC.W 24
                DC.W 32
                DC.W 40
                DC.W 48
                DC.W 56
                DC.W 64
                DC.W 72
                DC.W 80
                DC.W 88
                DC.W 96
                DC.W 104
                DC.W 112
                DC.W 120
                DC.W 128
                DC.W 136
                DC.W 144
                DC.W 152
                DC.W 160
                DC.W $FFFF
cols:           DC.W $00,$0430,$0540,$0650,$0760,$00,$07,$77
                DC.W $0700,$07,$0600,$06,$0500,$05,$0400,$04
******************************* Scrolline Data
color_puffer:   DC.W 0
lettercounter:  DC.W 0
screen1:        DC.L $078000
screen2:        DC.L $070000
base1:          DC.L $060000
base2:          DC.L $058000
base3:          DC.L $050000
base4:          DC.L $048000
handle:         DC.L 0
pause:          DC.W 0
sav_puffer:     DC.L 0
clr:            DC.B 27,"E",0
                EVEN
counter:        DC.W 0
zeiger:         DC.L 0
saver:          DC.L 0
letter:         DC.L 0
offset:         DC.L 0
text:
                DC.B 7,8,47,32,47,47,19,7,8,18,47,8,18,47,2,7,0,17,14,13,47,0,6,0,8,13,29,29,29,47,47,47,8,47,14,13,11,24,47,22,0,13,19,4,3,47,19,14,47,0,3,3,47,19,7,4,47,19,7,8,13,6,18,35,47,19,7,0,19,47
                DC.B 8,47,5,14,17,6,14,19,47,19,14,47,22,17,8,19,4,47,8,13,47,19,7,4,47,12,0,8,13,33,12,4,13,20,29,47,47,47,47,1,20,19,47,5,8,17,18,19,35,47,19,7,4,47,2,17,4,3,8,19,18,47,5,14,17,47,19,7,8,18,47
                DC.B 18,2,17,4,4,13,29,47,47,47,47,47,2,14,3,8,13,6,35,47,8,3,4,0,35,47,6,17,0,5,8,23,47,0,13,3,47,15,20,19,19,8,13,6,47,19,14,6,4,19,7,4,17,47,1,24,47,2,7,0,17,14,13,35,47,47
                DC.B 18,14,12,4,47,2,14,3,4,47,0,13,3,47,5,14,13,19,47,1,24,47,1,11,14,22,19,14,17,2,7,35,47,47,12,20,25,25,25,25,25,25,25,25,25,25,0,23,47,1,24,47,12,0,3,47,12,0,23,29,29,29,47,47,47,47,47
                DC.B 19,7,4,47,2,17,4,3,8,19,18,47,5,14,17,47,19,7,4,47,22,7,14,11,4,47,3,4,12,14,47,0,17,4,30,47,47,47,47,47,1,11,14,22,19,14,17,2,7,47,254,47,33,47,2,14,3,8,13,6,35,47,6,17,0,5,8,23,47,0,13,3,47
                DC.B 18,2,17,14,11,11,33,5,14,13,19,29,47,47,47,47,2,7,0,17,14,13,47,47,254,47,33,47,2,14,3,8,13,6,35,47,6,17,0,5,8,23,35,47,15,20,19,19,8,13,6,47,19,14,6,4,19,7,4,17,47,0,13,3,47,18,14,12,4,47
                DC.B 8,12,15,17,14,21,4,12,4,13,19,18,29,47,47,47,47,12,0,3,47,12,20,25,0,10,47,1,24,47,47,12,0,3,47,12,0,23,8,10,47,254,47,47,47,47,13,14,22,47,5,14,11,11,14,22,18,47,19,7,4,47,11,8,18,19,35,47,22,7,0,19,47
                DC.B 22,4,31,21,4,47,20,18,4,3,35,47,22,7,14,47,7,4,11,15,4,3,47,20,18,47,4,19,2,29,29,29,47,47,47,47,0,11,11,47,2,14,3,4,47,22,0,18,47,3,14,13,4,47,22,8,19,7,47,19,7,4,47
                DC.B 19,20,17,1,14,33,0,18,18,4,12,1,11,4,17,47,1,24,47,12,29,5,17,8,19,25,4,47,0,13,3,47,18,29,7,4,11,11,22,8,6,29,47,47,0,11,11,47,6,17,0,5,8,23,47,22,4,17,4,47,3,14,13,4,47,22,8,19,7,47
                DC.B 13,4,14,2,7,17,14,12,4,47,12,0,18,19,4,17,35,47,1,24,47,3,29,18,19,0,20,6,0,18,47,0,13,3,47,8,12,15,17,14,21,4,12,4,13,19,18,47,1,24,47,2,7,0,14,18,47,8,13,2,29,47,47,19,7,4,47
                DC.B 5,14,13,19,47,22,0,18,47,3,14,13,4,47,22,8,19,7,47,1,11,14,22,19,14,17,2,7,31,18,47,1,0,18,8,2,33,5,14,13,19,12,0,10,4,17,29,47,47,19,7,8,13,6,18,47,20,18,4,3,47,19,14,47
                DC.B 18,20,17,21,8,21,4,47,8,13,47,5,17,14,13,19,47,14,5,47,19,7,4,47,31,6,11,14,19,25,4,31,30,47,47,11,14,19,18,0,47,15,8,25,25,0,18,47,5,17,14,12,47,18,4,2,10,4,13,7,4,8,12,47,26,19,0,18,19,24,47,32,27,47
                DC.B 35,47,2,14,2,0,47,2,14,11,0,47,26,14,5,47,2,14,20,17,18,4,29,29,29,27,47,35,47,22,14,3,10,0,47,6,14,17,1,0,19,2,7,14,22,47,26,7,4,17,4,18,7,47,10,0,17,14,7,13,29,29,29,27,47,35,47
                DC.B 18,14,12,4,47,1,17,4,0,3,47,35,47,2,8,13,3,0,33,11,8,12,14,13,0,3,4,47,35,47,0,15,15,11,4,33,9,20,8,2,4,35,47,1,20,17,6,4,17,33,10,8,13,6,33,9,20,13,10,33,5,14,14,3,29,29,29,47,47,47,47
                DC.B 14,20,17,47,11,8,18,19,47,14,5,47,19,7,0,13,23,47,6,14,47,19,14,30,47,47,47,47,12,8,2,7,0,4,11,47,26,3,0,13,10,4,47,5,20,4,17,47,3,4,8,13,4,47,6,0,13,25,4,13,47,19,8,15,18,47,32,47
                DC.B 33,4,13,19,18,2,7,20,11,3,8,6,4,35,47,22,4,13,13,47,22,8,17,47,3,8,17,47,12,8,19,47,20,13,18,4,17,4,13,47,6,0,13,25,4,13,47,0,13,17,20,5,4,13,47,0,20,5,47,3,4,13,47,22,4,2,10,4,17,47
                DC.B 5,0,11,11,4,13,29,47,33,3,0,13,10,4,47,0,20,2,7,47,5,20,4,17,47,3,8,4,47,6,0,13,25,4,13,47,3,4,12,14,18,47,20,13,3,47,3,8,4,47,12,20,18,8,4,7,2,10,35,47,3,8,4,47,3,20,47,20,13,18,47
                DC.B 6,4,18,2,7,8,2,19,47,7,0,18,19,47,32,27,47,35,47,0,13,3,17,4,22,47,26,19,7,0,13,23,35,47,14,1,4,17,9,4,35,47,5,14,17,47,4,21,4,17,24,19,7,8,13,6,47,24,14,20,31,21,4,47,18,4,13,3,47
                DC.B 20,18,47,32,47,4,18,15,4,2,8,0,11,11,24,47,5,14,17,47,19,7,4,47,3,12,0,33,11,14,0,3,4,17,35,47,3,4,21,15,0,2,47,0,13,3,47,12,14,13,18,19,47,32,47,33,18,14,17,17,24,47,19,7,0,19,47,22,4,47,19,0,10,4,47
                DC.B 18,14,47,11,14,13,6,47,19,14,47,12,0,10,4,47,19,7,4,47,15,17,14,12,8,18,4,3,47,18,2,17,4,4,13,29,27,47,35,47,17,0,8,13,4,17,47,26,3,0,13,10,4,47,5,20,4,17,47,3,4,13,47,2,33,36,41,35,47,3,4,13,47
                DC.B 3,20,47,12,8,17,47,3,0,12,0,11,18,47,21,4,17,10,0,20,5,19,47,7,0,18,19,47,33,47,14,7,13,4,47,8,7,13,47,18,0,4,18,18,4,47,8,2,7,47,9,4,19,25,19,47,13,8,2,7,19,47,21,14,17,12,47
                DC.B 2,14,12,15,20,19,4,17,29,47,33,3,0,13,10,4,47,0,20,2,7,35,47,3,0,18,18,47,3,20,47,8,7,13,47,12,8,17,47,18,14,47,14,5,19,47,17,4,15,0,17,8,4,17,19,47,7,0,18,19,47,32,27,47,47,47,47,47,47,47
                DC.B 13,14,22,47,12,14,17,4,47,0,1,14,20,19,47,19,7,4,47,19,7,8,13,6,18,35,47,19,7,0,19,47,0,17,4,47,14,13,47,19,7,8,18,47,3,8,18,10,29,47,47,22,4,47,3,4,2,8,3,4,3,47,19,14,47,15,20,19,47
                DC.B 19,7,4,47,18,14,20,17,2,4,18,47,5,14,17,47,0,11,11,47,18,2,17,4,4,13,18,47,14,13,47,8,19,35,47,19,14,14,29,47,26,19,7,14,20,6,7,47,8,19,31,18,47,15,20,17,4,47,2,17,0,15,27,47,24,14,20,47
                DC.B 18,7,14,20,11,3,47,5,8,13,3,47,8,19,47,8,13,47,19,7,4,47,31,18,14,20,17,2,4,18,31,47,5,14,11,3,4,17,29,47,47,22,4,47,3,8,3,13,31,19,47,8,13,2,11,20,3,4,47,18,14,12,4,47,6,17,0,5,8,23,47
                DC.B 8,13,47,19,7,4,47,7,4,0,3,33,15,17,14,6,17,0,12,35,47,2,14,25,47,22,4,47,7,0,21,4,47,14,13,11,24,47,0,47,21,4,17,24,47,14,11,3,47,21,4,17,18,8,14,13,47,14,5,47,19,7,4,47
                DC.B 19,20,17,1,14,33,0,18,18,4,12,1,11,4,17,35,47,0,13,3,47,4,21,4,17,24,19,8,12,4,47,19,7,4,47,15,17,14,6,17,0,12,47,2,17,0,18,7,4,3,47,22,7,4,13,47,11,14,0,3,8,13,6,47,19,7,4,47
                DC.B 26,6,17,0,5,8,23,47,8,13,2,11,20,3,4,3,27,47,18,2,17,4,4,13,29,47,26,15,4,17,7,0,15,18,47,8,19,47,22,0,18,47,14,20,17,47,5,0,20,11,19,35,47,1,20,19,47,0,13,24,22,0,24,47,24,14,20,47
                DC.B 2,0,13,47,5,8,13,3,47,19,7,4,47,6,17,0,5,8,23,47,14,13,47,19,7,4,47,3,8,18,10,35,47,19,14,14,29,29,29,27,47,47,47,47,47,47,13,14,22,47,2,14,12,4,18,47,19,7,4,47,15,0,17,19,35,47,22,7,4,17,4,47
                DC.B 8,47,22,8,11,11,47,15,17,4,18,4,13,19,47,12,24,47,2,7,0,17,19,18,47,33,47,19,7,4,24,31,17,4,47,11,8,10,4,47,13,4,23,19,47,14,13,4,18,35,47,0,13,3,47,8,31,12,47,6,14,8,13,6,47,19,14,47,18,4,13,3,47
                DC.B 8,19,47,19,14,47,19,7,4,12,35,47,18,14,14,13,29,47,47,47,11,4,19,31,18,47,18,19,0,17,19,47,22,8,19,7,47,19,7,4,47,1,4,18,19,47,6,17,0,5,8,23,33,12,4,13,30,47,47,47,47,47
                DC.B 36,29,47,4,18,47,47,47,47,37,29,47,19,0,13,8,18,47,47,47,47,38,29,47,17,4,3,47,47,47,47,39,29,47,10,17,0,25,24,47,17,4,23,47,47,47,47,40,29,47,18,15,0,25,47,47,47,47,47,19,7,4,47,1,4,18,19,47
                DC.B 6,0,12,4,18,47,0,17,4,30,47,47,47,47,47,36,29,47,22,8,13,6,18,47,14,5,47,3,4,0,19,7,47,47,47,47,47,37,29,47,19,20,17,17,8,2,0,13,47,47,47,47,38,29,47,4,11,8,19,4,47,47,47,47,39,29,47,3,20,13,6,4,14,13,47
                DC.B 12,0,18,19,4,17,47,47,47,47,40,29,47,15,8,17,0,19,4,18,47,47,47,47,47,19,7,4,47,1,4,18,19,47,5,8,17,12,18,47,0,17,4,30,47,47,47,47,47,36,29,47,19,7,0,11,8,14,13,47,47,47,47,37,29,47
                DC.B 17,0,8,13,1,14,22,47,0,17,19,18,47,47,47,47,38,29,47,5,19,11,47,47,47,47,39,29,29,40,29,47,13,14,47,14,15,8,13,8,14,13,47,47,47,47,47,19,7,4,47,1,4,18,19,47,2,17,0,2,10,8,13,6,47,2,17,4,22,18,47,0,17,4,30,47
                DC.B 47,47,47,47,36,29,47,12,4,3,22,0,24,47,1,14,24,18,47,47,47,47,37,29,47,17,4,15,11,8,2,0,13,19,18,47,47,47,47,38,29,47,4,12,15,8,17,4,47,47,47,47,39,29,47,3,4,11,8,6,7,19,47,47,47,47,40,29,47
                DC.B 0,20,19,14,12,0,19,8,14,13,47,47,47,47,47,19,7,4,47,1,4,18,19,47,18,14,20,13,3,33,15,17,14,6,17,0,12,12,4,17,18,47,0,17,4,30,47,47,47,47,47,36,29,47,12,0,3,47,12,0,23,47,47,47,47,37,29,47
                DC.B 2,14,20,13,19,47,25,4,17,14,47,47,47,47,38,29,47,9,14,0,17,3,47,47,47,47,39,29,47,0,13,47,2,14,14,11,47,47,47,47,40,29,47,4,13,18,47,47,47,47,47,19,7,4,47,1,4,18,19,47
                DC.B 15,17,14,6,17,0,12,12,4,17,18,47,0,17,4,30,47,47,47,47,47,36,29,47,13,8,2,10,47,47,47,47,37,29,47,12,0,13,8,10,8,13,47,47,47,47,38,29,47,25,8,6,6,24,47,18,19,0,17,3,20,18,19,47,47,47,47
                DC.B 39,29,47,9,0,18,47,47,47,47,40,29,47,3,8,6,8,19,0,11,47,8,13,18,0,13,8,19,24,47,47,47,47,47,19,7,4,47,1,4,18,19,47,3,4,12,14,18,47,0,17,4,30,47,47,47,47,47,36,29,47
                DC.B 4,20,17,14,15,4,0,13,47,3,4,12,14,18,47,47,47,47,37,29,47,18,24,13,19,0,23,47,19,4,17,17,14,17,47,47,47,47,38,29,47,12,8,13,3,1,14,12,1,47,47,47,47,39,29,47,3,0,17,10,47,18,8,3,4,47,14,5,47,19,7,4,47
                DC.B 18,15,14,14,13,47,47,47,47,40,29,47,2,20,3,3,11,24,47,3,4,12,14,18,47,47,47,47,47,0,13,3,47,5,8,13,0,11,11,24,35,47,19,7,4,47,1,4,18,19,47,3,4,12,14,33,2,17,4,22,18,47,0,17,4,30,47
                DC.B 47,47,47,47,36,29,47,19,7,4,47,2,0,17,4,1,4,0,17,18,47,47,47,47,37,29,47,19,7,4,47,11,14,18,19,47,1,14,24,18,47,47,47,47,38,29,47,19,7,4,47,4,23,2,4,15,19,8,14,13,18,47
                DC.B 47,47,47,39,29,47,14,21,4,17,11,0,13,3,4,17,18,47,47,47,47,40,29,47,20,13,11,8,12,8,19,4,3,47,12,0,19,17,8,2,10,18,47,47,47,47,47,47,47,47,47,19,7,0,19,47,22,0,18,47,8,19,47,5,14,17,47,19,7,4,47
                DC.B 2,7,0,17,19,18,29,29,29,47,47,47,47,11,4,19,31,18,47,6,14,47,14,13,47,22,8,19,7,47,19,0,11,10,8,13,6,47,15,20,17,4,47,1,20,11,11,18,7,8,19,29,29,29,47,47,47,47,47,47,47,47,8,5,47,24,14,20,47
                DC.B 7,0,21,4,47,19,7,4,47,6,0,12,4,47,31,22,8,13,6,18,47,14,5,47,3,4,0,19,7,31,47,26,6,17,4,0,19,47,8,18,13,31,19,47,8,19,47,28,32,28,32,27,47,0,13,3,47,24,14,20,17,47,18,2,14,17,4,47,8,18,47
                DC.B 1,4,19,19,4,17,47,19,7,0,13,47,12,8,13,4,35,47,2,14,13,19,0,2,19,47,12,4,47,32,47,47,47,47,47,12,24,47,18,2,14,17,4,47,8,18,30,47,47,47,47,47,47,12,14,17,4,47,19,7,0,13,47,43,45,45,45,45,45,47,15,14,8,13,19,18,29,47
                DC.B 47,47,8,47,3,14,13,31,19,47,8,19,47,4,23,0,2,19,11,24,47,0,19,47,19,7,4,47,12,14,12,4,13,19,35,47,10,14,25,47,3,8,18,10,47,1,47,8,18,47,3,0,12,0,6,4,3,35,47,0,13,3,47,8,47,2,0,13,31,19,47
                DC.B 15,11,0,24,47,8,19,47,0,13,24,12,14,17,4,47,13,14,22,29,47,47,8,47,15,7,14,13,4,3,47,19,7,0,11,8,14,13,35,47,0,13,3,47,19,7,4,24,47,18,0,8,3,35,47,8,47,9,20,18,19,47,7,0,21,4,47
                DC.B 19,14,47,18,4,13,3,47,8,19,47,19,14,47,19,7,4,12,29,29,29,47,47,47,11,4,19,31,18,47,18,4,4,35,47,8,31,12,47,6,14,8,13,6,47,19,14,47,18,4,13,3,47,8,19,47,0,18,47,18,14,14,13,47,0,18,47,8,47,7,0,21,4,47
                DC.B 18,19,0,12,15,18,29,29,29,47,47,47,47,26,24,14,20,47,18,7,14,20,11,3,47,6,4,19,47,19,7,0,19,47,18,2,14,17,4,47,33,22,8,19,7,14,20,19,33,47,2,7,4,0,19,8,13,6,47,32,27,47,47,47,47,47,47,47
                DC.B 8,47,19,7,8,13,10,47,8,19,31,18,47,19,8,12,4,47,19,14,47,4,13,3,47,19,7,8,18,47,18,2,17,14,11,11,8,13,4,47,7,4,17,4,29,29,29,47,47,11,4,19,31,18,47,22,17,0,15,15,47,8,13,29,29,29,47,47,47,47
                DC.B 36,45,47,47,47,44,47,47,47,43,47,47,47,42,47,47,47,41,47,47,47,40,47,47,47,39,47,47,47,38,47,47,47,37,47,47,47,36,47,47,47,45,47,47,47,33,36,47,47,47,33,37,47,47,47,33,38,47,47,47,7,4,24,35,47,2,7,0,17,14,13,47,32,47
                DC.B 22,0,10,4,47,20,15,47,32,47,47,47,33,39,47,47,47,33,40,47,47,47,33,41,47,47,47,22,7,0,19,47,28,47,47,47,14,7,35,47,18,7,8,19,47,32,47,47,47,18,14,17,17,24,47,32,47,47,47,47
                DC.B 1,24,4,35,47,1,24,4,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,47
                DC.B 47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,22,17,0,15,15,47,32,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47
                DC.B $FF
table:
                DC.W %1111111111
                DC.W %111111111111
                DC.W %1111111111111
                DC.W %11111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %111111100000000
                DC.W %1111110000000000
                DC.W %1111111100000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %11111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %111111100000
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %1111111000000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %111111111110000
                DC.W %11111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %11111111110000
                DC.W %111111111110000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111000000000
                DC.W %11111111111
                DC.W %1111111111111
                DC.W %11111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111110000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111110000000
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %11111111111111
                DC.W %1111111111111
                DC.W %11111111111
                DC.W %1111111000000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %111111100000
                DC.W %0
                DC.W %111111100000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111000000000
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %1111111000000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %1111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111000000000
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111110000000
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111110000000
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %0
                DC.W %1111110000000000
                DC.W %1111111000000000
                DC.W %1111111000000000
                DC.W %1111110000000000
                DC.W %0
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111110000000
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %111111100000000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %0
                DC.W %1111110000000000
                DC.W %1111111000000000
                DC.W %1111111000000000
                DC.W %1111111000000000
                DC.W %1111110000000000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %11111111111
                DC.W %1111111111111
                DC.W %11111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111110000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000001
                DC.W %1111111100000011
                DC.W %1111111100000001
                DC.W %1111111110000000
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %11111111111111
                DC.W %1111111111111
                DC.W %11111111111
                DC.W %1111111000000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %111111100000
                DC.W %0
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111000000000
                DC.W %111111100000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %111111100000000
                DC.W %111111100000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %111111100000
                DC.W %111111111
                DC.W %1111111111
                DC.W %1111111111
                DC.W %1111111111
                DC.W %1111111111
                DC.W %111111111
                DC.W %11111
                DC.W %11111
                DC.W %11111
                DC.W %11111
                DC.W %11111
                DC.W %11111
                DC.W %11111
                DC.W %11111
                DC.W %111111111
                DC.W %1111111111
                DC.W %1111111111
                DC.W %1111111111
                DC.W %1111111111
                DC.W %111111111
                DC.W %1111110000000000
                DC.W %1111111000000000
                DC.W %1111111000000000
                DC.W %1111111000000000
                DC.W %1111111000000000
                DC.W %1111110000000000
                DC.W %1100000000000000
                DC.W %1100000000000000
                DC.W %1100000000000000
                DC.W %1100000000000000
                DC.W %1100000000000000
                DC.W %1100000000000000
                DC.W %1100000000000000
                DC.W %1100000000000000
                DC.W %1111110000000000
                DC.W %1111111000000000
                DC.W %1111111000000000
                DC.W %1111111000000000
                DC.W %1111111000000000
                DC.W %1111110000000000
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %111111100000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %11111111111111
                DC.W %1111111111111
                DC.W %11111111111
                DC.W %1111111110000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %1111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111000000000
                DC.W %111111100000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %111111100000000
                DC.W %111111100000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %11111111110000
                DC.W %111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111100000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %111111111100000
                DC.W %11111111100000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %111111100000
                DC.W %111111100000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %111111000000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111111001
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111110111111
                DC.W %1111111110001111
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %111111100000000
                DC.W %11111100000
                DC.W %1111111110000
                DC.W %11111111110000
                DC.W %111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1101111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %111111100000
                DC.W %111111100000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111111100000
                DC.W %1111111111111000
                DC.W %1111111111111100
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111110011111
                DC.W %1111111110000111
                DC.W %1111111110000011
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %111111100000000
                DC.W %111111100000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1001111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %111111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %111111100000
                DC.W %11111111111
                DC.W %1111111111111
                DC.W %11111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111110000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111110000000
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %11111111111111
                DC.W %1111111111111
                DC.W %11111111111
                DC.W %1111111000000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %1111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111000000000
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %111111110000000
                DC.W %1111111000000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111000000000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %11111111111
                DC.W %1111111111111
                DC.W %11111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111110000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111110000000
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %11111111111111
                DC.W %1111111111111
                DC.W %11111111111
                DC.W %1111111000000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %11011111110000
                DC.W %111101111110000
                DC.W %1111110111110000
                DC.W %111111011110000
                DC.W %1011111101100000
                DC.W %1101111110100000
                DC.W %1110111111000000
                DC.W %1111011111100000
                DC.W %1111101111100000
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %111111110000000
                DC.W %1111111000000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %111111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %1111111100000
                DC.W %11111111111
                DC.W %1111111111111
                DC.W %11111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %11111111111111
                DC.W %1111111111111
                DC.W %11111111111
                DC.W %111111111
                DC.W %1111111
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1110000000000000
                DC.W %1111100000000000
                DC.W %1111111000000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111000000000
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %111111
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1100000000000000
                DC.W %111111110000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %11111111111111
                DC.W %1111111111111
                DC.W %11111111111
                DC.W %1111111100000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111000000000
                DC.W %111111110000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %111111111111001
                DC.W %111111111111111
                DC.W %11111111111111
                DC.W %1111111111111
                DC.W %111111111111
                DC.W %11111111111
                DC.W %1111111111
                DC.W %111111111
                DC.W %1111111
                DC.W %1111111100000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %111111111110000
                DC.W %111111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111100000000
                DC.W %1111111000000000
                DC.W %1111110000000000
                DC.W %1111100000000000
                DC.W %1110000000000000
                DC.W %111111110000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111001111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111001
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %111111110000000
                DC.W %1111111100000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %111111111110000
                DC.W %11111111110000
                DC.W %1111111100000
                DC.W %111111110000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %111111111111111
                DC.W %11111111111111
                DC.W %111111111111
                DC.W %1111111111
                DC.W %1111111111
                DC.W %111111111111
                DC.W %11111111111111
                DC.W %111111111111111
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %111111110000000
                DC.W %1111111100000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %111111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111100000000
                DC.W %1111110000000000
                DC.W %1111110000000000
                DC.W %1111111100000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %111111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %1111111100000
                DC.W %111111110000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %111111111111111
                DC.W %11111111111111
                DC.W %111111111111
                DC.W %1111111111
                DC.W %111111111
                DC.W %11111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %111111
                DC.W %1111111100000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %111111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111100000000
                DC.W %1111110000000000
                DC.W %1111100000000000
                DC.W %1111000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1100000000000000
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %11111111
                DC.W %1111111111
                DC.W %111111111111
                DC.W %11111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %1111111111111
                DC.W %1111111110000000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111100000000
                DC.W %1111110000000000
                DC.W %1111000000000000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %111111000000
                DC.W %1111111100000
                DC.W %11111111100000
                DC.W %11111111100000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %11111111100000
                DC.W %11111111100000
                DC.W %1111111100000
                DC.W %111111000000
                DC.W %11111100000000
                DC.W %111111110000000
                DC.W %111111111000000
                DC.W %111111111000000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %11111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %11111111110000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %111111111000000
                DC.W %111111111000000
                DC.W %111111110000000
                DC.W %11111100000000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %11111111111
                DC.W %1111111111111
                DC.W %11111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %111111100000011
                DC.W %11111
                DC.W %111111
                DC.W %111111
                DC.W %111111
                DC.W %11111
                DC.W %0
                DC.W %11111
                DC.W %111111
                DC.W %111111
                DC.W %11111
                DC.W %1111111000000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %111111111110000
                DC.W %111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111000000000
                DC.W %1111000000000000
                DC.W %1100000000000000
                DC.W %0
                DC.W %1100000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1100000000000000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %1111
                DC.W %11101
                DC.W %11111
                DC.W %1111
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %1100000     DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %111111000000
                DC.W %1111111100000
                DC.W %11111111100000
                DC.W %11111111100000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %11111111100000
                DC.W %11111111100000
                DC.W %1111111100000
                DC.W %111111000000
                DC.W %11111100000000
                DC.W %111111110000000
                DC.W %111111111000000
                DC.W %111111111000000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %11111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %11111111110000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %111111111000000
                DC.W %111111111000000
                DC.W %111111110000000
                DC.W %11111100000000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %11111111111
                DC.W %1111111111111
                DC.W %11111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %111111100000011
                DC.W %11111
                DC.W %111111
                DC.W %111111
                DC.W %111111
                DC.W %11111
                DC.W %0
                DC.W %11111
                DC.W %111111
                DC.W %111111
                DC.W %11111
                DC.W %1111111000000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %111111111110000
                DC.W %111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111000000000
                DC.W %1111000000000000
                DC.W %1100000000000000
                DC.W %0
                DC.W %1100000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1100000000000000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %1111
                DC.W %11111
                DC.W %11111
                DC.W %1111
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %1100000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1100000000000000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %111111
                DC.W %1111111
                DC.W %1111111
                DC.W %111111
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %111111
                DC.W %1111111
                DC.W %1111111
                DC.W %111111
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %1000000000000000
                DC.W %1000000000000000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %1000000000000000
                DC.W %1000000000000000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %11111
                DC.W %111111
                DC.W %111111
                DC.W %11111
                DC.W %11
                DC.W %1111
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %1000000000000000
                DC.W %1100000000000000
                DC.W %1100000000000000
                DC.W %1100000000000000
                DC.W %1100000000000000
                DC.W %1000000000000000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %11111111
                DC.W %111111111
                DC.W %111111111
                DC.W %111111111
                DC.W %111111111
                DC.W %111111111
                DC.W %11111111
                DC.W %11111111
                DC.W %11111111
                DC.W %11111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %111111
                DC.W %0
                DC.W %111111
                DC.W %1111111
                DC.W %1111111
                DC.W %111111
                DC.W %1100000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1100000000000000
                DC.W %1100000000000000
                DC.W %1100000000000000
                DC.W %1100000000000000
                DC.W %1000000000000000
                DC.W %1000000000000000
                DC.W %1000000000000000
                DC.W %1000000000000000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %1000000000000000
                DC.W %1000000000000000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %11111111
                DC.W %111111111
                DC.W %111111111
                DC.W %111111111
                DC.W %111111111
                DC.W %111111111
                DC.W %11111111
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %1111111100000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111100000000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %1
                DC.W %11
                DC.W %111
                DC.W %1111
                DC.W %11111
                DC.W %111111
                DC.W %1111111
                DC.W %11111111
                DC.W %111111111
                DC.W %1111111111
                DC.W %11111111111
                DC.W %111111111110
                DC.W %111111111100
                DC.W %111111111000
                DC.W %11111100000
                DC.W %11111100000
                DC.W %1111111110000
                DC.W %11111111110000
                DC.W %111111111110000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111100000000
                DC.W %1111111000000000
                DC.W %1111110000000000
                DC.W %1111100000000000
                DC.W %1111000000000000
                DC.W %1110000000000000
                DC.W %1100000000000000
                DC.W %1000000000000000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %111111000
                DC.W %1111111100
                DC.W %1111111100
                DC.W %111111100
                DC.W %111000
                DC.W %11110000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %11,%111
                DC.W %1111,%11111
                DC.W %111111,%1111111
                DC.W %11111111,%111111111
                DC.W %1111111111,%11111111111
                DC.W %11111111111,%1111110111
                DC.W %111,%111
                DC.W %111,%111
                DC.W %111,%111
                DC.W %111,%11
                DC.W %1111000000000000,%1111100000000000
                DC.W %1111100000000000,%1111100000000000
                DC.W %1111100000000000,%1111100000000000
                DC.W %1111100000000000,%1111100000000000
                DC.W %1111100000000000,%1111100000000000
                DC.W %1111100000000000,%1111100000000000
                DC.W %1111100000000000,%1111100000000000
                DC.W %1111100000000000,%1111100000000000
                DC.W %1111100000000000,%1111100000000000
                DC.W %1111100000000000,%1111000000000000
                DC.W %11111111111111,%111111111111111
                DC.W %111111111111111,%111111111111111
                DC.W %111111111111111,%111111111111111
                DC.W %111111111111111,%11111111111111
                DC.W %11111,%111111
                DC.W %1111111,%11111111
                DC.W %111111111,%1111111111
                DC.W %11111111111,%111111111111
                DC.W %1111111111111,%11111111111111
                DC.W %111111111