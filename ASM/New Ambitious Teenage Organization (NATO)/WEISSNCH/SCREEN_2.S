****************************************
*   Code for the 2nd Weissnich-Screen  *
*--------------------------------------*
* Done by Blowtorch and debugged by    *
* Charon. Sorry, but there are some    *
* bugs left ! (I had not the time to   *
* remove them)                         *
*                                      *
* 1.bug: Do never stop the scroller    *
*        with char-number 254. the     *
*        program will crash !          *
*                                      *
* 2.bug: When loading from a main-     *
*        menu there might be errors    *
*        in the tube; but only in the  *
*        beginning.                    *
*                                      *
* The font s linked at the end of the  *
* code. Rip it, if you want, but       *
* please mention Blowtorch in the      *
* credits. (He has done the font)      *
*                                      *
* The Code was documented by Charon    *
****************************************

                movea.l #$028300,A0     ; Here I tried to remove
                move.l  #7999,D0        ; the Tube-bug
killemall:      move.l  #0,(A0)+
                dbra    D0,killemall

                move.w  #0,-(SP)        ; Loading Grafixx
                pea     datei
                move.w  #$3D,-(SP)
                trap    #1
                addq.l  #8,SP
                move.w  D0,handle2

                pea     $030000-160*190
                move.l  #32000,-(SP)
                move.w  handle2,-(SP)
                move.w  #$3F,-(SP)
                trap    #1
                adda.l  #12,SP

                move.w  handle2,-(SP)
                move.w  #$3E,-(SP)
                trap    #1
                addq.l  #4,SP

                movea.l #$030000-160*190,A0 ; Copying the Grafix
                movea.l #$030000+160*50,A1 ; under itself
                move.l  #16000,D0
copy:           move.w  (A0)+,(A1)+
                dbra    D0,copy

                clr.l   -(SP)           ; Supervisor
                move.w  #$20,-(SP)
                trap    #1
                addq.l  #6,SP

                move.l  #ikbws,-(SP)    ; Mouse and Keyboard dead
                move.w  #0,-(SP)
                move.w  #$19,-(SP)
                trap    #14
                addq.l  #8,SP

                movea.l screen1,A1      ; Originally there was some
                movea.l screen2,A2      ; Background Gfx, but I
                move.l  #16000,D0       ; removed it, so these lines
copy2:          move.w  (A1)+,(A2)+     ; are now non-sense
                dbra    D0,copy2

                move.l  #off,-(SP)      ; I don't understand this,
                move.w  #0,-(SP)        ; coz the Mouse is dead since
                move.w  #25,-(SP)       ; the XBios above...
                trap    #14             ; Blowtorch is a bit stupid...
                addq.l  #8,SP

                move.w  #7,lettercounter ; Set letter = ready
                move.l  #wave_form,wave
                move.l  #$05FF00,saver

                moveq   #1,D0           ; Activate Muzak
                jsr     muzak
                move.l  #muzak+8,$04DA.w
                move.l  #routine,$04D2.w ; Activate Screen

                move.l  #palette,$045A  ; Set new Colors

wait:           move.l  screen1,sav_puffer ; Change Screens
                move.l  screen2,screen1
                move.l  sav_puffer,screen2

                move.w  #-1,-(SP)       ; Set Screens
                move.l  screen1,-(SP)
                move.l  screen2,-(SP)
                move.w  #5,-(SP)
                trap    #14
                adda.l  #12,SP

                move.w  #37,-(SP)       ; VBL
                trap    #14
                addq.l  #2,SP

                bra     wait            ; And back...

routine:
                cmpi.w  #0,pause        ; Is the scroller paused ?
                bne     time_kill       ; Yes...

                movea.l saver,A3

                sub.l   D0,D0           ; The following rout is
                addi.w  #1,lettercounter ; the scroll-rout.
                cmpi.w  #8,lettercounter ; I don't want to explain all
                bne     same_letter     ; this here, coz I'm very tired
                clr.w   lettercounter
next:           movea.l #text,A0
                move.l  offset,D1
                addi.l  #1,offset
                move.b  0(A0,D1.w),D0
                cmp.b   #$FE,D0
                bne     no_stand
                move.w  #200,pause
                bra     routine
no_stand:       cmp.b   #$FF,D0
                bne     okay2
                clr.l   offset
                bra     next
okay2:          mulu    #80,D0
                add.l   #table,D0
                move.l  D0,zeiger

same_letter:    move.w  #19,D1
y_zeile:        move.l  (A3),D0
                cmpi.w  #2,counter
                ble     roll_it
                swap    D0
                movea.l zeiger,A0
                move.w  (A0)+,D0
                move.l  A0,zeiger
                swap    D0
                rol.l   #4,D0
                move.l  D0,(A3)+

                dbra    D1,y_zeile

                clr.w   counter
                bra     ready

roll_it:        rol.l   #4,D0
                move.l  D0,(A3)+
                dbra    D1,y_zeile

                addi.w  #1,counter

ready:          move.l  base1,sav_puffer
                move.l  base2,base1
                move.l  base3,base2
                move.l  base4,base3
                move.l  sav_puffer,base4

                movea.l base2,A0

                movea.l saver,A3

                move.w  #19,D2
y_loop:
                move.w  8(A0),(A0)
                move.w  16(A0),8(A0)
                move.w  24(A0),16(A0)
                move.w  32(A0),24(A0)
                move.w  40(A0),32(A0)
                move.w  48(A0),40(A0)
                move.w  56(A0),48(A0)
                move.w  64(A0),56(A0)
                move.w  72(A0),64(A0)
                move.w  80(A0),72(A0)
                move.w  88(A0),80(A0)
                move.w  96(A0),88(A0)
                move.w  104(A0),96(A0)
                move.w  112(A0),104(A0)
                move.w  120(A0),112(A0)
                move.w  128(A0),120(A0)
                move.w  136(A0),128(A0)
                move.w  144(A0),136(A0)
                move.w  152(A0),144(A0)

                move.l  (A3)+,D0
                move.w  D0,152(A0)

                adda.l  #160,A0

                dbra    D2,y_loop

                bra     after_pause

time_kill:      subq.w  #1,pause        ; Count down if paused

after_pause:    cmpi.l  #300,wave_offset ; Sine-tab ready ?
                bne     go_on
                clr.l   wave_offset     ; Let's Wrap !
go_on:
                movea.l base2,A0
                move.w  #19,D0
                movea.l wave,A3
                adda.l  wave_offset,A3
                suba.l  #10,A3
                move.l  #0,D2
                moveq   #0,D3
clear_bend:
                move.l  #0,D1
                move.w  (A3)+,D1
                mulu    #160,D1
                add.l   screen1,D1
                add.l   #160*30,D1
                add.l   D2,D1
                movea.l D1,A1

                move.b  D3,(A1)
                move.b  D3,160*1(A1)
                move.b  D3,160*2(A1)
                move.b  D3,160*3(A1)
                move.b  D3,160*4(A1)
                move.b  D3,160*5(A1)
                move.b  D3,160*6(A1)
                move.b  D3,160*7(A1)
                move.b  D3,160*8(A1)
                move.b  D3,160*9(A1)
                move.b  D3,160*10(A1)
                move.b  D3,160*11(A1)
                move.b  D3,160*12(A1)
                move.b  D3,160*13(A1)
                move.b  D3,160*14(A1)
                move.b  D3,160*15(A1)
                move.b  D3,160*16(A1)
                move.b  D3,160*17(A1)
                move.b  D3,160*18(A1)
                move.b  D3,160*19(A1)

                moveq   #0,D1
                move.w  (A3)+,D1
                mulu    #160,D1
                add.l   screen1,D1
                add.l   #160*30,D1
                add.l   D2,D1
                movea.l D1,A1

                move.b  D3,1(A1)
                move.b  D3,160*1+1(A1)
                move.b  D3,160*2+1(A1)
                move.b  D3,160*3+1(A1)
                move.b  D3,160*4+1(A1)
                move.b  D3,160*5+1(A1)
                move.b  D3,160*6+1(A1)
                move.b  D3,160*7+1(A1)
                move.b  D3,160*8+1(A1)
                move.b  D3,160*9+1(A1)
                move.b  D3,160*10+1(A1)
                move.b  D3,160*11+1(A1)
                move.b  D3,160*12+1(A1)
                move.b  D3,160*13+1(A1)
                move.b  D3,160*14+1(A1)
                move.b  D3,160*15+1(A1)
                move.b  D3,160*16+1(A1)
                move.b  D3,160*17+1(A1)
                move.b  D3,160*18+1(A1)
                move.b  D3,160*19+1(A1)

                adda.l  #8,A0
                add.l   #8,D2

                dbra    D0,clear_bend

                movea.l base2,A0
                move.w  #19,D0
                movea.l wave,A3
                adda.l  wave_offset,A3
                addi.l  #2,wave_offset
                moveq   #0,D2
bend:
                move.l  #0,D1
                move.w  (A3)+,D1
                mulu    #160,D1
                add.l   screen1,D1
                add.l   #160*30,D1
                add.l   D2,D1
                movea.l D1,A1

                move.b  (A0),(A1)
                move.b  160*1(A0),160*1(A1)
                move.b  160*2(A0),160*2(A1)
                move.b  160*3(A0),160*3(A1)
                move.b  160*4(A0),160*4(A1)
                move.b  160*5(A0),160*5(A1)
                move.b  160*6(A0),160*6(A1)
                move.b  160*7(A0),160*7(A1)
                move.b  160*8(A0),160*8(A1)
                move.b  160*9(A0),160*9(A1)
                move.b  160*10(A0),160*10(A1)
                move.b  160*11(A0),160*11(A1)
                move.b  160*12(A0),160*12(A1)
                move.b  160*13(A0),160*13(A1)
                move.b  160*14(A0),160*14(A1)
                move.b  160*15(A0),160*15(A1)
                move.b  160*16(A0),160*16(A1)
                move.b  160*17(A0),160*17(A1)
                move.b  160*18(A0),160*18(A1)
                move.b  160*19(A0),160*19(A1)

                move.l  #0,D1
                move.w  (A3)+,D1
                mulu    #160,D1
                add.l   screen1,D1
                add.l   #160*30,D1
                add.l   D2,D1
                movea.l D1,A1

                move.b  1(A0),1(A1)
                move.b  160*1+1(A0),160*1+1(A1)
                move.b  160*2+1(A0),160*2+1(A1)
                move.b  160*3+1(A0),160*3+1(A1)
                move.b  160*4+1(A0),160*4+1(A1)
                move.b  160*5+1(A0),160*5+1(A1)
                move.b  160*6+1(A0),160*6+1(A1)
                move.b  160*7+1(A0),160*7+1(A1)
                move.b  160*8+1(A0),160*8+1(A1)
                move.b  160*9+1(A0),160*9+1(A1)
                move.b  160*10+1(A0),160*10+1(A1)
                move.b  160*11+1(A0),160*11+1(A1)
                move.b  160*12+1(A0),160*12+1(A1)
                move.b  160*13+1(A0),160*13+1(A1)
                move.b  160*14+1(A0),160*14+1(A1)
                move.b  160*15+1(A0),160*15+1(A1)
                move.b  160*16+1(A0),160*16+1(A1)
                move.b  160*17+1(A0),160*17+1(A1)
                move.b  160*18+1(A0),160*18+1(A1)
                move.b  160*19+1(A0),160*19+1(A1)

                adda.l  #8,A0
                add.l   #8,D2

                dbra    D0,bend



                movea.l #$030000-160*380,A6
                adda.l  tube_offset,A6
                cmpi.w  #1,tube_counter
                bne     again_tube
                addi.l  #160,tube_offset
                cmpi.l  #160*430,tube_offset
                bne     okay
                move.l  #160*190,tube_offset
okay:           clr.w   tube_counter
                bra     draw_now
again_tube:     addi.w  #1,tube_counter
draw_now:       movea.l screen1,A5

; Now this is the barrel-scroller:

                movem.l 160*4(A6),D1-A4
                movem.l D1-A4,160*0(A5)
                movem.l 160*4+48(A6),D1-A4
                movem.l D1-A4,160*0+48(A5)
                movem.l 160*4+96(A6),D1-A4
                movem.l D1-A4,160*0+96(A5)
                movem.l 160*4+144(A6),D1-A0
                movem.l D1-A0,160*0+144(A5)
                movem.l 160*11(A6),D1-A4
                movem.l D1-A4,160*1(A5)
                movem.l 160*11+48(A6),D1-A4
                movem.l D1-A4,160*1+48(A5)
                movem.l 160*11+96(A6),D1-A4
                movem.l D1-A4,160*1+96(A5)
                movem.l 160*11+144(A6),D1-A0
                movem.l D1-A0,160*1+144(A5)
                movem.l 160*15(A6),D1-A4
                movem.l D1-A4,160*2(A5)
                movem.l 160*15+48(A6),D1-A4
                movem.l D1-A4,160*2+48(A5)
                movem.l 160*15+96(A6),D1-A4
                movem.l D1-A4,160*2+96(A5)
                movem.l 160*15+144(A6),D1-A0
                movem.l D1-A0,160*2+144(A5)
                movem.l 160*19(A6),D1-A4
                movem.l D1-A4,160*3(A5)
                movem.l 160*19+48(A6),D1-A4
                movem.l D1-A4,160*3+48(A5)
                movem.l 160*19+96(A6),D1-A4
                movem.l D1-A4,160*3+96(A5)
                movem.l 160*19+144(A6),D1-A0
                movem.l D1-A0,160*3+144(A5)
                movem.l 160*22(A6),D1-A4
                movem.l D1-A4,160*4(A5)
                movem.l 160*22+48(A6),D1-A4
                movem.l D1-A4,160*4+48(A5)
                movem.l 160*22+96(A6),D1-A4
                movem.l D1-A4,160*4+96(A5)
                movem.l 160*22+144(A6),D1-A0
                movem.l D1-A0,160*4+144(A5)
                movem.l 160*25(A6),D1-A4
                movem.l D1-A4,160*5(A5)
                movem.l 160*25+48(A6),D1-A4
                movem.l D1-A4,160*5+48(A5)
                movem.l 160*25+96(A6),D1-A4
                movem.l D1-A4,160*5+96(A5)
                movem.l 160*25+144(A6),D1-A0
                movem.l D1-A0,160*5+144(A5)
                movem.l 160*27(A6),D1-A4
                movem.l D1-A4,160*6(A5)
                movem.l 160*27+48(A6),D1-A4
                movem.l D1-A4,160*6+48(A5)
                movem.l 160*27+96(A6),D1-A4
                movem.l D1-A4,160*6+96(A5)
                movem.l 160*27+144(A6),D1-A0
                movem.l D1-A0,160*6+144(A5)
                movem.l 160*29(A6),D1-A4
                movem.l D1-A4,160*7(A5)
                movem.l 160*29+48(A6),D1-A4
                movem.l D1-A4,160*7+48(A5)
                movem.l 160*29+96(A6),D1-A4
                movem.l D1-A4,160*7+96(A5)
                movem.l 160*29+144(A6),D1-A0
                movem.l D1-A0,160*7+144(A5)
                movem.l 160*32(A6),D1-A4
                movem.l D1-A4,160*8(A5)
                movem.l 160*32+48(A6),D1-A4
                movem.l D1-A4,160*8+48(A5)
                movem.l 160*32+96(A6),D1-A4
                movem.l D1-A4,160*8+96(A5)
                movem.l 160*32+144(A6),D1-A0
                movem.l D1-A0,160*8+144(A5)
                movem.l 160*34(A6),D1-A4
                movem.l D1-A4,160*9(A5)
                movem.l 160*34+48(A6),D1-A4
                movem.l D1-A4,160*9+48(A5)
                movem.l 160*34+96(A6),D1-A4
                movem.l D1-A4,160*9+96(A5)
                movem.l 160*34+144(A6),D1-A0
                movem.l D1-A0,160*9+144(A5)
                movem.l 160*36(A6),D1-A4
                movem.l D1-A4,160*10(A5)
                movem.l 160*36+48(A6),D1-A4
                movem.l D1-A4,160*10+48(A5)
                movem.l 160*36+96(A6),D1-A4
                movem.l D1-A4,160*10+96(A5)
                movem.l 160*36+144(A6),D1-A0
                movem.l D1-A0,160*10+144(A5)
                movem.l 160*38(A6),D1-A4
                movem.l D1-A4,160*11(A5)
                movem.l 160*38+48(A6),D1-A4
                movem.l D1-A4,160*11+48(A5)
                movem.l 160*38+96(A6),D1-A4
                movem.l D1-A4,160*11+96(A5)
                movem.l 160*38+144(A6),D1-A0
                movem.l D1-A0,160*11+144(A5)
                movem.l 160*41(A6),D1-A4
                movem.l D1-A4,160*12(A5)
                movem.l 160*41+48(A6),D1-A4
                movem.l D1-A4,160*12+48(A5)
                movem.l 160*41+96(A6),D1-A4
                movem.l D1-A4,160*12+96(A5)
                movem.l 160*41+144(A6),D1-A0
                movem.l D1-A0,160*12+144(A5)
                movem.l 160*43(A6),D1-A4
                movem.l D1-A4,160*13(A5)
                movem.l 160*43+48(A6),D1-A4
                movem.l D1-A4,160*13+48(A5)
                movem.l 160*43+96(A6),D1-A4
                movem.l D1-A4,160*13+96(A5)
                movem.l 160*43+144(A6),D1-A0
                movem.l D1-A0,160*13+144(A5)
                movem.l 160*45(A6),D1-A4
                movem.l D1-A4,160*14(A5)
                movem.l 160*45+48(A6),D1-A4
                movem.l D1-A4,160*14+48(A5)
                movem.l 160*45+96(A6),D1-A4
                movem.l D1-A4,160*14+96(A5)
                movem.l 160*45+144(A6),D1-A0
                movem.l D1-A0,160*14+144(A5)
                movem.l 160*47(A6),D1-A4
                movem.l D1-A4,160*15(A5)
                movem.l 160*47+48(A6),D1-A4
                movem.l D1-A4,160*15+48(A5)
                movem.l 160*47+96(A6),D1-A4
                movem.l D1-A4,160*15+96(A5)
                movem.l 160*47+144(A6),D1-A0
                movem.l D1-A0,160*15+144(A5)
                movem.l 160*49(A6),D1-A4
                movem.l D1-A4,160*16(A5)
                movem.l 160*49+48(A6),D1-A4
                movem.l D1-A4,160*16+48(A5)
                movem.l 160*49+96(A6),D1-A4
                movem.l D1-A4,160*16+96(A5)
                movem.l 160*49+144(A6),D1-A0
                movem.l D1-A0,160*16+144(A5)
                movem.l 160*51(A6),D1-A4
                movem.l D1-A4,160*17(A5)
                movem.l 160*51+48(A6),D1-A4
                movem.l D1-A4,160*17+48(A5)
                movem.l 160*51+96(A6),D1-A4
                movem.l D1-A4,160*17+96(A5)
                movem.l 160*51+144(A6),D1-A0
                movem.l D1-A0,160*17+144(A5)
                movem.l 160*52(A6),D1-A4
                movem.l D1-A4,160*18(A5)
                movem.l 160*52+48(A6),D1-A4
                movem.l D1-A4,160*18+48(A5)
                movem.l 160*52+96(A6),D1-A4
                movem.l D1-A4,160*18+96(A5)
                movem.l 160*52+144(A6),D1-A0
                movem.l D1-A0,160*18+144(A5)
                movem.l 160*54(A6),D1-A4
                movem.l D1-A4,160*19(A5)
                movem.l 160*54+48(A6),D1-A4
                movem.l D1-A4,160*19+48(A5)
                movem.l 160*54+96(A6),D1-A4
                movem.l D1-A4,160*19+96(A5)
                movem.l 160*54+144(A6),D1-A0
                movem.l D1-A0,160*19+144(A5)
                movem.l 160*56(A6),D1-A4
                movem.l D1-A4,160*20(A5)
                movem.l 160*56+48(A6),D1-A4
                movem.l D1-A4,160*20+48(A5)
                movem.l 160*56+96(A6),D1-A4
                movem.l D1-A4,160*20+96(A5)
                movem.l 160*56+144(A6),D1-A0
                movem.l D1-A0,160*20+144(A5)
                movem.l 160*58(A6),D1-A4
                movem.l D1-A4,160*21(A5)
                movem.l 160*58+48(A6),D1-A4
                movem.l D1-A4,160*21+48(A5)
                movem.l 160*58+96(A6),D1-A4
                movem.l D1-A4,160*21+96(A5)
                movem.l 160*58+144(A6),D1-A0
                movem.l D1-A0,160*21+144(A5)
                movem.l 160*59(A6),D1-A4
                movem.l D1-A4,160*22(A5)
                movem.l 160*59+48(A6),D1-A4
                movem.l D1-A4,160*22+48(A5)
                movem.l 160*59+96(A6),D1-A4
                movem.l D1-A4,160*22+96(A5)
                movem.l 160*59+144(A6),D1-A0
                movem.l D1-A0,160*22+144(A5)
                movem.l 160*61(A6),D1-A4
                movem.l D1-A4,160*23(A5)
                movem.l 160*61+48(A6),D1-A4
                movem.l D1-A4,160*23+48(A5)
                movem.l 160*61+96(A6),D1-A4
                movem.l D1-A4,160*23+96(A5)
                movem.l 160*61+144(A6),D1-A0
                movem.l D1-A0,160*23+144(A5)
                movem.l 160*63(A6),D1-A4
                movem.l D1-A4,160*24(A5)
                movem.l 160*63+48(A6),D1-A4
                movem.l D1-A4,160*24+48(A5)
                movem.l 160*63+96(A6),D1-A4
                movem.l D1-A4,160*24+96(A5)
                movem.l 160*63+144(A6),D1-A0
                movem.l D1-A0,160*24+144(A5)
                movem.l 160*64(A6),D1-A4
                movem.l D1-A4,160*25(A5)
                movem.l 160*64+48(A6),D1-A4
                movem.l D1-A4,160*25+48(A5)
                movem.l 160*64+96(A6),D1-A4
                movem.l D1-A4,160*25+96(A5)
                movem.l 160*64+144(A6),D1-A0
                movem.l D1-A0,160*25+144(A5)
                movem.l 160*66(A6),D1-A4
                movem.l D1-A4,160*26(A5)
                movem.l 160*66+48(A6),D1-A4
                movem.l D1-A4,160*26+48(A5)
                movem.l 160*66+96(A6),D1-A4
                movem.l D1-A4,160*26+96(A5)
                movem.l 160*66+144(A6),D1-A0
                movem.l D1-A0,160*26+144(A5)
                movem.l 160*67(A6),D1-A4
                movem.l D1-A4,160*27(A5)
                movem.l 160*67+48(A6),D1-A4
                movem.l D1-A4,160*27+48(A5)
                movem.l 160*67+96(A6),D1-A4
                movem.l D1-A4,160*27+96(A5)
                movem.l 160*67+144(A6),D1-A0
                movem.l D1-A0,160*27+144(A5)
                movem.l 160*69(A6),D1-A4
                movem.l D1-A4,160*28(A5)
                movem.l 160*69+48(A6),D1-A4
                movem.l D1-A4,160*28+48(A5)
                movem.l 160*69+96(A6),D1-A4
                movem.l D1-A4,160*28+96(A5)
                movem.l 160*69+144(A6),D1-A0
                movem.l D1-A0,160*28+144(A5)
                movem.l 160*70(A6),D1-A4
                movem.l D1-A4,160*29(A5)
                movem.l 160*70+48(A6),D1-A4
                movem.l D1-A4,160*29+48(A5)
                movem.l 160*70+96(A6),D1-A4
                movem.l D1-A4,160*29+96(A5)
                movem.l 160*70+144(A6),D1-A0
                movem.l D1-A0,160*29+144(A5)
                movem.l 160*72(A6),D1-A4
                movem.l D1-A4,160*30(A5)
                movem.l 160*72+48(A6),D1-A4
                movem.l D1-A4,160*30+48(A5)
                movem.l 160*72+96(A6),D1-A4
                movem.l D1-A4,160*30+96(A5)
                movem.l 160*72+144(A6),D1-A0
                movem.l D1-A0,160*30+144(A5)
                movem.l 160*73(A6),D1-A4
                movem.l D1-A4,160*31(A5)
                movem.l 160*73+48(A6),D1-A4
                movem.l D1-A4,160*31+48(A5)
                movem.l 160*73+96(A6),D1-A4
                movem.l D1-A4,160*31+96(A5)
                movem.l 160*73+144(A6),D1-A0
                movem.l D1-A0,160*31+144(A5)
                movem.l 160*74(A6),D1-A4
                movem.l D1-A4,160*32(A5)
                movem.l 160*74+48(A6),D1-A4
                movem.l D1-A4,160*32+48(A5)
                movem.l 160*74+96(A6),D1-A4
                movem.l D1-A4,160*32+96(A5)
                movem.l 160*74+144(A6),D1-A0
                movem.l D1-A0,160*32+144(A5)
                movem.l 160*76(A6),D1-A4
                movem.l D1-A4,160*33(A5)
                movem.l 160*76+48(A6),D1-A4
                movem.l D1-A4,160*33+48(A5)
                movem.l 160*76+96(A6),D1-A4
                movem.l D1-A4,160*33+96(A5)
                movem.l 160*76+144(A6),D1-A0
                movem.l D1-A0,160*33+144(A5)
                movem.l 160*77(A6),D1-A4
                movem.l D1-A4,160*34(A5)
                movem.l 160*77+48(A6),D1-A4
                movem.l D1-A4,160*34+48(A5)
                movem.l 160*77+96(A6),D1-A4
                movem.l D1-A4,160*34+96(A5)
                movem.l 160*77+144(A6),D1-A0
                movem.l D1-A0,160*34+144(A5)
                movem.l 160*78(A6),D1-A4
                movem.l D1-A4,160*35(A5)
                movem.l 160*78+48(A6),D1-A4
                movem.l D1-A4,160*35+48(A5)
                movem.l 160*78+96(A6),D1-A4
                movem.l D1-A4,160*35+96(A5)
                movem.l 160*78+144(A6),D1-A0
                movem.l D1-A0,160*35+144(A5)
                movem.l 160*80(A6),D1-A4
                movem.l D1-A4,160*36(A5)
                movem.l 160*80+48(A6),D1-A4
                movem.l D1-A4,160*36+48(A5)
                movem.l 160*80+96(A6),D1-A4
                movem.l D1-A4,160*36+96(A5)
                movem.l 160*80+144(A6),D1-A0
                movem.l D1-A0,160*36+144(A5)
                movem.l 160*81(A6),D1-A4
                movem.l D1-A4,160*37(A5)
                movem.l 160*81+48(A6),D1-A4
                movem.l D1-A4,160*37+48(A5)
                movem.l 160*81+96(A6),D1-A4
                movem.l D1-A4,160*37+96(A5)
                movem.l 160*81+144(A6),D1-A0
                movem.l D1-A0,160*37+144(A5)
                movem.l 160*82(A6),D1-A4
                movem.l D1-A4,160*38(A5)
                movem.l 160*82+48(A6),D1-A4
                movem.l D1-A4,160*38+48(A5)
                movem.l 160*82+96(A6),D1-A4
                movem.l D1-A4,160*38+96(A5)
                movem.l 160*82+144(A6),D1-A0
                movem.l D1-A0,160*38+144(A5)
                movem.l 160*83(A6),D1-A4
                movem.l D1-A4,160*39(A5)
                movem.l 160*83+48(A6),D1-A4
                movem.l D1-A4,160*39+48(A5)
                movem.l 160*83+96(A6),D1-A4
                movem.l D1-A4,160*39+96(A5)
                movem.l 160*83+144(A6),D1-A0
                movem.l D1-A0,160*39+144(A5)
                movem.l 160*85(A6),D1-A4
                movem.l D1-A4,160*40(A5)
                movem.l 160*85+48(A6),D1-A4
                movem.l D1-A4,160*40+48(A5)
                movem.l 160*85+96(A6),D1-A4
                movem.l D1-A4,160*40+96(A5)
                movem.l 160*85+144(A6),D1-A0
                movem.l D1-A0,160*40+144(A5)
                movem.l 160*86(A6),D1-A4
                movem.l D1-A4,160*41(A5)
                movem.l 160*86+48(A6),D1-A4
                movem.l D1-A4,160*41+48(A5)
                movem.l 160*86+96(A6),D1-A4
                movem.l D1-A4,160*41+96(A5)
                movem.l 160*86+144(A6),D1-A0
                movem.l D1-A0,160*41+144(A5)
                movem.l 160*87(A6),D1-A4
                movem.l D1-A4,160*42(A5)
                movem.l 160*87+48(A6),D1-A4
                movem.l D1-A4,160*42+48(A5)
                movem.l 160*87+96(A6),D1-A4
                movem.l D1-A4,160*42+96(A5)
                movem.l 160*87+144(A6),D1-A0
                movem.l D1-A0,160*42+144(A5)
                movem.l 160*88(A6),D1-A4
                movem.l D1-A4,160*43(A5)
                movem.l 160*88+48(A6),D1-A4
                movem.l D1-A4,160*43+48(A5)
                movem.l 160*88+96(A6),D1-A4
                movem.l D1-A4,160*43+96(A5)
                movem.l 160*88+144(A6),D1-A0
                movem.l D1-A0,160*43+144(A5)
                movem.l 160*89(A6),D1-A4
                movem.l D1-A4,160*44(A5)
                movem.l 160*89+48(A6),D1-A4
                movem.l D1-A4,160*44+48(A5)
                movem.l 160*89+96(A6),D1-A4
                movem.l D1-A4,160*44+96(A5)
                movem.l 160*89+144(A6),D1-A0
                movem.l D1-A0,160*44+144(A5)
                movem.l 160*90(A6),D1-A4
                movem.l D1-A4,160*45(A5)
                movem.l 160*90+48(A6),D1-A4
                movem.l D1-A4,160*45+48(A5)
                movem.l 160*90+96(A6),D1-A4
                movem.l D1-A4,160*45+96(A5)
                movem.l 160*90+144(A6),D1-A0
                movem.l D1-A0,160*45+144(A5)
                movem.l 160*92(A6),D1-A4
                movem.l D1-A4,160*46(A5)
                movem.l 160*92+48(A6),D1-A4
                movem.l D1-A4,160*46+48(A5)
                movem.l 160*92+96(A6),D1-A4
                movem.l D1-A4,160*46+96(A5)
                movem.l 160*92+144(A6),D1-A0
                movem.l D1-A0,160*46+144(A5)
                movem.l 160*93(A6),D1-A4
                movem.l D1-A4,160*47(A5)
                movem.l 160*93+48(A6),D1-A4
                movem.l D1-A4,160*47+48(A5)
                movem.l 160*93+96(A6),D1-A4
                movem.l D1-A4,160*47+96(A5)
                movem.l 160*93+144(A6),D1-A0
                movem.l D1-A0,160*47+144(A5)
                movem.l 160*94(A6),D1-A4
                movem.l D1-A4,160*48(A5)
                movem.l 160*94+48(A6),D1-A4
                movem.l D1-A4,160*48+48(A5)
                movem.l 160*94+96(A6),D1-A4
                movem.l D1-A4,160*48+96(A5)
                movem.l 160*94+144(A6),D1-A0
                movem.l D1-A0,160*48+144(A5)
                movem.l 160*95(A6),D1-A4
                movem.l D1-A4,160*49(A5)
                movem.l 160*95+48(A6),D1-A4
                movem.l D1-A4,160*49+48(A5)
                movem.l 160*95+96(A6),D1-A4
                movem.l D1-A4,160*49+96(A5)
                movem.l 160*95+144(A6),D1-A0
                movem.l D1-A0,160*49+144(A5)
                movem.l 160*96(A6),D1-A4
                movem.l D1-A4,160*50(A5)
                movem.l 160*96+48(A6),D1-A4
                movem.l D1-A4,160*50+48(A5)
                movem.l 160*96+96(A6),D1-A4
                movem.l D1-A4,160*50+96(A5)
                movem.l 160*96+144(A6),D1-A0
                movem.l D1-A0,160*50+144(A5)
                movem.l 160*97(A6),D1-A4
                movem.l D1-A4,160*51(A5)
                movem.l 160*97+48(A6),D1-A4
                movem.l D1-A4,160*51+48(A5)
                movem.l 160*97+96(A6),D1-A4
                movem.l D1-A4,160*51+96(A5)
                movem.l 160*97+144(A6),D1-A0
                movem.l D1-A0,160*51+144(A5)
                movem.l 160*98(A6),D1-A4
                movem.l D1-A4,160*52(A5)
                movem.l 160*98+48(A6),D1-A4
                movem.l D1-A4,160*52+48(A5)
                movem.l 160*98+96(A6),D1-A4
                movem.l D1-A4,160*52+96(A5)
                movem.l 160*98+144(A6),D1-A0
                movem.l D1-A0,160*52+144(A5)
                movem.l 160*99(A6),D1-A4
                movem.l D1-A4,160*53(A5)
                movem.l 160*99+48(A6),D1-A4
                movem.l D1-A4,160*53+48(A5)
                movem.l 160*99+96(A6),D1-A4
                movem.l D1-A4,160*53+96(A5)
                movem.l 160*99+144(A6),D1-A0
                movem.l D1-A0,160*53+144(A5)
                movem.l 160*100(A6),D1-A4
                movem.l D1-A4,160*54(A5)
                movem.l 160*100+48(A6),D1-A4
                movem.l D1-A4,160*54+48(A5)
                movem.l 160*100+96(A6),D1-A4
                movem.l D1-A4,160*54+96(A5)
                movem.l 160*100+144(A6),D1-A0
                movem.l D1-A0,160*54+144(A5)
                movem.l 160*102(A6),D1-A4
                movem.l D1-A4,160*55(A5)
                movem.l 160*102+48(A6),D1-A4
                movem.l D1-A4,160*55+48(A5)
                movem.l 160*102+96(A6),D1-A4
                movem.l D1-A4,160*55+96(A5)
                movem.l 160*102+144(A6),D1-A0
                movem.l D1-A0,160*55+144(A5)
                movem.l 160*103(A6),D1-A4
                movem.l D1-A4,160*56(A5)
                movem.l 160*103+48(A6),D1-A4
                movem.l D1-A4,160*56+48(A5)
                movem.l 160*103+96(A6),D1-A4
                movem.l D1-A4,160*56+96(A5)
                movem.l 160*103+144(A6),D1-A0
                movem.l D1-A0,160*56+144(A5)
                movem.l 160*104(A6),D1-A4
                movem.l D1-A4,160*57(A5)
                movem.l 160*104+48(A6),D1-A4
                movem.l D1-A4,160*57+48(A5)
                movem.l 160*104+96(A6),D1-A4
                movem.l D1-A4,160*57+96(A5)
                movem.l 160*104+144(A6),D1-A0
                movem.l D1-A0,160*57+144(A5)
                movem.l 160*105(A6),D1-A4
                movem.l D1-A4,160*58(A5)
                movem.l 160*105+48(A6),D1-A4
                movem.l D1-A4,160*58+48(A5)
                movem.l 160*105+96(A6),D1-A4
                movem.l D1-A4,160*58+96(A5)
                movem.l 160*105+144(A6),D1-A0
                movem.l D1-A0,160*58+144(A5)
                movem.l 160*106(A6),D1-A4
                movem.l D1-A4,160*59(A5)
                movem.l 160*106+48(A6),D1-A4
                movem.l D1-A4,160*59+48(A5)
                movem.l 160*106+96(A6),D1-A4
                movem.l D1-A4,160*59+96(A5)
                movem.l 160*106+144(A6),D1-A0
                movem.l D1-A0,160*59+144(A5)
                movem.l 160*107(A6),D1-A4
                movem.l D1-A4,160*60(A5)
                movem.l 160*107+48(A6),D1-A4
                movem.l D1-A4,160*60+48(A5)
                movem.l 160*107+96(A6),D1-A4
                movem.l D1-A4,160*60+96(A5)
                movem.l 160*107+144(A6),D1-A0
                movem.l D1-A0,160*60+144(A5)
                movem.l 160*109(A6),D1-A4
                movem.l D1-A4,160*61(A5)
                movem.l 160*109+48(A6),D1-A4
                movem.l D1-A4,160*61+48(A5)
                movem.l 160*109+96(A6),D1-A4
                movem.l D1-A4,160*61+96(A5)
                movem.l 160*109+144(A6),D1-A0
                movem.l D1-A0,160*61+144(A5)
                movem.l 160*110(A6),D1-A4
                movem.l D1-A4,160*62(A5)
                movem.l 160*110+48(A6),D1-A4
                movem.l D1-A4,160*62+48(A5)
                movem.l 160*110+96(A6),D1-A4
                movem.l D1-A4,160*62+96(A5)
                movem.l 160*110+144(A6),D1-A0
                movem.l D1-A0,160*62+144(A5)
                movem.l 160*111(A6),D1-A4
                movem.l D1-A4,160*63(A5)
                movem.l 160*111+48(A6),D1-A4
                movem.l D1-A4,160*63+48(A5)
                movem.l 160*111+96(A6),D1-A4
                movem.l D1-A4,160*63+96(A5)
                movem.l 160*111+144(A6),D1-A0
                movem.l D1-A0,160*63+144(A5)
                movem.l 160*113(A6),D1-A4
                movem.l D1-A4,160*64(A5)
                movem.l 160*113+48(A6),D1-A4
                movem.l D1-A4,160*64+48(A5)
                movem.l 160*113+96(A6),D1-A4
                movem.l D1-A4,160*64+96(A5)
                movem.l 160*113+144(A6),D1-A0
                movem.l D1-A0,160*64+144(A5)
                movem.l 160*114(A6),D1-A4
                movem.l D1-A4,160*65(A5)
                movem.l 160*114+48(A6),D1-A4
                movem.l D1-A4,160*65+48(A5)
                movem.l 160*114+96(A6),D1-A4
                movem.l D1-A4,160*65+96(A5)
                movem.l 160*114+144(A6),D1-A0
                movem.l D1-A0,160*65+144(A5)
                movem.l 160*115(A6),D1-A4
                movem.l D1-A4,160*66(A5)
                movem.l 160*115+48(A6),D1-A4
                movem.l D1-A4,160*66+48(A5)
                movem.l 160*115+96(A6),D1-A4
                movem.l D1-A4,160*66+96(A5)
                movem.l 160*115+144(A6),D1-A0
                movem.l D1-A0,160*66+144(A5)
                movem.l 160*116(A6),D1-A4
                movem.l D1-A4,160*67(A5)
                movem.l 160*116+48(A6),D1-A4
                movem.l D1-A4,160*67+48(A5)
                movem.l 160*116+96(A6),D1-A4
                movem.l D1-A4,160*67+96(A5)
                movem.l 160*116+144(A6),D1-A0
                movem.l D1-A0,160*67+144(A5)
                movem.l 160*118(A6),D1-A4
                movem.l D1-A4,160*68(A5)
                movem.l 160*118+48(A6),D1-A4
                movem.l D1-A4,160*68+48(A5)
                movem.l 160*118+96(A6),D1-A4
                movem.l D1-A4,160*68+96(A5)
                movem.l 160*118+144(A6),D1-A0
                movem.l D1-A0,160*68+144(A5)
                movem.l 160*119(A6),D1-A4
                movem.l D1-A4,160*69(A5)
                movem.l 160*119+48(A6),D1-A4
                movem.l D1-A4,160*69+48(A5)
                movem.l 160*119+96(A6),D1-A4
                movem.l D1-A4,160*69+96(A5)
                movem.l 160*119+144(A6),D1-A0
                movem.l D1-A0,160*69+144(A5)
                movem.l 160*121(A6),D1-A4
                movem.l D1-A4,160*70(A5)
                movem.l 160*121+48(A6),D1-A4
                movem.l D1-A4,160*70+48(A5)
                movem.l 160*121+96(A6),D1-A4
                movem.l D1-A4,160*70+96(A5)
                movem.l 160*121+144(A6),D1-A0
                movem.l D1-A0,160*70+144(A5)
                movem.l 160*122(A6),D1-A4
                movem.l D1-A4,160*71(A5)
                movem.l 160*122+48(A6),D1-A4
                movem.l D1-A4,160*71+48(A5)
                movem.l 160*122+96(A6),D1-A4
                movem.l D1-A4,160*71+96(A5)
                movem.l 160*122+144(A6),D1-A0
                movem.l D1-A0,160*71+144(A5)
                movem.l 160*124(A6),D1-A4
                movem.l D1-A4,160*72(A5)
                movem.l 160*124+48(A6),D1-A4
                movem.l D1-A4,160*72+48(A5)
                movem.l 160*124+96(A6),D1-A4
                movem.l D1-A4,160*72+96(A5)
                movem.l 160*124+144(A6),D1-A0
                movem.l D1-A0,160*72+144(A5)
                movem.l 160*125(A6),D1-A4
                movem.l D1-A4,160*73(A5)
                movem.l 160*125+48(A6),D1-A4
                movem.l D1-A4,160*73+48(A5)
                movem.l 160*125+96(A6),D1-A4
                movem.l D1-A4,160*73+96(A5)
                movem.l 160*125+144(A6),D1-A0
                movem.l D1-A0,160*73+144(A5)
                movem.l 160*127(A6),D1-A4
                movem.l D1-A4,160*74(A5)
                movem.l 160*127+48(A6),D1-A4
                movem.l D1-A4,160*74+48(A5)
                movem.l 160*127+96(A6),D1-A4
                movem.l D1-A4,160*74+96(A5)
                movem.l 160*127+144(A6),D1-A0
                movem.l D1-A0,160*74+144(A5)
                movem.l 160*128(A6),D1-A4
                movem.l D1-A4,160*75(A5)
                movem.l 160*128+48(A6),D1-A4
                movem.l D1-A4,160*75+48(A5)
                movem.l 160*128+96(A6),D1-A4
                movem.l D1-A4,160*75+96(A5)
                movem.l 160*128+144(A6),D1-A0
                movem.l D1-A0,160*75+144(A5)
                movem.l 160*130(A6),D1-A4
                movem.l D1-A4,160*76(A5)
                movem.l 160*130+48(A6),D1-A4
                movem.l D1-A4,160*76+48(A5)
                movem.l 160*130+96(A6),D1-A4
                movem.l D1-A4,160*76+96(A5)
                movem.l 160*130+144(A6),D1-A0
                movem.l D1-A0,160*76+144(A5)
                movem.l 160*131(A6),D1-A4
                movem.l D1-A4,160*77(A5)
                movem.l 160*131+48(A6),D1-A4
                movem.l D1-A4,160*77+48(A5)
                movem.l 160*131+96(A6),D1-A4
                movem.l D1-A4,160*77+96(A5)
                movem.l 160*131+144(A6),D1-A0
                movem.l D1-A0,160*77+144(A5)
                movem.l 160*133(A6),D1-A4
                movem.l D1-A4,160*78(A5)
                movem.l 160*133+48(A6),D1-A4
                movem.l D1-A4,160*78+48(A5)
                movem.l 160*133+96(A6),D1-A4
                movem.l D1-A4,160*78+96(A5)
                movem.l 160*133+144(A6),D1-A0
                movem.l D1-A0,160*78+144(A5)
                movem.l 160*135(A6),D1-A4
                movem.l D1-A4,160*79(A5)
                movem.l 160*135+48(A6),D1-A4
                movem.l D1-A4,160*79+48(A5)
                movem.l 160*135+96(A6),D1-A4
                movem.l D1-A4,160*79+96(A5)
                movem.l 160*135+144(A6),D1-A0
                movem.l D1-A0,160*79+144(A5)
                movem.l 160*136(A6),D1-A4
                movem.l D1-A4,160*80(A5)
                movem.l 160*136+48(A6),D1-A4
                movem.l D1-A4,160*80+48(A5)
                movem.l 160*136+96(A6),D1-A4
                movem.l D1-A4,160*80+96(A5)
                movem.l 160*136+144(A6),D1-A0
                movem.l D1-A0,160*80+144(A5)
                movem.l 160*138(A6),D1-A4
                movem.l D1-A4,160*81(A5)
                movem.l 160*138+48(A6),D1-A4
                movem.l D1-A4,160*81+48(A5)
                movem.l 160*138+96(A6),D1-A4
                movem.l D1-A4,160*81+96(A5)
                movem.l 160*138+144(A6),D1-A0
                movem.l D1-A0,160*81+144(A5)
                movem.l 160*140(A6),D1-A4
                movem.l D1-A4,160*82(A5)
                movem.l 160*140+48(A6),D1-A4
                movem.l D1-A4,160*82+48(A5)
                movem.l 160*140+96(A6),D1-A4
                movem.l D1-A4,160*82+96(A5)
                movem.l 160*140+144(A6),D1-A0
                movem.l D1-A0,160*82+144(A5)
                movem.l 160*142(A6),D1-A4
                movem.l D1-A4,160*83(A5)
                movem.l 160*142+48(A6),D1-A4
                movem.l D1-A4,160*83+48(A5)
                movem.l 160*142+96(A6),D1-A4
                movem.l D1-A4,160*83+96(A5)
                movem.l 160*142+144(A6),D1-A0
                movem.l D1-A0,160*83+144(A5)
                movem.l 160*143(A6),D1-A4
                movem.l D1-A4,160*84(A5)
                movem.l 160*143+48(A6),D1-A4
                movem.l D1-A4,160*84+48(A5)
                movem.l 160*143+96(A6),D1-A4
                movem.l D1-A4,160*84+96(A5)
                movem.l 160*143+144(A6),D1-A0
                movem.l D1-A0,160*84+144(A5)
                movem.l 160*145(A6),D1-A4
                movem.l D1-A4,160*85(A5)
                movem.l 160*145+48(A6),D1-A4
                movem.l D1-A4,160*85+48(A5)
                movem.l 160*145+96(A6),D1-A4
                movem.l D1-A4,160*85+96(A5)
                movem.l 160*145+144(A6),D1-A0
                movem.l D1-A0,160*85+144(A5)
                movem.l 160*147(A6),D1-A4
                movem.l D1-A4,160*86(A5)
                movem.l 160*147+48(A6),D1-A4
                movem.l D1-A4,160*86+48(A5)
                movem.l 160*147+96(A6),D1-A4
                movem.l D1-A4,160*86+96(A5)
                movem.l 160*147+144(A6),D1-A0
                movem.l D1-A0,160*86+144(A5)
                movem.l 160*149(A6),D1-A4
                movem.l D1-A4,160*87(A5)
                movem.l 160*149+48(A6),D1-A4
                movem.l D1-A4,160*87+48(A5)
                movem.l 160*149+96(A6),D1-A4
                movem.l D1-A4,160*87+96(A5)
                movem.l 160*149+144(A6),D1-A0
                movem.l D1-A0,160*87+144(A5)
                movem.l 160*151(A6),D1-A4
                movem.l D1-A4,160*88(A5)
                movem.l 160*151+48(A6),D1-A4
                movem.l D1-A4,160*88+48(A5)
                movem.l 160*151+96(A6),D1-A4
                movem.l D1-A4,160*88+96(A5)
                movem.l 160*151+144(A6),D1-A0
                movem.l D1-A0,160*88+144(A5)
                movem.l 160*153(A6),D1-A4
                movem.l D1-A4,160*89(A5)
                movem.l 160*153+48(A6),D1-A4
                movem.l D1-A4,160*89+48(A5)
                movem.l 160*153+96(A6),D1-A4
                movem.l D1-A4,160*89+96(A5)
                movem.l 160*153+144(A6),D1-A0
                movem.l D1-A0,160*89+144(A5)
                movem.l 160*155(A6),D1-A4
                movem.l D1-A4,160*90(A5)
                movem.l 160*155+48(A6),D1-A4
                movem.l D1-A4,160*90+48(A5)
                movem.l 160*155+96(A6),D1-A4
                movem.l D1-A4,160*90+96(A5)
                movem.l 160*155+144(A6),D1-A0
                movem.l D1-A0,160*90+144(A5)
                movem.l 160*157(A6),D1-A4
                movem.l D1-A4,160*91(A5)
                movem.l 160*157+48(A6),D1-A4
                movem.l D1-A4,160*91+48(A5)
                movem.l 160*157+96(A6),D1-A4
                movem.l D1-A4,160*91+96(A5)
                movem.l 160*157+144(A6),D1-A0
                movem.l D1-A0,160*91+144(A5)
                movem.l 160*159(A6),D1-A4
                movem.l D1-A4,160*92(A5)
                movem.l 160*159+48(A6),D1-A4
                movem.l D1-A4,160*92+48(A5)
                movem.l 160*159+96(A6),D1-A4
                movem.l D1-A4,160*92+96(A5)
                movem.l 160*159+144(A6),D1-A0
                movem.l D1-A0,160*92+144(A5)
                movem.l 160*162(A6),D1-A4
                movem.l D1-A4,160*93(A5)
                movem.l 160*162+48(A6),D1-A4
                movem.l D1-A4,160*93+48(A5)
                movem.l 160*162+96(A6),D1-A4
                movem.l D1-A4,160*93+96(A5)
                movem.l 160*162+144(A6),D1-A0
                movem.l D1-A0,160*93+144(A5)
                movem.l 160*164(A6),D1-A4
                movem.l D1-A4,160*94(A5)
                movem.l 160*164+48(A6),D1-A4
                movem.l D1-A4,160*94+48(A5)
                movem.l 160*164+96(A6),D1-A4
                movem.l D1-A4,160*94+96(A5)
                movem.l 160*164+144(A6),D1-A0
                movem.l D1-A0,160*94+144(A5)
                movem.l 160*167(A6),D1-A4
                movem.l D1-A4,160*95(A5)
                movem.l 160*167+48(A6),D1-A4
                movem.l D1-A4,160*95+48(A5)
                movem.l 160*167+96(A6),D1-A4
                movem.l D1-A4,160*95+96(A5)
                movem.l 160*167+144(A6),D1-A0
                movem.l D1-A0,160*95+144(A5)
                movem.l 160*170(A6),D1-A4
                movem.l D1-A4,160*96(A5)
                movem.l 160*170+48(A6),D1-A4
                movem.l D1-A4,160*96+48(A5)
                movem.l 160*170+96(A6),D1-A4
                movem.l D1-A4,160*96+96(A5)
                movem.l 160*170+144(A6),D1-A0
                movem.l D1-A0,160*96+144(A5)
                movem.l 160*173(A6),D1-A4
                movem.l D1-A4,160*97(A5)
                movem.l 160*173+48(A6),D1-A4
                movem.l D1-A4,160*97+48(A5)
                movem.l 160*173+96(A6),D1-A4
                movem.l D1-A4,160*97+96(A5)
                movem.l 160*173+144(A6),D1-A0
                movem.l D1-A0,160*97+144(A5)
                movem.l 160*177(A6),D1-A4
                movem.l D1-A4,160*98(A5)
                movem.l 160*177+48(A6),D1-A4
                movem.l D1-A4,160*98+48(A5)
                movem.l 160*177+96(A6),D1-A4
                movem.l D1-A4,160*98+96(A5)
                movem.l 160*177+144(A6),D1-A0
                movem.l D1-A0,160*98+144(A5)
                movem.l 160*181(A6),D1-A4
                movem.l D1-A4,160*99(A5)
                movem.l 160*181+48(A6),D1-A4
                movem.l D1-A4,160*99+48(A5)
                movem.l 160*181+96(A6),D1-A4
                movem.l D1-A4,160*99+96(A5)
                movem.l 160*181+144(A6),D1-A0
                movem.l D1-A0,160*99+144(A5)
                movem.l 160*187(A6),D1-A4
                movem.l D1-A4,160*100(A5)
                movem.l 160*187+48(A6),D1-A4
                movem.l D1-A4,160*100+48(A5)
                movem.l 160*187+96(A6),D1-A4
                movem.l D1-A4,160*100+96(A5)
                movem.l 160*187+144(A6),D1-A0
                movem.l D1-A0,160*100+144(A5)

                rts

muzak:          IBYTES 'HAROLD.IMG' ; The Muzak-file

                DATA
off:            DC.B $13
                EVEN
handle2:        DC.L 0
color_puffer:   DC.W 0
lettercounter:  DC.W 0
screen1:        DC.L $078000
screen2:        DC.L $070000
base1:          DC.L $060000
base2:          DC.L $058000
base3:          DC.L $050000
base4:          DC.L $048000
ikbws:          DC.B $13
tube_offset:    DC.L 0
datei:          DC.B "bender.doo",0
                EVEN
tube_counter:   DC.W 0
palette:
                DC.W $00,$0430,$0540,$0650,$0760,$02,$0300,$0400
                DC.W $0500,$0600,$0700,$07,$06,$05,$77,$0770
pause:          DC.W 0
sav_puffer:     DC.L 0
wave_offset:    DC.L 0
wave:           DC.L 0
; The sine-tab:
                DC.W 139,139,139,139,139,139,138,138,138,137,137,136,136,135,134,134,133,132,131,130,130,129,128,127,126,125,124,123,121,120
                DC.W 119,118,117,116,115,113,112,111,110,109,107,106,105,104,103,102,100,99,98,97,96,95,94,93,92,91,90,89,88,87
                DC.W 87,86,85,84,84,83,83,82,82,81,81,81,80,80,80,80,80,80,80,80,80,80,80,80,80,81,81,82,82,83
                DC.W 83,84,84,85,86,87,87,88,89,90,91,92,93,94,95,96,97,98,99,100,101,103,104,105,106,107,109,110,111,112
                DC.W 113,115,116,117,118,119,120,121,122,124,125,126,127,128,129,129,130,131,132,133,134,134,135,135,136,137,137,138,138,138
                DC.W 139
wave_form:
                DC.W 139,139,139,139,139,139,138,138,138,137,137,136,136,135,134,134,133,132,131,130,130,129,128,127,126,125,124,123,121,120
                DC.W 119,118,117,116,115,113,112,111,110,109,107,106,105,104,103,102,100,99,98,97,96,95,94,93,92,91,90,89,88,87
                DC.W 87,86,85,84,84,83,83,82,82,81,81,81,80,80,80,80,80,80,80,80,80,80,80,80,80,81,81,82,82,83
                DC.W 83,84,84,85,86,87,87,88,89,90,91,92,93,94,95,96,97,98,99,100,101,103,104,105,106,107,109,110,111,112
                DC.W 113,115,116,117,118,119,120,121,122,124,125,126,127,128,129,129,130,131,132,133,134,134,135,135,136,137,137,138,138,138
                DC.W 139
                DC.W 139,139,139,139,139,139,138,138,138,137,137,136,136,135,134,134,133,132,131,130,130,129,128,127,126,125,124,123,121,120
                DC.W 119,118,117,116,115,113,112,111,110,109,107,106,105,104,103,102,100,99,98,97,96,95,94,93,92,91,90,89,88,87
                DC.W 87,86,85,84,84,83,83,82,82,81,81,81,80,80,80,80,80,80,80,80,80,80,80,80,80,81,81,82,82,83
                DC.W 83,84,84,85,86,87,87,88,89,90,91,92,93,94,95,96,97,98,99,100,101,103,104,105,106,107,109,110,111,112
                DC.W 113,115,116,117,118,119,120,121,122,124,125,126,127,128,129,129,130,131,132,133,134,134,135,135,136,137,137,138,138,138
                DC.W 139

clr:            DC.B 27,"E",0
counter:        DC.W 0
zeiger:         DC.L 0
saver:          DC.L 0
letter:         DC.L 0
offset:         DC.L 0
; That's the scrolltext, try to find out the charset !
; (Hint: Nr.254 stops the scroller, Nr.30 is a ':' !!!)
text:
                DC.B 11,4,19,31,18,47,22,17,0,15,15,47,47,47,47,4,17,17,29,29,29,47,18,14,17,17,24,35,47,19,7,8,18,47
                DC.B 22,0,18,47,0,47,1,8,19,47,19,14,14,47,4,0,17,11,24,29,29,29,47,47,47,0,13,24,22,0,24,47
                DC.B 19,7,8,18,47,8,18,47,2,7,0,17,14,13,47,0,6,0,8,13,29,47,47,47,5,8,13,0,11,11,24,47
                DC.B 8,47,5,8,13,8,18,7,4,3,47,19,7,8,18,47,5,31,8,13,6,47,3,4,12,14,35,47,38,47
                DC.B 12,14,13,19,7,18,47,0,5,19,4,17,47,8,19,31,18,47,15,11,0,13,13,4,3,47,17,4,11,4,0,18,4,29,47
                DC.B 1,20,19,47,18,8,13,2,4,47,38,47,12,14,13,19,7,18,47,14,13,11,24,47,19,7,4,47
                DC.B 6,17,0,5,8,23,23,47,5,14,17,47,19,7,8,18,47,18,2,17,4,4,13,47,22,4,17,4,47,12,8,18,18,8,13,6,47
                DC.B 29,47,47,11,0,18,19,47,22,4,4,10,47,8,47,0,18,10,4,3,47,1,11,14,22,19,14,17,2,7,47,19,7,4,47
                DC.B 11,0,18,19,47,19,8,12,4,47,5,14,17,47,7,8,18,47,6,17,0,5,8,23,35,47,0,13,3,47,19,14,3,0,24,47
                DC.B 8,47,12,0,3,4,47,19,7,4,47,6,17,0,5,8,23,47,12,24,18,4,11,5,47,32,47,47,47,47,47
                DC.B 19,7,4,47,2,17,4,3,8,19,18,30,47,47,47,47,2,14,3,8,13,6,30,47,1,11,14,22,19,14,17,2,7,47
                DC.B 47,47,6,17,0,5,8,23,23,47,0,13,3,47,0,47,11,8,19,19,11,4,47,1,8,19,47,14,5,47
                DC.B 2,14,3,8,13,6,30,47,2,7,0,17,14,13,29,29,29,29,29,29,29,29,29,47,47,47,47,47,47,47
                DC.B 13,14,22,47,8,31,21,4,47,6,14,19,47,18,14,12,4,47,13,4,22,18,29,29,29,29,47,47
                DC.B 22,4,47,13,14,22,47,7,0,21,4,47,14,13,4,47,12,14,17,4,47,0,12,8,6,0,33,12,4,12,1,4,17,29,47
                DC.B 47,7,8,18,47,13,0,12,4,47,8,18,47,31,17,4,12,0,11,31,47,0,13,3,47,7,4,47,3,14,4,18,47
                DC.B 12,14,18,19,11,24,47,12,20,25,0,4,8,23,29,47,19,7,4,47,0,12,8,6,0,33,15,0,17,19,47,14,5,47
                DC.B 19,7,4,47,13,0,19,14,47,7,0,18,47,2,7,0,13,6,4,3,47,8,19,18,47,13,0,12,4,47,19,14,47
                DC.B 31,19,7,4,47,5,17,0,6,6,11,4,18,31,35,47,19,7,0,19,31,18,47,1,4,2,14,25,47,19,7,4,17,4,47
                DC.B 8,18,47,0,11,17,4,0,3,24,47,0,47,31,13,0,19,14,31,47,14,13,47,19,7,4,47,0,12,8,6,0,47,32,47
                DC.B 47,47,22,7,0,19,47,19,14,47,22,17,8,19,4,47,13,14,22,47,28,47,47,47,4,17,17,29,29,29,47
                DC.B 24,4,18,47,32,47,47,47,4,17,17,29,29,29,47,13,14,29,29,29,47,47,47,0,0,7,47,32,47,47
                DC.B 13,14,47,13,14,47,13,14,29,29,29,29,47,47,47,7,12,12,29,29,29,47,7,14,22,47,0,1,14,20,19,47
                DC.B 19,0,11,10,8,13,6,47,0,1,14,20,19,47,14,20,17,47,19,7,8,17,3,47,3,4,12,14,47,28,47
                DC.B 26,19,7,8,18,47,8,18,47,14,20,17,47,5,8,17,18,19,47,32,27,47,47,11,4,19,31,18,47,7,0,21,4,47
                DC.B 0,47,11,14,14,10,47,5,0,17,47,8,13,19,14,47,19,7,4,47,5,20,19,20,17,4,29,29,29,29,29,29,29,47
                DC.B 8,31,12,47,15,4,17,7,0,15,18,47,6,14,8,13,6,47,19,14,47,3,14,47,0,47,10,8,13,3,47,14,5,47
                DC.B 0,47,1,8,6,33,3,4,12,14,47,37,29,47,8,19,31,18,47,13,0,12,4,47,22,8,11,11,47,47
                DC.B 15,17,14,1,0,1,11,24,47,1,4,47,19,7,4,47,31,5,29,0,29,19,29,33,3,4,12,14,31,29,47,47
                DC.B 8,31,11,11,47,19,17,24,47,19,14,47,15,20,19,47,8,13,47,12,14,17,4,47,18,14,20,13,3,35,47,12,14,17,4,47
                DC.B 18,2,17,14,11,11,19,4,23,19,35,47,12,14,17,4,35,47,12,14,17,4,35,47,12,14,17,4,29,29,29,29,29,47
                DC.B 26,24,4,0,7,47,32,32,32,32,47,47,12,12,12,14,14,14,17,17,17,4,4,4,47,32,32,32,32,32,32,27,47
                DC.B 1,0,6,33,22,0,7,13,47,47,1,8,6,33,22,0,7,13,47,47,1,20,6,33,22,0,7,13,47,32,32,32,32,32,47
                DC.B 47,47,11,4,19,31,18,47,19,17,24,47,19,14,47,1,4,0,19,47,0,47,17,4,2,14,17,3,47,14,5,47
                DC.B 19,7,4,47,2,0,17,4,1,4,0,17,18,47,32,47,47,47,14,20,17,18,47,8,18,47,18,8,2,10,4,17,47,32,47,47
                DC.B 1,11,8,8,8,8,8,17,15,47,47,47,1,11,20,20,20,20,20,17,15,47,47,47,1,11,8,8,8,8,8,8,17,15,47,47
                DC.B 47,1,11,0,0,0,0,0,17,15,47,47,47,1,11,4,4,4,4,4,4,17,15,47,47,47,1,11,8,15,47,26,28,27,47,47
                DC.B 1,11,20,14,0,0,0,0,7,17,15,47,32,32,32,47,47,1,11,8,8,8,8,8,17,15,47,47,47
                DC.B 1,11,14,14,14,14,14,17,15,47,11,4,19,31,18,47,22,14,14,14,14,14,17,15,29,29,29,29,29,29,47
                DC.B $FF
                EVEN
; And finally the font...
table:
                DC.W %1111111111
                DC.W %111111111111
                DC.W %1111111111111
                DC.W %11111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %111111100000000
                DC.W %1111110000000000
                DC.W %1111111100000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %11111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %111111100000
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %1111111000000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %111111111110000
                DC.W %11111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %11111111110000
                DC.W %111111111110000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111000000000
                DC.W %11111111111
                DC.W %1111111111111
                DC.W %11111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111110000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111110000000
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %11111111111111
                DC.W %1111111111111
                DC.W %11111111111
                DC.W %1111111000000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %111111100000
                DC.W %0
                DC.W %111111100000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111000000000
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %1111111000000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %1111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111000000000
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111110000000
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111110000000
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %0
                DC.W %1111110000000000
                DC.W %1111111000000000
                DC.W %1111111000000000
                DC.W %1111110000000000
                DC.W %0
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111110000000
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %111111100000000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %0
                DC.W %1111110000000000
                DC.W %1111111000000000
                DC.W %1111111000000000
                DC.W %1111111000000000
                DC.W %1111110000000000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %11111111111
                DC.W %1111111111111
                DC.W %11111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111110000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000001
                DC.W %1111111100000011
                DC.W %1111111100000001
                DC.W %1111111110000000
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %11111111111111
                DC.W %1111111111111
                DC.W %11111111111
                DC.W %1111111000000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %111111100000
                DC.W %0
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111000000000
                DC.W %111111100000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %111111100000000
                DC.W %111111100000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %111111100000
                DC.W %111111111
                DC.W %1111111111
                DC.W %1111111111
                DC.W %1111111111
                DC.W %1111111111
                DC.W %111111111
                DC.W %11111
                DC.W %11111
                DC.W %11111
                DC.W %11111
                DC.W %11111
                DC.W %11111
                DC.W %11111
                DC.W %11111
                DC.W %111111111
                DC.W %1111111111
                DC.W %1111111111
                DC.W %1111111111
                DC.W %1111111111
                DC.W %111111111
                DC.W %1111110000000000
                DC.W %1111111000000000
                DC.W %1111111000000000
                DC.W %1111111000000000
                DC.W %1111111000000000
                DC.W %1111110000000000
                DC.W %1100000000000000
                DC.W %1100000000000000
                DC.W %1100000000000000
                DC.W %1100000000000000
                DC.W %1100000000000000
                DC.W %1100000000000000
                DC.W %1100000000000000
                DC.W %1100000000000000
                DC.W %1111110000000000
                DC.W %1111111000000000
                DC.W %1111111000000000
                DC.W %1111111000000000
                DC.W %1111111000000000
                DC.W %1111110000000000
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %111111100000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %11111111111111
                DC.W %1111111111111
                DC.W %11111111111
                DC.W %1111111110000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %1111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111000000000
                DC.W %111111100000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %111111100000000
                DC.W %111111100000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %11111111110000
                DC.W %111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111100000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %111111111100000
                DC.W %11111111100000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %111111100000
                DC.W %111111100000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %111111000000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111111001
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111110111111
                DC.W %1111111110001111
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %111111100000000
                DC.W %11111100000
                DC.W %1111111110000
                DC.W %11111111110000
                DC.W %111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1101111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %111111100000
                DC.W %111111100000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111111100000
                DC.W %1111111111111000
                DC.W %1111111111111100
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111110011111
                DC.W %1111111110000111
                DC.W %1111111110000011
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %111111100000000
                DC.W %111111100000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1001111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %111111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %111111100000
                DC.W %11111111111
                DC.W %1111111111111
                DC.W %11111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111110000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111110000000
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %11111111111111
                DC.W %1111111111111
                DC.W %11111111111
                DC.W %1111111000000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %1111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111000000000
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %111111110000000
                DC.W %1111111000000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111000000000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %11111111111
                DC.W %1111111111111
                DC.W %11111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111110000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111110000000
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %11111111111111
                DC.W %1111111111111
                DC.W %11111111111
                DC.W %1111111000000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %11011111110000
                DC.W %111101111110000
                DC.W %1111110111110000
                DC.W %111111011110000
                DC.W %1011111101100000
                DC.W %1101111110100000
                DC.W %1110111111000000
                DC.W %1111011111100000
                DC.W %1111101111100000
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %111111110000000
                DC.W %1111111000000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %111111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %1111111100000
                DC.W %11111111111
                DC.W %1111111111111
                DC.W %11111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %11111111111111
                DC.W %1111111111111
                DC.W %11111111111
                DC.W %111111111
                DC.W %1111111
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1110000000000000
                DC.W %1111100000000000
                DC.W %1111111000000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111000000000
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %111111
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1100000000000000
                DC.W %111111110000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %11111111111111
                DC.W %1111111111111
                DC.W %11111111111
                DC.W %1111111100000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111000000000
                DC.W %111111110000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %111111111111001
                DC.W %111111111111111
                DC.W %11111111111111
                DC.W %1111111111111
                DC.W %111111111111
                DC.W %11111111111
                DC.W %1111111111
                DC.W %111111111
                DC.W %1111111
                DC.W %1111111100000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %111111111110000
                DC.W %111111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111100000000
                DC.W %1111111000000000
                DC.W %1111110000000000
                DC.W %1111100000000000
                DC.W %1110000000000000
                DC.W %111111110000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111001111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111001
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %111111110000000
                DC.W %1111111100000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %111111111110000
                DC.W %11111111110000
                DC.W %1111111100000
                DC.W %111111110000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %111111111111111
                DC.W %11111111111111
                DC.W %111111111111
                DC.W %1111111111
                DC.W %1111111111
                DC.W %111111111111
                DC.W %11111111111111
                DC.W %111111111111111
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %111111110000000
                DC.W %1111111100000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %111111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111100000000
                DC.W %1111110000000000
                DC.W %1111110000000000
                DC.W %1111111100000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %111111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %1111111100000
                DC.W %111111110000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %111111111111111
                DC.W %11111111111111
                DC.W %111111111111
                DC.W %1111111111
                DC.W %111111111
                DC.W %11111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %111111
                DC.W %1111111100000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %111111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111100000000
                DC.W %1111110000000000
                DC.W %1111100000000000
                DC.W %1111000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1100000000000000
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %11111111
                DC.W %1111111111
                DC.W %111111111111
                DC.W %11111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %1111111111111
                DC.W %1111111110000000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111100000000
                DC.W %1111110000000000
                DC.W %1111000000000000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %111111000000
                DC.W %1111111100000
                DC.W %11111111100000
                DC.W %11111111100000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %11111111100000
                DC.W %11111111100000
                DC.W %1111111100000
                DC.W %111111000000
                DC.W %11111100000000
                DC.W %111111110000000
                DC.W %111111111000000
                DC.W %111111111000000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %11111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %11111111110000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %111111111000000
                DC.W %111111111000000
                DC.W %111111110000000
                DC.W %11111100000000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %11111111111
                DC.W %1111111111111
                DC.W %11111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %111111100000011
                DC.W %11111
                DC.W %111111
                DC.W %111111
                DC.W %111111
                DC.W %11111
                DC.W %0
                DC.W %11111
                DC.W %111111
                DC.W %111111
                DC.W %11111
                DC.W %1111111000000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %111111111110000
                DC.W %111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111000000000
                DC.W %1111000000000000
                DC.W %1100000000000000
                DC.W %0
                DC.W %1100000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1100000000000000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %1111
                DC.W %11111
                DC.W %11111
                DC.W %1111
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %1100000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1100000000000000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %111111
                DC.W %1111111
                DC.W %1111111
                DC.W %111111
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %111111
                DC.W %1111111
                DC.W %1111111
                DC.W %111111
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %1000000000000000
                DC.W %1000000000000000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %1000000000000000
                DC.W %1000000000000000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %11111
                DC.W %111111
                DC.W %111111
                DC.W %11111
                DC.W %11
                DC.W %1111
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %1000000000000000
                DC.W %1100000000000000
                DC.W %1100000000000000
                DC.W %1100000000000000
                DC.W %1100000000000000
                DC.W %1000000000000000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %11111111
                DC.W %111111111
                DC.W %111111111
                DC.W %111111111
                DC.W %111111111
                DC.W %111111111
                DC.W %11111111
                DC.W %11111111
                DC.W %11111111
                DC.W %11111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %111111
                DC.W %0
                DC.W %111111
                DC.W %1111111
                DC.W %1111111
                DC.W %111111
                DC.W %1100000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1100000000000000
                DC.W %1100000000000000
                DC.W %1100000000000000
                DC.W %1100000000000000
                DC.W %1000000000000000
                DC.W %1000000000000000
                DC.W %1000000000000000
                DC.W %1000000000000000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %1000000000000000
                DC.W %1000000000000000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %11111111
                DC.W %111111111
                DC.W %111111111
                DC.W %111111111
                DC.W %111111111
                DC.W %111111111
                DC.W %11111111
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %1111111100000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111100000000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %1
                DC.W %11
                DC.W %111
                DC.W %1111
                DC.W %11111
                DC.W %111111
                DC.W %1111111
                DC.W %11111111
                DC.W %111111111
                DC.W %1111111111
                DC.W %11111111111
                DC.W %111111111110
                DC.W %111111111100
                DC.W %111111111000
                DC.W %11111100000
                DC.W %11111100000
                DC.W %1111111110000
                DC.W %11111111110000
                DC.W %111111111110000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111100000000
                DC.W %1111111000000000
                DC.W %1111110000000000
                DC.W %1111100000000000
                DC.W %1111000000000000
                DC.W %1110000000000000
                DC.W %1100000000000000
                DC.W %1000000000000000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %111111000
                DC.W %1111111100
                DC.W %1111111100
                DC.W %111111100
                DC.W %111000
                DC.W %11110000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %11,%111
                DC.W %1111,%11111
                DC.W %111111,%1111111
                DC.W %11111111,%111111111
                DC.W %1111111111,%11111111111
                DC.W %11111111111,%1111110111
                DC.W %111,%111
                DC.W %111,%111
                DC.W %111,%111
                DC.W %111,%11
                DC.W %1111000000000000,%1111100000000000
                DC.W %1111100000000000,%1111100000000000
                DC.W %1111100000000000,%1111100000000000
                DC.W %1111100000000000,%1111100000000000
                DC.W %1111100000000000,%1111100000000000
                DC.W %1111100000000000,%1111100000000000
                DC.W %1111100000000000,%1111100000000000
                DC.W %1111100000000000,%1111100000000000
                DC.W %1111100000000000,%1111100000000000
                DC.W %1111100000000000,%1111000000000000
                DC.W %11111111111111,%111111111111111
                DC.W %111111111111111,%111111111111111
                DC.W %111111111111111,%111111111111111
                DC.W %111111111111111,%11111111111111
                DC.W %11111,%111111
                DC.W %1111111,%11111111
                DC.W %111111111,%1111111111
                DC.W %11111111111,%111111111111
                DC.W %1111111111111,%11111111111111
                DC.W %111111111111111,%111111111111111
                DC.W %1111111100000000,%1111111111000000
                DC.W %1111111111100000,%1111111111100000
                DC.W %1111111111000000,%1111111111000000
                DC.W %1111111110000000,%1111111100000000
                DC.W %1111111000000000,%1111110000000000
                DC.W %1111100000000000,%1111100000000000
                DC.W %1111111111100000,%1111111111110000
                DC.W %1111111111110000,%1111111111110000
                DC.W %1111111111110000,%1111111111110000
                DC.W %1111111111110000,%1111111111100000
                DC.W %111111111111111,%1111111111111111
                DC.W %1111111111111111,%1111111111111111
                DC.W %1111111111111111,%111111111111111
                DC.W %0,%11111111111
                DC.W %111111111111,%111111111111
                DC.W %111111111111,%111111111111
                DC.W %11111111111,%0
                DC.W %111111111111111,%1111111111111111
                DC.W %1111111111111111,%1111111111111111
                DC.W %1111111111111111,%111111111111111
                DC.W %1111111111100000,%1111111111110000
                DC.W %1111111111110000,%1111111111110000
                DC.W %1111111111110000,%1111111111110000
                DC.W %1111111110000,%1111111111110000
                DC.W %1111111111110000,%1111111111110000
                DC.W %1111111111110000,%1111111111110000
                DC.W %1111111111110000,%1111111110000
                DC.W %1111111111110000,%1111111111110000
                DC.W %1111111111110000,%1111111111110000
                DC.W %1111111111110000,%1111111111100000
                DC.W %0,%0
                DC.W %1,%11
                DC.W %111,%1111
                DC.W %11111,%111111
                DC.W %1111111,%11111110
                DC.W %111111100,%1111111111
                DC.W %11111111111,%111111111111
                DC.W %111111111111,%111111111111
                DC.W %11111111111,%0
                DC.W %0,%0
                DC.W %111111100000000,%1111111110000000
                DC.W %1111111110000000,%1111111110000000
                DC.W %1111111110000000,%1111111110000000
                DC.W %1111111110000000,%1111111110000000
                DC.W %1111111110000000,%1111111110000000
                DC.W %1111111110000000,%1111111110000000
                DC.W %1111111110000000,%1111111110000000
                DC.W %1111111110000000,%1111111110000000
                DC.W %1111111110000000,%1111111110000000
                DC.W %1111111110000000,%111111100000000
                DC.W %111111111111111,%1111111111111111
                DC.W %1111111111111111,%1111111111111111
                DC.W %1111111111111111,%1111111111111111
                DC.W %1111111100000000,%1111111111111111
                DC.W %1111111111111111,%1111111111111111
                DC.W %1111111111111111,%1111111111111111
                DC.W %111111111111111,%0
                DC.W %111111111111111,%1111111111111111
                DC.W %1111111111111111,%1111111111111111
                DC.W %1111111111111111,%111111111111111
                DC.W %1111111111100000,%1111111111110000
                DC.W %1111111111110000,%1111111111110000
                DC.W %1111111111110000,%1111111111100000
                DC.W %0,%1111111100000000
                DC.W %1111111111000000,%1111111111100000
                DC.W %1111111111100000,%1111111111110000
                DC.W %1111111111110000,%111111110000
                DC.W %1111111111110000,%1111111111100000
                DC.W %1111111111100000,%1111111111000000
                DC.W %1111111110000000,%1111111000000000
                DC.W %11111111111,%1111111111111
                DC.W %11111111111111,%111111111111111
                DC.W %111111111111111,%1111111111111111
                DC.W %1111111110000000,%1111111111111111
                DC.W %1111111111111111,%1111111111111111
                DC.W %1111111111111111,%1111111111111111
                DC.W %1111111111111111,%1111111110000000
                DC.W %1111111111111111,%111111111111111
                DC.W %111111111111111,%11111111111111
                DC.W %1111111111111,%11111111111
                DC.W %1111111111100000,%1111111111110000
                DC.W %1111111111110000,%1111111111110000
                DC.W %1111111111110000,%1111111111100000
                DC.W %0,%1111111100000000
                DC.W %1111111111000000,%1111111111100000
                DC.W %1111111111100000,%1111111111110000
                DC.W %1111111111110000,%111111110000
                DC.W %1111111111110000,%1111111111100000
                DC.W %1111111111100000,%1111111111000000
                DC.W %1111111110000000,%1111111000000000
                DC.W %111111111111111,%1111111111111111
                DC.W %1111111111111111,%1111111111111111
                DC.W %1111111111111111,%1111111111111111
                DC.W %111111111111111,%0
                DC.W %0,%0
                DC.W %0,%1
                DC.W %1,%11
                DC.W %11,%111
                DC.W %111,%1111
                DC.W %1111,%111
                DC.W %1111111111100000,%1111111111110000
                DC.W %1111111111110000,%1111111111110000
                DC.W %1111111111110000,%1111111111110000
                DC.W %1111111111100000,%111111111100000
                DC.W %111111111000000,%1111111111000000
                DC.W %1111111110000000,%1111111110000000
                DC.W %1111111100000000,%1111111100000000
                DC.W %1111111000000000,%1111111000000000
                DC.W %1111110000000000,%1111110000000000
                DC.W %1111100000000000,%1111000000000000
                DC.W %111111111111,%11111111111111
                DC.W %111111111111111,%111111111111111
                DC.W %1111111111111111,%1111111000000000
                DC.W %1111110000000000,%1111111000000000
                DC.W %111111111111111,%111111111111111
                DC.W %111111111111111,%1111111111111111
                DC.W %1111111000000000,%1111110000000000
                DC.W %1111111000000000,%1111111111111111
                DC.W %111111111111111,%111111111111111
                DC.W %11111111111111,%111111111111
                DC.W %1111111100000000,%1111111111000000
                DC.W %1111111111100000,%1111111111100000
                DC.W %1111111111110000,%11111110000
                DC.W %1111110000,%11111110000
                DC.W %1111111111100000,%1111111111100000
                DC.W %1111111111100000,%1111111111110000
                DC.W %11111110000,%1111110000
                DC.W %11111110000,%1111111111110000
                DC.W %1111111111100000,%1111111111100000
                DC.W %1111111111000000,%1111111100000000
                DC.W %111111111111,%11111111111111
                DC.W %111111111111111,%111111111111111
                DC.W %1111111111111111,%1111111000000000
                DC.W %1111111000000000,%1111111111111111
                DC.W %111111111111111,%111111111111111
                DC.W %11111111111111,%111111111111
                DC.W %0,%111111000000000
                DC.W %1111111100000000,%1111111111111111
                DC.W %1111111111111111,%111111111111111
                DC.W %11111111111111,%111111111111
                DC.W %1111111100000000,%1111111111000000
                DC.W %1111111111100000,%1111111111100000
                DC.W %1111111111110000,%111111110000
                DC.W %111111110000,%1111111111110000
                DC.W %1111111111110000,%1111111111110000
                DC.W %1111111111110000,%1111111111110000
                DC.W %11111110000,%11111110000
                DC.W %111111110000,%1111111111100000
                DC.W %1111111111100000,%1111111111000000
                DC.W %1111111110000000,%1111111000000000
                DC.W %11111111111,%1111111111111
                DC.W %11111111111111,%111111111111111
                DC.W %111111111111111,%1111111111111111
                DC.W %1111111100000000,%1111111000000001
                DC.W %1111111000000111,%1111111000011111
                DC.W %1111111001111111,%1111111011111110
                DC.W %1111111011111000,%1111111100000000
                DC.W %1111111111111111,%111111111111111
                DC.W %111111111111111,%11111111111111
                DC.W %1111111111111,%11111111111
                DC.W %1111111000000000,%1111111110000000
                DC.W %1111111111000000,%1111111111100000
                DC.W %1111111111100000,%1111111111110000
                DC.W %111111110000,%1111011111110000
                DC.W %1111011111110000,%1110011111110000
                DC.W %1000011111110000,%11111110000
                DC.W %11111110000,%111111110000
                DC.W %1111111111110000,%1111111111100000
                DC.W %1111111111100000,%1111111111000000
                DC.W %1111111110000000,%1111111000000000
                END
