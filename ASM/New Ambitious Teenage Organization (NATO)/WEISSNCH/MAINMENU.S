*************************************
* The Main-Menu code fr the         *
* Weissnich-Demo...                 *
* Made by Charon and Blowtorch      *
*                                   *
* Always run the program from       *
* the AUTO-folder, coz there might  *
* be errors when not loading from   *
* it.                               *
*************************************

                movea.l SP,A5
                lea     L000F,A6
                lea     512(A6),SP
                movea.l 4(A5),A5
                move.l  12(A5),D0
                add.l   20(A5),D0
                add.l   28(A5),D0
                addi.l  #$0300,D0
                move.l  D0,-(SP)
                move.l  A5,-(SP)
                clr.w   -(SP)
                move.w  #$4A,-(SP)
                trap    #1
                lea     12(SP),SP

                clr.l   -(SP)
                move.w  #$20,-(SP)
                trap    #1
                addq.l  #6,SP

                move.b  #2,$0484.w      ; Keyklick off
                DC.W $A00A      ; Mouse invisible
                move.b  #$12,$FFFFFC02.w ; Mouse off

                move.b  #2,$FFFF820A.w  ; 50 Hz

                move.l  #$31415926,$0426 ; New reset-vector
                move.l  #rset,$042A
                move.l  #$752019F3,$0420
                move.l  #$237698AA,$043A
                move.l  #$5555AAAA,$051A


                move.l  #wave_form,wave_zeiger

                movea.l #$070000,A0
                movea.l #datei,A1
                move.l  #7999,D0
louhp:          move.l  (A1)+,(A0)+
                dbra    D0,louhp

                movea.l #$070000,A0
                movea.l #$078000,A1
                move.l  #16000,D0
copy_screenz:   move.w  (A0)+,(A1)+
                dbra    D0,copy_screenz

                move.w  #7,lettercounter
                move.l  #$05FF00,saver

                move.l  #routine,$04D2
                move.l  #swappuf,$04D6

                moveq   #1,D0
                jsr     muzak
                move.l  #muzak+8,$04DA

;                                       Load-Program...
taste:          move.w  #7,-(SP)        ; Menu  (Key)
                trap    #1
                addq.l  #2,SP
                cmpi.b  #$32,D0         ; '2' ?
                beq.s   demo1
                cmpi.b  #$31,D0         ; '1' ?
                bne.s   taste
                lea     file1,A5        ; 1.Name to A5
                bra.s   demo2
demo1:
                lea     file2,A5        ; 2.Name to A5
demo2:
                moveq   #0,D0           ; Music off
                jsr     muzak

                move.l  #0,$04D2        ; VBLs off
                move.l  #0,$04D6
                move.l  #0,$04DA

                movea.l screen1,A6
                move.l  #7999,D0
scnclr:         movem.l clrscn,D1-A3
                movem.l D1-A3,(A6)
                adda.l  #10,A6
                dbra    D0,scnclr

                pea     envcmd          ; Load..........
                pea     envcmd          ; Env+Cmd
                move.l  A5,-(SP)        ; Name onto SP
                clr.w   -(SP)           ; load+start
                move.w  #$4B,-(SP)      ; Exec...
                trap    #1
                lea     16(SP),SP
finito:         clr.w   -(SP)
                trap    #1
                rts

swappuf:        move.l  screen1,sav_puffer ; Change screens
                move.l  screen2,screen1
                move.l  sav_puffer,screen2

                move.w  #-1,-(SP)       ; Set screens
                move.l  screen1,-(SP)
                move.l  screen2,-(SP)
                move.w  #5,-(SP)
                trap    #14
                adda.l  #12,SP

                rts
routine:
                move.w  #0,$FFFF8240
                move.w  #$0700,$FFFF8242
                move.w  #$0610,$FFFF8244
                move.w  #$0520,$FFFF8246
                move.w  #$0430,$FFFF8248
                move.w  #$0340,$FFFF824A
                move.w  #$0250,$FFFF824C
                move.w  #$0160,$FFFF824E
                move.w  #$70,$FFFF8250
                move.w  #$77,$FFFF8252
                move.w  #$07,$FFFF8254
                move.w  #$05,$FFFF8256
                move.w  #$04,$FFFF8258
                move.w  #$03,$FFFF825A
                move.w  #$0666,$FFFF825C
                move.w  #$0777,$FFFF825E

                movea.l screen2,A6
                adda.l  #160*199,A6
                movem.l $010000,D0-A5

                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)
                movem.l D0-A5,-(A6)

                movea.l base2,A0
                movea.l screen2,A1

                clr.l   D5
                movea.l wave_zeiger,A2
                cmpi.w  #$FFFF,(A2)
                bne     okay
                move.l  #wave_form,wave_zeiger
                movea.l wave_zeiger,A2
okay:           move.w  (A2)+,D5
                move.l  A2,wave_zeiger
                mulu    #160,D5
                adda.l  D5,A1

                move.w  #19,D0

copy:           move.w  (A0),(A1)
                move.w  8(A0),8(A1)
                move.w  16(A0),16(A1)
                move.w  24(A0),24(A1)
                move.w  32(A0),32(A1)
                move.w  40(A0),40(A1)
                move.w  48(A0),48(A1)
                move.w  56(A0),56(A1)
                move.w  64(A0),64(A1)
                move.w  72(A0),72(A1)
                move.w  80(A0),80(A1)
                move.w  88(A0),88(A1)
                move.w  96(A0),96(A1)
                move.w  104(A0),104(A1)
                move.w  112(A0),112(A1)
                move.w  120(A0),120(A1)
                move.w  128(A0),128(A1)
                move.w  136(A0),136(A1)
                move.w  144(A0),144(A1)
                move.w  152(A0),152(A1)

                adda.l  #160,A0
                adda.l  #160,A1

                dbra    D0,copy


                movea.l base2,A0
                movea.l screen2,A1
                move.w  -40(A2),D0
                mulu    #160,D0
                adda.l  D0,A1
                adda.l  #2,A1

                move.w  #19,D0

copy2:          move.w  (A0),(A1)
                move.w  8(A0),8(A1)
                move.w  16(A0),16(A1)
                move.w  24(A0),24(A1)
                move.w  32(A0),32(A1)
                move.w  40(A0),40(A1)
                move.w  48(A0),48(A1)
                move.w  56(A0),56(A1)
                move.w  64(A0),64(A1)
                move.w  72(A0),72(A1)
                move.w  80(A0),80(A1)
                move.w  88(A0),88(A1)
                move.w  96(A0),96(A1)
                move.w  104(A0),104(A1)
                move.w  112(A0),112(A1)
                move.w  120(A0),120(A1)
                move.w  128(A0),128(A1)
                move.w  136(A0),136(A1)
                move.w  144(A0),144(A1)
                move.w  152(A0),152(A1)

                adda.l  #160,A0
                adda.l  #160,A1

                dbra    D0,copy2


                movea.l base2,A0
                movea.l screen2,A1
                move.w  -80(A2),D0
                mulu    #160,D0
                adda.l  D0,A1
                adda.l  #4,A1

                move.w  #19,D0

copy3:          move.w  (A0),(A1)
                move.w  8(A0),8(A1)
                move.w  16(A0),16(A1)
                move.w  24(A0),24(A1)
                move.w  32(A0),32(A1)
                move.w  40(A0),40(A1)
                move.w  48(A0),48(A1)
                move.w  56(A0),56(A1)
                move.w  64(A0),64(A1)
                move.w  72(A0),72(A1)
                move.w  80(A0),80(A1)
                move.w  88(A0),88(A1)
                move.w  96(A0),96(A1)
                move.w  104(A0),104(A1)
                move.w  112(A0),112(A1)
                move.w  120(A0),120(A1)
                move.w  128(A0),128(A1)
                move.w  136(A0),136(A1)
                move.w  144(A0),144(A1)
                move.w  152(A0),152(A1)

                adda.l  #160,A0
                adda.l  #160,A1

                dbra    D0,copy3

                movea.l base2,A0
                movea.l screen2,A1
                move.w  -120(A2),D0
                mulu    #160,D0
                adda.l  D0,A1
                adda.l  #6,A1

                move.w  #19,D0

copy4:          move.w  (A0),(A1)
                move.w  8(A0),8(A1)
                move.w  16(A0),16(A1)
                move.w  24(A0),24(A1)
                move.w  32(A0),32(A1)
                move.w  40(A0),40(A1)
                move.w  48(A0),48(A1)
                move.w  56(A0),56(A1)
                move.w  64(A0),64(A1)
                move.w  72(A0),72(A1)
                move.w  80(A0),80(A1)
                move.w  88(A0),88(A1)
                move.w  96(A0),96(A1)
                move.w  104(A0),104(A1)
                move.w  112(A0),112(A1)
                move.w  120(A0),120(A1)
                move.w  128(A0),128(A1)
                move.w  136(A0),136(A1)
                move.w  144(A0),144(A1)
                move.w  152(A0),152(A1)

                adda.l  #160,A0
                adda.l  #160,A1

                dbra    D0,copy4

                move.w  #0,$FFFF8240    ; Now change colors for scroller
                move.w  #$0700,$FFFF8242 ; 1. red
                move.w  #$07,$FFFF8244  ;  2. blue
                move.w  #$0707,$FFFF8246
                move.w  #$70,$FFFF8248  ;  3. green
                move.w  #$0770,$FFFF824A
                move.w  #$77,$FFFF824C
                move.w  #$0777,$FFFF824E
                move.w  #$66,$FFFF8250  ;  4. green-blue
                move.w  #$0566,$FFFF8252
                move.w  #$0357,$FFFF8254
                move.w  #$0664,$FFFF8256
                move.w  #$74,$FFFF8258
                move.w  #$0664,$FFFF825A
                move.w  #$0377,$FFFF825C
                move.w  #$0777,$FFFF825E


                cmpi.w  #0,pause
                bne     time_kill

                movea.l saver,A3

                sub.l   D0,D0
                addi.w  #1,lettercounter
                cmpi.w  #8,lettercounter
                bne     same_letter
                clr.w   lettercounter
next:           movea.l #text,A0
                move.l  offset,D1
                addi.l  #1,offset
                move.b  0(A0,D1.w),D0
                cmp.b   #$FE,D0
                bne     no_stand
                move.w  #200,pause
                move.w  #7,lettercounter
                bra     routine
no_stand:       cmp.b   #$FF,D0
                bne     okay2
                clr.l   offset
                bra     next
okay2:          mulu    #80,D0
                add.l   #table,D0
                move.l  D0,zeiger

same_letter:    move.w  #19,D1
y_zeile:        move.l  (A3),D0
                cmpi.w  #2,counter
                ble     roll_it
                swap    D0
                movea.l zeiger,A0
                move.w  (A0)+,D0
                move.l  A0,zeiger
                swap    D0
                rol.l   #4,D0
                move.l  D0,(A3)+

                dbra    D1,y_zeile

                clr.w   counter
                bra     ready

roll_it:        rol.l   #4,D0
                move.l  D0,(A3)+
                dbra    D1,y_zeile

                addi.w  #1,counter

ready:          move.l  base1,sav_puffer
                move.l  base2,base1
                move.l  base3,base2
                move.l  base4,base3
                move.l  sav_puffer,base4

                movea.l base2,A0

                movea.l saver,A3

                move.w  #19,D2
y_loop:
                move.w  8(A0),(A0)
                move.w  16(A0),8(A0)
                move.w  24(A0),16(A0)
                move.w  32(A0),24(A0)
                move.w  40(A0),32(A0)
                move.w  48(A0),40(A0)
                move.w  56(A0),48(A0)
                move.w  64(A0),56(A0)
                move.w  72(A0),64(A0)
                move.w  80(A0),72(A0)
                move.w  88(A0),80(A0)
                move.w  96(A0),88(A0)
                move.w  104(A0),96(A0)
                move.w  112(A0),104(A0)
                move.w  120(A0),112(A0)
                move.w  128(A0),120(A0)
                move.w  136(A0),128(A0)
                move.w  144(A0),136(A0)
                move.w  152(A0),144(A0)

                move.l  (A3)+,D0
                move.w  D0,152(A0)

                adda.l  #160,A0

                dbra    D2,y_loop

                bra     after_pause

time_kill:      subq.w  #1,pause

after_pause:    rts

rset:
                movea.l #$FFFF8240,A0
                move.w  #$00,(A0)+
                move.w  #$0700,(A0)+
                move.w  #$0720,(A0)+
                move.w  #$0730,(A0)+
                move.w  #$0740,(A0)+
                move.w  #$0750,(A0)+
                move.w  #$0760,(A0)+
                move.w  #$0770,(A0)+
                move.w  #$07,(A0)+
                move.w  #$70,(A0)+
                move.w  #$72,(A0)+
                move.w  #$73,(A0)+
                move.w  #$74,(A0)+
                move.w  #$75,(A0)+
                move.w  #$76,(A0)+
                move.w  #$77,(A0)

                movea.l #file,A5
                movea.l screen1,A6
                move.l  #7999,D0
scrpt:          movem.l (A5),D1-A3
                movem.l D1-A3,(A6)
                adda.l  #10,A5
                adda.l  #10,A6
                dbra    D0,scrpt

again:          bra     again

muzak:          IBYTES 'CYBERMIN.IMG'

                DATA
datei:          IBYTES 'MAINMENU.DOO'
file:           IBYTES 'RESET.DOO'
lettercounter:  DC.W 0
screen1:        DC.L $078000
screen2:        DC.L $070000
base1:          DC.L $060000
base2:          DC.L $058000
base3:          DC.L $050000
base4:          DC.L $048000
pause:          DC.W 0
sav_puffer:     DC.L 0
wave_zeiger:    DC.L 0
file1:          DC.B 'SCREEN_1.DAT',0
                EVEN
file2:          DC.B 'SCREEN_2.DAT',0
                EVEN
envcmd:         DC.B $00
                DC.W 140,141,143,144,146,147,149,151,152,154
                DC.W 155,157,158,159,161,162,163,165,166,167
                DC.W 168,169,170,171,172,173,174,175,176,176
                DC.W 177,177,178,178,179,179,179,179,179,179
                DC.W 179,179,179,179,179,178,178,178,177,177
                DC.W 176,175,174,174,173,172,171,170,169,168
                DC.W 167,165,164,163,161,160,159,157,156,154
                DC.W 153,151,150,148,147,145,144,142,140,139
                DC.W 137,136,134,132,131,129,128,126,125,123
                DC.W 122,120,119,118,116,115,114,113,111,110
                DC.W 109,108,107,106,105,105,104,103,103,102
                DC.W 101,101,101,100,100,100,100,100,100,100
                DC.W 100,100,100,100,101,101,102,102,103,103
                DC.W 104,105,106,107,108,109,110,111,112,113
                DC.W 114,116,117,118,120,121,122,124,125,127
                DC.W 128,130,131,133,135,136,138,139
wave_form:      DC.W 140,141,143,144,146,147,149,151,152,154
                DC.W 155,157,158,159,161,162,163,165,166,167
                DC.W 168,169,170,171,172,173,174,175,176,176
                DC.W 177,177,178,178,179,179,179,179,179,179
                DC.W 179,179,179,179,179,178,178,178,177,177
                DC.W 176,175,174,174,173,172,171,170,169,168
                DC.W 167,165,164,163,161,160,159,157,156,154
                DC.W 153,151,150,148,147,145,144,142,140,139
                DC.W 137,136,134,132,131,129,128,126,125,123
                DC.W 122,120,119,118,116,115,114,113,111,110
                DC.W 109,108,107,106,105,105,104,103,103,102
                DC.W 101,101,101,100,100,100,100,100,100,100
                DC.W 100,100,100,100,101,101,102,102,103,103
                DC.W 104,105,106,107,108,109,110,111,112,113
                DC.W 114,116,117,118,120,121,122,124,125,127
                DC.W 128,130,131,133,135,136,138,139,$FFFF

clr:            DC.B 27,"E",0
counter:        DC.W 0
zeiger:         DC.L 0
saver:          DC.L 0
letter:         DC.L 0
offset:         DC.L 0
clrscn:         DC.L 0,0,0,0,0,0,0,0,0,0,0
text:
                DC.B 47,47,47,19,7,4,47,13,0,19,14,47,28,47,47,47,47,47,47,47,47,19,7,4,47,47,47,13,0,19,14,47,32,47,47,254,47,19,7,4,47,13,0,19,14,47,1,17,8,13,6,18,47,24,14,20,30,47,47,47,47,19,7,4,47
                DC.B 22,4,8,18,18,13,8,2,7,33,3,4,12,14,47,32,47,47,47,47,22,4,47,7,4,0,17,47,24,14,20,47,2,0,11,11,30,47,47,31,22,7,0,19,31,18,47,19,7,4,47,13,0,19,14,47,28,31,47,47,47,47,22,4,11,11,35,47
                DC.B 9,20,18,19,47,0,47,13,4,22,29,29,29,47,47,4,17,17,29,29,29,47,47,13,14,35,47,22,4,47,3,14,13,31,19,47,2,17,0,2,10,47,0,13,3,47,22,4,31,17,4,47,18,20,17,4,11,24,47,13,14,19,47,19,7,4,47,1,4,18,19,29,29,29,47,47
                DC.B 26,19,7,8,18,47,15,8,4,2,4,47,14,5,47,19,4,23,19,47,22,0,18,47,11,4,13,3,4,3,47,5,17,14,12,47,19,7,4,47,5,8,17,18,19,47,20,13,8,14,13,33,8,13,19,17,14,35,47,1,20,19,47,8,47,19,7,8,13,10,47
                DC.B 24,14,20,47,7,0,21,4,47,6,20,4,18,18,4,3,47,19,7,0,19,27,47,47,47,47,19,7,4,47,13,0,19,14,47,8,18,47,0,47,13,4,22,47,6,4,17,12,0,13,47,18,19,33,2,17,4,22,35,47,19,7,0,19,47,7,0,18,47,19,7,4,47
                DC.B 5,14,11,11,14,22,8,13,6,47,12,4,12,1,4,17,18,30,47,47,47,47,1,0,17,17,0,10,20,3,0,47,254,47,8,18,47,14,20,17,47,14,13,11,24,47,0,12,8,6,0,33,2,14,3,4,17,35,47,1,20,19,47,7,4,31,18,47,0,47
                DC.B 33,21,4,17,24,33,47,1,0,3,47,14,13,4,35,47,5,14,17,6,4,19,47,7,8,12,29,47,47,47,47,1,11,14,22,19,14,17,2,7,47,254,47,3,14,4,18,47,18,19,33,2,14,3,8,13,6,47,0,13,3,47,6,17,0,5,8,23,35,47,0,13,3,47
                DC.B 7,4,31,18,47,18,14,14,14,14,47,11,0,25,24,47,32,47,47,47,47,2,7,0,17,14,13,47,47,254,47,19,7,0,19,31,18,47,12,4,35,47,8,47,3,14,47,18,19,33,2,14,3,8,13,6,35,47,6,17,0,5,8,23,35,47
                DC.B 22,17,8,19,8,13,6,47,0,13,3,47,0,13,18,22,4,17,8,13,6,47,0,11,11,47,11,4,19,19,4,17,18,35,47,0,13,3,35,47,0,18,47,18,14,14,13,47,0,18,47,12,24,47,18,14,20,13,3,17,14,20,19,47,22,14,17,10,18,35,47
                DC.B 12,20,25,0,4,23,29,47,47,47,47,5,17,0,13,10,5,20,17,19,47,254,47,8,18,47,14,13,11,24,47,0,47,15,0,18,18,8,21,4,47,12,4,12,1,4,17,35,47,22,7,14,47,3,14,4,18,47,13,4,8,19,7,4,17,47,2,14,3,8,13,6,47
                DC.B 13,14,17,47,6,17,0,5,8,23,29,47,7,4,47,14,13,11,24,47,10,13,14,22,18,47,19,7,4,47,1,4,18,19,47,0,13,3,47,13,4,22,4,18,19,47,9,14,10,4,18,29,47,47,47,47,47,47,0,18,47,24,14,20,47,2,0,13,47,18,4,4,35,47
                DC.B 22,4,47,7,0,21,4,47,14,13,11,24,47,37,47,18,19,33,2,14,3,4,17,18,35,47,0,13,3,47,1,11,14,22,19,14,17,2,7,47,8,18,47,19,14,14,47,11,0,25,24,47,19,14,47,3,14,47,0,13,24,19,7,8,13,6,47,0,19,47,19,7,4,47
                DC.B 12,14,12,4,13,19,47,26,7,4,47,11,8,10,4,18,47,15,0,17,19,24,18,47,12,14,17,4,47,19,7,0,13,47,18,8,19,19,8,13,6,47,8,13,47,5,17,14,13,19,47,14,5,47,15,8,23,4,11,18,27,35,47,18,14,47,8,47,26,2,7,0,17,14,13,27,47
                DC.B 0,12,47,19,7,4,47,14,13,11,24,47,6,20,24,47,19,7,0,19,47,7,0,18,47,4,13,14,20,6,7,47,19,8,12,4,47,0,13,3,47,12,14,19,8,21,0,19,8,14,13,47,19,14,47,3,14,47,0,13,24,19,7,8,13,6,29,47,47,47,47,47
                DC.B 0,13,24,22,0,24,35,47,8,5,47,24,14,20,47,15,17,14,6,17,0,12,47,41,43,45,45,45,47,0,13,3,47,8,5,47,24,14,20,47,11,8,21,4,47,13,4,0,17,47,12,0,13,13,7,4,8,12,47,14,17,47,7,4,8,3,4,11,1,4,17,6,35,47
                DC.B 22,17,8,19,4,47,12,4,47,32,47,47,12,24,47,0,3,3,17,4,18,18,4,47,22,8,11,11,47,1,4,47,18,7,14,22,13,47,1,24,47,15,17,4,18,18,8,13,6,47,17,4,18,4,19,29,47,47,47,47,47,12,24,47,19,4,11,4,15,7,14,13,4,47
                DC.B 13,20,12,1,4,17,47,8,18,30,47,47,47,47,45,41,37,36,34,47,47,254,47,47,47,39,44,37,42,45,41,47,47,254,47,47,2,0,11,11,47,5,17,14,12,47,38,15,12,47,19,14,47,42,15,12,35,47,0,18,10,47,5,14,17,47,0,11,4,23,0,13,3,4,17,29,47
                DC.B 47,47,19,7,4,47,2,17,4,3,8,19,18,47,5,14,17,47,19,7,4,47,12,0,8,13,33,12,4,13,20,47,6,14,47,19,14,30,47,47,47,1,11,14,22,19,14,17,2,7,30,47,47,47,8,3,4,0,35,47,2,14,3,8,13,6,47,0,13,3,47
                DC.B 5,14,13,19,29,47,47,47,47,2,7,0,17,14,13,30,47,47,18,14,12,4,47,26,28,27,47,12,14,17,4,47,2,14,3,4,35,47,6,17,0,5,8,23,23,47,0,13,3,47,8,13,2,11,20,3,8,13,6,47,19,7,4,47,12,20,25,4,23,23,29,47,47,47
                DC.B 12,0,3,47,12,0,23,30,47,47,3,20,12,3,20,12,3,20,17,20,12,3,4,3,20,12,3,4,4,3,20,12,29,29,29,47,47,47,24,4,18,35,47,7,4,47,7,0,18,47,3,14,13,4,47,19,7,4,47,12,20,25,25,25,25,25,25,0,23,47,32,47,47,47,47
                DC.B 19,7,4,47,20,11,19,8,12,0,19,4,47,12,4,6,0,33,7,8,31,18,47,6,14,47,19,14,30,47,47,47,47,19,7,4,47,4,23,2,4,15,19,8,14,13,18,47,26,6,8,6,0,33,19,7,0,13,23,47,19,14,47,3,0,17,24,11,47,5,14,17,47
                DC.B 0,11,11,47,24,14,20,17,47,7,4,11,15,47,0,13,3,47,5,14,17,47,18,4,13,3,8,13,6,47,20,18,47,19,7,4,47,12,20,25,0,23,47,32,47,7,8,47,12,0,3,47,12,0,23,35,47,8,18,47,24,14,20,17,47,18,19,47,18,19,8,11,11,47
                DC.B 0,11,8,21,4,47,28,27,47,35,47,19,7,4,47,5,8,13,6,4,17,1,14,1,18,47,26,7,8,47,14,1,4,17,9,4,47,32,47,12,4,6,0,33,19,7,0,13,23,47,5,14,17,47,4,21,4,17,24,19,7,8,13,6,47,24,14,20,31,21,4,47
                DC.B 18,4,13,3,47,20,18,47,32,47,18,14,17,17,24,35,47,22,4,47,19,0,10,4,47,18,14,47,11,14,13,6,47,19,14,47,3,14,47,19,7,4,47,15,17,14,12,8,18,4,3,47,18,2,17,4,4,13,29,27,47,35,47,18,19,47,2,14,13,13,4,23,8,14,13,47
                DC.B 26,7,8,47,21,0,13,19,0,6,4,47,32,47,12,20,2,7,47,5,20,13,47,0,19,47,19,7,4,47,12,4,6,0,33,2,14,15,24,15,0,17,19,24,47,32,27,47,35,47,15,0,20,11,14,47,18,8,12,14,4,18,47,26,22,7,4,13,47,3,14,47
                DC.B 24,14,20,47,11,4,0,21,4,47,19,7,4,47,0,17,12,24,47,28,47,7,0,21,4,47,24,14,20,47,5,20,13,47,19,7,4,17,4,47,28,27,47,47,47,47,47,19,7,4,47,1,14,17,8,13,6,47,13,14,17,12,0,11,47,6,17,4,4,19,8,13,6,18,47
                DC.B 6,14,47,19,14,30,47,26,19,7,0,19,31,18,47,19,7,4,47,20,11,19,8,12,0,19,4,47,8,13,19,4,17,13,0,11,47,6,17,4,4,19,8,13,6,18,27,47,47,47,15,0,19,17,8,2,10,35,47,17,4,3,47,12,4,13,35,47,19,7,4,47
                DC.B 22,8,25,0,17,3,35,47,19,7,4,47,19,17,20,4,18,0,24,4,17,35,47,9,14,13,13,24,47,1,29,26,6,14,14,3,4,27,35,47,4,22,14,10,47,26,19,7,14,20,6,7,47,24,14,20,31,17,4,47,18,19,20,15,8,3,47,11,8,10,4,47
                DC.B 7,4,11,11,27,35,47,12,17,29,6,14,4,1,4,11,47,0,13,3,47,7,8,18,47,8,13,5,14,17,12,0,19,8,2,18,33,11,0,12,4,17,18,35,47,14,11,11,8,4,35,47,19,7,4,47,47
                DC.B 0,13,19,8,33,5,17,0,20,4,13,1,4,22,4,6,20,13,6,18,33,5,17,14,13,19,35,47,12,0,18,19,4,17,47,14,5,47,3,4,18,0,18,19,4,17,47,26,3,4,0,3,47,18,8,13,2,4,47,18,14,12,4,47,24,4,0,17,18,47,28,27,47,0,13,3,47
                DC.B 19,14,47,12,24,47,20,13,2,11,4,47,17,0,8,13,4,17,35,47,19,7,0,13,23,47,5,14,17,47,12,24,47,5,8,17,18,19,47,2,14,12,15,20,19,4,17,35,47,19,7,4,47,2,33,36,41,47,32,47,47,47,47,47,47,13,14,17,12,0,11,11,24,47
                DC.B 22,4,47,3,14,13,31,19,47,5,20,2,10,33,6,17,4,4,19,47,0,13,24,47,15,4,14,15,11,4,35,47,1,20,19,47,18,8,13,2,4,47,19,4,0,2,7,4,17,18,47,0,13,3,47,3,8,2,19,0,19,14,17,18,47,0,17,4,47
                DC.B 13,14,47,15,4,14,15,11,4,35,47,22,4,47,22,0,13,19,47,19,14,47,6,8,6,0,33,5,20,2,10,33,6,17,4,4,19,30,47,47,47,18,0,3,3,0,12,47,7,20,18,18,4,8,13,47,26,13,14,1,14,3,24,47,2,14,20,11,3,47
                DC.B 4,23,15,17,4,18,18,47,19,7,4,47,19,7,8,13,6,35,47,22,7,0,19,47,8,47,22,14,20,11,3,47,3,14,47,22,8,19,7,47,24,14,20,47,32,32,32,32,32,32,32,32,27,35,47,12,17,29,10,20,13,25,12,0,13,13,47
                DC.B 26,24,14,20,31,17,4,47,33,3,4,0,3,33,47,8,5,47,24,14,20,47,6,14,13,13,0,47,1,4,47,19,7,4,47,13,4,22,47,3,8,17,4,23,47,32,27,35,47,12,17,29,14,4,25,0,11,47,26,19,7,8,18,47,19,20,17,10,8,18,7,47
                DC.B 0,18,18,7,14,11,4,47,32,32,32,32,47,3,8,4,47,32,32,32,32,32,27,35,47,12,17,29,22,4,11,19,13,4,17,47,26,6,14,47,7,14,12,4,35,47,24,14,20,47,0,13,3,47,24,14,20,17,47,22,0,19,4,17,33,12,14,20,13,19,0,8,13,18,47,32,27,47
                DC.B 47,47,47,8,19,31,18,47,19,8,12,4,47,5,14,17,47,19,7,4,47,2,17,0,15,19,0,11,10,33,15,0,17,19,47,13,14,22,29,29,29,47,47,47,47,47,47,47,19,7,4,47,18,19,47,2,14,13,13,4,23,8,14,13,47,8,18,47,10,13,14,22,13,47
                DC.B 0,18,47,19,7,4,47,11,0,25,24,4,18,19,47,2,17,4,22,47,0,19,47,19,7,4,47,12,14,12,4,13,19,35,47,1,20,19,47,19,7,4,47,3,4,11,19,0,33,5,14,17,2,4,47,18,0,8,3,35,47,19,7,0,19,47,19,7,4,24,31,17,4,47
                DC.B 12,14,17,4,47,19,7,0,13,47,19,22,8,2,4,47,11,0,25,24,47,19,7,0,13,47,19,7,4,47,18,19,47,2,13,23,35,47,0,13,3,47,19,7,4,24,47,7,0,3,47,0,13,47,4,21,8,3,4,13,2,4,30,47,47,19,7,4,24,47
                DC.B 13,4,4,3,4,3,47,37,47,24,4,0,17,18,47,19,14,47,3,14,47,19,7,4,47,31,18,24,13,19,0,23,47,19,4,17,17,14,17,31,47,3,4,12,14,29,47,47,0,13,24,22,0,24,35,47,11,4,6,0,2,24,47,18,0,8,3,35,47,19,7,0,19,47
                DC.B 19,7,4,24,47,22,4,17,4,47,20,13,1,4,0,19,0,1,11,4,47,11,0,25,24,29,29,29,47,47,47,47,1,20,19,47,13,14,22,35,47,7,4,17,4,31,18,47,19,7,4,47,13,29,0,29,19,29,14,29,47,32,47,47,47,22,4,31,17,4,47
                DC.B 11,0,25,24,4,17,47,19,7,0,13,47,18,19,47,2,13,23,35,47,3,4,11,19,0,47,5,14,17,2,4,47,0,13,3,47,11,4,6,0,2,24,47,19,14,6,4,19,7,4,17,47,32,32,32,47,47,47,22,4,47,13,4,4,3,4,3,47
                DC.B 39,47,12,14,13,19,7,18,47,19,14,47,3,14,47,19,7,8,18,47,21,4,17,24,47,26,32,32,32,32,27,47,11,8,19,19,11,4,47,3,4,12,14,35,47,0,13,3,47,22,4,31,17,4,47,9,20,18,19,47,22,14,17,10,8,13,6,47,14,13,47
                DC.B 9,20,18,19,47,14,13,4,47,18,2,17,4,4,13,35,47,14,5,47,22,7,8,2,7,47,22,4,47,18,19,0,17,19,4,3,47,22,14,17,10,8,13,6,47,12,14,17,4,47,19,7,0,13,47,37,47,12,14,13,19,7,18,47,0,6,14,47,32,47,47,47,47
                DC.B 18,19,47,2,14,13,13,4,23,8,14,13,35,47,3,4,11,19,0,47,5,14,17,2,4,47,0,13,3,47,11,4,6,0,2,24,30,47,47,47,19,17,24,47,19,14,47,1,4,0,19,47,3,8,18,47,32,32,32,32,32,47,47,47,47,47,47,47,47
                DC.B 24,14,20,47,18,19,8,11,11,47,3,14,13,31,19,47,10,13,14,22,35,47,22,7,0,19,47,19,7,4,47,0,1,1,17,4,21,8,0,19,8,14,13,47,31,13,29,0,29,19,29,14,29,31,47,18,19,0,13,3,18,47,5,14,17,35,47,18,14,47,11,4,19,47
                DC.B 12,4,47,19,4,11,11,47,24,14,20,29,47,47,22,4,31,17,4,47,19,7,4,47,31,13,4,22,47,0,12,1,8,19,8,14,20,18,47,19,4,4,13,0,6,4,47,14,17,6,0,13,8,25,0,19,8,14,13,31,47,32,47,47,47,0,13,3,47
                DC.B 7,4,17,4,31,18,47,19,7,4,47,18,19,14,17,24,47,14,5,47,5,14,20,13,3,8,13,6,47,19,7,8,18,47,2,17,4,22,30,47,47,47,47,8,19,47,22,0,18,47,8,13,47,12,0,17,2,7,47,36,44,44,45,35,47,22,7,4,13,47
                DC.B 22,4,47,22,4,17,4,47,0,11,11,47,15,17,14,6,17,0,12,12,8,13,6,47,8,13,47,14,20,17,47,6,14,14,3,47,14,11,3,47,6,5,0,33,1,0,18,8,2,29,47,47,1,20,19,47,1,11,14,22,19,14,17,2,7,47,26,7,8,18,47
                DC.B 13,0,12,4,47,22,0,18,47,31,1,19,10,31,27,47,22,0,13,19,4,3,47,19,14,47,15,17,14,6,17,0,12,47,8,13,47,0,47,5,0,18,19,4,17,47,11,0,13,6,20,0,6,4,35,47,18,14,47,7,4,47,1,20,24,4,3,47,19,7,4,47
                DC.B 31,0,19,0,17,8,47,18,19,47,0,18,18,4,12,1,11,4,17,47,1,14,14,10,31,47,0,13,3,47,31,18,19,47,8,13,19,4,17,13,31,47,0,13,3,47,6,14,19,47,19,7,4,47,19,20,17,1,14,33,0,18,18,4,12,1,11,4,17,29,47
                DC.B 8,47,22,0,18,47,5,0,18,2,8,13,0,19,4,3,47,1,24,47,19,7,4,47,8,3,4,0,47,14,5,47,5,14,20,13,3,8,13,6,47,0,47,2,17,4,22,35,47,19,7,14,20,6,7,47,22,4,47,3,8,3,13,31,19,47,4,21,4,13,47
                DC.B 10,13,14,22,35,47,22,7,0,19,47,0,47,31,12,14,21,4,29,22,31,47,8,18,29,47,47,22,4,47,19,7,14,20,6,7,19,47,0,13,3,47,19,7,14,20,6,7,19,35,47,0,13,3,47,18,20,3,3,4,13,11,24,47,8,47,2,0,12,4,47,20,15,47
                DC.B 22,8,19,7,47,31,11,4,19,31,18,47,2,0,11,11,47,20,18,47,19,7,4,47,31,13,29,0,29,19,29,14,29,31,47,32,31,47,47,47,47,1,20,19,47,22,4,47,18,19,8,11,11,47,7,0,3,47,13,14,47,8,3,4,0,35,47,22,7,0,19,47
                DC.B 19,7,8,18,47,0,1,1,17,4,21,8,0,19,8,14,13,47,2,14,20,11,3,47,1,4,47,18,19,0,13,3,47,5,14,17,29,47,47,1,20,19,47,18,8,13,2,4,47,1,11,14,22,19,14,17,2,7,47,8,18,47,0,13,47,0,12,4,17,8,2,0,13,47
                DC.B 0,3,47,7,4,47,8,18,47,8,13,47,19,7,4,47,20,29,18,29,0,29,47,4,21,4,17,24,47,18,20,12,12,4,17,33,7,14,11,8,3,0,24,35,47,7,8,18,47,4,13,6,11,8,18,7,47,22,0,18,47,6,14,14,3,47,4,13,14,20,6,7,47
                DC.B 19,14,47,18,0,24,30,47,31,13,4,22,47,0,12,1,8,19,8,14,20,18,47,19,4,4,13,0,6,4,47,14,17,6,0,13,8,25,0,19,8,14,13,31,47,32,47,47,47,47,47,47,15,4,17,7,0,15,18,47,24,14,20,47,22,14,13,3,4,17,35,47
                DC.B 22,7,24,47,22,4,47,2,0,11,11,47,14,20,17,18,4,11,21,4,18,47,31,19,4,4,13,0,6,4,31,47,28,47,47,22,4,11,11,35,47,8,47,26,2,7,0,17,14,13,27,47,0,12,47,19,7,4,47,14,11,3,4,18,19,47,12,4,12,1,4,17,35,47
                DC.B 0,13,3,47,8,31,12,47,14,13,11,24,47,36,41,47,26,36,42,47,8,13,47,9,20,11,24,27,29,47,5,17,0,13,10,47,5,20,17,19,47,8,18,47,18,4,2,14,13,3,35,47,7,4,31,18,47,36,41,35,47,19,14,14,29,47
                DC.B 1,11,14,22,19,14,17,2,7,47,8,18,47,36,40,47,0,13,3,47,1,0,17,17,0,10,20,3,0,47,8,18,47,14,13,11,24,47,26,32,32,32,32,32,27,47,36,39,29,47,47,47,8,5,47,24,14,20,47,19,7,8,13,10,35,47,19,7,0,19,47
                DC.B 19,7,0,19,31,18,47,19,7,4,47,17,4,0,18,14,13,47,5,14,17,47,19,7,4,47,16,20,0,11,8,19,24,47,14,5,47,19,7,4,47,12,0,8,13,33,12,4,13,20,35,47,24,14,20,31,17,4,47,22,17,14,13,6,29,47,47,22,4,47,7,0,21,4,47
                DC.B 33,0,47,11,14,19,47,14,5,33,47,15,17,14,2,4,18,18,14,17,33,19,8,12,4,47,11,4,5,19,35,47,1,20,19,47,22,4,47,17,4,0,11,11,24,47,3,14,13,31,19,47,10,13,14,22,35,47,22,7,0,19,47,19,14,47,15,20,19,47
                DC.B 8,13,19,14,47,19,7,4,47,18,2,17,4,4,13,29,29,29,29,47,47,47,47,47,22,4,31,17,4,47,6,14,8,13,6,47,19,14,47,3,14,47,0,47,12,4,6,0,33,3,4,12,14,35,47,0,18,47,22,4,11,11,29,47,8,19,18,47,13,0,12,4,47
                DC.B 22,8,11,11,47,1,4,47,19,7,4,47,31,14,13,8,14,13,33,3,4,12,14,31,47,26,0,18,47,0,47,9,14,10,4,47,19,14,47,19,7,4,47,31,20,13,8,14,13,33,3,4,12,14,31,27,29,47,47,8,19,47,22,8,11,11,47
                DC.B 5,4,0,19,20,17,4,47,0,19,47,11,4,0,18,19,47,36,45,47,18,2,17,4,4,13,18,35,47,22,8,19,7,47,0,47,6,20,4,18,19,47,0,15,15,4,0,17,4,13,2,4,47,1,24,47,19,7,4,47,5,8,13,6,4,17,1,14,1,18,47,0,13,3,47
                DC.B 15,4,17,7,0,15,18,47,19,7,4,47,18,19,47,2,14,13,13,4,23,8,14,13,29,47,47,47,47,22,4,47,7,0,21,4,13,31,19,47,6,8,21,4,13,47,8,19,47,0,47,18,15,4,2,8,0,11,47,17,4,11,4,0,18,4,33,3,0,19,4,35,47
                DC.B 8,19,47,22,8,11,11,47,1,4,47,17,4,11,4,0,18,4,3,35,47,0,18,47,18,14,14,13,47,0,18,47,19,7,4,47,3,4,12,14,47,8,18,47,17,4,0,3,24,29,47,19,7,8,18,47,22,8,11,11,47,1,4,47,8,13,47,39,33,36,37,47
                DC.B 12,14,13,19,7,18,29,47,47,47,47,47,47,47,8,47,7,0,21,4,47,13,14,47,8,3,4,0,35,47,22,7,0,19,47,19,14,47,22,17,8,19,4,47,4,11,18,4,35,47,18,14,47,11,4,19,31,18,47,18,0,24,47,6,14,14,3,1,24,4,29,47,47
                DC.B 4,13,9,14,24,47,14,20,17,47,15,17,14,3,20,2,19,18,47,13,14,22,47,0,13,3,47,8,13,47,5,20,19,20,17,4,47,32,47,47,47,47,47,47,1,24,4,35,1,24,4,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,29,47
                DC.B 47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,28,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,32,47,47,47,47,47,47,47,47,47,47,47,47
                DC.B 47,47,47,47,47,47,47,47
                DC.B 47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,22,17,0,15,15,47,32,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47
                DC.B $FF
                EVEN
table:
                DC.W %1111111111
                DC.W %111111111111
                DC.W %1111111111111
                DC.W %11111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %111111100000000
                DC.W %1111110000000000
                DC.W %1111111100000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %11111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %111111100000
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %1111111000000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %111111111110000
                DC.W %11111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %11111111110000
                DC.W %111111111110000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111000000000
                DC.W %11111111111
                DC.W %1111111111111
                DC.W %11111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111110000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111110000000
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %11111111111111
                DC.W %1111111111111
                DC.W %11111111111
                DC.W %1111111000000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %111111100000
                DC.W %0
                DC.W %111111100000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111000000000
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %1111111000000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %1111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111000000000
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111110000000
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111110000000
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %0
                DC.W %1111110000000000
                DC.W %1111111000000000
                DC.W %1111111000000000
                DC.W %1111110000000000
                DC.W %0
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111110000000
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %111111100000000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %0
                DC.W %1111110000000000
                DC.W %1111111000000000
                DC.W %1111111000000000
                DC.W %1111111000000000
                DC.W %1111110000000000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %11111111111
                DC.W %1111111111111
                DC.W %11111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111110000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000001
                DC.W %1111111100000011
                DC.W %1111111100000001
                DC.W %1111111110000000
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %11111111111111
                DC.W %1111111111111
                DC.W %11111111111
                DC.W %1111111000000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %111111100000
                DC.W %0
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111000000000
                DC.W %111111100000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %111111100000000
                DC.W %111111100000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %111111100000
                DC.W %111111111
                DC.W %1111111111
                DC.W %1111111111
                DC.W %1111111111
                DC.W %1111111111
                DC.W %111111111
                DC.W %11111
                DC.W %11111
                DC.W %11111
                DC.W %11111
                DC.W %11111
                DC.W %11111
                DC.W %11111
                DC.W %11111
                DC.W %111111111
                DC.W %1111111111
                DC.W %1111111111
                DC.W %1111111111
                DC.W %1111111111
                DC.W %111111111
                DC.W %1111110000000000
                DC.W %1111111000000000
                DC.W %1111111000000000
                DC.W %1111111000000000
                DC.W %1111111000000000
                DC.W %1111110000000000
                DC.W %1100000000000000
                DC.W %1100000000000000
                DC.W %1100000000000000
                DC.W %1100000000000000
                DC.W %1100000000000000
                DC.W %1100000000000000
                DC.W %1100000000000000
                DC.W %1100000000000000
                DC.W %1111110000000000
                DC.W %1111111000000000
                DC.W %1111111000000000
                DC.W %1111111000000000
                DC.W %1111111000000000
                DC.W %1111110000000000
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %111111100000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %11111111111111
                DC.W %1111111111111
                DC.W %11111111111
                DC.W %1111111110000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %1111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111000000000
                DC.W %111111100000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %111111100000000
                DC.W %111111100000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %11111111110000
                DC.W %111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111100000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %111111111100000
                DC.W %11111111100000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %111111100000
                DC.W %111111100000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %111111000000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111111001
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111110111111
                DC.W %1111111110001111
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %111111100000000
                DC.W %11111100000
                DC.W %1111111110000
                DC.W %11111111110000
                DC.W %111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1101111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %111111100000
                DC.W %111111100000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111111100000
                DC.W %1111111111111000
                DC.W %1111111111111100
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111110011111
                DC.W %1111111110000111
                DC.W %1111111110000011
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %111111100000000
                DC.W %111111100000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1001111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %111111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %111111100000
                DC.W %11111111111
                DC.W %1111111111111
                DC.W %11111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111110000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111110000000
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %11111111111111
                DC.W %1111111111111
                DC.W %11111111111
                DC.W %1111111000000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %1111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111000000000
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %111111110000000
                DC.W %1111111000000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111000000000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %11111111111
                DC.W %1111111111111
                DC.W %11111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111110000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111100000000
                DC.W %1111111110000000
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %11111111111111
                DC.W %1111111111111
                DC.W %11111111111
                DC.W %1111111000000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %11011111110000
                DC.W %111101111110000
                DC.W %1111110111110000
                DC.W %111111011110000
                DC.W %1011111101100000
                DC.W %1101111110100000
                DC.W %1110111111000000
                DC.W %1111011111100000
                DC.W %1111101111100000
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %111111110000000
                DC.W %1111111000000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %111111110000
                DC.W %111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %111111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %1111111100000
                DC.W %11111111111
                DC.W %1111111111111
                DC.W %11111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %11111111111111
                DC.W %1111111111111
                DC.W %11111111111
                DC.W %111111111
                DC.W %1111111
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1110000000000000
                DC.W %1111100000000000
                DC.W %1111111000000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111000000000
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %111111
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1100000000000000
                DC.W %111111110000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %11111111111111
                DC.W %1111111111111
                DC.W %11111111111
                DC.W %1111111100000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111000000000
                DC.W %111111110000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %111111111111001
                DC.W %111111111111111
                DC.W %11111111111111
                DC.W %1111111111111
                DC.W %111111111111
                DC.W %11111111111
                DC.W %1111111111
                DC.W %111111111
                DC.W %1111111
                DC.W %1111111100000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %111111111110000
                DC.W %111111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111100000000
                DC.W %1111111000000000
                DC.W %1111110000000000
                DC.W %1111100000000000
                DC.W %1110000000000000
                DC.W %111111110000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111001111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111001
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %111111110000000
                DC.W %1111111100000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %111111111110000
                DC.W %11111111110000
                DC.W %1111111100000
                DC.W %111111110000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %111111111111111
                DC.W %11111111111111
                DC.W %111111111111
                DC.W %1111111111
                DC.W %1111111111
                DC.W %111111111111
                DC.W %11111111111111
                DC.W %111111111111111
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %111111110000000
                DC.W %1111111100000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %111111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111100000000
                DC.W %1111110000000000
                DC.W %1111110000000000
                DC.W %1111111100000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %111111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %1111111100000
                DC.W %111111110000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %111111111111111
                DC.W %11111111111111
                DC.W %111111111111
                DC.W %1111111111
                DC.W %111111111
                DC.W %11111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %111111
                DC.W %1111111100000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %11111111110000
                DC.W %111111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111100000000
                DC.W %1111110000000000
                DC.W %1111100000000000
                DC.W %1111000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1100000000000000
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %11111111
                DC.W %1111111111
                DC.W %111111111111
                DC.W %11111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %1111111111111
                DC.W %1111111110000000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111100000000
                DC.W %1111110000000000
                DC.W %1111000000000000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %111111000000
                DC.W %1111111100000
                DC.W %11111111100000
                DC.W %11111111100000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %11111111100000
                DC.W %11111111100000
                DC.W %1111111100000
                DC.W %111111000000
                DC.W %11111100000000
                DC.W %111111110000000
                DC.W %111111111000000
                DC.W %111111111000000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %11111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %11111111110000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %111111111000000
                DC.W %111111111000000
                DC.W %111111110000000
                DC.W %11111100000000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %11111111111
                DC.W %1111111111111
                DC.W %11111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %111111100000011
                DC.W %11111
                DC.W %111111
                DC.W %111111
                DC.W %111111
                DC.W %11110������������������38�����៟��������������38���������៟��������������38����������៟��������������38����������៟��������������38���������៟��������������38��������������������៟��������������38��������������������៟1111111111111
                DC.W %111111111111111
                DC.W %11111111
                DC.W %1111111111
                DC.W %111111111111
                DC.W %11111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %111111111111111
                DC.W %1111111111111
                DC.W %1111111110000000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111100000000
                DC.W %1111110000000000
                DC.W %1111000000000000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %1111111111100000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %111111000000
                DC.W %1111111100000
                DC.W %11111111100000
                DC.W %11111111100000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %11111111100000
                DC.W %11111111100000
                DC.W %1111111100000
                DC.W %111111000000
                DC.W %11111100000000
                DC.W %111111110000000
                DC.W %111111111000000
                DC.W %111111111000000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %11111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %1111111110000
                DC.W %11111111110000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %111111111100000
                DC.W %111111111000000
                DC.W %111111111000000
                DC.W %111111110000000
                DC.W %11111100000000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %11111111111
                DC.W %1111111111111
                DC.W %11111111111111
                DC.W %111111111111111
                DC.W %111111111111111
                DC.W %1111111111111111
                DC.W %1111111111111111
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %111111100000011
                DC.W %11111
                DC.W %111111
                DC.W %111111
                DC.W %111111
                DC.W %11111
                DC.W %0
                DC.W %11111
                DC.W %111111
                DC.W %111111
                DC.W %11111
                DC.W %1111111000000000
                DC.W %1111111110000000
                DC.W %1111111111000000
                DC.W %1111111111100000
                DC.W %1111111111100000
                DC.W %1111111111110000
                DC.W %1111111111110000
                DC.W %111111111110000
                DC.W %111111111100000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111000000000
                DC.W %1111000000000000
                DC.W %1100000000000000
                DC.W %0
                DC.W %1100000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1100000000000000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %1111
                DC.W %11111
                DC.W %11111
                DC.W %1111
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %1100000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1100000000000000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %111111
                DC.W %1111111
                DC.W %1111111
                DC.W %111111
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %111111
                DC.W %1111111
                DC.W %1111111
                DC.W %111111
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %1000000000000000
                DC.W %1000000000000000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %1000000000000000
                DC.W %1000000000000000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %11111
                DC.W %111111
                DC.W %111111
                DC.W %11111
                DC.W %11
                DC.W %1111
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %1000000000000000
                DC.W %1100000000000000
                DC.W %1100000000000000
                DC.W %1100000000000000
                DC.W %1100000000000000
                DC.W %1000000000000000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %11111111
                DC.W %111111111
                DC.W %111111111
                DC.W %111111111
                DC.W %111111111
                DC.W %111111111
                DC.W %11111111
                DC.W %11111111
                DC.W %11111111
                DC.W %11111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %1111111
                DC.W %111111
                DC.W %0
                DC.W %111111
                DC.W %1111111
                DC.W %1111111
                DC.W %111111
                DC.W %1100000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1110000000000000
                DC.W %1100000000000000
                DC.W %1100000000000000
                DC.W %1100000000000000
                DC.W %1100000000000000
                DC.W %1000000000000000
                DC.W %1000000000000000
                DC.W %1000000000000000
                DC.W %1000000000000000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %1000000000000000
                DC.W %1000000000000000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %11111111
                DC.W %111111111
                DC.W %111111111
                DC.W %111111111
                DC.W %111111111
                DC.W %111111111
                DC.W %11111111
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %1111111100000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111110000000
                DC.W %1111111100000000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %1
                DC.W %11
                DC.W %111
                DC.W %1111
                DC.W %11111
                DC.W %111111
                DC.W %1111111
                DC.W %11111111
                DC.W %111111111
                DC.W %1111111111
                DC.W %11111111111
                DC.W %111111111110
                DC.W %111111111100
                DC.W %111111111000
                DC.W %11111100000
                DC.W %11111100000
                DC.W %1111111110000
                DC.W %11111111110000
                DC.W %111111111110000
                DC.W %1111111111100000
                DC.W %1111111111000000
                DC.W %1111111110000000
                DC.W %1111111100000000
                DC.W %1111111000000000
                DC.W %1111110000000000
                DC.W %1111100000000000
                DC.W %1111000000000000
                DC.W %1110000000000000
                DC.W %1100000000000000
                DC.W %1000000000000000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %111111000
                DC.W %1111111100
                DC.W %1111111100
                DC.W %111111100
                DC.W %111000
                DC.W %11110000
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %0
                DC.W %11,%111
                DC.W %1111,%11111
                DC.W %111111,%1111111
                DC.W %11111111,%111111111
                DC.W %1111111111,%11111111111
                DC.W %11111111111,%1111110111
                DC.W %111,%111
                DC.W %111,%111
                DC.W %111,%111
                DC.W %111,%11
                DC.W %1111000000000000,%1111100000000000
                DC.W %1111100000000000,%1111100000000000
                DC.W %1111100000000000,%1111100000000000
                DC.W %1111100000000000,%1111100000000000
                DC.W %1111100000000000,%1111100000000000
                DC.W %1111100000000000,%1111100000000000
                DC.W %1111100000000000,%1111100000000000
                DC.W %1111100000000000,%1111100000000000
                DC.W %1111100000000000,%1111100000000000
                DC.W %1111100000000000,%1111000000000000
                DC.W %11111111111111,%111111111111111
                DC.W %111111111111111,%111111111111111
                DC.W %111111111111111,%111111111111111
                DC.W %111111111111111,%11111111111111
                DC.W %11111,%111111
                DC.W %1111111,%11111111
                DC.W %111111111,%1111111111
                DC.W %11111111111,%111111111111
                DC.W %1111111111111,%11111111111111
                DC.W %111111111111111,%111111111111111
                DC.W %1111111100000000,%1111111111000000
                DC.W %1111111111100000,%1111111111100000
                DC.W %1111111111000000,%1111111111000000
                DC.W %1111111110000000,%1111111100000000
                DC.W %1111111000000000,%1111110000000000
                DC.W %1111100000000000,%1111100000000000
                DC.W %1111111111100000,%1111111111110000
                DC.W %1111111111110000,%1111111111110000
                DC.W %1111111111110000,%1111111111110000
                DC.W %1111111111110000,%1111111111100000
                DC.W %111111111111111,%1111111111111111
                DC.W %1111111111111111,%1111111111111111
                DC.W %1111111111111111,%111111111111111
                DC.W %0,%11111111111
                DC.W %111111111111,%111111111111
                DC.W %111111111111,%111111111111
                DC.W %11111111111,%0
                DC.W %111111111111111,%1111111111111111
                DC.W %1111111111111111,%1111111111111111
                DC.W %1111111111111111,%111111111111111
                DC.W %1111111111100000,%1111111111110000
                DC.W %1111111111110000,%1111111111110000
                DC.W %1111111111110000,%1111111111110000
                DC.W %1111111110000,%1111111111110000
                DC.W %1111111111110000,%1111111111110000
                DC.W %1111111111110000,%1111111111110000
                DC.W %1111111111110000,%1111111110000
                DC.W %1111111111110000,%1111111111110000
                DC.W %1111111111110000,%1111111111110000
                DC.W %1111111111110000,%1111111111100000
                DC.W %0,%0
                DC.W %1,%11
                DC.W %111,%1111
                DC.W %11111,%111111
                DC.W %1111111,%11111110
                DC.W %111111100,%1111111111
                DC.W %11111111111,%111111111111
                DC.W %111111111111,%111111111111
                DC.W %11111111111,%0
                DC.W %0,%0
                DC.W %111111100000000,%1111111110000000
                DC.W %1111111110000000,%1111111110000000
                DC.W %1111111110000000,%1111111110000000
                DC.W %1111111110000000,%1111111110000000
                DC.W %1111111110000000,%1111111110000000
                DC.W %1111111110000000,%1111111110000000
                DC.W %1111111110000000,%1111111110000000
                DC.W %1111111110000000,%1111111110000000
                DC.W %1111111110000000,%1111111110000000
                DC.W %1111111110000000,%111111100000000
                DC.W %111111111111111,%1111111111111111
                DC.W %1111111111111111,%1111111111111111
                DC.W %1111111111111111,%1111111111111111
                DC.W %1111111100000000,%1111111111111111
                DC.W %1111111111111111,%1111111111111111
                DC.W %1111111111111111,%1111111111111111
                DC.W %111111111111111,%0
                DC.W %111111111111111,%1111111111111111
                DC.W %1111111111111111,%1111111111111111
                DC.W %1111111111111111,%111111111111111
                DC.W %1111111111100000,%1111111111110000
                DC.W %1111111111110000,%1111111111110000
                DC.W %1111111111110000,%1111111111100000
                DC.W %0,%1111111100000000
                DC.W %1111111111000000,%1111111111100000
                DC.W %1111111111100000,%1111111111110000
                DC.W %1111111111110000,%111111110000
                DC.W %1111111111110000,%1111111111100000
                DC.W %1111111111100000,%1111111111000000
                DC.W %1111111110000000,%1111111000000000
                DC.W %11111111111,%1111111111111
                DC.W %11111111111111,%111111111111111
                DC.W %111111111111111,%1111111111111111
                DC.W %1111111110000000,%1111111111111111
                DC.W %1111111111111111,%1111111111111111
                DC.W %1111111111111111,%1111111111111111
                DC.W %1111111111111111,%1111111110000000
                DC.W %1111111111111111,%111111111111111
                DC.W %111111111111111,%11111111111111
                DC.W %1111111111111,%11111111111
                DC.W %1111111111100000,%1111111111110000
                DC.W %1111111111110000,%1111111111110000
                DC.W %1111111111110000,%1111111111100000
                DC.W %0,%1111111100000000
                DC.W %1111111111000000,%1111111111100000
                DC.W %11111