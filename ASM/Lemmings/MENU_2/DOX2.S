                           
                                THE LEMMINGS         
                                   presents        
                                 DOC FILE #2       
                           
                            Docs in this file are: 
                           
                            1:Populous II          
                            2:Fusion Mega Ripper   
                            3:Fusion Memory Ripper 
                           

 

                    POPULOUS II - TRIALS OF THE OLYMPIAN GODS
                    =========================================

 OVERVIEW
 ~~~~~~~~
      As one of the many sons of Zeus the All-Father, you demand your rightful
 place among the gods on Mount Olympus. But Zeus isn't about to give you your 
 inheritance just for the asking. You must prove your worthiness by defeating 
 the 32 divine opponents who rule the 1000 worlds of Populous II.

 CREATE YOUR DEITY
 ~~~~~~~~~~~~~~~~~
      Your first task is to create the kind of deity that you want to be. You
 choose the eyes, mouth and headpiece that indicate whether you're benevolent
 and wise, fierce and war-like, brutish and cruel, or some bizarre combination
 of these characteristics.
      Your god's personality affects how opponents react to you. For example,
 if your deity looks aggressive, your opponent wages war harder. If your deity
 looks like a scholar, the combat is more subtle and clever.
 
 CONQUEST GAMES ARE PART OF A SERIES
 ~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~
      There are two ways to play Populous II: Conquest Games and Custom Games.
 In conquest mode, you must conquer a series of worlds. Each world gets
 progressivly harder as you face tougher terrains, stronger gods, and more
 potent divine powers (known as Divine Intervention Effects).
 
 EACH CONQUEST EARNS YOU EXPERIENCE
 ~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~
      If you played a Conquest Game well, you're awarded experience. After each
 conquest, you can exchange your experience for greater power in six forces of
 nature. You can decide to concentrate on a particular element - becoming, say,
 a fire god - or you can spread your experience over all the forces.
 
 THE ULTIMATE GOAL - DEFEAT ZEUS
 ~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~
      The final battle in the conquest series is against your father and
 supreme master, Zeus. Defeat Zeus and you can take your seat among the gods.
 
 CUSTOM GAMES LET YOU CALL THE SHOTS
 ~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~
      In Custom mode, play a random land with all effects you have earned in
 your conquest games. For example, if you have played three Conquest games and
 seen variety of different effects, in a custom mode you'll be able to play a
 game with all those effects combined. 
 
 CONQUEST PROGRESS AFFECTS CUSTOM GAMES
 ~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~
      In a custom Game, the divine Intervention Effects you can do are limited
 by your progress in the Conquest series - you can't do effects you haven't
 already used in a Conquest Game. This is the only limitation to the kind of
 Custom Game you can make.
 
 IN THE BEGINNING...
 ~~~~~~~~~~~~~~~~~~~
      This section will help you get started by showing you the techniques and
 concepts you'll need to conquer the first world in the Conquest series.
 
 CREATE A GOD
 ~~~~~~~~~~~~
      From the game Menu, left-click on Create Your Deity. The Create Deity
 screen appears:
 
 Click proceed to return to the Game Menu. You'll start the game with five
 lightning bolts of experience. Apply them to one of the six elements. You can
 spread your experience around by clicking once on five different icons, or you
 can build up your strength in one by clicking five times on one element.
 
      After the end of each battle, you can earn more lightning bolts of
 experience to build up your experience in the other elements even further.
 
 CHOOSE A CONQUEST GAME
 ~~~~~~~~~~~~~~~~~~~~~~
      Left-click on Conquest Game at the game menu. The Next Conquest screen
 shows you which Divine Intervention Effects and special rules apply to the
 world you're about to conquer. In this first world you can only do five
 effects: Raise and Lower land, Place Papal Magnet, Ordain Perseus, Armageddon,
 and Column of Fire. A tick indicates that a special rule applies to you in
 this world - for example, the tick next to "Water is Fatal" indicates that
 people always drown if they fall in the water.
 
      There are 1000 worlds in the Conquest series.Each world has a number and
 a name. The number for the first world in the series is 0; its name is DOEGAC.
 Each time you conquer a world ,Zeus will give you the name of the next world
 he wants you to do battle on. Always write down this name to continue the
 Conquest series where you left off.
 
      Click proceed to begin the game.
 
 PAUSING THE GAME
 ~~~~~~~~~~~~~~~~
      Once the battle starts, you'll want to pause the game from time to time
 so you can follow the tutorial. To pause the game, press the F10 key. To
 resume the game, press F10 again.
 
 THE BATTLE BEGINS
 ~~~~~~~~~~~~~~~~~
      When the game begins, you're looking down at your worshippers.
 
 THE WORLD MAP is a view of the entire world you're currently on. Good and Bad
 populations inhabit the world usually on opposite sides of the map.
 
 THE CLOSE-UP MAP is a magnified view of a point on the World Map. All divine
 activities are carried out here.
 
 WALKERS represent a number of people wandering the land as a tribe seeking to
 establish well-populated settlements. Walkers need shelter against the climate
 and they'll settle on any piece of flat land that can support them. When they
 settle, they create dwellings.
 
 DIVINE INTERVENTION EFFECTS are an arsenal of awesome powers and potent
 disasters. There are six categories or elements, each with five individual
 Effects. The Effects you can do depend on the world you're fighting on.
 
 THE MANA GAUGE measures your Mana. Mana is a reservoir of power you can use to
 do Effects. Mana comes with pious worship of your followers - the more
 worshippers you have, the greater your Mana. The red line at the base of the
 Mana Gauge indicates your total Mana. The pointer indicates which Effects you
 can currently do.
 
      Right now you only have enough Mana to raise the lower land. Occasionally
 you'll use up your Mana and won't be able to raise or lower land, but don't
 worry. As you help your people multiply, your Mana will increase.
 
 THE BASIC COMMANDS let you influence the general behavious of your followers,
 get information on populations and settlements, and bring up the Game
 Requester.
 
 THE COLOSSEUM is a population indicator for both Good and Bad worshippers. As
 populations change, the Colosseum fills and empties to reflect the fluctuating
 numbers of dwellers. Good populations appear in blue-Bad populations appear in
 red.The Colosseum can also be used to track walkers and settlements and get
 information on their strength and inventions.
 
 CHANGING YOUR VIEW
 ~~~~~~~~~~~~~~~~~~
      Changing your view is fundamental to playing Populous. There are several
 ways to change your view. The easiest is to scroll with the CURSOR KEYS or the
 NUMERIC KEYPAD.
 
      The World Map can also be used to change your view. The area you're
 currently viewing is marked with a black diamond:
 
      Point to the World Map and click a mouse button. A right click jumps to
 your view to the spot your pointing to.A left-click moves your view one
 increment in that direction.
 
      You can also scroll your view by clicking on the directional arrows
 around the World Map. The longer you hold down the mouse button, the more the
 map scrolls.
 
 FLATTEN LAND
 ~~~~~~~~~~~~
      Your followers need flat lands to farm and settle on, so the first thing
 you should dp is faltten the landscape around their settlements. The lay of
 the land is on a grid of squares, so you won't be able to raise and/or lower
 on your or your enemies land.
 
      To raise a square of land, move the diamond cursor to the centre of the
 square and left-click.
 
      To lower a square of land, move the diamond cursor to the centre of the
 square and right click.

 CREATE LARGE SETTLEMENTS
 ~~~~~~~~~~~~~~~~~~~~~~~~
      Creating new settlements is fundamental to winning a world. Settlements
 grow according to the amount of farmland around them the more farmland, the
 bigger the settlement.
 
      The biggest settlemants are castles. Castles increase your population the
 fastest, so initially they're the most valuable. Castles are also the most
 technologically advanced, and better weapons means your people will be more
 effective fighters. To create a castle, flatten the land widely around any
 dwelling.
 
 SPROG EARLY, SPROG OFTEN
 ~~~~~~~~~~~~~~~~~~~~~~~~
      As a settlement fills with people, its flag rises. When its flag reaches
 the top, the settlement is full. At this point, a walker will automatically
 leave and go in search of a new place to settle.
 
      In the early parts of a battle, you don't want to wait for your
 settlements to fill up before releasing walkers. The more large settlements
 you have, the faster your population will rise. This is where the technique of
 sprogging comes in. Sprogging is the most important means of spreading your
 population. When you sprog, you're commanding a settlement to send a portion
 of its population out into the world in search of a new home.
 
      To sprog a walker from a dwelling , point to the centre of a dwelling and
 click the right mouse button. The diamond cursor must be on the exact centre
 of the dwelling. Then click the right mouse button.
 
 
 COMPARE POPULATIONS
 ~~~~~~~~~~~~~~~~~~~
      As you play, use the Colosseum to compare your population with the
 enemy's. The Good population appears as blue dots - Bad appears as red.
 
 USE DIVINE INTERVENTION EFFECTS
 ~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~
      Once you've increased your Mana, you can use some of the five Effects
 available on DOEGAC. To switch between People Effects and Fire Effects, click
 on the appropriate icon. (People-first in row from left to right, Fire-fifth
 in row)

 FIRE EFFECTS
 ~~~~~~~~~~~~
      The one Fire Effect available on DOEGAC is Fire Column, which starts a
 huge column of fire that moves across the land. To do Column, left-click on
 the Fire Column.
 
      A small column on the Close-Up Map and left-click to set the column
 down - it will appear in a somewhat random location. As dwellings burn, enemy
 worshippers perish. Any land that the column moves across will turn orange,
 indicatins that it's scorched and ruined. The enemy will have to raise or
 lower the ruined land in order to make it arable farmland again.
 
 PEOPLE EFFECTS
 ~~~~~~~~~~~~~~
      There are four People Effects on DOEGAC.
   1: Raise and lower Land
   2: Place Papal Magnet
   3: Ordain Perseus (Change current leader to a Hero!)
   4: Armageddon (Fight until either good or bad wins)
 
 Papal Magnets
 ~~~~~~~~~~~~~
      The papal magnets are icons of worship for Good and Bad. You can move
 your magnet to Bad territory, then influence your worshippers to go to it and
 invade Bad settlements. The first of your walkers to encounter your papal
 magnet becomes your 'leader'. Convert strong leaders into special walkers
 called Heroes with your papal magnet. You cannot place your papal magnet 
 unless you have a leader.
 
 USE INFLUENCE BEHAVIOUR COMMANDS TO MOVE PEOPLE
 ~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~
      Use the Influence Behaviour Commands to influence the behaviour of your
 followers. The Influence Behaviour commands are available on every world and
 can be used without cost to Mana.
 
   *  Go to Papal Magnet:Influence your people to find their ordained leader
 and follow him to the Papal Magnet. You can always find the leader by
 right-clicking on this option. Use this option to draw your leader and
 worshippers together, then turn into a hero. If you like.
 
   *  Settle:Influence your walkers to build new dwellings and your people to
 reproduce. To encourage faster settling,sprog worshippers from their dwellings
 by right-clicking on any house.
 
   *  Fight:Encourage your walkers to attack Bad settlements and worshippers.
 Fight also encourages your people to settle and produce more walkers for
 battle.
 
   *  Gather together:Encourage your walkers toward each other and combine into
 one stronger walker. Note that each walker represents a group of people, so
 when your walkers are gathering together, tribes are actually combining to
 make a larger troop. Use this behaviour when you want to build and strengthen
 walkers. This option also influences your people to settle as they come 
 together.
 
 SETTLEMENT POPULATION
 ~~~~~~~~~~~~~~~~~~~~~
      You can check on the population of a settlement at any time. Query any
 settlement and you'll see the level of technology from the first (very
 primitive) to a sword (very advanced), and a population count in the form of
 eight flags moving up and down flagpoles around the back of the colosseum. It
 appears in decimal order:
 
 Hundred millions - Ten Millions - Millions - Hundred Thousands...
                                 ...Ten thousands - Thousands - Hundreds - Tens

 TO CHECK THE POPULATION OF A SETTLEMENT:
 
      1) Left-click on the Query icon
 
      2) Move your cursor to a settlement on the close-up map
 
      3) Left-click on the dwelling to attach the query icon to it. The
 settlement appears in the centre of the colosseum and a question mark appears
 on top of the dwelling.
 
 In the middle of the colosseum, you'll see a picture of the settlement. The
 flags on the colosseum flagpoles reflect the amount of the population.
 
 If you sprog a walker from a queried settlement, the first walker out of the
 settlement takes the query marker with them.
 
 KEYBOARD EQUIVALENTS
 ~~~~~~~~~~~~~~~~~~~~
 Pause                        F10
 Zoom In                      - (Minus) key on keypad
 Zoom Out                     + (Plus) key on keypad
 Full Screen                  Enter on keypad
 People Effects               F1
 Vegetation Effects           F2
 Earth Effects                F3
 Air Effects                  F4
 Fire Effects                 F5
 Water Effects                F6
 Take a Snapshot              F7
 Scroll Up                                        
 Scroll Down                  
 Scroll Right                 
 Scroll Left                  

 PLAYING BY SERIAL LINK
 ~~~~~~~~~~~~~~~~~~~~~~
      There are two ways to play Populous II against a human opponent: 
 using a modem to connect a remote player, or by using a null modem cable to
 connect the serial ports of two computers (this is DATALINK mode!).

 To play a serial game, both players need original (?!) copies of Populous II.

 HOW TO MAKE A NULL MODEM CABLE (Note this is not in the manual!)
 ~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~
      This bit was provided by me (Dark Sorcerer) and note that only the
 'Lemmings ' provide the best quality docs!

      Here at the 'Lemmings ' sub HQ we find it essential to give you the
 finest quality of docs and cracks. Only providing the best.
 
     1)   Get some wire! 3 core
     2)   Get two 25 pin D-connectors (Plugs/Female)
     3)   Connect the following:-

     Plug 1                        Plug 2
     ~~~~~~                        ~~~~~~
       2                             3
       3                             2
       7                             7

                     NICE POWER CODE - ADKIWBKDCJZLTUWZ
                     ~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~
 

                              FUSION MEGA RIPPER
                              ==================

 RIP A 3 VOICES MUSIC
 ~~~~~~~~~~~~~~~~~~~~

 Press F2 or F3 to search for a Count Zero or Mad Max music. If the ripper
 finds one, than press F3 to listen to it and use low and up arrows to try the
 differents musics in the same data file. If the ripper finds a music, but that
 you don't hear any sound when you press F3, use + and - to select the right
 length of the music.

 RIP A TCB 'An Cool' MODULE
 ~~~~~~~~~~~~~~~~~~~~~~~~~~

 Press F5 to search for a TCB module. You can't listen to it, you must save it
 and use the TCB tracker, ESC and SPACE to escape.

 RIP AN AMIGA 32 INSTRUMENTS MODULE
 ~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~

 Press F4 to search for a module, F3 to listen to it, F1 to save it, F2 to look
 for another module in the same file.

 RIP A QUARTET MUSIC
 ~~~~~~~~~~~~~~~~~~~

 Press F7 to rip a Quartet music.

 RIP A SAMPLE
 ~~~~~~~~~~~~

 Press F6 to search a sample. ( and ) to select the lenght ( start ) of the
 sample . Control and + to select the length ( end ) of the sample. Left and
 right arrows to select the frequency, high and low arrows to select the
 volume. F1 to save the sample, F3 to listen to it.

 RIP A PIC ( LOGO, FONTS, PICS ... )
 ~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~

 Use cursor keys, 2, 4, 6, 8, + and - to center the pic and the right planes.
 Select Sprites format with keys (, ), 7, 9

 DECRUNCH
 ~~~~~~~~

 This program decrunch Ice ( 2.1/2.2 and 2.3 ), press I to select Ice 2.1 or
 2.2, Jek, Automation, Jam, Pompey Packer, etc ... If you load a packed file,
 you can save it decrunched by pressing F10.

 COLOURS
 ~~~~~~~

 A pic begins by the 16 colours. Use 0 and . to recover the right colors. You
 must have the octets of the colors just at the top level of the pic, not on
 the screen !! When the pic is centered, you just have to press the keys for
 the right colors:
 0 ------> degas elite
 . ------> neochrome

 

                            FUSION MEMORY RIPPER
                            ====================

 This program only works on 1040. You can rip programs which are not in files
 or that the mega ripper doesn't decrunch. Load the program a first time,
 than press reset when you are told to transform your 1040 in 520. Load the
 program a second time and insert the disk that want to rip. Select 1 or 2 if
 the program is in files or not. Press the reset button when you want to rip.
 Then load the mega ripper and press UNDO for the loading selection. Then use
 the mega ripper to rip as normal. But this program doesn't work if the reset
 is blocked in the program you want to rip.
		        
 
