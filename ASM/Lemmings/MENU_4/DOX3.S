                           
                                THE LEMMINGS         
                                   presents        
                                 DOC FILE #3       
                           
                            Docs in this file are: 
                           
                            1:Vroom                
                            2:Midi Maze            
                           

 

                                     VROOM
                                     =====
 GAME TYPES:
 ~~~~~~~~~~~
 1:Arcade - easiest to control, hardest to qualify due to explosive tyres and
   the need to overtake a certain number of cars.

 2:Training - this is training for the racing game. You will notice that the
   steering is a lot more sensitive and skidding occurs a lot more.

 3:Racing - more of the above only you actually race against other cars this
   time. You do a qualify lap to start with to see which position you start
   the race in and you can obtain championship points by finishing in the first
   six drivers in each race (10 - 1st, 8 - 2nd, 6 - 3rd, 4 - 4th, 2 - 5th,
   1 - 6th). The championship takes part over the six Grand Prix tracks.

 4:Demo - this leaves the computer to do its own thing and show you some good
   cornering techniques and also some good crashes.


 CONTROL TYPES:
 ~~~~~~~~~~~~~~
 1:Mouse - the best control method. Forward to accelerate, pull backwards to
   decelerate, left and right steer, left mouse button to come down a gear and
   right mouse button to shift up one. It is the smoothest and most responsive
   control method in the game.

 2:Joystick - can only be used on Arcade game because of the speed of Training
   and Racing. Up accelerates, down decelerates, left and right steer, up and
   fire moves up a gear, pressing just fire moves down. Not a recommended
   method of control due to the complexity of gear-changing.


 GRAND PRIXs:
 ~~~~~~~~~~~~
 In training and racing options you can change this to race on a chosen circuit
 or all of them.

 1:JAPAN (Fuji Yama) - A simple track with only one difficult corner.Most can
   be taken at full speed. Not normally necessary to change tyres in the six
   laps.
   - 4.618 Km -

 2:AUSTRIA (Zeltweg) - Another fairly simple track but there are more difficult
   corners than Japan. If you skid a lot you may need to change your tyres but
   often can be avoided.
   - 5.911 Km -

 3:FRANCE (Castellet) - This track has got a lot of simple corners but two very
   nasty corners just before the pits. There is also a nasty chicane on a bend.
   You may need to change tyres.
   - 3.813 Km -

 4:U.K. (Silverstone) - This track is fairly straight forward but is pretty
   long. There are some nice tunnels and a nasty chicane on a tight bend. You
   will probably have to change tyres before the six laps are over.
   - 4.778 Km -

 5:SWEDEN (Anderstorp) - Another fairly straight forward track but there are
   some deceiving corners and hills. You will be more than likely to change
   your tyres on this circuit.
   - 4.618 Km -

 6:U.S.A. (Watkin's Glen) - This is a nice fast smooth track to end off the
   championship with. You'll have to change your tyres because it's so long and
   you are likely to skid once or twice.
   - 6.405 Km -

 LINK UP:
 ~~~~~~~~
 1:NOCOMM - This is the default option for if you're driving alone. Ignore this
   section if you are.

 2:LOCAL - This is for two player games using an RS232 Null Modem cable. If you
   haven't got one you can make one by connecting the pins as follows:

                2 -to- 3           3 -to- 2          7 -to- 7

 3:MODEM - This option is for when you play by modem. (What a surprise!)

 GEAR TYPES:
 ~~~~~~~~~~~
 1:MANUAL - Only for the real professional! It's difficult to concentrate on
   gear changes at the same time as turning the corners and avoiding the other
   cars.

 2:AUTOMATIC - Perhaps the best option. Leaves you to concentrate on steering
   and you can't screw up your engine. Don't worry about speeds - both manual
   and automatic have got the same acceleration and top speed (about 325 Km/h).



                                 MIDI MAZE
                                 =========

 1. Welcome to Midi-Maze
 ~~~~~~~~~~~~~~~~~~~~~~~
 Once upon a time in a measure far, far from sanity, there existed sixteen
 notes, or more... But in our fable only sixteen ascended the scale to jam in..
 Midi Maze!!!

 We take you back to a time before chords or even polyphony, scores of octaves
 came to watch the barbaric finally. The air reverberating with the chorus of
 'Have a Nice Day!'. Scary, isn't it?

 Dear Readers... it was note against note, colour against colour. It was not 
 Pretty! Your mission young smiley, is to defend your colour, edit the "bad" 
 notes and may the best note win! The refrain is simple: 'Sixteen notes enter,
 One note leaves.'

 In this program we relive the simpler time. You become a player in the maze,
 one on one or one on many... Enjoy!!!

 2. Set-up and Requirements
 ~~~~~~~~~~~~~~~~~~~~~~~~~~
 Midi-maze will run on any Atari ST. One MIDI cable is needed for each computer
 IF you are using the multiple machine option. A joystick is recommended,
 however, if you want use the mouse pressing the 'ALT' key and the 'M' key
 together will select mouse control. The 'ALT-J' combination will select back
 to joystick control.

 SINGLE PLAYER AND SOLO MODE: Insert disk and turn on ST. Midi-Maze will auto
 boot. After the boot process is complete the computer will either say 'master
 machine' or 'slave machine,' depending on if you have a MIDI cable connected 
 from the MIDI-IN to MIDI-OUT port. If you have a midi cable connected, you
 should get the prompt 'master machine' in that case skip the next step! If
 your machine says 'slave machine' you need to press the 
 'ALT' and the 'S' key at the same time. Pressing the 'ALT-S' key combination
 will activate the Solo-mode, which does not require the midi cables to be
 connected. Hitting the 'ALT-S' combination again, returns the computer to
 'slave machine' mode.

 MULTIPLE PLAYERS AND THE 'MASTER MACHINE': All cables should be connected,
 MIDI-IN to MIDI-OUT (see 'MIDI-ring' below). Insert Midi-maze disk into each
 computer one at a time and turn on ST. All the machines will say 'slave
 machine' except for the last machine in the sequence, which will say 'Master
 Machine'. The 'Master machine' is the last computer to be activated in the
 'MIDI-ring'.

 Please note. The slave machines have no control at all, and all selections are
 made by the 'Master machine', unless they activate the 'Solo-mode' as
 described above. If solo-mode is in effect, they take themselves out of the
 MIDI-ring and should be physically removed if the other players want to play
 multiple machines. Any number of players can activate the 'Solo-mode' but they
 will all need to have at least a disk with some maze files on it.  The 'Master
 machine' may also become a 'Solo machine' if desired. If you need to
 re-establish the MIDI-ring use the 'ALT-S' to turn the solo machines back to
 'Slaves'. If for some reason you have turned the master into a Slave machine
 'ALT-R' will return it to 'master' status.

 THE MIDI-RING:  Up to 16 machines can be connected in the following manner. 
 You will need one MIDI-cable for each machine you want to connect.   Insert 
 one  end of each cable into the MIDI-IN port and the other to the  MIDI-out 
 port.  You  are creating a 'Midi-ring' you should be able to start  at  the 
 first ST and follow the MIDI-cables, MIDI-IN to MIDI-OUT all the way around 
 back to the first ST (see diagram).

 Note:   If after activating all the machines, all the computers say 'Slave' 
 you probably have a MIDI cable connected wrong!  Check all your connections 
 and  make sure they're hooked up correctly!   When you think its hooked  up 
 right;  Press ALT and the R key together on the machine you want to be  the 
 master.  After  you  press  the 'ALT-R' this machine will  be  the  'Master 
 machine' and will need to have the maze files in the disk drive.

 VIEWSCREEN:   This  is your window to the maze.   What you see is what  you 
 get! In the center is a tiny coloured sighting bead that indicates:  1. Your 
 colour,  2.  That  you have a 'bullet' ready and 3.  The destination of  the 
 bullet. A whole new dimension to the term, 'drawing a bead on someone'.

 JOYSTICK CONTROL:  Forward, back, right, left and fire button.  Need we say 
 more?   Easy to learn, but difficult to master!  Hint:  Shoot anything that 
 moves.  Advance hint:  don't get hit!

 THE  'SCORE' SCORE:   shows each of the players Face-busting  totals.   The 
 first Smiley to the top of the score wins the Set.
 
 HAPPINESS  QUOTIENT:   Your Happiness indicator located above  the  viewing 
 window,  indicates  how many hits your 'ego' can take.   A nice full  smile 
 indicates 3 hits;  a straight across grin,  2 hits and a full frown only  1 
 hit.  When wearing a frown, you really don't want to see people!
 
 POP CHART:   This is where your opponents deflated egos are kept.  When the 
 box  is  filled (10 smileybuster symbols),  you win!.   You can tell  at  a 
 glance how many and who, you have been 'editing'.
 
 3. GEM Controls
 ~~~~~~~~~~~~~~~
 Starting from the top:  The GEM pull-downs are of the standard format.  All 
 Game controls are located in the 'MAZE' pull-down.
 
 'LOAD...':   This is where you load a maze into the program.  This function 
 automatically looks for a file with a '.MAZ' extension.
 
 'RESET  SCORE':   To  reset the cumulative score that keeps track  of  each 
 player wins, since power up or the last 'Reset Score'.
 
 'NAMES':  This feature will allow all human players to name their Smiley.
 
 'PLAY..!':  By selecting this window or by hitting return once, you can now 
 select any of the Midi-Maze options.   Please note that if you wish to play 
 the same options again, all you have to do is hit return!
 
 'QUIT':   Rather  self-explanatory,  this  command causes your  machine  to 
 reboot.
 
 4. Play Controls
 ~~~~~~~~~~~~~~~~
 '#  MACHINE/S ON-LINE':   This indicated the number of computers  that  are 
 networked together via the MIDI port.  (Not including MidiCam machines).
 
 'RELOAD TIME':  The default setting of 'Fast' gives the maximum setting for 
 fair  play.   The  'Slow' setting gives a more patient and  stalking  game, 
 forcing the players to choose their shots and be more accurate!
 
 'REGEN TIME':   Regen time is the time it takes for the players to  recover 
 from a hit.  The 'Slow' option means you stay weaker for a good long time!
 
 'REVIVE  TIME':   The  amount  of time you stay dead  and  staring  at  the 
 opponents 'Have a nice day' is regulated by this switch.
 
 '1 LIFE',  '2 LIVES' and '3 LIVES' settings decide if you come back to life 
 with a Frown, Grin or Smile, respectively.
 
 DRONE CONTROLS:   Proof positive that computers are very fast  morons,  the 
 first  drone  setting 'Very Dumb' provides 'Target'  class  drones,  'Plain 
 Dumb'  or  'Standard Drones' at least defend themselves and 'Not  so  Dumb' 
 provides 'Ninja' class drones that are very sneaky and fast.   The computer 
 opponents  are usually no match for a large contingent of humans  but  will 
 devastate  small groups or a single player.   Vary the game  difficulty  by 
 trying various maze and drone combinations.
 
 'SINGLES' play is the standard setting,  However,  if you have more players 
 and would like to play teams, the 'Teams' setting will give you a selection 
 window  that  you  can assign any player or drone to any one  of  4  teams; 
 yellow,  blue, orange or green.  Note:  You can have drones on human teams, 
 if you shoot a drone teammate they may shoot you back!   If the drones  are 
 playing on a team,  they are more difficult to beat since their scores  are 
 cumulative.  Also  you  can shoot members of your own team,  they  will  be 
 weakened,  but you can't kill them.   If 'Friendly Fire' is selected,  your 
 shots will not hurt your teammates.
 
 5. Smiley Busting Made Easy
 ~~~~~~~~~~~~~~~~~~~~~~~~~~~
 Welcome  to  the Midi-Maze training grounds!   Here we will  learn  how  to 
 properly 'Bust Face'.
 
 STANDARD TACTICS:   
 The 'Face-off:   Center the 'bad note' on your screen,  either head  toward 
 him firing or sit back and lob your shots at him till he pops.   Advantage:  
 This is the easiest way to aim since you are traveling in the direction you 
 are  firing  and the target usually gets easier to hit as you  get  closer.  
 Disadvantage:  In most cases, if you're both facing each other it's usually 
 a shooting match;  the person who has a higher initial 'Happiness Quotient' 
 usually wins unless, you're good at 'evasive boogie-ing'.

 ADVANCED TACTICS: 
 Here are some maneuvers that you might try if you're hard pressed. The moving
 180 or 360 degree turn, while running down a long corridor or one with a
 turn-off or a straight stretch, do a forward right turn till you're facing 90
 degrees to your original direction, then do a reverse left turn till you're
 looking straight back along the way you came and move backward! If done
 correctly, you should have your pursuer in your sights. That should make his
 day! Round-the-corner shots are nice if you can pop your head round the corner
 just enough to hit your target then back round the corner fast enough to avoid
 the return fire!
  
 Here is a risky trick (if it does not work you're fried);  if  someone  is 
 following you really close and you're both close to one of the walls:
 
 The  Quick  reverse will put you behind if you can squeeze by  him  on  the 
 other  wall.   These  are but a few of  the  possible  combinations.   Just 
 experiment and see what works best for you!
 
 6. Maze Construction
 ~~~~~~~~~~~~~~~~~~~~
 There is a standard maze (MIDIMAZE.MAZ) that  is loaded in with the program 
 and  any  number that can be loaded after system  initialization.   If  you 
 would  like  to create your own mazes,  they can be created with  any  work 
 processor or text editor that saves files in ASCII.
 
 There  are  some very simple rules you have to follow or your maze  may  do 
 some unpredictable things.  The walls of the maze consist of two parts; the 
 wall-endpoints and wall-segments.   Both the endpoints and the segments are 
 represented by 'X's.   Open spaces, or corridors are represented by periods 
 '.'   Endpoints  can only be on the even rows or columns,  and  the  middle 
 segments  have to be on the odd rows or columns.   Endpoints without  walls 
 are  2 dimensional posts which are invisible,  but can be  run  into.   The 
 number  at the beginning of the file is the size of the maze both  vertical 
 and horizontal minus 1.   In the example below the dimensions are 15 by  15 
 (numbered 0-14).   The easiest way to make a maze is to load in an existing 
 maze and modify it.

                 14                       14                    
                 XXXXXXXXXXXXXXX          XXXXXXXXXXXXXXX      
                 X.............X          X.............X       
                 X.X.X.X.X.X.X.X          X.XXXXXXXXXXX.X       
                 X.............X          X.X...........X       
                 X.X.X.X.X.X.X.X          X.X.XXX.XXXXX.X       
                 X.............X          X.X.X.X.....X.X
                 X.X.X.X.X.X.X.X          X.X.XXX.....X.X
                 X.............X          X.X.........X.X
                 X.X.X.X.X.X.X.X          X.X.....XXX.X.X
                 X.............X          X.X.....X.X.X.X
                 X.X.X.X.X.X.X.X          X.XXXXX.XXX.X.X
                 X.............X          X...........X.X
                 X.X.X.X.X.X.X.X          X.XXXXXXXXXXX.X
                 X.............X          X.............X
                 XXXXXXXXXXXXXXX          XXXXXXXXXXXXXXX

                  MEDSTART.MAZ              MIDIMAZE.MAZ
                 (all possible             (default maze)
                   endpoints)

 7. Midi-Cam Option
 ~~~~~~~~~~~~~~~~~~
 Included  in  the  Midi-Maze program is an  option  called  Midi-Cam,  this 
 feature  allows a unused (non-player) computer to provide a  audience  view 
 and  spot coverage of the game much like television coverage of a  sporting 
 event!
 
 This feature is available only on a computer not involved in game play  but 
 connected via midi to the other machines.   The audience view is a overhead 
 or  map  view of the maze including the positions of all  the  players  and 
 computer drones.  Further features includes a viewscreen that automatically 
 or manually switches between the various players and drones both active and 
 non-active.   This camera view lets people watching the game see the entire 
 game and enjoy the action from the computer and players viewpoint.
 
 Midi-cam  can be attached and activated at any time between games  (anytime 
 you  have  a mouse pointer on the master-machine).   The  map  and  cameras 
 display as soon as the game starts.
 
 MIDI-CAM CONTROLS:  The Midi-Cam option only has a few manual controls.  To 
 select  the  Midi-Cam  option press 'ALT-C'.   To switch back  to  a  slave 
 machine,  press 'ALT-S'.  You should only operate the Midi-Cam from a slave 
 machine.   These controls are only active between games.  During a game you 
 can  watch  all  the action on the top view of the map  or  by  the  remote 
 viewscreen.  The remote viewscreen will display the same view as the player 
 (human or drone) would see.
 
 To  manually  select players 1-10 press the number key from  1  to  0.   To 
 select players 11-16 press SHIFT and the number key from 1 to 6.  The SPACE 
 BAR  selects  the  map  view and also returns  the  Midi-Cam  to  automatic 
 scanning.  They  joystick  also  selects the players and  the  FIRE  button 
 doubles as the SPACE BAR.


