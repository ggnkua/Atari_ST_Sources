                           
                                THE LEMMINGS         
                                   present         
                                 DOC FILE #5       
                           
                            Docs in this file are: 
                           
                                Titus The Fox      
                           

 

                                 TITUS THE FOX
                                 =============

 OPERATING THE GAME:
 ~~~~~~~~~~~~~~~~~~~

 Start & Passwords:
 ~~~~~~~~~~~~~~~~~~
    When Titus the Fox has loaded you have two possibilities of play:

  1:START - This option is chosen if you are playing for the first time. It
    starts a new game and can also be chosen by people who want to play the
    game right from the very beginning.

  2:PASSWORD - This allows the player to enter a four number code which is
    obtained from a level when you collect the magic lantern. Type in this
    code here and it will allow you to start from your chosen level.

 Energy & Lives:
 ~~~~~~~~~~~~~~~
    You start off with 16 energy bars and you lose 2 of these each time you
 are hit by an enemy or one of their weapons. Once you have lost all 16, you
 have 1 more left before you lose your life. You start the game with three
 lives (unless you use the trainer). You can increase energy and life reserves
 by picking up the diamond icons. Each one of these gives you back 1 bar of
 energy if you have lost any and for every ten you have collected during a
 level, you will be given an extra life at the end of it. You can lose a life
 by pressing F1 and you will go back to your last remembered position. You can
 remember a position by picking up the padlock icons scattered about. You can
 also quit the game by pressing F2. If you press F4 you can see which level
 you're on, how many bonuses you've picked up and how many lives you've got
 left.

 Movements of Titus:
 ~~~~~~~~~~~~~~~~~~~
    At first Titus, may seem a little tricky to control but you will soon get
 the hang of it. You can jump to various heights by pushing the joystick up for
 varying amounts of time. You can also move left and right while you're in mid
 air and also throw any object you may be holding.
    To pick up an object you must be standing on the same level as it, then
 pull the joystick down and press fire. It can sometimes be a bit tricky to
 pick up objects but you will get used to the positioning.
    There are three ways to throw an object:
  1:In the direction you are facing - launches the object and some cannot be
    re-used (See later). This is the most used method of killing the opposition
    safely. Simply press fire.
  2:Straight up - Press fire while pushing the joystick up. You will need to
    move out of the way once you have thrown the object as they tend to stun
    you if they land on you. This is a good way of killing enemies above you.
  3:Straight down - This isn't exactly throwing the object, more dropping it.
    To do this you pull the joystick down and press fire. You will also use
    this method to kill enemies often. Simply position yourself at the edge of
    a platform and drop the object on the enemy. You can place objects on top
    of one another using this method.

    There are several passages that Titus must enter (and some secret) that can
 be accessed by holding the joystick down for a while.
    Titus can also crawl by holding the joystick down while moving either left
 or right but he cannot carry any object while doing this. It is sometimes
 possible to move an object along a tunnel gradually, though. Also, you cannot
 enter passages while carrying an object.

 Objects:
 ~~~~~~~~
    Normally, when you throw an object sidewards, it is irretrievable. There
 are, naturally, a few exceptions. These are usually objects which Titus
 needs to solve a puzzle or finish a level.
    Here are the special objects and descriptions of their use.
  1:The ball - this is used to either kill enemies (it is reusable) or to
    bounce on to reach heights otherwise unreachable (you can also use the
    spring for this purpose but it can only be thrown once).
  2:The skateboard - you can travel around on this while letting it just slide
    through the enemy killing them. You will fall off it if it falls any
    heights. It is also reusable if you should throw it.
  3:The flying carpet - this is used to glide through the air. Once you have
    picked it up, you throw it so it unrolls and then jump on it to glide
    through the air. Once it hits the ground, it rolls up again.
  4:The golden scooter - this is much the same as the skateboard only it is
    a little bit faster and I think it is only found once in the game on one
    of the later levels.
  5:The wheely bin - I think it's a wheely bin, anyway. It is found on level
    two and it's only use is to kill the enemy. Once it has hit the enemy, it
    will fly off somewhere for you to find like the ball.
  6:The boxes - these can be stacked on top of each other to reach fairly high
    places. If you accidentally throw one, you will not get it back but you
    can throw them upwards without losing them.
  7:The bowling ball - there is supposedly a ball which eliminates all enemies
    in its path but I haven't found it yet so you'll have to look for it
    yourself, but it is in the manual.

 Key summary:
 ~~~~~~~~~~~~
  F1:Lose a life and return to last point remembered.
  F2:Finish game.
  F4:See information screen (Level, lives etc.).
  F5:Music on/off
  F6:Sound FX on/off
  F7:Screen 50/60 Hz
   P:Pause
 
