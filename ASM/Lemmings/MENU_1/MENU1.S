***************************************************************************
* THE LEMMINGS� Menu 1 Source                                             *
***************************************************************************

HEIGHT	EQU 32		;FONT SIZE
HEIGHT1	EQU 32		;BLOCK SIZE
SIZE	EQU HEIGHT1*160

PC	ADDQ.L	#8,A7
	clr.l -(a7)
	move.w #32,-(a7)
	trap #1
	addq.l #6,a7
	MOVE.L D0,SSP
	lea $80000,a7
	jsr xx
	MOVE.L $42E,A0
	SUB.L #$8000,A0
	MOVE.W #-1,-(A7)
	MOVE.L A0,-(A7)
	MOVE.L A0,-(A7)
	MOVE.W #5,-(A7)
	TRAP #14
	LEA 12(A7),A7
	move.l SSP,-(a7)
	move.w #32,-(a7)
	trap #1
	addq.l #6,a7
	MOVE.L KEY,D0
	SUB.L #$30,D0
	clr.l d1
	move.b d0,d1
	move.l #games,a0
	subq.b #1,d1
	mulu #$d,d1
	add.l d1,a0
	move.l 	a0,fadd+2
	LEA	LOAD(PC),A0
	LEA	RTR(PC),A1
	LEA	-$300(A7),A2
	move.l	a2,a3
LP1	MOVE.B	(A0)+,(A2)+
	CMP.L	A0,A1
	BNE	LP1
	jmp	(a3)
LOAD	clr.w -(a7)
fadd	move.l 	#0,-(a7)
	move.w #$3d,-(a7)
	trap 	#1
	add.l 	#$8,a7
	tst.l d0
	bmi error
	move.l d0,d7
	move.l #PC-$1c,-(a7)
	move.l #$fffff,-(a7)
	move.w d7,-(a7)
	move.w #$3f,-(a7)
	trap #1
	add.l #12,a7
	move.w d7,-(a7)
	move.w #$3e,-(a7)
	trap #1
	addq.l #4,a7
	LEA	PC-$1c,A0
	LEA	PC,A1
	lea	PC-$100,a5

	move.l	a1,8(a5)
	move.l	2(a0),$c(a5)
	ADDA.L	2(A0),A1

	move.l	a1,$10(a5)
	move.l	6(a0),$14(a5)
	ADDA.L	6(A0),A1

	move.l	a1,$18(a5)
	move.l	$e(a0),$1c(a5)
	ADDA.L	$E(A0),A1

	LEA	PC,A0
	MOVE.L	A0,D0
	move.l	(a1),d1
	tst.l d1
	beq DONE
	ADDA.L	(A1)+,A0
	MOVEQ	#0,D1
RELOCATE ADD.L	D0,(A0)
R1	MOVE.B	(A1)+,D1
	BEQ.S	DONE
	CMP.B	#1,D1
	BNE.S	R2
	ADDA.L	#$FE,A0
	BRA.S	R1
R2	ADDA.L	D1,A0
	MOVEQ	#0,D1
	BRA.S	RELOCATE
error	move.w #$4c,-(a7)
	trap #1
DONE	move.l #PC-$1c,a0
	move.l #$1b,d0
done	clr.b (a0)+
	dbf d0,done
	move.l #PC-$100,-(a7)
	clr.l -(a7)
	jmp PC
RTR
games	dc.b "lemmings.prg",$0
	dc.b "mercIII.prg ",$0
	dc.b "entombed.prg",$0
	;dc.b "vtemp.prg   ",$0
	;dc.b "            ",$0
	;dc.b "            ",$0
	;dc.b "            ",$0
	;dc.b "            ",$0
	;dc.b "            ",$0
SSP	DC.L 0
MOS	DC.W $1212,0
xx	MOVE.L #MOS,-(A7)
	MOVE.W #0,-(A7)
	MOVE.W #25,-(A7)
	TRAP #14
	ADDQ.L #8,A7
	CLR.W -(A7)
	MOVE.L #$68000,-(A7)
	MOVE.L #$68000,-(A7)
	MOVE.W #5,-(A7)
	TRAP #14
	LEA 12(A7),A7
	MOVE.L #$FF8240,A0
	MOVEQ.L #0,D0
	MOVE.L D0,(A0)+
	MOVE.L D0,(A0)+
	MOVE.L D0,(A0)+
	MOVE.L D0,(A0)+
	MOVE.L D0,(A0)+
	MOVE.L D0,(A0)+
	MOVE.L D0,(A0)+
	MOVE.L D0,(A0)+
	MOVE.W #37,-(A7)
	TRAP #14
	ADDQ.L #2,A7
	MOVE.L #GAMES,-(A7)
	MOVE.W #9,-(A7)
	TRAP #1
	ADDQ.L #6,A7
	MOVE.L #GAMES,-(A7)
	MOVE.W #9,-(A7)
	TRAP #1
	ADDQ.L #6,A7
	MOVE.L #$68000,MAP
	CLR.W -(A7)
	MOVE.L #$78000,-(A7)
	MOVE.L #$78000,-(A7)
	MOVE.W #5,-(A7)
	TRAP #14
	LEA 12(A7),A7
	MOVEM.L PIC+2,D0-D7
	MOVEM.L D0-D7,$FF8240
	MOVE.L #$6FD00,A0
XXXX	CLR.L (A0)+
	CMP.L #$7FD00,A0
	BNE XXXX
	MOVE.L #1,D0
	Jsr play
	MOVE.L #PIC+34,A0
	MOVE.L #$78000,A1
XXXL1	MOVE.L (A0)+,(A1)+
	CMP.L #PIC+34+$7D00,A0
	BNE XXXL1
	MOVEM.L PIC1+2,D0-D7
	MOVEM.L D0-D7,PAL
	MOVE.L #PIC1+34,A0
	MOVE.L #$70000,A1
XXXL2	MOVE.L (A0)+,(A1)+
	CMP.L #$77D00,A1
	BNE XXXL2
	JSR PRESHFT
	MOVE.W #49*6,D7
WWW	MOVE.W #37,-(A7)
	TRAP #14
	ADDQ.L #2,A7
	DBF D7,WWW
	jsr init
	MOVE.L #$70000,A0
XXXL33	CLR.L (A0)+
	CMP.L #$7FD00,A0
	BNE XXXL33
	MOVE.W #2,HZ
MENUL	JSR SCROLL
	JSR SPEC_A
	JSR WOBBLE
	JSR PUT_TXT
	MOVE.B SCR+1,$FF8201
	MOVE.B SCR+2,$FF8203
	EOR.L #$8000,SCR
	MOVE.W VSYNC,D0
XXV	CMP.W VSYNC,D0
	BEQ XXV
	MOVE.W #255,-(A7)
	MOVE.W #6,-(A7)
	TRAP #1
	ADDQ.L #4,A7
	CMP.W #"0",D0
	BLT MENUL	
	CMP.W #"9",D0
	BGT MENUL	
	CMP.W #"0",D0
	BNE MENUL1
	EOR.W #2,HZ
	EOR.W #2,FONT+2
	BRA MENUL
MENUL1	TST.W D0
	BEQ MENUL
	MOVE.L D0,KEY
	MOVE.L #$70000,A0
CLEAR	CLR.L (A0)+
	CMP.L #$7FD00,A0
	BNE CLEAR
	jsr end
	Jsr stop
	CLR.W $FF8246
	CLR.W $FF825E
	MOVE.W #$777,$FF8240
	MOVE.W HZ,D0
	MOVE.B D0,$FF820A
	RTS
HZ	DC.W 0
PAL	DS.L 8
VSYNC	DC.W 0
vbiC	ADD.W #1,VSYNC
	MOVEM.L	D0-A6,-(A7)
	MOVEM.L FONT+2,D0-D7
	MOVEM.L D0-D7,$FF8240
	CLR.B	$FFFA1B
	move.l	#timb,$120
	move.b	#32,$fffa21
	move.b	#$8,$fffa1b
	bset.b	#0,$fffa13
	bset.b	#0,$fffa07
	MOVE.L	$4D6,A0
	JSR	(A0)
	MOVEM.L	(A7)+,D0-A6
	rtE
timb	MOVEM.L D0-D7,-(A7)
	MOVEM.L PAL,D0-D7
	MOVEM.L D0-d7,$FF8240
	MOVEM.L (A7)+,D0-D7
	CLR.B	$FFFA1B
	move.l	#TIMB1,$120
	move.b	#136,$fffa21
	move.b	#$8,$fffa1b
	bclr.b	#0,$fffa0f
	rte
TIMB1	MOVE.W	#$777,$FF8242
	bclr.b	#0,$fffa13
	bclr.b	#0,$fffa07
	bclr.b	#0,$fffa0f
	RTE
init	move.b 	$fffa07,old07
	move.b 	$fffa09,old09
	move.b 	$fffa0b,old0b
	move.b 	$fffa0d,old0d
	move.b 	$fffa0f,old0f
	move.b 	$fffa11,old11
	move.b 	$fffa13,old13
	move.b 	$fffa15,old15
	move.b 	$fffa1b,old1b
	move.b 	$fffa21,old21
	CLR.B	$FFFA07
	CLR.B	$FFFA09
	BSET	#6,$FFFA09
	MOVE.L	$70,S70
	move.l	#vbiC,$70
	rts
S70	DC.L 	0
end	MOVE.L	S70,$70
	move.b 	old07,$fffa07
	move.b 	old09,$fffa09
	move.b 	old0b,$fffa0b
	move.b 	old0d,$fffa0d
	move.b 	old0f,$fffa0f
	move.b 	old11,$fffa11
	move.b 	old13,$fffa13
	move.b 	old15,$fffa15
	move.b 	old1b,$fffa1b
	move.b 	old21,$fffa21
	bclr.b	#0,$fffa07
	rts
old07	dc.b	0
old09	dc.b	0
old0b	dc.b	0
old0d	dc.b	0
old0f	dc.b	0
old11	dc.b	0
old13	dc.b	0
old15	dc.b	0
old1b	dc.b	0
old21	dc.b	0

SCR	DC.L $70000
TMP1	EQU $70000
TMP2	EQU $78000
CONTR	DC.L ZS1
SD7	DC.W 0
TEMP3	DC.L 0
TEMP	DC.L 0
TEMP1	DC.L TMP1
TEMP2	DC.L TMP2
SCROLL	MOVE.L CONTR,A0
	JMP (A0)
ZS1	MOVE.L #TEXT,SA0+2
ZS2	CLR.L D0
SA0	MOVE.B -1,D0
	MOVE.L SA0+2,A1
	CLR.L D7
	MOVE.B 1(A1),D7
	TST.B D7
	BEQ ZS1
	ADDQ.L #1,SA0+2
	SUB.B #32,D0
	MOVE.L D0,D1
	MULU #4,D0
	SUB.B #32,D7
	MULU #4,D7
	MOVE.L #FONTAB,A0
	MOVE.L A0,A1
	ADD.L D0,A0
	ADD.L D7,A1
	MOVE.W #3,SD7
	MOVE.L (A0),TEMP
	MOVE.L (A1),TEMP3
	MOVE.L #ZS3,CONTR
ZS3	MOVE.L TEMP,A2
	MOVE.L TEMP3,A4
	MOVE.L TEMP1,A0
	CMP.L #TMP2,A0
	BNE ZS3X
	ADDQ.L #8,TEMP
ZS3X	MOVE.L A0,A3
	MOVE.L #HEIGHT-1,D0
ZS31	MOVE.L D0,-(A7)
	MOVEM.L $08(A0),D0-D7
	MOVEM.L D0-D7,$00(A0)
	MOVEM.L $28(A0),D0-D7
	MOVEM.L D0-D7,$20(A0)
	MOVEM.L $48(A0),D0-D7
	MOVEM.L D0-D7,$40(A0)
	MOVEM.L $68(A0),D0-D7
	MOVEM.L D0-D7,$60(A0)
	MOVEM.L $88(A0),D0-D5
	MOVEM.L D0-D5,$80(A0)
	MOVE.L (A7)+,D0
	CMP.L #TMP2,A3
	BNE ZS32X	
	MOVEP.L (A2),D2
	MOVEP.L D2,$91(A0)
	MOVEP.L 1(A2),D2
	MOVEP.L D2,$98(A0)
	CMP.W #0,SD7
	BEQ KIMP
	MOVEP.L 8(A2),D2
	MOVEP.L D2,$99(A0)
	BRA ZS32XX
KIMP	MOVEP.L (A4),D2
	MOVEP.L D2,$99(A0)
	BRA ZS32XX
ZS32X	MOVE.L (A2),$98(A0)
	MOVE.L 4(A2),$9C(A0)
ZS32XX	LEA 160(A0),A0
	LEA 160(A4),A4
	LEA 160(A2),A2
	DBF D0,ZS31
	MOVE.L TEMP1,A2
	MOVE.L TEMP2,TEMP1
	MOVE.L A2,TEMP2
	MOVE.W SD7,D7
	DBF D7,ZS4
	MOVE.L #ZS2,CONTR
ZS4	MOVE.W D7,SD7
	RTS	
FONTAB	DC.L BS+$00+(SIZE*0),BS+$10+(SIZE*0),BS+$20+(SIZE*0),BS+$30+(SIZE*0),BS+$40+(SIZE*0),BS+$50+(SIZE*0),BS+$60+(SIZE*0),BS+$70+(SIZE*0),BS+$80+(SIZE*0),BS+$90+(SIZE*0)
	DC.L BS+$00+(SIZE*1),BS+$10+(SIZE*1),BS+$20+(SIZE*1),BS+$30+(SIZE*1),BS+$40+(SIZE*1),BS+$50+(SIZE*1),BS+$60+(SIZE*1),BS+$70+(SIZE*1),BS+$80+(SIZE*1),BS+$90+(SIZE*1)
	DC.L BS+$00+(SIZE*2),BS+$10+(SIZE*2),BS+$20+(SIZE*2),BS+$30+(SIZE*2),BS+$40+(SIZE*2),BS+$50+(SIZE*2),BS+$60+(SIZE*2),BS+$70+(SIZE*2),BS+$80+(SIZE*2),BS+$90+(SIZE*2)
	DC.L BS+$00+(SIZE*3),BS+$10+(SIZE*3),BS+$20+(SIZE*3),BS+$30+(SIZE*3),BS+$40+(SIZE*3),BS+$50+(SIZE*3),BS+$60+(SIZE*3),BS+$70+(SIZE*3),BS+$80+(SIZE*3),BS+$90+(SIZE*3)
	DC.L BS+$00+(SIZE*4),BS+$10+(SIZE*4),BS+$20+(SIZE*4),BS+$30+(SIZE*4),BS+$40+(SIZE*4),BS+$50+(SIZE*4),BS+$60+(SIZE*4),BS+$70+(SIZE*4),BS+$80+(SIZE*4),BS+$90+(SIZE*4)
	DC.L BS+$00+(SIZE*5),BS+$10+(SIZE*5),BS+$20+(SIZE*5),BS+$30+(SIZE*5),BS+$40+(SIZE*5),BS+$50+(SIZE*5),BS+$60+(SIZE*5),BS+$70+(SIZE*5),BS+$80+(SIZE*5),BS+$90+(SIZE*5)

KEY	DC.L 0
FONT	INCBIN "font1.PI1"
BS	EQU FONT+34

play	move.b #6,$484
	jsr dat
	move.l #dat+8,$4d6
rt	rts
stop	clr.l $4d6
	clr.l d0
	jsr dat

	move.w #2,d0
	move.l #8,d1
stop1	move.b d1,$ff8800
	clr.b $ff8802
	addq.l #1,d1
	dbf d0,stop1

	rts
	
dat	incbin "medusa.sng"
	even

SPEC_A	LEA ST(PC),A0
	BSR V1
	BSR V2
	BSR V3
	BSR DRAW
	RTS
V1	MOVEQ.W #0,D0
	MOVEQ.W #0,D1
	MOVE.B #1,$FF8800
	MOVE.B $FF8800,D0
	ASL.W #8,D0
	MOVE.B #0,$FF8800
	MOVE.B $FF8800,D0
	MOVE.B #8,$FF8800
	MOVE.B $FF8800,D1
	BRA STORE
V2	MOVEQ.W #0,D0
	MOVEQ.W #0,D1
	MOVE.B #3,$FF8800
	MOVE.B $FF8800,D0
	ASL.W #8,D0
	MOVE.B #2,$FF8800
	MOVE.B $FF8800,D0
	MOVE.B #9,$FF8800
	MOVE.B $FF8800,D1
	BRA STORE
V3	MOVEQ.W #0,D0
	MOVEQ.W #0,D1
	MOVE.B #5,$FF8800
	MOVE.B $FF8800,D0
	ASL.W #8,D0
	MOVE.B #4,$FF8800
	MOVE.B $FF8800,D0
	MOVE.B #10,$FF8800
	MOVE.B $FF8800,D1
STORE	AND.W #$FFF,D0
	TST.B D1
	BEQ STORE3
	SUBQ.W #1,D1
STORE3	AND.W #15,D1
	DIVU #104,D0
	MOVE.B (A0,D0.W),D2
	CMP.B D2,D1
	BLT STORE1
	MOVE.B D1,(A0,D0.W)
STORE1	RTS
DRAW	LEA ST(PC),A0
	MOVE.L #$99,D0
	MOVE.L #39,D1
	MOVE.L SCR,A4
	LEA 169*160(A4),A4
	LEA 30*160(A4),A6
	MOVE.W #%01111110,D3
	MOVEQ.W #0,D4
DRAW1	MOVE.L A4,A1
	MOVE.L A6,A3
	MOVEQ.W #0,D2
	MOVE.B (A0,D1.W),D2
	TST.B D2
	BEQ DRAW1_5
	SUB.B #1,(A0,D1.W)
DRAW1_5	ADD.L D0,A1
	ADD.L D0,A3
	MULU #4,D2
	MOVE.L DRAW_TAB(PC,D2.W),A2
	JMP (A2)
DRAW1_4	BTST #0,D0
	BEQ DRAW1_6
	SUBQ.L #1,D0
	BRA DRAW1_7
DRAW1_6	SUBQ.L #7,D0
DRAW1_7	DBF D1,DRAW1
	RTS
DRAW_TAB	DC.L VD0,VD1,VD2,VD3,VD4,VD5,VD6,VD7,VD8,VD9,VD10,VD11,VD12,VD13,VD14,VD15
VD0	
	MOVE.B D4,160*1(A1)
	MOVE.B D4,160*2(A1)
	MOVE.B D4,160*3(A1)
	MOVE.B D4,160*4(A1)
	MOVE.B D4,160*5(A1)
	MOVE.B D4,160*6(A1)
	MOVE.B D4,160*7(A1)
	MOVE.B D4,160*8(A1)
	MOVE.B D4,160*9(A1)
	MOVE.B D4,160*10(A1)
	MOVE.B D4,160*11(A1)
	MOVE.B D4,160*12(A1)
	MOVE.B D4,160*13(A1)
	MOVE.B D4,160*14(A1)
	MOVE.B D4,160*15(A1)
	MOVE.B D4,-160*14(A3)
	MOVE.B D4,-160*13(A3)
	MOVE.B D4,-160*12(A3)
	MOVE.B D4,-160*11(A3)
	MOVE.B D4,-160*10(A3)
	MOVE.B D4,-160*9(A3)
	MOVE.B D4,-160*8(A3)
	MOVE.B D4,-160*7(A3)
	MOVE.B D4,-160*6(A3)
	MOVE.B D4,-160*5(A3)
	MOVE.B D4,-160*4(A3)
	MOVE.B D4,-160*3(A3)
	MOVE.B D4,-160*2(A3)
	MOVE.B D4,-160*1(A3)
	BRA DRAW1_4	
VD1	
	MOVE.B D4,160*1(A1)
	MOVE.B D4,160*2(A1)
	MOVE.B D4,160*3(A1)
	MOVE.B D4,160*4(A1)
	MOVE.B D4,160*5(A1)
	MOVE.B D4,160*6(A1)
	MOVE.B D4,160*7(A1)
	MOVE.B D4,160*8(A1)
	MOVE.B D4,160*9(A1)
	MOVE.B D4,160*10(A1)
	MOVE.B D4,160*11(A1)
	MOVE.B D4,160*12(A1)
	MOVE.B D4,160*13(A1)
	MOVE.B D4,160*14(A1)
	MOVE.B D3,160*15(A1)
	MOVE.B D4,-160*14(A3)
	MOVE.B D4,-160*13(A3)
	MOVE.B D4,-160*12(A3)
	MOVE.B D4,-160*11(A3)
	MOVE.B D4,-160*10(A3)
	MOVE.B D4,-160*9(A3)
	MOVE.B D4,-160*8(A3)
	MOVE.B D4,-160*7(A3)
	MOVE.B D4,-160*6(A3)
	MOVE.B D4,-160*5(A3)
	MOVE.B D4,-160*4(A3)
	MOVE.B D4,-160*3(A3)
	MOVE.B D4,-160*2(A3)
	MOVE.B D4,-160*1(A3)
	BRA DRAW1_4	
VD2	
	MOVE.B D4,160*1(A1)
	MOVE.B D4,160*2(A1)
	MOVE.B D4,160*3(A1)
	MOVE.B D4,160*4(A1)
	MOVE.B D4,160*5(A1)
	MOVE.B D4,160*6(A1)
	MOVE.B D4,160*7(A1)
	MOVE.B D4,160*8(A1)
	MOVE.B D4,160*9(A1)
	MOVE.B D4,160*10(A1)
	MOVE.B D4,160*11(A1)
	MOVE.B D4,160*12(A1)
	MOVE.B D4,160*13(A1)
	MOVE.B D3,160*14(A1)
	MOVE.B D3,160*15(A1)
	MOVE.B D3,-160*14(A3)
	MOVE.B D4,-160*13(A3)
	MOVE.B D4,-160*12(A3)
	MOVE.B D4,-160*11(A3)
	MOVE.B D4,-160*10(A3)
	MOVE.B D4,-160*9(A3)
	MOVE.B D4,-160*8(A3)
	MOVE.B D4,-160*7(A3)
	MOVE.B D4,-160*6(A3)
	MOVE.B D4,-160*5(A3)
	MOVE.B D4,-160*4(A3)
	MOVE.B D4,-160*3(A3)
	MOVE.B D4,-160*2(A3)
	MOVE.B D4,-160*1(A3)
	BRA DRAW1_4	
VD3	
	MOVE.B D4,160*1(A1)
	MOVE.B D4,160*2(A1)
	MOVE.B D4,160*3(A1)
	MOVE.B D4,160*4(A1)
	MOVE.B D4,160*5(A1)
	MOVE.B D4,160*6(A1)
	MOVE.B D4,160*7(A1)
	MOVE.B D4,160*8(A1)
	MOVE.B D4,160*9(A1)
	MOVE.B D4,160*10(A1)
	MOVE.B D4,160*11(A1)
	MOVE.B D4,160*12(A1)
	MOVE.B D3,160*13(A1)
	MOVE.B D3,160*14(A1)
	MOVE.B D3,160*15(A1)
	MOVE.B D3,-160*14(A3)
	MOVE.B D3,-160*13(A3)
	MOVE.B D4,-160*12(A3)
	MOVE.B D4,-160*11(A3)
	MOVE.B D4,-160*10(A3)
	MOVE.B D4,-160*9(A3)
	MOVE.B D4,-160*8(A3)
	MOVE.B D4,-160*7(A3)
	MOVE.B D4,-160*6(A3)
	MOVE.B D4,-160*5(A3)
	MOVE.B D4,-160*4(A3)
	MOVE.B D4,-160*3(A3)
	MOVE.B D4,-160*2(A3)
	MOVE.B D4,-160*1(A3)
	BRA DRAW1_4	
VD4	
	MOVE.B D4,160*1(A1)
	MOVE.B D4,160*2(A1)
	MOVE.B D4,160*3(A1)
	MOVE.B D4,160*4(A1)
	MOVE.B D4,160*5(A1)
	MOVE.B D4,160*6(A1)
	MOVE.B D4,160*7(A1)
	MOVE.B D4,160*8(A1)
	MOVE.B D4,160*9(A1)
	MOVE.B D4,160*10(A1)
	MOVE.B D4,160*11(A1)
	MOVE.B D3,160*12(A1)
	MOVE.B D3,160*13(A1)
	MOVE.B D3,160*14(A1)
	MOVE.B D3,160*15(A1)
	MOVE.B D3,-160*14(A3)
	MOVE.B D3,-160*13(A3)
	MOVE.B D3,-160*12(A3)
	MOVE.B D4,-160*11(A3)
	MOVE.B D4,-160*10(A3)
	MOVE.B D4,-160*9(A3)
	MOVE.B D4,-160*8(A3)
	MOVE.B D4,-160*7(A3)
	MOVE.B D4,-160*6(A3)
	MOVE.B D4,-160*5(A3)
	MOVE.B D4,-160*4(A3)
	MOVE.B D4,-160*3(A3)
	MOVE.B D4,-160*2(A3)
	MOVE.B D4,-160*1(A3)
	BRA DRAW1_4	
VD5	
	MOVE.B D4,160*1(A1)
	MOVE.B D4,160*2(A1)
	MOVE.B D4,160*3(A1)
	MOVE.B D4,160*4(A1)
	MOVE.B D4,160*5(A1)
	MOVE.B D4,160*6(A1)
	MOVE.B D4,160*7(A1)
	MOVE.B D4,160*8(A1)
	MOVE.B D4,160*9(A1)
	MOVE.B D4,160*10(A1)
	MOVE.B D3,160*11(A1)
	MOVE.B D3,160*12(A1)
	MOVE.B D3,160*13(A1)
	MOVE.B D3,160*14(A1)
	MOVE.B D3,160*15(A1)
	MOVE.B D3,-160*14(A3)
	MOVE.B D3,-160*13(A3)
	MOVE.B D3,-160*12(A3)
	MOVE.B D3,-160*11(A3)
	MOVE.B D4,-160*10(A3)
	MOVE.B D4,-160*9(A3)
	MOVE.B D4,-160*8(A3)
	MOVE.B D4,-160*7(A3)
	MOVE.B D4,-160*6(A3)
	MOVE.B D4,-160*5(A3)
	MOVE.B D4,-160*4(A3)
	MOVE.B D4,-160*3(A3)
	MOVE.B D4,-160*2(A3)
	MOVE.B D4,-160*1(A3)
	BRA DRAW1_4	
VD6	
	MOVE.B D4,160*1(A1)
	MOVE.B D4,160*2(A1)
	MOVE.B D4,160*3(A1)
	MOVE.B D4,160*4(A1)
	MOVE.B D4,160*5(A1)
	MOVE.B D4,160*6(A1)
	MOVE.B D4,160*7(A1)
	MOVE.B D4,160*8(A1)
	MOVE.B D4,160*9(A1)
	MOVE.B D3,160*10(A1)
	MOVE.B D3,160*11(A1)
	MOVE.B D3,160*12(A1)
	MOVE.B D3,160*13(A1)
	MOVE.B D3,160*14(A1)
	MOVE.B D3,160*15(A1)
	MOVE.B D3,-160*14(A3)
	MOVE.B D3,-160*13(A3)
	MOVE.B D3,-160*12(A3)
	MOVE.B D3,-160*11(A3)
	MOVE.B D3,-160*10(A3)
	MOVE.B D4,-160*9(A3)
	MOVE.B D4,-160*8(A3)
	MOVE.B D4,-160*7(A3)
	MOVE.B D4,-160*6(A3)
	MOVE.B D4,-160*5(A3)
	MOVE.B D4,-160*4(A3)
	MOVE.B D4,-160*3(A3)
	MOVE.B D4,-160*2(A3)
	MOVE.B D4,-160*1(A3)
	BRA DRAW1_4	
VD7	
	MOVE.B D4,160*1(A1)
	MOVE.B D4,160*2(A1)
	MOVE.B D4,160*3(A1)
	MOVE.B D4,160*4(A1)
	MOVE.B D4,160*5(A1)
	MOVE.B D4,160*6(A1)
	MOVE.B D4,160*7(A1)
	MOVE.B D4,160*8(A1)
	MOVE.B D3,160*9(A1)
	MOVE.B D3,160*10(A1)
	MOVE.B D3,160*11(A1)
	MOVE.B D3,160*12(A1)
	MOVE.B D3,160*13(A1)
	MOVE.B D3,160*14(A1)
	MOVE.B D3,160*15(A1)
	MOVE.B D3,-160*14(A3)
	MOVE.B D3,-160*13(A3)
	MOVE.B D3,-160*12(A3)
	MOVE.B D3,-160*11(A3)
	MOVE.B D3,-160*10(A3)
	MOVE.B D3,-160*9(A3)
	MOVE.B D4,-160*8(A3)
	MOVE.B D4,-160*7(A3)
	MOVE.B D4,-160*6(A3)
	MOVE.B D4,-160*5(A3)
	MOVE.B D4,-160*4(A3)
	MOVE.B D4,-160*3(A3)
	MOVE.B D4,-160*2(A3)
	MOVE.B D4,-160*1(A3)
	BRA DRAW1_4	
VD8	
	MOVE.B D4,160*1(A1)
	MOVE.B D4,160*2(A1)
	MOVE.B D4,160*3(A1)
	MOVE.B D4,160*4(A1)
	MOVE.B D4,160*5(A1)
	MOVE.B D4,160*6(A1)
	MOVE.B D4,160*7(A1)
	MOVE.B D3,160*8(A1)
	MOVE.B D3,160*9(A1)
	MOVE.B D3,160*10(A1)
	MOVE.B D3,160*11(A1)
	MOVE.B D3,160*12(A1)
	MOVE.B D3,160*13(A1)
	MOVE.B D3,160*14(A1)
	MOVE.B D3,160*15(A1)
	MOVE.B D3,-160*14(A3)
	MOVE.B D3,-160*13(A3)
	MOVE.B D3,-160*12(A3)
	MOVE.B D3,-160*11(A3)
	MOVE.B D3,-160*10(A3)
	MOVE.B D3,-160*9(A3)
	MOVE.B D3,-160*8(A3)
	MOVE.B D4,-160*7(A3)
	MOVE.B D4,-160*6(A3)
	MOVE.B D4,-160*5(A3)
	MOVE.B D4,-160*4(A3)
	MOVE.B D4,-160*3(A3)
	MOVE.B D4,-160*2(A3)
	MOVE.B D4,-160*1(A3)
	BRA DRAW1_4	
VD9	
	MOVE.B D4,160*1(A1)
	MOVE.B D4,160*2(A1)
	MOVE.B D4,160*3(A1)
	MOVE.B D4,160*4(A1)
	MOVE.B D4,160*5(A1)
	MOVE.B D4,160*6(A1)
	MOVE.B D3,160*7(A1)
	MOVE.B D3,160*8(A1)
	MOVE.B D3,160*9(A1)
	MOVE.B D3,160*10(A1)
	MOVE.B D3,160*11(A1)
	MOVE.B D3,160*12(A1)
	MOVE.B D3,160*13(A1)
	MOVE.B D3,160*14(A1)
	MOVE.B D3,160*15(A1)
	MOVE.B D3,-160*14(A3)
	MOVE.B D3,-160*13(A3)
	MOVE.B D3,-160*12(A3)
	MOVE.B D3,-160*11(A3)
	MOVE.B D3,-160*10(A3)
	MOVE.B D3,-160*9(A3)
	MOVE.B D3,-160*8(A3)
	MOVE.B D3,-160*7(A3)
	MOVE.B D4,-160*6(A3)
	MOVE.B D4,-160*5(A3)
	MOVE.B D4,-160*4(A3)
	MOVE.B D4,-160*3(A3)
	MOVE.B D4,-160*2(A3)
	MOVE.B D4,-160*1(A3)
	BRA DRAW1_4	
VD10	
	MOVE.B D4,160*1(A1)
	MOVE.B D4,160*2(A1)
	MOVE.B D4,160*3(A1)
	MOVE.B D4,160*4(A1)
	MOVE.B D4,160*5(A1)
	MOVE.B D3,160*6(A1)
	MOVE.B D3,160*7(A1)
	MOVE.B D3,160*8(A1)
	MOVE.B D3,160*9(A1)
	MOVE.B D3,160*10(A1)
	MOVE.B D3,160*11(A1)
	MOVE.B D3,160*12(A1)
	MOVE.B D3,160*13(A1)
	MOVE.B D3,160*14(A1)
	MOVE.B D3,160*15(A1)
	MOVE.B D3,-160*14(A3)
	MOVE.B D3,-160*13(A3)
	MOVE.B D3,-160*12(A3)
	MOVE.B D3,-160*11(A3)
	MOVE.B D3,-160*10(A3)
	MOVE.B D3,-160*9(A3)
	MOVE.B D3,-160*8(A3)
	MOVE.B D3,-160*7(A3)
	MOVE.B D3,-160*6(A3)
	MOVE.B D4,-160*5(A3)
	MOVE.B D4,-160*4(A3)
	MOVE.B D4,-160*3(A3)
	MOVE.B D4,-160*2(A3)
	MOVE.B D4,-160*1(A3)
	BRA DRAW1_4	
VD11	
	MOVE.B D4,160*1(A1)
	MOVE.B D4,160*2(A1)
	MOVE.B D4,160*3(A1)
	MOVE.B D4,160*4(A1)
	MOVE.B D3,160*5(A1)
	MOVE.B D3,160*6(A1)
	MOVE.B D3,160*7(A1)
	MOVE.B D3,160*8(A1)
	MOVE.B D3,160*9(A1)
	MOVE.B D3,160*10(A1)
	MOVE.B D3,160*11(A1)
	MOVE.B D3,160*12(A1)
	MOVE.B D3,160*13(A1)
	MOVE.B D3,160*14(A1)
	MOVE.B D3,160*15(A1)
	MOVE.B D3,-160*14(A3)
	MOVE.B D3,-160*13(A3)
	MOVE.B D3,-160*12(A3)
	MOVE.B D3,-160*11(A3)
	MOVE.B D3,-160*10(A3)
	MOVE.B D3,-160*9(A3)
	MOVE.B D3,-160*8(A3)
	MOVE.B D3,-160*7(A3)
	MOVE.B D3,-160*6(A3)
	MOVE.B D3,-160*5(A3)
	MOVE.B D4,-160*4(A3)
	MOVE.B D4,-160*3(A3)
	MOVE.B D4,-160*2(A3)
	MOVE.B D4,-160*1(A3)
	BRA DRAW1_4	
VD12	
	MOVE.B D4,160*1(A1)
	MOVE.B D4,160*2(A1)
	MOVE.B D4,160*3(A1)
	MOVE.B D3,160*4(A1)
	MOVE.B D3,160*5(A1)
	MOVE.B D3,160*6(A1)
	MOVE.B D3,160*7(A1)
	MOVE.B D3,160*8(A1)
	MOVE.B D3,160*9(A1)
	MOVE.B D3,160*10(A1)
	MOVE.B D3,160*11(A1)
	MOVE.B D3,160*12(A1)
	MOVE.B D3,160*13(A1)
	MOVE.B D3,160*14(A1)
	MOVE.B D3,160*15(A1)
	MOVE.B D3,-160*14(A3)
	MOVE.B D3,-160*13(A3)
	MOVE.B D3,-160*12(A3)
	MOVE.B D3,-160*11(A3)
	MOVE.B D3,-160*10(A3)
	MOVE.B D3,-160*9(A3)
	MOVE.B D3,-160*8(A3)
	MOVE.B D3,-160*7(A3)
	MOVE.B D3,-160*6(A3)
	MOVE.B D3,-160*5(A3)
	MOVE.B D3,-160*4(A3)
	MOVE.B D4,-160*3(A3)
	MOVE.B D4,-160*2(A3)
	MOVE.B D4,-160*1(A3)
	BRA DRAW1_4	
VD13	
	MOVE.B D4,160*1(A1)
	MOVE.B D4,160*2(A1)
	MOVE.B D3,160*3(A1)
	MOVE.B D3,160*4(A1)
	MOVE.B D3,160*5(A1)
	MOVE.B D3,160*6(A1)
	MOVE.B D3,160*7(A1)
	MOVE.B D3,160*8(A1)
	MOVE.B D3,160*9(A1)
	MOVE.B D3,160*10(A1)
	MOVE.B D3,160*11(A1)
	MOVE.B D3,160*12(A1)
	MOVE.B D3,160*13(A1)
	MOVE.B D3,160*14(A1)
	MOVE.B D3,160*15(A1)
	MOVE.B D3,-160*14(A3)
	MOVE.B D3,-160*13(A3)
	MOVE.B D3,-160*12(A3)
	MOVE.B D3,-160*11(A3)
	MOVE.B D3,-160*10(A3)
	MOVE.B D3,-160*9(A3)
	MOVE.B D3,-160*8(A3)
	MOVE.B D3,-160*7(A3)
	MOVE.B D3,-160*6(A3)
	MOVE.B D3,-160*5(A3)
	MOVE.B D3,-160*4(A3)
	MOVE.B D3,-160*3(A3)
	MOVE.B D4,-160*2(A3)
	MOVE.B D4,-160*1(A3)
	BRA DRAW1_4	
VD14	
	MOVE.B D4,160*1(A1)
	MOVE.B D3,160*2(A1)
	MOVE.B D3,160*3(A1)
	MOVE.B D3,160*4(A1)
	MOVE.B D3,160*5(A1)
	MOVE.B D3,160*6(A1)
	MOVE.B D3,160*7(A1)
	MOVE.B D3,160*8(A1)
	MOVE.B D3,160*9(A1)
	MOVE.B D3,160*10(A1)
	MOVE.B D3,160*11(A1)
	MOVE.B D3,160*12(A1)
	MOVE.B D3,160*13(A1)
	MOVE.B D3,160*14(A1)
	MOVE.B D3,160*15(A1)
	MOVE.B D3,-160*14(A3)
	MOVE.B D3,-160*13(A3)
	MOVE.B D3,-160*12(A3)
	MOVE.B D3,-160*11(A3)
	MOVE.B D3,-160*10(A3)
	MOVE.B D3,-160*9(A3)
	MOVE.B D3,-160*8(A3)
	MOVE.B D3,-160*7(A3)
	MOVE.B D3,-160*6(A3)
	MOVE.B D3,-160*5(A3)
	MOVE.B D3,-160*4(A3)
	MOVE.B D3,-160*3(A3)
	MOVE.B D3,-160*2(A3)
	MOVE.B D4,-160*1(A3)
	BRA DRAW1_4	
VD15	
	MOVE.B D3,160*1(A1)
	MOVE.B D3,160*2(A1)
	MOVE.B D3,160*3(A1)
	MOVE.B D3,160*4(A1)
	MOVE.B D3,160*5(A1)
	MOVE.B D3,160*6(A1)
	MOVE.B D3,160*7(A1)
	MOVE.B D3,160*8(A1)
	MOVE.B D3,160*9(A1)
	MOVE.B D3,160*10(A1)
	MOVE.B D3,160*11(A1)
	MOVE.B D3,160*12(A1)
	MOVE.B D3,160*13(A1)
	MOVE.B D3,160*14(A1)
	MOVE.B D3,160*15(A1)
	MOVE.B D3,-160*14(A3)
	MOVE.B D3,-160*13(A3)
	MOVE.B D3,-160*12(A3)
	MOVE.B D3,-160*11(A3)
	MOVE.B D3,-160*10(A3)
	MOVE.B D3,-160*9(A3)
	MOVE.B D3,-160*8(A3)
	MOVE.B D3,-160*7(A3)
	MOVE.B D3,-160*6(A3)
	MOVE.B D3,-160*5(A3)
	MOVE.B D3,-160*4(A3)
	MOVE.B D3,-160*3(A3)
	MOVE.B D3,-160*2(A3)
	MOVE.B D3,-160*1(A3)
	BRA DRAW1_4	
ST	DS.B 40
WID	EQU 10
WID1	EQU WID+1
HT	EQU 57
MATHS	DS.L 16
PRESHFT	MOVE.L #W_ST1,A0
	MOVE.L #W_ST2,A1
	MOVE.W #HT-1,D0
PRES4	MOVE.L #$70000,(A0)+
	MOVE.L #$70000,(A1)+
	DBF D0,PRES4
	MOVE.L #W_TAB,A0
	MOVE.L #W_TABE,A1
PRES5	MOVE.W (A0)+,(A1)+
	CMP.L #W_TABE,A0
	BNE PRES5
	MOVEQ.L #0,D0
	MOVE.L #BASE,A1
	MOVE.L #MATHS,A6
PRES1	MOVE.L A1,(A6)
	SUB.L #BASE,(A6)+
	MOVE.L #$70000,A0
	MOVE.L #HT-1,D7
PRES2	MOVE.L A0,-(A7)
	MOVE.L #WID-1,D6
	MOVEQ.L #0,D1
	MOVEQ.L #0,D2
	MOVEQ.L #0,D3
	MOVEQ.L #0,D4
PRES3	MOVE.W (A0),D1
	MOVE.W 2(A0),D2
	MOVE.W 4(A0),D3
	MOVE.W 6(A0),D4
	ROR.L D0,D1
	ROR.L D0,D2
	ROR.L D0,D3
	ROR.L D0,D4
	MOVE.W D1,(A1)+
	MOVE.W D2,(A1)+
	MOVE.W D3,(A1)+
	MOVE.W D4,(A1)+
	MOVE.L (A0),D1
	MOVE.L 2(A0),D2
	MOVE.L 4(A0),D3
	MOVE.L 6(A0),D4
	ADDQ.L #8,A0
	DBF D6,PRES3
	CLR.W D1
	CLR.W D2
	CLR.W D3
	CLR.W D4
	ROR.L D0,D1
	ROR.L D0,D2
	ROR.L D0,D3
	ROR.L D0,D4
	MOVE.W D1,(A1)+
	MOVE.W D2,(A1)+
	MOVE.W D3,(A1)+
	MOVE.W D4,(A1)+
	MOVE.L (A7)+,A0
	ADD.L #160,A0
	DBF D7,PRES2
	ADDQ.L #1,D0
	CMP.L #16,D0
	BNE PRES1
	RTS
W_S1	DC.L W_ST1
W_S2	DC.L W_ST2
W_ST1	DS.L HT
W_ST2	DS.L HT
W_POS	DC.L W_TAB
WW_POS	DC.W 87
W_TAB	
	DC.W 5,4,3,2,1,0,-1,-2,-3,-4,-5,-5,-4,-3,-2,-1,0,1,2,3,4,5
	DC.W 5,4,3,2,1,0,-1,-2,-3,-4,-5,-5,-4,-3,-2,-1,0,1,2,3,4,5
	DC.W 5,4,3,2,1,0,-1,-2,-3,-4,-5,-5,-4,-3,-2,-1,0,1,2,3,4,5
	DC.W 5,4,3,2,1,0,-1,-2,-3,-4,-5,-5,-4,-3,-2,-1,0,1,2,3,4,5
	DC.W 5,4,3,2,1,0,-1,-2,-3,-4,-5,-5,-4,-3,-2,-1,0,1,2,3,4,5
	DC.W 4,3,2,1,0,-1,-2,-3,-4,-4,-3,-2,-1,0,1,2,3,4
	DC.W 3,2,1,0,-1,-2,-3,-3,-2,-1,0,1,2,3
	DC.W 2,1,0,-1,-2,-2,-1,0,1,2
	DC.W 1,0,-1,-1,0,1
	DC.L 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	DC.L 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	DC.L 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	DC.L 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	DC.L 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	DC.L 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	DC.L 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	DC.L 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	DC.L 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	DC.L 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	DC.L 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	DC.W 1,0,-1,-1,0,1
	DC.W 2,1,0,-1,-2,-2,-1,0,1,2
	DC.W 3,2,1,0,-1,-2,-3,-3,-2,-1,0,1,2,3
	DC.W 4,3,2,1,0,-1,-2,-3,-4,-4,-3,-2,-1,0,1,2,3,4
	DC.W 7,7,6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-7,-7,-7,-7,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6,7,7
	DC.W 5,4,3,2,1,0,-1,-2,-3,-4,-5,-5,-4,-3,-2,-1,0,1,2,3,4,5
	DC.W 7,7,6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-7,-7,-7,-7,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6,7,7
	DC.W 6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6
	DC.W 8,8,7,7,6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-7,-7,-8,-8,-8,-8,-7,-7,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6,7,7,8,8
	DC.W 8,8,7,7,6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-7,-7,-8,-8,-8,-8,-7,-7,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6,7,7,8,8
	DC.W 6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6
	DC.W 3,2,1,0,-1,-2,-3,-3,-2,-1,0,1,2,3
	DC.W 3,2,1,0,-1,-2,-3,-3,-2,-1,0,1,2,3
	DC.W 5,4,3,2,1,0,-1,-2,-3,-4,-5,-5,-4,-3,-2,-1,0,1,2,3,4,5
	DC.W 7,7,6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-7,-7,-7,-7,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6,7,7
	DC.W 7,7,6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-7,-7,-7,-7,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6,7,7
	DC.W 7,7,6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-7,-7,-7,-7,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6,7,7
	DC.W 3,2,1,0,-1,-2,-3,-3,-2,-1,0,1,2,3
	DC.W 6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6
	DC.W 6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6
	DC.W 5,4,3,2,1,0,-1,-2,-3,-4,-5,-5,-4,-3,-2,-1,0,1,2,3,4,5
	DC.W 5,4,3,2,1,0,-1,-2,-3,-4,-5,-5,-4,-3,-2,-1,0,1,2,3,4,5
	DC.W 5,4,3,2,1,0,-1,-2,-3,-4,-5,-5,-4,-3,-2,-1,0,1,2,3,4,5
	DC.W 6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6
	DC.W 3,2,1,0,-1,-2,-3,-3,-2,-1,0,1,2,3
	DC.W 5,4,3,2,1,0,-1,-2,-3,-4,-5,-5,-4,-3,-2,-1,0,1,2,3,4,5
	DC.W 7,7,6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-7,-7,-7,-7,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6,7,7
	DC.W 8,8,7,7,6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-7,-7,-8,-8,-8,-8,-7,-7,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6,7,7,8,8
	DC.W 8,8,7,7,6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-7,-7,-8,-8,-8,-8,-7,-7,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6,7,7,8,8
	DC.W 3,2,1,0,-1,-2,-3,-3,-2,-1,0,1,2,3
	DC.W 7,7,6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-7,-7,-7,-7,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6,7,7
	DC.W 7,7,6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-7,-7,-7,-7,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6,7,7
	DC.W 8,8,7,7,6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-7,-7,-8,-8,-8,-8,-7,-7,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6,7,7,8,8
	DC.W 8,8,7,7,6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-7,-7,-8,-8,-8,-8,-7,-7,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6,7,7,8,8
	DC.W 8,8,7,7,6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-7,-7,-8,-8,-8,-8,-7,-7,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6,7,7,8,8
	DC.W 3,2,1,0,-1,-2,-3,-3,-2,-1,0,1,2,3
	DC.W 8,8,7,7,6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-7,-7,-8,-8,-8,-8,-7,-7,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6,7,7,8,8
	DC.W 7,7,6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-7,-7,-7,-7,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6,7,7
	DC.W 5,4,3,2,1,0,-1,-2,-3,-4,-5,-5,-4,-3,-2,-1,0,1,2,3,4,5
	DC.W 5,4,3,2,1,0,-1,-2,-3,-4,-5,-5,-4,-3,-2,-1,0,1,2,3,4,5
	DC.W 6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6
	DC.W 6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6
	DC.W 5,4,3,2,1,0,-1,-2,-3,-4,-5,-5,-4,-3,-2,-1,0,1,2,3,4,5
	DC.W 8,8,7,7,6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-7,-7,-8,-8,-8,-8,-7,-7,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6,7,7,8,8
	DC.W 5,4,3,2,1,0,-1,-2,-3,-4,-5,-5,-4,-3,-2,-1,0,1,2,3,4,5
	DC.W 5,4,3,2,1,0,-1,-2,-3,-4,-5,-5,-4,-3,-2,-1,0,1,2,3,4,5
	DC.W 7,7,6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-7,-7,-7,-7,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6,7,7
	DC.W 7,7,6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-7,-7,-7,-7,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6,7,7
	DC.W 7,7,6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-7,-7,-7,-7,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6,7,7
	DC.W 5,4,3,2,1,0,-1,-2,-3,-4,-5,-5,-4,-3,-2,-1,0,1,2,3,4,5
	DC.W 8,8,7,7,6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-7,-7,-8,-8,-8,-8,-7,-7,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6,7,7,8,8
	DC.W 6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6
	DC.W 8,8,7,7,6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-7,-7,-8,-8,-8,-8,-7,-7,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6,7,7,8,8
	DC.W 7,7,6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-7,-7,-7,-7,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6,7,7
	DC.W 6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6
	DC.W 6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6
	DC.W 8,8,7,7,6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-7,-7,-8,-8,-8,-8,-7,-7,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6,7,7,8,8
	DC.W 7,7,6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-7,-7,-7,-7,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6,7,7
	DC.W 6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6
	DC.W 6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6
	DC.W 7,7,6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-7,-7,-7,-7,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6,7,7
	DC.W 7,7,6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-7,-7,-7,-7,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6,7,7
	DC.W 6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6
	DC.W 8,8,7,7,6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-7,-7,-8,-8,-8,-8,-7,-7,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6,7,7,8,8
	DC.W 8,8,7,7,6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-7,-7,-8,-8,-8,-8,-7,-7,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6,7,7,8,8
	DC.W 8,8,7,7,6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-7,-7,-8,-8,-8,-8,-7,-7,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6,7,7,8,8
	DC.W 8,8,7,7,6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-7,-7,-8,-8,-8,-8,-7,-7,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6,7,7,8,8
	DC.W 6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6
	DC.W 6,6,5,5,4,4,3,3,2,2,1,1,0,0,-1,-1,-2,-2,-3,-3,-4,-4,-5,-5,-6,-6,-6,-6,-5,-5,-4,-4,-3,-3,-2,-2,-1,-1,0,0,1,1,2,2,3,3,4,4,5,5,6,6
	DC.W 5,4,3,2,1,0,-1,-2,-3,-4,-5,-5,-4,-3,-2,-1,0,1,2,3,4,5
W_TABE
	DS.B W_TABE-W_TAB
WOBBLE	MOVE.L W_S1,A6
	MOVE.L W_S2,W_S1
	MOVE.L A6,W_S2
	MOVE.L W_POS,-(A7)
	JSR W_PLC
	MOVE.L (A7)+,A0
	MOVE.W WW_POS,D0
	ADD.W (A0)+,D0
	CMP.L #W_TABE,A0
	BNE WOBB1
	MOVE.L #W_TAB,A0
WOBB1	MOVE.L A0,W_POS
	MOVE.W D0,WW_POS
	RTS
WIPE	DS.L WID1*2+1
W_PLC	MOVE.W #HT-1,D7
	MOVE.L A6,-(A7)
W_PLCC	MOVE.L (A6)+,A3
	MOVEM.L WIPE,D1-D5/A4-A5
	MOVEM.L D1-D5/A4-A5,(A3)
	MOVEM.L D1-D5/A4-A5,28(A3)
	MOVEM.L D0-D5/A4-A5,56(A3)
	DBF D7,W_PLCC
	MOVE.L (A7)+,A6
	MOVEQ.L #0,D0
	MOVE.W WW_POS,D0
	MOVE.L W_POS,A0
	MOVE.W #HT-1,D7
	MOVE.L SCR,A1
	ADD.L #40*160,A1
	MOVE.L #BASE,A2
W_PLC1	MOVEM.L D0/A1,-(A7)
	ADD.W #3200,D0
	MOVE.L D0,D1
	AND.L #15,D1
	LSR.L #1,D0
	AND.W #$FFF8,D0
	SUB.L #1600,D0
	ADD.L D0,A1
	MOVE.L A1,(A6)+
	MOVE.L #MATHS,A5
	MULU #4,D1
	MOVE.L 0(A5,D1.W),D1
	MOVE.L A2,A3
	ADD.L D1,A3
	MOVEM.L (A3)+,D1-D5/A4-A5
	MOVEM.L D1-D5/A4-A5,(A1)
	MOVEM.L (A3)+,D1-D5/A4-A5
	MOVEM.L D1-D5/A4-A5,28(A1)
	MOVEM.L (A3)+,D1-D5/A4-A5
	MOVEM.L D1-D5/A4-A5,56(A1)
	MOVE.L (A3)+,84(A1)
	MOVEM.L (A7)+,D0/A1
	ADD.L #160,A1
	ADD.L #WID1*8,A2
	ADD.W (A0)+,D0
	DBF D7,W_PLC1
	RTS
TOG	DC.W 0
MAP	DC.L 0
PUT_TXT	MOVE.L SCR,A1
	ADD.L #160*(32+76)+2,A1
	ADD.L #160,MAP
	MOVE.L MAP,A0
	CMP.L #$68000+(160*96),A0
	BNE PT1
	MOVE.L #$68000,MAP
PT1	JSR PT2
	ADD.L #160*3,A0
	JSR PT2
	JSR PT2
	ADD.L #160*2,A0
	JSR PT2
	JSR PT2
	JSR PT2
	ADD.L #160*1,A0
	JSR PT2
	JSR PT2
	JSR PT2
	JSR PT2
	JSR PT2
	JSR PT2
	JSR PT2
	JSR PT2
	JSR PT2
	JSR PT2
	JSR PT2
	JSR PT2
	JSR PT2
	JSR PT2
	JSR PT2
	JSR PT2
	JSR PT2
	JSR PT2
	JSR PT2
	JSR PT2
	JSR PT2
	JSR PT2
	JSR PT2
	JSR PT2
	JSR PT2
	JSR PT2
	JSR PT2
	JSR PT2
	JSR PT2
	JSR PT2
	JSR PT2
	JSR PT2
	ADD.L #160*1,A0
	JSR PT2
	JSR PT2
	JSR PT2
	ADD.L #160*2,A0
	JSR PT2
	JSR PT2
	ADD.L #160*3,A0
	JSR PT2
	RTS
PT2	MOVE.W $00(A0),$00(A1)
	MOVE.W $08(A0),$08(A1)
	MOVE.W $10(A0),$10(A1)
	MOVE.W $18(A0),$18(A1)
	MOVE.W $20(A0),$20(A1)
	MOVE.W $28(A0),$28(A1)
	MOVE.W $30(A0),$30(A1)
	MOVE.W $38(A0),$38(A1)
	MOVE.W $40(A0),$40(A1)
	MOVE.W $48(A0),$48(A1)
	MOVE.W $50(A0),$50(A1)
	MOVE.W $58(A0),$58(A1)
	MOVE.W $60(A0),$60(A1)
	MOVE.W $68(A0),$68(A1)
	MOVE.W $70(A0),$70(A1)
	MOVE.W $78(A0),$78(A1)
	MOVE.W $80(A0),$80(A1)
	MOVE.W $88(A0),$88(A1)
	MOVE.W $90(A0),$90(A1)
	MOVE.W $98(A0),$98(A1)
	ADD.L #160,A0
	ADD.L #160,A1
	RTS
****************************************************************************
GAMES	
;	dc.b "0123456789012345678901234567890123456789",$D,$A
	dc.b "   Hello there and welcome to Lemmings  ",$D,$A
	dc.b "               Menu No. 1               ",$D,$A
	dc.b "                                        ",$D,$A
	dc.b "       Press the following keys:        ",$D,$A
	dc.b "       �������������������������        ",$D,$A
	dc.b "    1:Oh No! More Lemmings (Trained)    ",$D,$A
	dc.b "    2:Mercenary 3 - The Dion Crisis     ",$D,$A
	dc.b "    3:Entombed (An ST Format game!)     ",$D,$A
	dc.b "                                        ",$D,$A
	dc.b "          0:Toggle 50/60 Hertz          ",$D,$A
	dc.b "                                        ",$D,$A,$D,$A,0

****************************************************************************
TEXT	
	dc.b "   WELCOME TO THE LEMMINGS MENU NUMERO 1. WE BRING YOU NOT JUST ONE FANTASTIC SEQUEL BUT TWO (WITH A DECENT DISK FILLER AS WELL). THE SEQUELS ARE OH NO! MORE LEMMINGS (CRACKED AND TRAINED BY FACTORY) AND MERCENARY III (DON'T KNOW WHO DID"
	dc.b " THIS ONE BUT IT'S STILL VERY GOOD). THE DISK FILLER WAS TAKEN OFF AN ST FORMAT COVER DISK. IT'S A PRETTY GOOD GAME CONSIDERING ITS SIZE BUT IT'S VERY DIFFICULT.     LEMMINGS DOES NOT NEED THE ORIGINAL GAME TO PLAY IT - IT IS THE"
	dc.b " STANDALONE VERSION. I ADVISE AGAINST USING THE TRAINER, AS IT MAKES THE GAME PRETTY UNPLAYABLE. EVEN SO, THE LATER LEVELS ARE STILL WELL 'ARD.      ANYWAY, LESS OF THE GAMES INFO. LET'S GET ONTO THIS WEEK'S NEWS. THE HEADLINES......"
	dc.b "         PADDY PANTSDOWN.....       WHAT A NICE THING TO READ AT 7 O' CLOCK ON A WEDNESDAY MORNING. I HAVE TO ADMIT, I NEARLY DIED LAUGHING. SOME TORY GOES AND NICKS OFF WITH SOME CONFIDENTIAL MATERIAL FROM A SOLICITOR'S, AND WHAT FOR?"
	dc.b "          TO GET RID OF THE WORST OPPOSITION FOR THE COMING GENERAL ELECTION. WHAT A DAFT IDEA! AT LEAST THEY COULD HAVE TRIED TO GET SOMETHING AGAINST NEIL KINNOCK INSTEAD. OOPS! SORRY, THE SUNDAY TIMES THIS MORNING SAYS THEY HAVE JUST"
	dc.b " DONE THAT......    WELL I NEVER. WHAT IS THE WORLD COMING TO? WILL THE TORIES GET INTO POWER AGAIN?  WE'LL HAVE TO WAIT UNTIL THURSDAY APRIL 9TH....       I FEEL A SUDDEN URGE COMING ON.....  OH NO, IT'S TAKING OVER.....  THE GREETINGS"
	dc.b " ARE COMING.....  HERE THEY ARE.....  SECRET MESONIC HANDSHAKES AND SLEAZY WINKS GO OUT TO THE FOLLOWING.....     HYSTERIA (ESPECIALLY NEUROMANCER - CAN'T WAIT FOR YOUR NEW DEMO AND GAME!), ADRENALIN (ESPECIALLY PONY - GOOD LUCK WITH YOUR"
	dc.b " EXAMS), THE WILD BOYS (ESPECIALLY SNAZ), INSANITY (ESPECIALLY ICEMAN - NICE TO SEE YOU'RE SLAGGING OFF THE NOW DEAD EVOLUTION!!), SYNCRO SYSTEMS (ESP. STICK - NICE TO SEE YOU'RE GETTING GAMES QUICKER), THE MUTANT (HOW'S THE CODING GOING?),"
	dc.b " CYNIX (ESPECIALLY SKYWALKER - NICE CRACKS), GENESIS INC. (ESPECIALLY GOR - NOTER 2 IS GREAT, PARTICULARLY THE STUFF WITH IT), ELECTRONIC IMAGES (WHEN'S THE NEW GENETIX DEMO COMING OUT?) AND ALL MY OTHER CONTACTS AND MATES IN THE SIXTH"
	dc.b " FORM....... CREDITS FOR THIS MENU ARE AS FOLLOWS:     CODING - FM OF THE STORMMASTERS     GRAFIX - THE SORCEROR     MUSIC - MAD MAX     COMPILATION - INFO FREAKO     " 
	dc.b " TIME TO WRAP NOW....... BYEEEEEE.......                    ",0
	even

****************************************************************************

BASE
BASE1	EQU BASE+(((WID1*8)*HT)*16)

PIC	INCBIN "menu1.PI1"

PIC1	INCBIN "LOGO.PI1"
