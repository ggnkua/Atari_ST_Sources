                           
                                THE LEMMINGS         
                                   present         
                                 DOC FILE #1       
                           
                            Docs in this file are: 
                           
                            1:Oh No! More Lemmings 
                            2:Mercenary III                         
                            3:Entombed             
                           

 

                              OH NO! MORE LEMMINGS
                              ====================

 The Game:
 ~~~~~~~~~

 Lemmings is an intriguing one or two player game in which you help hordes of
 otherwise-mindless  rodents  -  known  as  WALKERS - escape over 100 hostile
 environments.

 Lemmings  drop through a trapdoor onto each screen and, as they're creatures
 of  very  little  brain,  they need all the help they can get to survive the
 dangers thereon.

 To  assist  these cuddly, yet suicidally stupid creatures you use your mouse
 (similar  to  a  Lemming but it has more buttons) to select a skill from the
 panel  of icons at the base of the screen.  Once highlighted you then choose
 a  suitable  Lemming, from the throng on screen, to perform that skill.  You
 have a strict time limit in which to get a required percentage of the little
 perishers through each level.

 A  quick brain, the ability to plan ahead and a lifetime's dedication to the
 SAVE  A  LEMMING  CAMPAIGN  are  what's required to get the right Lemming to
 perform  the  right  action  at  the  right  time.   A  forgotten Blocker or
 misplaced bridge could spell disaster for every Lemming on screen.


 Icons (from left to right):
 ~~~~~~~~~~~~~~~~~~~~~~~~~~~

  1: Decrease flow of Lemmings onto the level.

  2: Increase flow of Lemmings onto the level.

  3: Climber.

  4: Parachutist.

  5: Bomb to dispatch single Lemmings (One way to get rid of blockers).

  6: Blocker.

  7: Bridge Builder - each limited to twelve bricks.

  8: Horizontal Digger.

  9: Diagonal Digger.

 10: Verticle Digger.

 11: Pause.

 12: Nuke 'Em destroys all Lemmings - should you find yourself in a 'no-win'
    situation (double click to activate).



 * The green display to the right of the icons depicts the whole level.

 * The square cursor on that display depicts the current area shown on-screen
  (this cursor may be used for fast scrolling across levels).

 Each trait may only be used a limited number of times (shown above icon).

 * (one-player mode only)

 Directly  above  the  icon  panel  are (left to right):  Lemming identifier,
 Number  of  Lemmings  currently  occupying the level, % of rescued Lemmings,
 Time remaining to complete level.

 In  two-player  mode  the  screen  splits.   The  left  player controls blue
 Lemmings  the  right,  green.  Each player competes to get as many of his 40
 Lemmings (plus some of his opponent's) safely to the exit.

 Both players have to click on Nuke for Lemming Armageddon to take place.


 Controls:
 ~~~~~~~~~

 Mouse (In two player game 1up uses mouse, 2up uses joystick).

 Point  and  click  on  chosen icon to highlight it - if required - point and
 click on selected Lemming.

 Pushing mouse left or right to screen edge scrolls the play area.

 Holding the right mouse button allows you to select only Lemmings that are
  not WALKERS.

 Each level displays an access password when completed.

 

                      MERCENARY III - THE DION CRISIS
                      ===============================

 Controls:
 ~~~~~~~~~

 In elevators - B : Basement
                G : Ground
                1 : First Floor
                2 : Second Floor
                etc.

 Craft - B : Board
         L : Leave
         1-0 : Throttle (if applicable)
         F1-F10 : Reverse throttle
          : Fine tune throttle decrease
          : Fine tune throttle increase
 
 Walking - R : Run
           W : Walk

 Objects -  : Get object
            : Drop object

 Other controls will be explained in the game. I'm sorry that these docs are so
 short, but I don't exactly know much about the game. I do know that you have
 to get rid of the current president P C Bil, however. I think this may involve
 either killing him or trying to be elected yourself. Anyway, sorry I can't say
 anymore. Try reading some reviews in magazines to find out more.

 

                                  ENTOMBED
                                  ========

 The Scenario:
 ~~~~~~~~~~~~~

 Being a master tomb builder gave Ya Salam many benefits - his own chariot
 space at the quarry, immortalization after death, a mummified crocodile for
 the kitchen (return within 28 days if not completely satisfied) - but it had
 one slight disadvantage, namely Ya Salam had to test the traps and pitfalls
 in the tombs he made!
    Phew! That wasn't too difficult. Nobody gives a prickly pear about these
 scenarios anyway. Having said that, I do have this thirty page novella... No?
 Oh well, please yourselves.


 The Game:
 ~~~~~~~~~

 'Entombed' consists of five levels of platform fun so cunning you could dice
 carrots with them. When the game loads it goes into a title sequence thingy
 and will happily stay there forever unless you press the fire button on a
 joystick in port 1. This will put you on the level select screen. You can
 play the first four levels in any order you like - or any order you dislike
 - but all four must be completed before you can try level five. To select a
 level use the joystick to move Ya to the level you want to try, then press
 fire.
    The tombs contain nasty things, like spikes, fire, and boiling water (or
 it could be sparkling Perrier, it's hard to tell). There are also useful
 objects to collect, such as a bow, arrows, keys, and hourglasses. The latter
 are needed to delay changes in the layout of the tombs. You can tell part of
 the tomb is about to change when it starts to flicker, allowing you to see
 what it will change into. While it's flickering it behaves like what it was
 before it started to flicker, so don't walk into a set of flickering spikes
 thinking it's safe.
    Still with me? Never mind, you'll pick it up as you go along - rather like
 a vacuum cleaner.
    Your objective on each level is simply to find the exit, which is a little
 doorway with a sunset visible through it, and very nice it is too.


 The Controls:
 ~~~~~~~~~~~~~

 Joystick:

    Up - Jump or climb up ladder.

    Down - Climb down ladder.

    Left - Walk left.

    Right - Work it out for yourself.

    Fire - Fire an arrow. You can only do this if you've got a bow and some
              arrows. You can fire while jumping or falling if that's what
              you're into, but if you get a kick out of shooting from a ladder
              you'll find no joy in this game.

 Keyboard:

    'P' - Pause game. Any other key to resume.

    '0' to '9', main keyboard - these allow you to use some of that delay time
              obtained by collecting hourglasses. The keys '1' to '9' give you
              a delay of 1 to 9 seconds, and pressing '0' gives a delay of 10
              seconds, assuming you've collected that much time. If part of the
              tomb has already started to flicker when you use the delay it
              will continue to flicker until the delay time runs out. Lawks!
              Isn't it hard putting this into words? Just play the game, you'll
              soon get the hang of it.

    All other keys - I don't think any of these do anything. They aren't meant
              to do anything, put it that way.


 The Display:
 ~~~~~~~~~~~~

 This consists of a full-screen 8 way scrolling thingy with a tidgy line of
 info at the bottom. From left to right the info line shows: lives remaining,
 score, bows collected, arrows remaining, keys collected,and the two digits at
 the rightmost end are the number of seconds of delay time remaining.


 The Bank - Filling The Machine:
 ~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~

 No, I don't think we want this. If I was that lad I'd grab the dosh and run
 off to Spain with that girl.


 The Last Word:
 ~~~~~~~~~~~~~~

 Well, that's all the explaining done. If you're still not clear on how
 something works just try waggling the joystick a lot and pressing the fire
 button in frustration, that usually does the trick. Do NOT try pulling your
 eyelid right down and blowing your nose, as suggested in the advert, because
 if you do your eyeball will pop out.

 
