a1_font	incbin	"\fonts\a1_mac.fon"
	even

a2_font	incbin	"\fonts\a2_roman.fon"
	even

*a3_font	incbin	"\fonts\a3_chic.fon"
*	even

a1_ptr	dc.l	1
a2_ptr	dc.l	1
*a3_ptr	dc.l	1