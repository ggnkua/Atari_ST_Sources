************************************************************************
**************************  sound  *************************************
L0069:	LEA	L00B5(PC),A0
	BSR.S   L006B 
	TST.W   D0
	BNE.S   L006A 
	MOVEQ   #1,D0 
L006A:	MOVE.L	L00B3(PC),A1
	ANDI.W  #$FF,D0 
	SUBQ.W  #1,D0 
	MULU	  #6,D0 
	ADD.W  D0,A1 
	MOVE.W  (A1)+,D0
	MOVE.W  (A1)+,D1
	LEA	  L00A5(PC),A6
	MOVE.W  (A1),(A6)+
	MOVE.W  (A1)+,(A6)+ 
	BSR	  L009D 
	RTS 
L006B:MOVE.W  L00B4(PC),D7
	BNE.S   L006C 
	MOVEQ   #0,D7 
	LEA	  L00AA(PC),A6
	MOVE.W  12(A0),(A6) 
	LEA	  32(A0),A1 
	LEA	  L00AC(PC),A6
	MOVE.L  A1,(A6) 
	MOVE.W  4(A0),D7
	ADDQ.W  #1,D7 
	ASL.W   #6,D7 
	ADD.L  D7,A1 
	LEA	  L00AD(PC),A6
	MOVE.L  A1,(A6) 
	MOVE.W  6(A0),D7
	ADDQ.W  #1,D7 
	ASL.W   #6,D7 
	ADD.L  D7,A1 
	LEA	  L00AB(PC),A6
	MOVE.L  A1,(A6) 
	MOVE.W  8(A0),D7
	ADDQ.W  #1,D7 
	MOVE.W  12(A0),D6 
	MULU	  D6,D7 
	ADD.L  D7,A1 
	LEA	  L00AE(PC),A6
	MOVE.L  A1,(A6) 
	MOVEQ   #0,D7 
	MOVE.W  10(A0),D7 
	ADDQ.W  #1,D7 
	MULU	  #$C,D7
	ADD.L  D7,A1 
	LEA	  L00B3(PC),A6
	MOVE.L  A1,(A6)+
	MOVE.W  16(A0),D7 
	ADDQ.W  #1,D7 
	MULU	  #6,D7 
	ADD.W  D7,A1 
	MOVE.L  A1,(A6)+
	LEA	  L00B4(PC),A6
	MOVE.W  #1,(A6) 
	LEA	  L00B1(PC),A6
	MOVE.W  #2,(A6) 
L006C:RTS 
L006D:LEA		L00A3(PC),A6
	LEA	  L00A5(PC),A0
	TST.W   4(A0) 
	BEQ.S   L006E 
	CLR.B   34(A6)
	CLR.B   38(A6)
	CLR.B   42(A6)
	MOVEM.L (A6),A0-A2/D0-D7
	MOVEM.L A0-A2/D0-D7,-$7800.W
	RTS 
L006E:SUBQ.W  #1,(A0) 
	BNE.S   L006F 
	MOVE.W  2(A0),(A0)
	LEA	  L00A6(PC),A0
	BSR	  L0072 
	LEA	  L00A7(PC),A0
	BSR	  L0072 
	LEA	  L00A8(PC),A0
	BSR	  L0072 
L006F:LEA		L00AF(PC),A5
	LEA	  L00A6(PC),A0
	BSR	  L0079 
	MOVE.W  D0,2(A5)
	MOVE.B  3(A5),2(A6) 
	MOVE.B  2(A5),6(A6) 
	MOVE.B  D1,34(A6) 
	LEA	  L00A7(PC),A0
	BSR	  L0079 
	MOVE.W  D0,2(A5)
	MOVE.B  3(A5),10(A6)
	MOVE.B  2(A5),14(A6)
	MOVE.B  D1,38(A6) 
	LEA	  L00A8(PC),A0
	BSR	  L0079 
	MOVE.W  D0,2(A5)
	MOVE.B  3(A5),18(A6)
	MOVE.B  2(A5),22(A6)
	MOVE.B  D1,42(A6) 
	MOVE.W  4(A5),D0
	BEQ.S   L0071 
	MOVE.W  D0,-(A7)
	LEA	  L00A9(PC),A0
	BSR	  L0079 
	MOVE.L 10(A0),A1 
	ADD.L  14(A0),A1 
	CMPI.B  #-$1F,1(A1) 
	BNE.S   L0070 
	CLR.W   4(A5) 
L0070:MOVE.W  (A7)+,D7
	LEA	  L00A4(PC),A1
	ADD.W   D7,D7 
	ADD.W   D7,D7 
	ADD.W  D7,A1 
	MOVEQ   #0,D6 
	MOVE.B  (A1)+,D6
	MOVE.W  D0,2(A5)
	MOVE.B  D0,0(A6,D6.W) 
	MOVE.B  (A1)+,D6
	MOVE.B  2(A5),0(A6,D6.W)
	MOVE.B  (A1)+,D6
	MOVE.B  D1,0(A6,D6.W) 
L0071:MOVE.B  (A5)+,D7
	ORI.B   #-$40,D7
	MOVE.B  D7,30(A6) 
	MOVE.B  (A5)+,26(A6)
	MOVEM.L (A6),A0-A2/D0-D7
	MOVEM.L A0-A2/D0-D7,-$7800.W
	RTS 
L0072:MOVEQ   #0,D5 
	MOVEQ   #6,D6 
	MOVE.W  L00AA(PC),D7
	MOVE.L 34(A0),A1 
	ADD.L  38(A0),A1 
	MOVE.B  (A1),D0 
	ANDI.W  #$7F,D0 
	CMPI.W  #1,D0 
	BEQ.S   L0073 
	CMP.W   40(A0),D7 
	BNE.S   L0076 
L0073:MOVE.L 52(A0),A3 
	MOVE.L (A0),A2 
	ADD.L  4(A0),A2
	CMPA.L  A3,A2 
	BNE.S   L0074 
	MOVE.L  D5,4(A0)
	MOVE.L (A0),A2 
L0074:MOVEQ   #0,D1 
	MOVE.B  (A2),D1 
	MOVE.B  1(A2),44(A0)
	MOVE.B  2(A2),22(A0)
	MOVE.B  3(A2),D2
	ANDI.W  #$F0,D2 
	CMPI.W  #$F0,D2 
	BNE.S   L0075 
	MOVE.B  3(A2),D2
	ANDI.B  #$F,D2
	MOVE.B  D2,60(A0) 
L0075:MOVE.L  D5,38(A0) 
	MULU	  D7,D1 
	MOVE.L L00AB(PC),A3
	ADD.L  D1,A3 
	MOVE.L  A3,34(A0) 
	ADDI.L  #$C,4(A0) 
	MOVE.L 34(A0),A1 
	ADD.L  38(A0),A1 
L0076:MOVE.B  (A1)+,D0
	MOVE.B  D0,D1 
	ANDI.W  #$7F,D1 
	TST.W   D1
	BEQ.S   L0078 
	MOVE.L  D5,56(A0) 
	MOVE.B  D1,8(A0)
	MOVE.L A1,A3 
	TST.L   38(A0)
	BNE.S   L0077 
	ADD.W  D7,A3 
L0077:MOVE.B  -2(A3),31(A0) 
	MOVE.B  (A1),9(A0)
	TST.B   D0
	BMI.S   L0078 
	MOVE.B  (A1),D1 
	ANDI.W  #$1F,D1 
	ADD.B   22(A0),D1 
	MOVE.L L00AD(PC),A2
	ASL.W   D6,D1 
	ADD.W  D1,A2 
	MOVE.L  D5,14(A0) 
	MOVE.B  (A2),23(A0) 
	MOVE.B  (A2)+,24(A0)
	MOVE.B  (A2)+,D1
	ANDI.W  #$FF,D1 
	MOVE.B  (A2)+,27(A0)
	MOVEQ   #0,D0 
	MOVE.B  #$40,46(A0) 
	MOVE.B  (A2)+,D0
	MOVE.B  D0,28(A0) 
	MOVE.B  D0,29(A0) 
	MOVE.B  (A2)+,30(A0)
	MOVE.L  A2,10(A0) 
	MOVE.L L00AC(PC),A2
	ASL.W   D6,D1 
	ADD.W  D1,A2 
	MOVE.L  A2,18(A0) 
	MOVE.L  D5,48(A0) 
	MOVE.B  D5,26(A0) 
	MOVE.B  D5,25(A0) 
L0078:ADDQ.L  #2,38(A0) 
	RTS 
L0079:MOVEQ   #0,D7 
	MOVE.B  D7,32(A0) 
L007A:TST.B   26(A0)
	BEQ.S   L007B 
	SUBQ.B  #1,26(A0) 
	BRA	  L0086 
L007B:MOVE.L 18(A0),A1 
	ADD.L  48(A0),A1 
L007C:CMPI.B  #-$1F,(A1)
	BEQ	  L0086 
	CMPI.B  #-$20,(A1)
	BNE.S   L007D 
	MOVE.B  1(A1),D0
	ANDI.L  #$3F,D0 
	MOVE.L  D0,48(A0) 
	MOVE.L 18(A0),A1 
	ADD.L  D0,A1 
L007D:CMPI.B  #-$1E,(A1)
	BNE.S   L007E 
	CLR.L   14(A0)
	MOVE.B  #1,23(A0) 
	ADDQ.L  #1,48(A0) 
	BRA.S   L007B 
L007E:CMPI.B  #-$17,(A1)
	BNE.S   L007F 
	MOVE.B  #$B,-$77B4.W
	MOVE.B  1(A1),-$77AE.W
	MOVE.B  #$C,-$779C.W
	CLR.B   -$778E.W
	MOVE.B  #$D,-$7754.W
	MOVE.B  #$A,-$7752.W
	ADDQ.L  #2,48(A0) 
	BRA.S   L007B 
L007F:CMPI.B  #-$19,(A1)
	BNE.S   L0080 
	MOVE.B  1(A1),D0
	ANDI.W  #$FF,D0 
	ASL.W   #6,D0 
	MOVE.L L00AC(PC),A1
	ADD.W  D0,A1 
	MOVE.L  A1,18(A0) 
	MOVE.L  D7,48(A0) 
	BRA	  L007C 
L0080:CMPI.B  #-$18,(A1)
	BNE.S   L0081 
	MOVE.B  1(A1),26(A0)
	ADDQ.L  #2,48(A0) 
	BRA	  L007A 
L0081:CMPI.B  #-$1C,(A1)
	BNE.S   L0082 
	MOVE.B  D7,42(A0) 
	MOVE.B  1(A1),32(A0)
	ADDQ.L  #2,48(A0) 
	BRA.S   L0085 
L0082:CMPI.B  #-$1B,(A1)
	BNE.S   L0083 
	MOVE.B  #1,42(A0) 
	ADDQ.L  #1,48(A0) 
	BRA	  L007A 
L0083:CMPI.B  #-$1A,(A1)
	BNE.S   L0084 
	MOVE.B  #2,42(A0) 
	ADDQ.L  #1,48(A0) 
	BRA.S   L0085 
L0084:CMPI.B  #-$1D,(A1)
	BNE.S   L0085 
	ADDQ.L  #3,48(A0) 
	MOVE.B  1(A1),27(A0)
	MOVE.B  2(A1),28(A0)
L0085:MOVE.L 18(A0),A1 
	ADD.L  48(A0),A1 
	MOVE.B  (A1),43(A0) 
	ADDQ.L  #1,48(A0) 
L0086:TST.B   25(A0)
	BEQ.S   L0087 
	SUBQ.B  #1,25(A0) 
	BRA.S   L008B 
L0087:SUBQ.B  #1,23(A0) 
	BNE.S   L008B 
	MOVE.B  24(A0),23(A0) 
L0088:MOVE.L 10(A0),A1 
	ADD.L  14(A0),A1 
	MOVE.B  (A1),D0 
	CMPI.B  #-$18,D0
	BNE.S   L0089 
	ADDQ.L  #2,14(A0) 
	MOVE.B  1(A1),25(A0)
	BRA.S   L0086 
L0089:CMPI.B  #-$1F,D0
	BEQ.S   L008B 
	CMPI.B  #-$20,D0
	BNE.S   L008A 
	MOVE.B  1(A1),D0
	ANDI.L  #$3F,D0 
	SUBQ.L  #5,D0 
	MOVE.L  D0,14(A0) 
	BRA.S   L0088 
L008A:MOVE.B  (A1),45(A0) 
	ADDQ.L  #1,14(A0) 
L008B:MOVE.B  43(A0),D0 
	BMI.S   L008C 
	ADD.B   8(A0),D0
	ADD.B   44(A0),D0 
L008C:ANDI.W  #$7F,D0 
	LEA	  L00B2(PC),A1
	ADD.W   D0,D0 
	MOVE.W  D0,D1 
	ADD.W  D0,A1 
	MOVE.W  (A1),D0 
	MOVE.B  33(A0),D3 
	MOVE.B  42(A0),D2 
	ANDI.L  #$F,D2
	BNE.S   L008D 
	BCLR	  D3,(A5) 
	ADDQ.W  #3,D3 
	BCLR	  D3,(A5) 
	BRA.S   L0090 
L008D:CMPI.B  #1,D2 
	BNE.S   L008F 
	BSET	  D3,(A5) 
	ADDQ.W  #3,D3 
	BCLR	  D3,(A5) 
	MOVE.B  8(A0),32(A0)
	MOVE.B  43(A0),D4 
	BPL.S   L008E 
	ANDI.B  #$7F,D4 
	MOVE.B  D4,32(A0) 
	BRA.S   L0090 
L008E:ADD.B   D4,32(A0) 
	BRA.S   L0090 
L008F:BCLR	  D3,(A5) 
	ADDQ.W  #3,D3 
	BSET	  D3,(A5) 
L0090:TST.B   32(A0)
	BEQ.S   L0091 
	MOVE.B  32(A0),D3 
	ANDI.B  #$1F,D3 
	EORI.B  #$1F,D3 
	MOVE.B  D3,1(A5)
L0091:MOVE.B  46(A0),D7 
	TST.B   30(A0)
	BEQ.S   L0092 
	SUBQ.B  #1,30(A0) 
	BRA.S   L009A 
L0092:MOVE.B  D1,D5 
	MOVE.B  28(A0),D4 
	ADD.B   D4,D4 
	MOVE.B  29(A0),D1 
	TST.B   D7
	BPL.S   L0093 
	BTST	  #0,D7 
	BNE.S   L0096 
L0093:BTST	  #5,D7 
	BNE.S   L0094 
	SUB.B   27(A0),D1 
	BCC.S   L0095 
	BSET	  #5,D7 
	MOVEQ   #0,D1 
	BRA.S   L0095 
L0094:ADD.B   27(A0),D1 
	CMP.B   D4,D1 
	BCS.S   L0095 
	BCLR	  #5,D7 
	MOVE.B  D4,D1 
L0095:MOVE.B  D1,29(A0) 
L0096:LSR.B   #1,D4 
	SUB.B   D4,D1 
	BCC.S   L0097 
	SUBI.W  #$100,D1
L0097:ADDI.B  #-$60,D5
	BCS.S   L0099 
L0098:ADD.W   D1,D1 
	ADDI.B  #$18,D5 
	BCC.S   L0098 
L0099:ADD.W   D1,D0 
L009A:EORI.B  #1,D7 
	MOVE.B  D7,46(A0) 
	BTST	  #5,9(A0)
	BEQ.S   L009B 
	MOVEQ   #0,D7 
	MOVE.W  D7,D1 
	MOVE.B  31(A0),D1 
	EXT.W   D1
	MOVE.L  56(A0),D2 
	MOVEQ   #$C,D3
	ASL.L   D3,D1 
	ADD.L   D1,D2 
	MOVE.L  D2,56(A0) 
	SWAP	  D2
	SUB.W   D2,D0 
L009B:MOVE.B  45(A0),D1 
	SUB.B   60(A0),D1 
	BPL.S   L009C 
	MOVEQ   #0,D1 
L009C:RTS 
L009D:MOVE.W  D0,D7 
	MULU	  #$C,D7
	MOVE.W  D1,D6 
	ADDQ.W  #1,D6 
	MULU	  #$C,D6
	MOVEQ   #2,D0 
	LEA	  L00A6(PC),A0
	LEA	  L00A1(PC),A1
	LEA	  L00A2(PC),A2
L009E:MOVE.L  A1,10(A0) 
	CLR.L   14(A0)
	MOVE.B  #0,45(A0) 
	CLR.B   8(A0) 
	CLR.B   9(A0) 
	MOVE.L  A1,18(A0) 
	CLR.L   48(A0)
	LEA	  23(A0),A3 
	MOVE.B  #1,(A3)+
	MOVE.B  #1,(A3)+
	CLR.B   (A3)+ 
	CLR.B   (A3)+ 
	CLR.B   (A3)+ 
	CLR.B   (A3)+ 
	CLR.B   (A3)+ 
	CLR.W   (A3)+ 
	CLR.B   (A3)+ 
	MOVE.B  (A2),D3 
	ANDI.L  #$F,D3
	ADD.W   D3,D3 
	ADD.W   D3,D3 
	MOVE.B  (A2)+,(A3)
	MOVE.L  L00AE(PC),(A0)
	MOVE.L  L00AE(PC),52(A0)
	ADD.L   D6,52(A0) 
	ADD.L   D3,52(A0) 
	ADD.L   D7,(A0) 
	ADD.L   D3,(A0) 
	MOVE.L  #$C,4(A0) 
	MOVE.L (A0),A3 
	MOVE.B  (A3),D1 
	ANDI.W  #$FF,D1 
	MOVE.W  L00AA(PC),D2
	MULU	  D1,D2 
	MOVE.L L00AB(PC),A4
	ADD.L  D2,A4 
	MOVE.L  A4,34(A0) 
	CLR.L   38(A0)
	MOVE.B  #2,42(A0) 
	MOVE.B  1(A3),44(A0)
	CLR.B   43(A0)
	MOVE.B  2(A3),22(A0)
	CLR.B   60(A0)
	MOVE.B  3(A3),D1
	ANDI.W  #$F0,D1 
	CMPI.W  #$F0,D1 
	BNE.S   L009F 
	MOVE.B  3(A3),D1
	ANDI.B  #$F,D1
	MOVE.B  D1,60(A0) 
L009F:CLR.B   45(A0)
	CLR.W   56(A0)
	LEA	  62(A0),A0 
	DBF	  D0,L009E
	LEA	  L00A5(PC),A0
	MOVE.W  2(A0),(A0)
	CLR.W   4(A0) 
	RTS 
	MOVE.W  L00B0(PC),D2
	MOVE.W  L00B1(PC),D1
	TST.W   D2
	BEQ.S   L00A0 
	LEA	  L00A9(PC),A0
	LEA	  L00AF(PC),A5
	MOVE.B  D2,8(A0)
	MOVE.B  D1,33(A0) 
	CLR.B   22(A0)
	MOVEQ   #6,D6 
	MOVEQ   #0,D5 
	ANDI.W  #$1F,D0 
	MOVE.L L00AD(PC),A2
	ASL.W   D6,D0 
	ADD.W  D0,A2 
	MOVE.L  D5,14(A0) 
	MOVE.B  (A2),23(A0) 
	MOVE.B  (A2)+,24(A0)
	MOVE.B  (A2)+,D0
	ANDI.W  #$FF,D0 
	MOVE.B  (A2)+,27(A0)
	MOVEQ   #0,D2 
	MOVE.B  #$40,46(A0) 
	MOVE.B  (A2)+,D2
	MOVE.B  D2,28(A0) 
	MOVE.B  D2,29(A0) 
	MOVE.B  (A2)+,30(A0)
	MOVE.L  A2,10(A0) 
	MOVE.L L00AC(PC),A2
	ASL.W   D6,D0 
	ADD.W  D0,A2 
	MOVE.L  A2,18(A0) 
	MOVE.L  D5,48(A0) 
	CLR.B   25(A0)
	CLR.B   26(A0)
	ADDQ.W  #1,D1 
	MOVE.W  D1,4(A5)
L00A0:RTS 
L00A1:DC.B	 $01,$00,$00,$00,$00,$00,$00,$E1
L00A2:DC.B	 $00,$01,$02,$00
L00A3:  ds.w 2
	DC.B	 $01,$01,$00,$00,$02,$02,$00,$00
	DC.B	 $03,$03,$00,$00,$04,$04,$00,$00
	DC.B	 $05,$05,$00,$00,$06,$06,$00,$00
	DC.B	 $07,$07,$FF,$FF,$08,$08,$00,$00
	DC.B	 $09,$09,$00,$00,$0A,$0A,$00,$00
L00A4:  ds.w 2
	DC.B	 $02,$06,'"',$00,$0A,$0E,'&',$00
	DC.B	 $12,$16,'*',$00
L00A5:DC.B	 $00,$04,$00,$04,$00,$00
L00A6:ds.W    31
L00A7:ds.W    31
L00A8:ds.W    31
L00A9:ds.W    31
L00AA:DC.B	 $00,'@',$00,$00
L00AB:ds.W    2 
L00AC:ds.W    2 
L00AD:ds.W    2 
L00AE:ds.W    2 
L00AF:ds.W    3 
L00B0:ds.W    1 
L00B1:ds.W    1 
L00B2:DC.B	 $0E,$EE,$0E,$17,$0D,'M',$0C,$8E
	DC.B	 $0B,$D9,$0B,'/',$0A,$8E,$09,$F7
	DC.B	 $09,'g',$08,$E0,$08,'a',$07,$E8
	DC.B	 $07,'w',$07,$0B,$06,$A6,$06,'G'
	DC.B	 $05,$EC,$05,$97,$05,'G',$04,$FB
	DC.B	 $04,$B3,$04,'p',$04,'0',$03,$F4
	DC.B	 $03,$BB,$03,$85,$03,'S',$03,'#'
	DC.B	 $02,$F6,$02,$CB,$02,$A3,$02,'}'
	DC.B	 $02,'Y',$02,'8',$02,$18,$01,$FA
	DC.B	 $01,$DD,$01,$C2,$01,$A9,$01,$91
	DC.B	 $01,'{',$01,'e',$01,'Q',$01,'>'
	DC.B	 $01,',',$01,$1C,$01,$0C,$00,$FD
	DC.B	 $00,$EE,$00,$E1,$00,$D4,$00,$C8
	DC.B	 $00,$BD,$00,$B2,$00,$A8,$00,$9F
	DC.B	 $00,$96,$00,$8E,$00,$86,$00,'~'
	DC.B	 $00,'w',$00,'p',$00,'j',$00,'d'
	DC.B	 $00,'^',$00,'Y',$00,'T',$00,'O'
	DC.B	 $00,'K',$00,'G',$00,'C',$00,'?'
	DC.B	 $00,';',$00,'8',$00,'5',$00,'2'
	DC.B	 $00,'/',$00,',',$00,'*',$00,$27
	DC.B	 $00,'%',$00,'#',$00,'!',$00,$1F
	DC.B	 $00,$1D,$00,$1C,$00,$1A,$00,$19
	DC.B	 $00,$17,$00,$16,$00,$15,$00,$13
	DC.B	 $00,$12,$00,$11,$00,$10,$00,$0F
L00B3: ds.W    8 
L00B4: ds.W    1 
L00B5:DC.B	 'TFMX',$00,$0B,$00,$0B 
	DC.B	 $00,'9',$00,$8F,$00,'@',$00,$03
	DC.B	 $00,$02,$00,$00,$00,$00,$00,$00
	ds.W    4 
	DC.B	 $E2,$E6,$00,$03,$07,$E0,$02,$00
	ds.W    28
	DC.B	 $E2,$E6,$00,$02,$05,$E0,$02,$00
	ds.W    28
	DC.B	 $E2,$E6,$00,$04,$07,$E0,$02,$00
	ds.W    28
	DC.B	 $E2,$E5,$9A,$E6,$0C,$00,$E1,$00
	ds.W    28
	DC.B	 $E2,$E4,$9D,$9E,$E6,$9E,$A0,$E5
	DC.B	 $9A,$93,$E1,$00,$00,$00,$00,$00
	ds.W    24
	DC.B	 $E2,$E6,$00,$00,$00,$E9,$06,$00
	DC.B	 $00,$E9,$05,$00,$00,$E9,$03,$00
	DC.B	 $00,$E9,$03,$00,$00,$E9,$05,$00
	DC.B	 $00,$E9,$06,$00,$00,$00,$E9,$0A
	DC.B	 $00,$E1,$00,$00,$00,$00,$00,$00
	ds.W    12
	DC.B	 $E2,$E6,$00,$E1,$00,$00,$00,$00
	ds.W    28
	DC.B	 $E2,$E6,$00,$05,$09,$0C,$E0,$02
	ds.W    28
	DC.B	 $E2,$E5,$95,$E6,$97,$94,$90,$E1
	ds.W    28
	DC.B	 $E2,$E6,$0C,$00,$E8,$0A,$00,$00
	DC.B	 $E3,$02,$05,$00,$00,$E3,$04,$07
	ds.W    1 
	DC.B	 $E3,$05,$08,$E1,$00,$00,$00,$00
	ds.W    19
	DC.B	 $E2,$E6,$00,$E8,$0F,$00,$E3,$02
	DC.B	 $04,$00,$E1,$00,$00,$00,$00,$00
	ds.W    24
	DC.B	 $E2,$E6,$00,$E1,$00,$00,$00,$00
	ds.W    28
	DC.B	 $01,$00,$00,$00,$00,$0F,$0F,$0E
	DC.B	 $0E,$0D,$0D,$0C,$0C,$0B,$0B,$0A
	DC.B	 $0A,$09,$09,$08,$07,$06,$05,$04
	DC.B	 $03,$02,$01,$00,$E1,$00,$00,$00
	ds.W    16
	DC.B	 $01,$01,$00,$00,$00,$0F,$0F,$0E
	DC.B	 $0E,$0D,$0D,$0C,$0C,$0B,$0B,$0A
	DC.B	 $0A,$09,$09,$08,$07,$06,$05,$04
	DC.B	 $03,$02,$01,$00,$E1,$00,$00,$00
	ds.W    16
	DC.B	 $01,$02,$00,$00,$00,$0F,$0F,$0E
	DC.B	 $0E,$0E,$0D,$0D,$0C,$0C,$0B,$0B
	DC.B	 $0A,$0A,$09,$09,$08,$07,$06,$05
	DC.B	 $04,$03,$02,$01,$00,$E1,$00,$00
	ds.W    16
	DC.B	 $01,$03,$01,$01,$00,$0D,$0F,$0F
	DC.B	 $0E,$0E,$0D,$0D,$0C,$0C,$0B,$0B
	DC.B	 $0A,$0A,$E1,$00,$00,$00,$00,$00
	ds.W    20
	DC.B	 $01,$04,$00,$00,$00,$0D,$0F,$0F
	DC.B	 $0E,$0D,$0C,$0B,$0A,$09,$08,$07
	DC.B	 $06,$05,$04,$03,$02,$01,$00,$E1
	ds.W    20
	DC.B	 $01,$05,$00,$00,$00,$10,$E1,$00
	ds.W    28
	DC.B	 $03,$06,$01,$02,$0F,$08,$08,$09
	DC.B	 $09,$09,$0A,$0A,$0B,$0C,$0C,$0C
	DC.B	 $0C,$0C,$0C,$0C,$0D,$0D,$0D,$0D
	DC.B	 $0D,$0E,$0E,$0E,$0E,$0E,$E1,$00
	ds.W    16
	DC.B	 $01,$07,$00,$00,$00,$0F,$0F,$0E
	DC.B	 $0E,$0D,$0D,$0C,$0C,$0B,$0B,$0A
	DC.B	 $0A,$09,$09,$08,$07,$06,$05,$04
	DC.B	 $03,$02,$01,$00,$E1,$00,$00,$00
	ds.W    16
	DC.B	 $01,$08,$00,$00,$00,$0D,$0F,$0F
	DC.B	 $0F,$0F,$0C,$0A,$00,$E1,$00,$00
	ds.W    24
	DC.B	 $03,$09,$01,$01,$0A,$0F,$0E,$0D
	DC.B	 $0C,$0B,$0A,$09,$08,$07,$06,$05
	DC.B	 $04,$03,$02,$01,$E1,$00,$00,$00
	ds.W    20
	DC.B	 $01,$0A,$01,$02,$0A,$0F,$0E,$E1
	ds.W    28
	DC.B	 $01,$0B,$01,$02,$00,$0F,$0E,$E1
	ds.W    60
	DC.B	 '-',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '-',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '-',$00,$00,$00,$00,$00,$00,$00
	ds.W    4 
	DC.B	 '-',$01,$00,$00,$00,$00,$00,$00
	DC.B	 '-',$01,$00,$00,$00,$00,$00,$00
	DC.B	 '-',$01,$00,$00,$00,$00,$00,$00
	DC.B	 '-',$00,$00,$00,$00,$00,$00,$00
	ds.W    4 
	DC.B	 '-',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '-',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '-',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '-',$01,$00,$00,$00,$00,$00,$00
	ds.W    4 
	DC.B	 '-',$01,$00,$00,$00,$00,$00,$00
	DC.B	 '-',$01,$00,$00,$00,$00,$00,$00
	DC.B	 ')',$02,$00,$00,$00,$00,$00,$00
	DC.B	 ')',$02,$00,$00,$00,$00,$00,$00
	DC.B	 ')',$02,$00,$00,$00,$00,$00,$00
	DC.B	 ')',$02,$00,$00,$00,$00,$00,$00
	DC.B	 ')',$01,$00,$00,$00,$00,$00,$00
	DC.B	 $00,$01,$00,$00,$00,$00,$00,$00
	DC.B	 ')',$01,$00,$00,$00,$00,$00,$00
	DC.B	 ')',$02,$00,$00,$00,$00,$00,$00
	ds.W    4 
	DC.B	 ')',$02,$00,$00,$00,$00,$00,$00
	DC.B	 ')',$02,$00,$00,$00,$00,$00,$00
	ds.W    4 
	DC.B	 ')',$01,$00,$00,$00,$00,$00,$00
	DC.B	 ')',$02,$00,$00,$00,$00,$00,$00
	ds.W    4 
	DC.B	 ')',$02,$00,$00,$00,$00,$00,$00
	DC.B	 $15,$00,$00,$00,$00,$00,$00,$00
	DC.B	 $15,$00,$00,$00,$15,$00,$00,$00
	DC.B	 '!',$01,$00,$00,$00,$00,$00,$00
	DC.B	 '!',$00,$00,$00,$00,$00,$00,$00
	DC.B	 $15,$00,$00,$00,$00,$00,$00,$00
	DC.B	 $15,$00,$00,$00,$15,$00,$00,$00
	DC.B	 '!',$01,$00,$00,$00,$00,$00,$00
	DC.B	 $15,$00,$00,$00,$00,$00,$00,$00
	ds.W    4 
	DC.B	 $15,$00,$00,$00,'!',$00,$00,$00
	DC.B	 '!',$01,$00,$00,$00,$00,$00,$00
	DC.B	 '!',$00,$00,$00,$00,$00,$00,$00
	DC.B	 $15,$00,$00,$00,$00,$00,$00,$00
	DC.B	 $15,$00,$00,$00,$15,$00,$00,$00
	DC.B	 '!',$01,$00,$00,$00,$00,$00,$00
	DC.B	 $13,$00,$00,$00,$13,$00,$00,$00
	DC.B	 '$',$00,$00,$00,$00,$00,$00,$00
	ds.W    28
	DC.B	 $18,' ',$00,$00,$00,$00,$00,$00
	ds.W    27
	DC.B	 $00,'$ ',$00,$00,$00,$00
	ds.W    28
	DC.B	 $00,$85,'0',$00,$00,$00,$00,$00
	ds.W    1 
	DC.B	 '0',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '0',$00,$00,$00,'0',$00,$00,$00
	ds.W    4 
	DC.B	 '0',$00,$00,$00,'0',$00,$00,$00
	ds.W    2 
	DC.B	 '0',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '0',$00,$00,$00,'0',$00,$00,$00
	ds.W    2 
	DC.B	 '3',$00,$00,$00,$00,$00,$00,$00
	ds.W    28
	DC.B	 '0',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '0',$00,$00,$00,'0',$00,$00,$00
	DC.B	 '0',$01,$00,$00,$00,$00,$00,$00
	DC.B	 '0',$01,$00,$00,'0',$00,$00,$00
	ds.W    2 
	DC.B	 '0',$00,$00,$00,'0',$00,$00,$00
	ds.W    2 
	DC.B	 '0',$01,$00,$00,$00,$00,$00,$00
	DC.B	 '0',$01,$00,$00,'0',$01,$00,$00
	DC.B	 $0C,$00,$00,$00,$0C,$00,$00,$00
	DC.B	 $18,$00,$00,$00,$0C,$00,$00,$00
	DC.B	 $0C,$01,$00,$00,$0C,$00,$00,$00
	DC.B	 $18,$00,$00,$00,$0C,$00,$00,$00
	DC.B	 $18,$00,$00,$00,$0C,$00,$00,$00
	DC.B	 $0C,$00,$00,$00,$18,$00,$00,$00
	DC.B	 $0C,$01,$00,$00,$0A,$00,$00,$00
	DC.B	 $16,$00,$00,$00,$0C,$00,$00,$00
	DC.B	 $0C,$00,$00,$00,$0C,$00,$00,$00
	DC.B	 $18,$00,$00,$00,$18,$00,$00,$00
	DC.B	 $0C,$01,$00,$00,$18,$00,$00,$00
	DC.B	 $0C,$00,$00,$00,$0C,$00,$00,$00
	DC.B	 $1A,$00,$00,$00,$0E,$00,$00,$00
	DC.B	 $0E,$00,$00,$00,$1A,$00,$00,$00
	DC.B	 $0C,$01,$00,$00,$1A,$00,$00,$00
	DC.B	 $0F,$00,$00,$00,$1C,$00,$00,$00
	DC.B	 ',',$02,$00,$00,$00,$00,$00,$00
	DC.B	 ',',$02,$00,$00,$00,$00,$00,$00
	DC.B	 ',',$02,$00,$00,',',$02,$00,$00
	ds.W    4 
	DC.B	 '.',$01,$00,$00,'.',$01,$00,$00
	ds.W    2 
	DC.B	 ')',$07,$00,$00,$00,$00,$00,$00
	ds.W    2 
	DC.B	 ')',$07,$00,$00,$00,$00,$00,$00
	DC.B	 $0C,$00,$00,$00,$00,$00,$00,$00
	DC.B	 $0C,$00,$00,$00,$00,$00,$00,$00
	DC.B	 $18,$00,$00,$00,$0C,$00,$00,$00
	DC.B	 $0A,$00,$00,$00,$0C,$00,$00,$00
	ds.W    2 
	DC.B	 $0C,$00,$00,$00,$00,$00,$00,$00
	DC.B	 $0C,$00,$00,$00,$18,$00,$00,$00
	DC.B	 $0C,$00,$00,$00,$0A,$00,$00,$00
	ds.W    2 
	DC.B	 $0C,$08,$00,$00,'0',$00,$00,$00
	ds.W    2 
	DC.B	 '0',$00,$00,$00,$0C,$04,$00,$00
	ds.W    2 
	DC.B	 '0',$00,$00,$00,'0',$00,$00,$00
	DC.B	 $0C,$08,$00,$00,'0',$00,$00,$00
	ds.W    2 
	DC.B	 '0',$00,$00,$00,$0C,$04,$00,$00
	ds.W    2 
	DC.B	 '0',$00,$00,$00,'0',$00,$00,$00
	DC.B	 $0C,$08,$00,$00,',',$02,$00,$00
	ds.W    2 
	DC.B	 ',',$02,$00,$00,$0C,$04,$00,$00
	ds.W    2 
	DC.B	 ',',$02,$00,$00,',',$02,$00,$00
	DC.B	 $0C,$08,$00,$00,',',$02,$00,$00
	ds.W    2 
	DC.B	 ',',$02,$00,$00,$0C,$04,$00,$00
	ds.W    2 
	DC.B	 ',',$02,$00,$00,',',$02,$00,$00
	DC.B	 $0C,$00,$00,$00,$00,$00,$00,$00
	DC.B	 $0C,$00,$00,$00,$00,$00,$00,$00
	DC.B	 $18,$00,$00,$00,$0C,$00,$00,$00
	DC.B	 $0A,$00,$00,$00,$0C,$00,$00,$00
	ds.W    2 
	DC.B	 $18,$00,$00,$00,$00,$00,$00,$00
	DC.B	 $16,$00,$00,$00,$00,$00,$00,$00
	DC.B	 $11,$00,$00,$00,$13,$00,$00,$00
	DC.B	 $16,$00,$00,$00,$0C,$00,$00,$00
	ds.W    2 
	DC.B	 $18,$00,$00,$00,$00,$00,$00,$00
	DC.B	 $13,$00,$00,$00,$00,$00,$00,$00
	DC.B	 $16,$00,$00,$00,$18,$00,$00,$00
	DC.B	 $0F,$00,$00,$00,$1B,$00,$00,$00
	DC.B	 $11,$00,$00,$00,$1D,$00,$00,$00
	DC.B	 $13,$00,$00,$00,$1F,$00,$00,$00
	DC.B	 $16,$00,$00,$00,'"',$00,$00,$00
	DC.B	 $0C,$00,$00,$00,$00,$00,$00,$00
	DC.B	 $0C,$00,$00,$00,$00,$00,$00,$00
	DC.B	 $18,$00,$00,$00,$0C,$00,$00,$00
	DC.B	 $11,$00,$00,$00,$13,$00,$00,$00
	ds.W    2 
	DC.B	 $16,$00,$00,$00,$00,$00,$00,$00
	DC.B	 $13,$00,$00,$00,$0C,$00,$00,$00
	DC.B	 $18,$00,$00,$00,$0C,$00,$00,$00
	DC.B	 $0C,$00,$00,$00,'0',$00,$00,$00
	ds.W    18
	DC.B	 '0',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '2',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '3',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '5 ',$00,$00,$00,$00,$00,$00 
	DC.B	 $B7,$00,$00,$00,$00,$00,$00,$00
	ds.W    12
	DC.B	 '5',$00,$00,$00,$00,$00,$00,$00
	ds.W    4 
	DC.B	 '3',$00,$00,$00,$00,$00,$00,$10
	DC.B	 '3',$00,$00,$00,$00,$00,$00,$00
	ds.W    16
	DC.B	 '2',$00,$00,$00,$00,$00,$00,$00
	ds.W    4 
	DC.B	 '0',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '4 ',$00,$00,$B5,$00,$00,$00 
	ds.W    16
	DC.B	 '5',$00,$00,$00,$00,$00,$00,' '
	DC.B	 '5 ',$00,$00,$B7,$00,$00,$00 
	ds.W    3 
	DC.B	 $00,' 8',$00,$00,$00,$00,$00 
	ds.W    17
	DC.B	 '7',$00,$00,$00,$00,$00,$00,$00
	ds.W    4 
	DC.B	 '5',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '6 ',$00,$00,$00,$00,$00,$00 
	ds.W    12
	DC.B	 $B7,$00,$00,$00,$00,$00,$00,$00
	ds.W    11
	DC.B	 $00,$03,'0',$00,$00,$00,$00,$00
	ds.W    17
	DC.B	 '+',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '.',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '0',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '0',$00,$00,$00,$00,$00,$00,$00
	ds.W    28
	DC.B	 '3',$00,$00,$00,$00,$00,$00,$00
	ds.W    16
	DC.B	 ',',$00,$00,$00,$00,$00,$00,$00
	ds.W    4 
	DC.B	 '.',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '?',$00,$00,$00,$00,$00,$00,$00
	ds.W    48
	DC.B	 '3',$00,$00,$00,$00,$00,$00,$00
	ds.W    4 
	DC.B	 '2',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '5',$00,$00,$00,$00,$00,$00,$00
	ds.W    16
	DC.B	 '5',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '3',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '2',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '0',$00,$00,$00,$00,$00,$00,$00
	ds.W    16
	DC.B	 '0',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '2',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '3',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '7',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '0',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '<',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '0',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '?',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '0',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '>',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '0',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '<',$00,$00,$00,$00,$00,$00,$00
	ds.W    48
	DC.B	 '<',$00,$00,$00,$00,$00,$00,$00
	DC.B	 ':',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '8',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '>',$00,$00,$00,$00,$00,$00,$00
	ds.W    16
	DC.B	 '<',$00,$00,$00,$00,$00,$00,$00
	DC.B	 ':',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '>',$00,$00,$00,$00,$00,$00,$00
	ds.W    4 
	DC.B	 '<',$00,$00,$00,$00,$00,$00,$00
	DC.B	 ':',$00,$00,$00,$00,$00,$00,$00
	ds.W    4 
	DC.B	 '>',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '<',$00,$00,$00,$00,$00,$00,$00
	DC.B	 ':',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '?',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '<',$00,$00,$00,$00,$00,$00,$00
	ds.W    48
	DC.B	 '<',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '?',$00,$00,$00,$00,$00,$00,$00
	DC.B	 'D',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '0',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '3',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '2',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '3',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '5',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '7',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '3',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '2',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '2',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '0',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '2',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '3',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '5',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '7',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '3',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '2',$00,$00,$00,$00,$00,$00,$00
	DC.B	 $09,$00,$00,$00,$00,$00,$00,$00
	ds.W    4 
	DC.B	 $0C,$01,$00,$00,$00,$00,$00,$00
	DC.B	 $07,$00,$00,$00,$00,$00,$00,$00
	ds.W    4 
	DC.B	 $09,$00,$00,$00,$00,$00,$00,$00
	DC.B	 $0C,$01,$00,$00,$00,$00,$00,$00
	DC.B	 $07,$00,$00,$00,$00,$00,$00,$00
	DC.B	 '-',$00,$00,$00,$00,$00,$00,$00
	ds.W    44
	DC.B	 '-',$00,$00,$00,$00,$00,$00,$00
	ds.W    4 
	DC.B	 '(',$00,$00,$00,$00,$00,$00,$00
	ds.W    4 
	DC.B	 '/ ',$00,$00,$00,$00,$00,$00 
	ds.W    12
	DC.B	 $B0,$00,$00,$00,$00,$00,$00,$00
	ds.W    11
	DC.B	 $00,$03,$00,$00,$00,$00,$00,$00
	ds.W    29
	DC.B	 '-',$00,$00,$00,$00,$00,$00,$00
	ds.W    44
	DC.B	 '4',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '4',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '7',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '9',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '9',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '9',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '4',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '7',$00,$00,$00,$00,$00,$00,$10
	DC.B	 '; ',$00,$00,$BC,$00,$00,$00 
	DC.B	 ';',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '7',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '9',$00,$00,$00,$00,$00,$00,$00
	ds.W    16
	DC.B	 '2',$00,$00,$00,$00,$00,$00,$00
	ds.W    4 
	DC.B	 '0',$00,$00,$00,$00,$00,$00,$00
	ds.W    4 
	DC.B	 '/',$00,$00,$00,$00,$00,$00,$00
	ds.W    32
	DC.B	 '9',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '4',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '7',$00,$00,$00,$00,$00,$00,$10
	DC.B	 '; ',$00,$00,$BC,$00,$00,$00 
	DC.B	 ';',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '7',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '9',$00,$00,$00,$00,$00,$00,$00
	ds.W    4 
	DC.B	 '9',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '4',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '7',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '<',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '>',$00,$00,$00,$00,$00,$00,$00
	DC.B	 '@',$00,$00,$00,$00,$00,$00,$00
	DC.B	 'C',$00,$00,$00,$00,$00,$00,$00
	DC.B	 'E',$00,$00,$00,'9',$00,$00,$00
	DC.B	 'C',$00,$00,$00,'9',$00,$00,$00
	DC.B	 'E',$00,$00,$00,'9',$00,$00,$00
	DC.B	 'G',$00,$00,$00,'9',$00,$00,$00
	DC.B	 'H',$00,$00,$00,'9',$00,$00,$00
	DC.B	 'G',$00,$00,$00,'9',$00,$00,$00
	DC.B	 'E',$00,$00,$00,'9',$00,$00,$00
	DC.B	 'C',$00,$00,$00,'9',$00,$00,$00
	DC.B	 '@',$00,$1C,$00,';',$00,'(',$00
	DC.B	 '8',$00,' ',$00,'4',$00,',',$00
	DC.B	 ';',$00,'#',$00,'8',$00,'/',$00
	DC.B	 '4',$00,'(',$00,'/',$00,'4',$00
	DC.B	 '8',$00,',',$00,'4',$00,',',$00
	DC.B	 '/',$00,'/',$00,'8',$00,';',$00
	DC.B	 '4',$00,'4',$00,'/',$00,'@',$00
	DC.B	 '4',$00,'8',$00,'/',$00,'8',$00
	DC.B	 $01,$03,$00,$F0,$05,$03,$03,$F0
	ds.W    1
	DC.B	 $00,$FF,$02,$03,$00,$00,$06,$03
	DC.B	 $03,$00,$00,$00,$00,$00,$03,$03
	ds.W    1 
	DC.B	 $05,$FF,$03,$00,$00,$00,$00,$00
	DC.B	 $04,$03,$00,$00,$06,$FF,$03,$00
	ds.W    2 
	DC.B	 $01,$FC,$00,$00,$05,$FC,$03,$00
	ds.W    2 
	DC.B	 $02,$FC,$00,$00,$05,$FC,$03,$00
	ds.W    2 
	DC.B	 $03,$02,$00,$00,$05,$FE,$03,$00
	ds.W    2 
	DC.B	 $04,$02,$00,$00,$06,$FE,$03,$00
	ds.W    2 
	DC.B	 $0A,$00,$04,$00,$0A,$00,$04,$FF
	DC.B	 $08,$05,$05,$F0,$00,$00,$00,$00
	ds.W    2 
	DC.B	 $07,$F4,$05,$00,$00,$00,$00,$00
	ds.W    2 
	DC.B	 $07,$F4,$05,$00,$00,$00,$00,$00
	ds.W    2 
	DC.B	 $07,$F4,$05,$00,$00,$00,$00,$00
	ds.W    2 
	DC.B	 $07,$F4,$05,$00,$00,$00,$00,$00
	DC.B	 $05,$F7,$03,$F0,$07,$F4,$05,$00
	ds.W    2 
	DC.B	 $06,$F7,$03,$00,$07,$F4,$05,$00
	ds.W    2 
	DC.B	 $05,$F7,$03,$00,$07,$F4,$05,$00
	ds.W    2 
	DC.B	 $06,$F7,$03,$00,$07,$F4,$05,$00
	DC.B	 $0B,$00,$06,$00,$05,$F7,$03,$00
	DC.B	 $07,$F4,$05,$00,$00,$00,$00,$00
	DC.B	 $06,$F7,$03,$00,$07,$F4,$05,$00
	DC.B	 $0B,$FF,$06,$00,$05,$F7,$03,$00
	DC.B	 $07,$F4,$05,$00,$00,$FF,$00,$00
	DC.B	 $06,$F7,$03,$00,$07,$F4,$05,$00
	DC.B	 $0B,$00,$06,$00,$05,$F7,$03,$00
	DC.B	 $07,$F4,$05,$00,$00,$00,$00,$00
	DC.B	 $06,$F7,$03,$00,$07,$F4,$05,$00
	DC.B	 $0B,$FD,$06,$00,$05,$F7,$03,$00
	DC.B	 $07,$F4,$05,$00,$00,$FD,$00,$00
	DC.B	 $06,$F7,$03,$00,$07,$F4,$05,$00
	DC.B	 $0A,$00,$04,$00,$0A,$00,$04,$FF
	DC.B	 $09,'<',$05,$00,$01,$03,$00,$00
	DC.B	 $05,$F7,$03,$F0,'"',$00,$0A,$00
	DC.B	 $02,$03,$00,$00,$06,$F7,$03,$00
	DC.B	 '#',$00,$0A,$00,$03,$03,$00,$00
	DC.B	 $05,$FF,$03,$00,'$',$00,$0A,$00
	DC.B	 $04,$03,$00,$00,$06,$FF,$03,$00
	DC.B	 '%',$00,$0A,$00,$03,$05,$00,$00
	DC.B	 $05,$01,$03,$00,'&',$00,$0A,$00
	DC.B	 $04,$05,$00,$00,$05,$01,$03,$00
	DC.B	 $27,$00,$0A,$00,$01,$03,$00,$00
	DC.B	 $05,$F7,$03,$F0,'(',$00,$0A,$00
	DC.B	 $02,$03,$00,$00,$06,$F7,$03,$00
	ds.W    1 
	DC.B	 $0A,$00,$01,$03,$00,$00,$05,$F7
	DC.B	 $03,$F0,'"',$00,$0A,$00,$02,$03
	ds.W    1 
	DC.B	 $06,$F7,$03,$00,'#',$00,$0A,$00
	DC.B	 $03,$03,$00,$00,$05,$FF,$03,$00
	DC.B	 '$',$00,$0A,$00,$04,$03,$00,$00
	DC.B	 $06,$FF,$03,$00,')',$00,$0A,$00
	DC.B	 $03,$05,$00,$00,$05,$01,$03,$00
	DC.B	 '&',$00,$0A,$00,$04,$05,$00,$00
	DC.B	 $05,$01,$03,$00,$27,$00,$0A,$00
	DC.B	 $01,$03,$00,$00,$05,$F7,$03,$F0
	DC.B	 '(',$00,$0A,$00,$02,$03,$00,$00
	DC.B	 $06,$F7,$03,$00,$00,$00,$0A,$00
	DC.B	 $0A,$00,$04,$00,$0A,$00,$04,$FF
	DC.B	 $08,$05,$05,$F0,'*',$00,$03,$00
	DC.B	 $11,$00,$00,$F0,$10,$00,$09,$00
	DC.B	 '*',$00,$03,$00,$11,$00,$00,$00
	DC.B	 $10,$00,$09,$00,'*',$00,$03,$00
	DC.B	 $12,$00,$00,$00,$15,$08,$09,$00
	DC.B	 '*',$00,$03,$00,$12,$00,$00,$00
	DC.B	 $15,$08,$09,$00,'+',$00,$03,$00
	DC.B	 $12,$02,$00,$00,$10,$FE,$09,$00
	DC.B	 '*',$00,$03,$00,$12,$02,$00,$00
	DC.B	 $14,$FE,$09,$00,'*',$00,$03,$00
	DC.B	 $11,$00,$00,$00,$10,$00,$09,$00
	DC.B	 '+',$00,$03,$00,$11,$00,$00,$00
	DC.B	 $13,$00,$09,$00,$16,$00,$0A,$00
	DC.B	 $11,$00,$00,$00,$10,$00,$09,$00
	DC.B	 $17,$00,$0A,$00,$11,$00,$00,$00
	DC.B	 $10,$00,$09,$00,$18,$00,$0A,$00
	DC.B	 $12,$00,$00,$00,$15,$08,$09,$00
	ds.W    2 
	DC.B	 $12,$00,$00,$00,$15,$08,$09,$00
	DC.B	 $19,$00,$0A,$00,$12,$02,$00,$00
	DC.B	 $10,$FE,$09,$00,$1A,$00,$0A,$00
	DC.B	 $12,$02,$00,$00,$14,$FE,$09,$00
	DC.B	 $1B,$00,$0A,$00,$11,$00,$00,$00
	DC.B	 $10,$00,$09,$00,$00,$00,$00,$00
	DC.B	 $11,$00,$00,$00,$13,$00,$09,$00
	DC.B	 $16,$00,$0A,$00,$11,$00,$00,$00
	DC.B	 $10,$00,$09,$00,$17,$00,$0A,$00
	DC.B	 $11,$00,$00,$00,$10,$00,$09,$00
	DC.B	 $1E,$00,$0A,$00,$12,$00,$00,$00
	DC.B	 $15,$08,$09,$00,$1F,$F1,$0A,$00
	DC.B	 $12,$00,$00,$00,$15,$08,$09,$00
	DC.B	 '!',$00,$0A,$00,$12,$02,$00,$00
	DC.B	 $10,$FE,$09,$00,' ',$00,$0A,$00
	DC.B	 $12,$02,$00,$00,$14,$FE,$09,$00
	DC.B	 $1C,$00,$0A,$00,$11,$00,$00,$00
	DC.B	 $10,$00,$09,$00,$1D,$00,$0A,$00
	DC.B	 $11,$00,$00,$00,$13,$00,$09,$00
	DC.B	 $01,$00,$00,$00,',',$0C,$03,$00
	ds.W    1 
	DC.B	 $00,$FF,$02,$00,$00,$00,',',$0C
	DC.B	 $03,$00,$00,$00,$00,$00,$03,$00
	ds.W    1 
	DC.B	 ',',$08,$03,$00,$00,$00,$00,$00
	DC.B	 $04,$00,$00,$00,',',$08,$03,$00
	ds.W    2 
	DC.B	 $01,$F9,$00,$00,',',$05,$03,$00
	ds.W    2 
	DC.B	 $02,$F9,$00,$00,',',$05,$03,$00
	ds.W    2 
	DC.B	 $03,$FF,$00,$00,',',$07,$03,$00
	ds.W    2 
	DC.B	 $04,$FF,$00,$00,',',$07,$03,$00
	ds.W    2 
	DC.B	 $01,$00,$00,$00,',',$0C,$03,$00
	DC.B	 '-',$00,$0A,$F0,$02,$00,$00,$00
	DC.B	 ',',$0C,$03,$00,'.',$00,$0A,$00
	DC.B	 $03,$00,$00,$00,',',$08,$03,$00
	DC.B	 '/',$00,$0A,$00,$04,$00,$00,$00
	DC.B	 ',',$08,$03,$00,'0',$00,$0A,$00
	DC.B	 $01,$F9,$00,$00,',',$05,$03,$00
	DC.B	 '1',$00,$0A,$00,$02,$F9,$00,$00
	DC.B	 ',',$05,$03,$00,'4',$00,$0A,$00
	DC.B	 $03,$FF,$00,$00,',',$07,$03,$00
	DC.B	 '5',$00,$0A,$00,$04,$FF,$00,$00
	DC.B	 ',',$07,$03,$00,'2',$00,$0A,$00
	DC.B	 $01,$00,$00,$00,',',$0C,$03,$00
	DC.B	 '3',$00,$09,$00,$02,$00,$00,$00
	DC.B	 ',',$0C,$03,$00,'6',$00,$09,$00
	DC.B	 $03,$00,$00,$00,',',$08,$03,$00
	DC.B	 '3',$00,$09,$00,$04,$00,$00,$00
	DC.B	 ',',$08,$03,$00,'6',$00,$09,$00
	DC.B	 $01,$F9,$00,$00,',',$05,$03,$00
	DC.B	 '3',$00,$09,$00,$02,$F9,$00,$00
	DC.B	 ',',$05,$03,$00,'6',$00,$09,$00
	DC.B	 $03,$FF,$00,$00,',',$07,$03,$00
	DC.B	 '3',$00,$09,$00,$04,$FF,$00,$00
	DC.B	 ',',$07,$03,$00,'7',$00,$09,$00
	DC.B	 $01,$00,$00,$00,',',$0C,$03,$00
	DC.B	 '8',$00,$09,$00,$02,$00,$00,$00
	DC.B	 ',',$0C,$03,$00,'8',$00,$09,$00
	DC.B	 $03,$00,$00,$00,',',$08,$03,$00
	DC.B	 '8',$00,$09,$00,$04,$00,$00,$00
	DC.B	 ',',$08,$03,$00,'8',$00,$09,$00
	DC.B	 $01,$F9,$00,$00,',',$05,$03,$00
	DC.B	 '8',$00,$09,$00,$02,$F9,$00,$00
	DC.B	 ',',$05,$03,$00,'8',$00,$09,$00
	DC.B	 $03,$FF,$00,$00,',',$07,$03,$00
	DC.B	 '9',$0C,$09,$00,$04,$FF,$00,$00
	DC.B	 ',',$07,$03,$00,'9',$00,$09,$00
	DC.B	 $01,$00,$00,$00,',',$0C,$03,$00
	DC.B	 '-',$00,$0A,$00,$02,$00,$00,$00
	DC.B	 ',',$0C,$03,$00,'.',$00,$0A,$00
	DC.B	 $03,$00,$00,$00,',',$08,$03,$00
	DC.B	 '/',$00,$0A,$00,$04,$00,$00,$00
	DC.B	 ',',$08,$03,$00,'0',$00,$0A,$00
	DC.B	 $01,$F9,$00,$00,',',$05,$03,$00
	DC.B	 '1',$00,$0A,$00,$02,$F9,$00,$00
	DC.B	 ',',$05,$03,$00,'4',$00,$0A,$00
	DC.B	 $03,$FF,$00,$00,',',$07,$03,$00
	DC.B	 '5',$00,$0A,$00,$04,$FF,$00,$00
	DC.B	 ',',$07,$03,$00,$00,$00,$0A,$00
	DC.B	 $01,$00,$00,$00,',',$0C,$03,$00
	DC.B	 '-',$00,$0A,$00,$02,$00,$00,$00
	DC.B	 ',',$0C,$03,$00,'.',$00,$0A,$00
	DC.B	 $03,$00,$00,$00,',',$08,$03,$00
	DC.B	 '/',$00,$0A,$00,$04,$00,$00,$00
	DC.B	 ',',$08,$03,$00,'0',$00,$0A,$00
	DC.B	 $01,$F9,$00,$00,',',$05,$03,$00
	DC.B	 '1',$00,$0A,$00,$02,$F9,$00,$00
	DC.B	 ',',$05,$03,$00,'4',$00,$0A,$00
	DC.B	 $03,$FF,$00,$00,',',$07,$03,$00
	DC.B	 '5',$00,$0A,$00,$04,$FF,$00,$00
	DC.B	 ',',$07,$03,$00,$00,$00,$0A,$00
	DC.B	 '-',$00,$0B,$00,',',$0C,$03,$00
	DC.B	 '-',$00,$0A,$00,'.',$00,$0B,$00
	DC.B	 ',',$0C,$03,$00,'.',$00,$0A,$00
	DC.B	 '/',$00,$0B,$00,',',$08,$03,$00
	DC.B	 '/',$00,$0A,$00,'0',$00,$0B,$00
	DC.B	 ',',$08,$03,$00,'0',$00,$0A,$00
	DC.B	 '1',$00,$0B,$00,',',$05,$03,$00
	DC.B	 '1',$00,$0A,$00,'4',$00,$0B,$00
	DC.B	 ',',$05,$03,$00,'4',$00,$0A,$00
	DC.B	 '5',$00,$0B,$00,',',$07,$03,$00
	DC.B	 '5',$00,$0A,$00,$00,$00,$00,$00
	DC.B	 ',',$07,$03,$00,$00,$00,$0A,$00
	DC.B	 $01,$00,$00,$00,',',$0C,$03,$00
	DC.B	 '-',$00,$0A,$00,$02,$00,$00,$00
	DC.B	 ',',$0C,$03,$00,'.',$00,$0A,$00
	DC.B	 $03,$00,$00,$00,',',$08,$03,$00
	DC.B	 '/',$00,$0A,$00,$04,$00,$00,$00
	DC.B	 ',',$08,$03,$00,'0',$00,$0A,$00
	DC.B	 $01,$F9,$00,$00,',',$05,$03,$00
	DC.B	 '1',$00,$0A,$00,$02,$F9,$00,$00
	DC.B	 ',',$05,$03,$00,'4',$00,$0A,$00
	DC.B	 $03,$FF,$00,$00,',',$07,$03,$00
	DC.B	 '5',$00,$0A,$00,$04,$FF,$00,$00
	DC.B	 ',',$07,$03,$00,$00,$00,$0A,$00
	DC.B	 $01,$00,$00,$F1,',',$0C,$03,$F1
	DC.B	 '-',$00,$0A,$F1,$02,$00,$00,$F2
	DC.B	 ',',$0C,$03,$F2,'.',$00,$0A,$F2
	DC.B	 $03,$00,$00,$F3,',',$08,$03,$F3
	DC.B	 '/',$00,$0A,$F3,$04,$00,$00,$F4
	DC.B	 ',',$08,$03,$F4,'0',$00,$0A,$F4
	DC.B	 $01,$F9,$00,$F5,',',$05,$03,$F5
	DC.B	 '1',$00,$0A,$F5,$02,$F9,$00,$F6
	DC.B	 ',',$05,$03,$F6,'4',$00,$0A,$F6
	DC.B	 $03,$FF,$00,$F7,',',$07,$03,$F7
	DC.B	 '5',$00,$0A,$F7,$04,$FF,$00,$F8
	DC.B	 ',',$07,$03,$F8,$00,$00,$0A,$F8
	DC.B	 $01,$00,$00,$F9,',',$0C,$03,$F9
	DC.B	 '-',$00,$0A,$F9,$02,$00,$00,$FA
	DC.B	 ',',$0C,$03,$FA,'.',$00,$0A,$FA
	DC.B	 $03,$00,$00,$FB,',',$08,$03,$FB
	DC.B	 '/',$00,$0A,$FB,$04,$00,$00,$FC
	DC.B	 ',',$08,$03,$FC,'0',$00,$0A,$FC
	ds.W    1
	DC.B	 $00,$FD,$00,$00,$00,$FD,$00,$00
	DC.B	 $00,$FD,$00,$00,$00,$8F,$00,$03
	ds.W    1 
	DC.B	 $00,'B',$00,$03,$00,$00,$00,$00
	ds.W    9 
 ENDE:
