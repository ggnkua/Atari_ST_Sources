; CIA List, 24585 hertz.
cia_list:
	dcb.w	32
	dc.w	$0781,$0747,$0710,$06DC,$06AB,$067D,$0651,$628
	dc.w	$0601,$05DB,$05B7,$0595,$0575,$0556,$0538,$51C
	dc.w	$0500,$04E6,$04CD,$04B5,$049E,$0488,$0472,$45E
	dc.w	$044A,$0436,$0424,$0412,$0400,$03F0,$03DF,$3D0
	dc.w	$03C0,$03B2,$03A3,$0395,$0388,$037B,$036E,$362
	dc.w	$0356,$034A,$033F,$0334,$0329,$031E,$0314,$30A
	dc.w	$0300,$02F7,$02EE,$02E5,$02DC,$02D3,$02CB,$2C2
	dc.w	$02BA,$02B3,$02AB,$02A3,$029C,$0295,$028E,$287
	dc.w	$0280,$027A,$0273,$026D,$0267,$0261,$025B,$255
	dc.w	$024F,$0249,$0244,$023E,$0239,$0234,$022F,$22A
	dc.w	$0225,$0220,$021B,$0216,$0212,$020D,$0209,$204
	dc.w	$0200,$01FC,$01F8,$01F4,$01F0,$01EC,$01E8,$1E4
	dc.w	$01E0,$01DC,$01D9,$01D5,$01D2,$01CE,$01CB,$1C7
	dc.w	$01C4,$01C1,$01BD,$01BA,$01B7,$01B4,$01B1,$1AE
	dc.w	$01AB,$01A8,$01A5,$01A2,$019F,$019D,$019A,$197
	dc.w	$0194,$0192,$018F,$018D,$018A,$0187,$0185,$183
	dc.w	$0180,$017E,$017B,$0179,$0177,$0175,$0172,$170
	dc.w	$016E,$016C,$016A,$0167,$0165,$0163,$0161,$15F
	dc.w	$015D,$015B,$0159,$0157,$0155,$0154,$0152,$150
	dc.w	$014E,$014C,$014A,$0149,$0147,$0145,$0143,$142
	dc.w	$0140,$013E,$013D,$013B,$013A,$0138,$0136,$135
	dc.w	$0133,$0132,$0130,$012F,$012D,$012C,$012A,$129
	dc.w	$0127,$0126,$0125,$0123,$0122,$0121,$011F,$11E
	dc.w	$011D,$011B,$011A,$0119,$0117,$0116,$0115,$114
	dc.w	$0112,$0111,$0110,$010F,$010E,$010C,$010B,$10A
	dc.w	$0109,$0108,$0107,$0106,$0104,$0103,$0102,$101
	dc.w	$0100,$0FF,$0FE,$0FD,$0FC,$0FB,$0FA,$F9
	dc.w	$0F8,$0F7,$0F6,$0F5,$0F4,$0F3,$0F2,$F1
