; CIA List, 32780 hertz.
cia_list:
	dcb.w	32
	dc.w	$0A01,$09B3,$096A,$0925,$08E4,$08A7,$086D,$835
	dc.w	$0801,$07CF,$079F,$0772,$0747,$071D,$06F6,$6D0
	dc.w	$06AB,$0688,$0667,$0647,$0628,$060A,$05EE,$5D2
	dc.w	$05B7,$059E,$0585,$056D,$0556,$053F,$052A,$515
	dc.w	$0500,$04ED,$04DA,$04C7,$04B5,$04A4,$0493,$482
	dc.w	$0472,$0463,$0453,$0445,$0436,$0428,$041B,$40D
	dc.w	$0400,$03F4,$03E7,$03DB,$03D0,$03C4,$03B9,$3AE
	dc.w	$03A3,$0399,$038F,$0385,$037B,$0371,$0368,$35F
	dc.w	$0356,$034D,$0344,$033C,$0334,$032B,$0323,$31C
	dc.w	$0314,$030C,$0305,$02FE,$02F7,$02F0,$02E9,$2E2
	dc.w	$02DC,$02D5,$02CF,$02C9,$02C2,$02BC,$02B6,$2B1
	dc.w	$02AB,$02A5,$02A0,$029A,$0295,$0290,$028A,$285
	dc.w	$0280,$027B,$0276,$0272,$026D,$0268,$0264,$25F
	dc.w	$025B,$0256,$0252,$024E,$0249,$0245,$0241,$23D
	dc.w	$0239,$0235,$0231,$022D,$022A,$0226,$0222,$21F
	dc.w	$021B,$0218,$0214,$0211,$020D,$020A,$0207,$203
	dc.w	$0200,$01FD,$01FA,$01F7,$01F4,$01F1,$01EE,$1EB
	dc.w	$01E8,$01E5,$01E2,$01DF,$01DC,$01DA,$01D7,$1D4
	dc.w	$01D2,$01CF,$01CC,$01CA,$01C7,$01C5,$01C2,$1C0
	dc.w	$01BD,$01BB,$01B9,$01B6,$01B4,$01B2,$01AF,$1AD
	dc.w	$01AB,$01A9,$01A6,$01A4,$01A2,$01A0,$019E,$19C
	dc.w	$019A,$0198,$0196,$0194,$0192,$0190,$018E,$18C
	dc.w	$018A,$0188,$0186,$0184,$0183,$0181,$017F,$17D
	dc.w	$017B,$017A,$0178,$0176,$0175,$0173,$0171,$16F
	dc.w	$016E,$016C,$016B,$0169,$0167,$0166,$0164,$163
	dc.w	$0161,$0160,$015E,$015D,$015B,$015A,$0158,$157
	dc.w	$0155,$0154,$0153,$0151,$0150,$014E,$014D,$14C
	dc.w	$014A,$0149,$0148,$0146,$0145,$0144,$0143,$141
