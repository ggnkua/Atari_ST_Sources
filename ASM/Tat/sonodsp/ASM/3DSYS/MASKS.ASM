leftm	macro
	dc	$ffffff,$7f7f7f,$3f3f3f,$1f1f1f
	dc	$0f0f0f,$070707,$030303,$010101
	dc	$ffffff,$7f7f7f,$3f3f3f,$1f1f1f
	dc	$0f0f0f,$070707,$030303,$010101
	dc	$ffffff,$7f7f7f,$3f3f3f,$1f1f1f
	dc	$0f0f0f,$070707,$030303,$010101
	dc	$ffffff,$7f7f7f,$3f3f3f,$1f1f1f
	dc	$0f0f0f,$070707,$030303,$010101
	endm
rightm	macro
	dc	$000000,$808080,$c0c0c0,$e0e0e0
	dc	$f0f0f0,$f8f8f8,$fcfcfc,$fefefe
	dc	$000000,$808080,$c0c0c0,$e0e0e0
	dc	$f0f0f0,$f8f8f8,$fcfcfc,$fefefe
	dc	$000000,$808080,$c0c0c0,$e0e0e0
	dc	$f0f0f0,$f8f8f8,$fcfcfc,$fefefe
	dc	$000000,$808080,$c0c0c0,$e0e0e0
	dc	$f0f0f0,$f8f8f8,$fcfcfc,$fefefe
	endm

leftmasks:
	leftm	;0
	leftm	;1
	leftm	;2
	leftm	;3
	leftm	;4
	leftm	;5
	leftm	;6
	leftm	;7
	leftm	;8
	leftm	;9
	leftm	;10
	leftm	;11
	leftm	;12
	leftm	;13

rightmasks:
	rightm	;0
	rightm	;1
	rightm	;2
	rightm	;3
	rightm	;4
	rightm	;5
	rightm	;6
	rightm	;7
	rightm	;8
	rightm	;9
	rightm	;10
	rightm	;11
	rightm	;12
	rightm	;13

	dc 0,0,0,0,0,0,0,0
offsets:
	dc 0,0,0,0,0,0,0,0
	dc 1,1,1,1,1,1,1,1
	dc 2,2,2,2,2,2,2,2
	dc 3,3,3,3,3,3,3,3
	dc 4,4,4,4,4,4,4,4
	dc 5,5,5,5,5,5,5,5
	dc 6,6,6,6,6,6,6,6
	dc 7,7,7,7,7,7,7,7
	dc 8,8,8,8,8,8,8,8
	dc 9,9,9,9,9,9,9,9
	dc 10,10,10,10,10,10,10,10
	dc 11,11,11,11,11,11,11,11
	dc 12,12,12,12,12,12,12,12
	dc 13,13,13,13,13,13,13,13
	dc 14,14,14,14,14,14,14,14
	dc 15,15,15,15,15,15,15,15
	dc 16,16,16,16,16,16,16,16
	dc 17,17,17,17,17,17,17,17
	dc 18,18,18,18,18,18,18,18
	dc 19,19,19,19,19,19,19,19
	dc 20,20,20,20,20,20,20,20
	dc 21,21,21,21,21,21,21,21
	dc 22,22,22,22,22,22,22,22
	dc 23,23,23,23,23,23,23,23
	dc 24,24,24,24,24,24,24,24
	dc 25,25,25,25,25,25,25,25
	dc 26,26,26,26,26,26,26,26
	dc 27,27,27,27,27,27,27,27
	dc 28,28,28,28,28,28,28,28
	dc 29,29,29,29,29,29,29,29
	dc 30,30,30,30,30,30,30,30
	dc 31,31,31,31,31,31,31,31
	dc 32,32,32,32,32,32,32,32
	dc 33,33,33,33,33,33,33,33
	dc 34,34,34,34,34,34,34,34
	dc 35,35,35,35,35,35,35,35
	dc 36,36,36,36,36,36,36,36
	dc 37,37,37,37,37,37,37,37
	dc 38,38,38,38,38,38,38,38
	dc 39,39,39,39,39,39,39,39
	dc 40,40,40,40,40,40,40,40
	dc 41,41,41,41,41,41,41,41
	dc 42,42,42,42,42,42,42,42
	dc 43,43,43,43,43,43,43,43
	dc 44,44,44,44,44,44,44,44
	dc 45,45,45,45,45,45,45,45
	dc 46,46,46,46,46,46,46,46
	dc 47,47,47,47,47,47,47,47
; Overflow
	dc 48,48,48,48,48,48,48,48
	dc 48,48,48,48,48,48,48,48

