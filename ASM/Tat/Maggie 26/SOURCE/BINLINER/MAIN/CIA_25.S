; CIA List, 24585 hertz.
cia_list:
	dcb.w	32
	dc.w	$0780,$0746,$070F,$06DC,$06AB,$067D,$0651,$627
	dc.w	$0600,$05DB,$05B7,$0595,$0574,$0555,$0538,$51B
	dc.w	$0500,$04E6,$04CD,$04B5,$049D,$0487,$0472,$45D
	dc.w	$0449,$0436,$0423,$0411,$0400,$03EF,$03DF,$3CF
	dc.w	$03C0,$03B1,$03A3,$0395,$0387,$037A,$036E,$361
	dc.w	$0355,$0349,$033E,$0333,$0328,$031E,$0313,$30A
	dc.w	$0300,$02F6,$02ED,$02E4,$02DB,$02D3,$02CA,$2C2
	dc.w	$02BA,$02B2,$02AA,$02A3,$029C,$0294,$028D,$286
	dc.w	$0280,$0279,$0273,$026C,$0266,$0260,$025A,$254
	dc.w	$024E,$0249,$0243,$023E,$0239,$0233,$022E,$229
	dc.w	$0224,$021F,$021B,$0216,$0211,$020D,$0208,$204
	dc.w	$0200,$01FB,$01F7,$01F3,$01EF,$01EB,$01E7,$1E3
	dc.w	$01E0,$01DC,$01D8,$01D5,$01D1,$01CE,$01CA,$1C7
	dc.w	$01C3,$01C0,$01BD,$01BA,$01B7,$01B3,$01B0,$1AD
	dc.w	$01AA,$01A7,$01A4,$01A2,$019F,$019C,$0199,$197
	dc.w	$0194,$0191,$018F,$018C,$0189,$0187,$0185,$182
	dc.w	$0180,$017D,$017B,$0179,$0176,$0174,$0172,$170
	dc.w	$016D,$016B,$0169,$0167,$0165,$0163,$0161,$15F
	dc.w	$015D,$015B,$0159,$0157,$0155,$0153,$0151,$14F
	dc.w	$014E,$014C,$014A,$0148,$0146,$0145,$0143,$141
	dc.w	$0140,$013E,$013C,$013B,$0139,$0137,$0136,$134
	dc.w	$0133,$0131,$0130,$012E,$012D,$012B,$012A,$128
	dc.w	$0127,$0126,$0124,$0123,$0121,$0120,$011F,$11D
	dc.w	$011C,$011B,$0119,$0118,$0117,$0116,$0114,$113
	dc.w	$0112,$0111,$010F,$010E,$010D,$010C,$010B,$10A
	dc.w	$0108,$0107,$0106,$0105,$0104,$0103,$0102,$101
	dc.w	$0100,$0FF,$0FD,$0FC,$0FB,$0FA,$0F9,$F8
	dc.w	$0F7,$0F6,$0F5,$0F4,$0F3,$0F2,$0F1,$F1
