	dc.w	$07fc,$07f9,$07f6,$07f3,$07f0,$07ed,$07ea,$07e7,$07e4,$07e1
	dc.w	$1fe0,$37e0,$4fe0,$67e0,$7fe0,$97e0,$afe0,$c7e0,$dfe0,$f7e0
	dc.w	$ff20,$fe60,$fda0,$fce0,$fc20,$fb60,$faa0,$f9e0,$f920,$f860
	dc.w	$f803,$f806,$f809,$f80c,$f80f,$f812,$f815,$f818,$f81b,$f81e
	dc.w	$e01f,$c81f,$b01f,$981f,$801f,$681f,$501f,$381f,$201f,$081f
	dc.w	$00df,$019f,$025f,$031f,$03df,$049f,$055f,$061f,$06df,$079f
