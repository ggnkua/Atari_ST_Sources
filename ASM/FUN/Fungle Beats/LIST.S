	DC.L	0				* 6:       * B . S . *    
	DC.W	0
	DC.L	120				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	160				* 6:       * B . S . *    
	DC.W	0
	DC.L	280				* 6:       * B . S . *    
	DC.W	0
	DC.L	400				* 6:       * B . S . *    
	DC.W	0
	DC.L	480				* 6:       * B . S . *    
	DC.W	0
	DC.L	600				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	640				* 6:       * B . S . *    
	DC.W	0
	DC.L	760				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	800				* 6:       * B . S . *    
	DC.W	0
	DC.L	920				* 6:       * B . S . *    
	DC.W	0
	DC.L	1040				* 6:       * B . S . *    
	DC.W	0
	DC.L	1120				* 6:       * B . S . *    
	DC.W	0
	DC.L	1240				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	1280				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	1280				* 6:       * B . S . *    
	DC.W	0
	DC.L	1400				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	1400				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	1440				* 6:       * B . S . *    
	DC.W	0
	DC.L	1560				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	1560				* 6:       * B . S . *    
	DC.W	0
	DC.L	1600				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	1680				* 6:       * B . S . *    
	DC.W	0
	DC.L	1720				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	1760				* 6:       * B . S . *    
	DC.W	0
	DC.L	1840				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	1880				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	1920				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	1920				* 6:       * B . S . *    
	DC.W	0
	DC.L	2040				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	2040				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	2080				* 6:       * B . S . *    
	DC.W	0
	DC.L	2200				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	2200				* 6:       * B . S . *    
	DC.W	0
	DC.L	2240				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	2320				* 6:       * B . S . *    
	DC.W	0
	DC.L	2360				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	2400				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	2400				* 6:       * B . S . *    
	DC.W	0
	DC.L	2420				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	2440				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	2460				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	2480				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	2480				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	2500				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	2520				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	2520				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	2520				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	2540				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	2560				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	2560				* 9: HUGE ANTIGREETZ GO TO
	DC.W	0
	DC.L	2560				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	2560				* 6:       * B . S . *    
	DC.W	0
	DC.L	2640				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	2680				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	2680				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	2680				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	2720				* 6:       * B . S . *    
	DC.W	0
	DC.L	2760				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	2840				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	2840				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	2840				* 6:       * B . S . *    
	DC.W	0
	DC.L	2880				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	2880				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	2960				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	2960				* 6:       * B . S . *    
	DC.W	0
	DC.L	3000				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	3000				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	3040				* 6:       * B . S . *    
	DC.W	0
	DC.L	3080				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	3120				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	3160				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	3200				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	3200				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	3200				* 6:       * B . S . *    
	DC.W	0
	DC.L	3280				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	3320				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	3320				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	3320				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	3360				* 6:       * B . S . *    
	DC.W	0
	DC.L	3400				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	3480				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	3480				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	3480				* 6:       * B . S . *    
	DC.W	0
	DC.L	3520				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	3520				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	3600				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	3600				* 6:       * B . S . *    
	DC.W	0
	DC.L	3640				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	3640				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	3680				* 6:       * B . S . *    
	DC.W	0
	DC.L	3720				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	3760				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	3800				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	3800				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	3800				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	3840				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	3840				* 9: HUGE ANTIGREETZ GO TO
	DC.W	0
	DC.L	3840				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	3840				* 6:       * B . S . *    
	DC.W	0
	DC.L	3920				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	3960				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	3960				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	3960				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	4000				* 6:       * B . S . *    
	DC.W	0
	DC.L	4040				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	4120				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	4120				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	4120				* 6:       * B . S . *    
	DC.W	0
	DC.L	4160				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	4160				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	4240				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	4240				* 6:       * B . S . *    
	DC.W	0
	DC.L	4280				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	4280				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	4320				* 6:       * B . S . *    
	DC.W	0
	DC.L	4360				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	4400				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	4440				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	4480				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	4480				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	4480				* 6:       * B . S . *    
	DC.W	0
	DC.L	4560				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	4600				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	4600				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	4600				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	4640				* 6:       * B . S . *    
	DC.W	0
	DC.L	4680				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	4760				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	4760				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	4760				* 6:       * B . S . *    
	DC.W	0
	DC.L	4800				* 8: GRTZ TO ALL ON #ATARI
	DC.W	0
	DC.L	4800				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	4880				* 6:       * B . S . *    
	DC.W	0
	DC.L	4920				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	4960				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	4960				* 6:       * B . S . *    
	DC.W	0
	DC.L	4980				* 31: 
	DC.W	0
	DC.L	5000				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	5020				* 31: 
	DC.W	0
	DC.L	5040				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	5040				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	5060				* 31: 
	DC.W	0
	DC.L	5080				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	5080				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	5080				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	5100				* 31: 
	DC.W	0
	DC.L	5120				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	5120				* 9: HUGE ANTIGREETZ GO TO
	DC.W	0
	DC.L	5120				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	5120				* 6:       * B . S . *    
	DC.W	0
	DC.L	5200				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	5240				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	5240				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	5240				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	5280				* 6:       * B . S . *    
	DC.W	0
	DC.L	5320				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	5400				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	5400				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	5400				* 6:       * B . S . *    
	DC.W	0
	DC.L	5440				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	5440				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	5520				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	5520				* 6:       * B . S . *    
	DC.W	0
	DC.L	5560				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	5560				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	5600				* 6:       * B . S . *    
	DC.W	0
	DC.L	5640				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	5680				* 5: ADDITIONAL VOCALS BY:
	DC.W	0
	DC.L	5680				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	5720				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	5760				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	5760				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	5760				* 6:       * B . S . *    
	DC.W	0
	DC.L	5840				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	5880				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	5880				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	5880				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	5920				* 6:       * B . S . *    
	DC.W	0
	DC.L	5940				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	6000				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	6040				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	6040				* 6:       * B . S . *    
	DC.W	0
	DC.L	6080				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	6080				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	6160				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	6160				* 6:       * B . S . *    
	DC.W	0
	DC.L	6200				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	6200				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	6240				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	6240				* 6:       * B . S . *    
	DC.W	0
	DC.L	6320				* 5: ADDITIONAL VOCALS BY:
	DC.W	0
	DC.L	6320				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	6360				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	6360				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	6360				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	6400				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	6400				* 9: HUGE ANTIGREETZ GO TO
	DC.W	0
	DC.L	6400				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	6400				* 6:       * B . S . *    
	DC.W	0
	DC.L	6480				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	6520				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	6520				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	6520				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	6560				* 6:       * B . S . *    
	DC.W	0
	DC.L	6600				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	6640				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	6680				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	6680				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	6680				* 6:       * B . S . *    
	DC.W	0
	DC.L	6720				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	6720				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	6800				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	6800				* 6:       * B . S . *    
	DC.W	0
	DC.L	6840				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	6880				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	6880				* 6:       * B . S . *    
	DC.W	0
	DC.L	6920				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	6960				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	6960				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	7000				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	7000				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	7040				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	7040				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	7040				* 6:       * B . S . *    
	DC.W	0
	DC.L	7120				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	7160				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	7160				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	7160				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	7200				* 6:       * B . S . *    
	DC.W	0
	DC.L	7220				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	7280				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	7320				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	7320				* 6:       * B . S . *    
	DC.W	0
	DC.L	7360				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	7360				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	7440				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	7440				* 6:       * B . S . *    
	DC.W	0
	DC.L	7480				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	7480				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	7520				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	7520				* 6:       * B . S . *    
	DC.W	0
	DC.L	7560				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	7580				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	7600				* 5: ADDITIONAL VOCALS BY:
	DC.W	0
	DC.L	7600				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	7640				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	7640				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	7640				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	7680				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	7680				* 9: HUGE ANTIGREETZ GO TO
	DC.W	0
	DC.L	7680				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	7680				* 6:       * B . S . *    
	DC.W	0
	DC.L	7760				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	7800				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	7800				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	7800				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	7840				* 6:       * B . S . *    
	DC.W	0
	DC.L	7880				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	7960				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	7960				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	7960				* 6:       * B . S . *    
	DC.W	0
	DC.L	8000				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	8000				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	8080				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	8080				* 6:       * B . S . *    
	DC.W	0
	DC.L	8120				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	8120				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	8160				* 6:       * B . S . *    
	DC.W	0
	DC.L	8200				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	8240				* 5: ADDITIONAL VOCALS BY:
	DC.W	0
	DC.L	8240				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	8280				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	8320				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	8320				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	8320				* 6:       * B . S . *    
	DC.W	0
	DC.L	8400				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	8440				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	8440				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	8440				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	8480				* 6:       * B . S . *    
	DC.W	0
	DC.L	8500				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	8560				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	8600				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	8600				* 6:       * B . S . *    
	DC.W	0
	DC.L	8640				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	8640				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	8720				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	8720				* 6:       * B . S . *    
	DC.W	0
	DC.L	8760				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	8760				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	8800				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	8800				* 6:       * B . S . *    
	DC.W	0
	DC.L	8880				* 5: ADDITIONAL VOCALS BY:
	DC.W	0
	DC.L	8880				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	8920				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	8920				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	8920				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	8960				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	8960				* 9: HUGE ANTIGREETZ GO TO
	DC.W	0
	DC.L	8960				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	8960				* 6:       * B . S . *    
	DC.W	0
	DC.L	9040				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	9080				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	9080				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	9080				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	9120				* 6:       * B . S . *    
	DC.W	0
	DC.L	9160				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	9200				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	9240				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	9240				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	9240				* 6:       * B . S . *    
	DC.W	0
	DC.L	9280				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	9280				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	9360				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	9360				* 6:       * B . S . *    
	DC.W	0
	DC.L	9400				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	9440				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	9440				* 6:       * B . S . *    
	DC.W	0
	DC.L	9480				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	9520				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	9520				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	9560				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	9560				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	9600				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	9600				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	9600				* 6:       * B . S . *    
	DC.W	0
	DC.L	9680				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	9720				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	9720				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	9720				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	9760				* 6:       * B . S . *    
	DC.W	0
	DC.L	9780				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	9840				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	9880				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	9880				* 6:       * B . S . *    
	DC.W	0
	DC.L	9920				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	9920				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	10000				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	10000				* 6:       * B . S . *    
	DC.W	0
	DC.L	10040				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	10040				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	10080				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	10080				* 6:       * B . S . *    
	DC.W	0
	DC.L	10120				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	10140				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	10160				* 5: ADDITIONAL VOCALS BY:
	DC.W	0
	DC.L	10160				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	10200				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	10200				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	10200				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	10240				* 8: GRTZ TO ALL ON #ATARI
	DC.W	0
	DC.L	10240				* 9: HUGE ANTIGREETZ GO TO
	DC.W	0
	DC.L	10240				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	10500				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	10520				* 11: MABN (SELLS CRAP)    
	DC.W	0
	DC.L	10560				* 11: MABN (SELLS CRAP)    
	DC.W	0
	DC.L	10800				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	10840				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	10880				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	11140				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	11160				* 12: ACN (SELLS PIRACY)   
	DC.W	0
	DC.L	11200				* 12: ACN (SELLS PIRACY)   
	DC.W	0
	DC.L	11360				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	11400				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	11440				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	11480				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	11520				* 8: GRTZ TO ALL ON #ATARI
	DC.W	0
	DC.L	11520				* 9: HUGE ANTIGREETZ GO TO
	DC.W	0
	DC.L	11520				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	11520				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	11640				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	11780				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	11800				* 11: MABN (SELLS CRAP)    
	DC.W	0
	DC.L	11800				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	11840				* 11: MABN (SELLS CRAP)    
	DC.W	0
	DC.L	11840				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	11960				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	12080				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	12080				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	12120				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	12160				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	12160				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	12280				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	12420				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	12440				* 12: ACN (SELLS PIRACY)   
	DC.W	0
	DC.L	12440				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	12480				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	12480				* 12: ACN (SELLS PIRACY)   
	DC.W	0
	DC.L	12480				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	12560				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	12600				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	12640				* 5: ADDITIONAL VOCALS BY:
	DC.W	0
	DC.L	12680				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	12720				* 5: ADDITIONAL VOCALS BY:
	DC.W	0
	DC.L	12720				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	12760				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	12760				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	12800				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	12800				* 9: HUGE ANTIGREETZ GO TO
	DC.W	0
	DC.L	12800				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	12800				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	12880				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	12920				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	12920				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	13000				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	13060				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	13080				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	13080				* 11: MABN (SELLS CRAP)    
	DC.W	0
	DC.L	13080				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	13120				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	13120				* 11: MABN (SELLS CRAP)    
	DC.W	0
	DC.L	13120				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	13200				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	13240				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	13240				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	13320				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	13360				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	13360				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	13400				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	13440				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	13440				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	13440				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	13520				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	13560				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	13560				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	13640				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	13700				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	13720				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	13720				* 12: ACN (SELLS PIRACY)   
	DC.W	0
	DC.L	13720				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	13760				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	13760				* 12: ACN (SELLS PIRACY)   
	DC.W	0
	DC.L	13760				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	13840				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	13880				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	13880				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	13960				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	14000				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	14040				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	14040				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	14080				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	14080				* 9: HUGE ANTIGREETZ GO TO
	DC.W	0
	DC.L	14080				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	14080				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	14160				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	14200				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	14200				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	14280				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	14340				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	14360				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	14360				* 11: MABN (SELLS CRAP)    
	DC.W	0
	DC.L	14360				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	14400				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	14400				* 11: MABN (SELLS CRAP)    
	DC.W	0
	DC.L	14400				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	14480				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	14520				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	14520				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	14600				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	14640				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	14640				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	14680				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	14720				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	14720				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	14720				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	14800				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	14840				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	14840				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	14920				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	14980				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	15000				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	15000				* 12: ACN (SELLS PIRACY)   
	DC.W	0
	DC.L	15000				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	15040				* 8: GRTZ TO ALL ON #ATARI
	DC.W	0
	DC.L	15040				* 12: ACN (SELLS PIRACY)   
	DC.W	0
	DC.L	15040				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	15280				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	15300				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	15320				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	15340				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	15360				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	15360				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	15360				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	15360				* 6:       * B . S . *    
	DC.W	0
	DC.L	15440				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	15480				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	15480				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	15480				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	15520				* 6:       * B . S . *    
	DC.W	0
	DC.L	15560				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	15620				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	15640				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	15640				* 11: MABN (SELLS CRAP)    
	DC.W	0
	DC.L	15640				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	15640				* 6:       * B . S . *    
	DC.W	0
	DC.L	15680				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	15680				* 11: MABN (SELLS CRAP)    
	DC.W	0
	DC.L	15680				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	15760				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	15760				* 6:       * B . S . *    
	DC.W	0
	DC.L	15800				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	15800				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	15840				* 6:       * B . S . *    
	DC.W	0
	DC.L	15880				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	15920				* 5: ADDITIONAL VOCALS BY:
	DC.W	0
	DC.L	15920				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	15920				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	15960				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	15960				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	16000				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	16000				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	16000				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	16000				* 6:       * B . S . *    
	DC.W	0
	DC.L	16080				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	16120				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	16120				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	16120				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	16160				* 6:       * B . S . *    
	DC.W	0
	DC.L	16180				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	16240				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	16260				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	16280				* 12: ACN (SELLS PIRACY)   
	DC.W	0
	DC.L	16280				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	16280				* 6:       * B . S . *    
	DC.W	0
	DC.L	16320				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	16320				* 12: ACN (SELLS PIRACY)   
	DC.W	0
	DC.L	16320				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	16400				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	16400				* 6:       * B . S . *    
	DC.W	0
	DC.L	16440				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	16440				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	16480				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	16480				* 6:       * B . S . *    
	DC.W	0
	DC.L	16560				* 5: ADDITIONAL VOCALS BY:
	DC.W	0
	DC.L	16560				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	16600				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	16600				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	16600				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	16640				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	16640				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	16640				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	16640				* 6:       * B . S . *    
	DC.W	0
	DC.L	16720				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	16760				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	16760				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	16760				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	16800				* 6:       * B . S . *    
	DC.W	0
	DC.L	16840				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	16900				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	16920				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	16920				* 11: MABN (SELLS CRAP)    
	DC.W	0
	DC.L	16920				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	16920				* 6:       * B . S . *    
	DC.W	0
	DC.L	16960				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	16960				* 11: MABN (SELLS CRAP)    
	DC.W	0
	DC.L	16960				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	17040				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	17040				* 6:       * B . S . *    
	DC.W	0
	DC.L	17080				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	17080				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	17120				* 6:       * B . S . *    
	DC.W	0
	DC.L	17160				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	17200				* 5: ADDITIONAL VOCALS BY:
	DC.W	0
	DC.L	17200				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	17200				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	17240				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	17240				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	17280				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	17280				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	17280				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	17280				* 6:       * B . S . *    
	DC.W	0
	DC.L	17360				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	17400				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	17400				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	17400				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	17440				* 6:       * B . S . *    
	DC.W	0
	DC.L	17460				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	17520				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	17540				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	17560				* 12: ACN (SELLS PIRACY)   
	DC.W	0
	DC.L	17560				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	17560				* 6:       * B . S . *    
	DC.W	0
	DC.L	17600				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	17600				* 12: ACN (SELLS PIRACY)   
	DC.W	0
	DC.L	17600				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	17680				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	17680				* 6:       * B . S . *    
	DC.W	0
	DC.L	17720				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	17720				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	17760				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	17760				* 6:       * B . S . *    
	DC.W	0
	DC.L	17840				* 5: ADDITIONAL VOCALS BY:
	DC.W	0
	DC.L	17840				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	17880				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	17880				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	17880				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	17920				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	17920				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	17920				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	17920				* 6:       * B . S . *    
	DC.W	0
	DC.L	18000				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	18040				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	18040				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	18040				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	18080				* 6:       * B . S . *    
	DC.W	0
	DC.L	18120				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	18180				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	18200				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	18200				* 11: MABN (SELLS CRAP)    
	DC.W	0
	DC.L	18200				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	18200				* 6:       * B . S . *    
	DC.W	0
	DC.L	18240				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	18240				* 11: MABN (SELLS CRAP)    
	DC.W	0
	DC.L	18240				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	18320				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	18320				* 6:       * B . S . *    
	DC.W	0
	DC.L	18360				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	18360				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	18400				* 6:       * B . S . *    
	DC.W	0
	DC.L	18440				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	18480				* 5: ADDITIONAL VOCALS BY:
	DC.W	0
	DC.L	18480				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	18480				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	18520				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	18520				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	18560				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	18560				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	18560				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	18560				* 6:       * B . S . *    
	DC.W	0
	DC.L	18640				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	18680				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	18680				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	18680				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	18720				* 6:       * B . S . *    
	DC.W	0
	DC.L	18740				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	18800				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	18820				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	18840				* 12: ACN (SELLS PIRACY)   
	DC.W	0
	DC.L	18840				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	18840				* 6:       * B . S . *    
	DC.W	0
	DC.L	18880				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	18880				* 12: ACN (SELLS PIRACY)   
	DC.W	0
	DC.L	18880				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	18960				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	18960				* 6:       * B . S . *    
	DC.W	0
	DC.L	19000				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	19000				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	19040				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	19040				* 6:       * B . S . *    
	DC.W	0
	DC.L	19120				* 5: ADDITIONAL VOCALS BY:
	DC.W	0
	DC.L	19120				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	19160				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	19160				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	19160				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	19200				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	19200				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	19200				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	19200				* 6:       * B . S . *    
	DC.W	0
	DC.L	19280				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	19320				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	19320				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	19320				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	19360				* 6:       * B . S . *    
	DC.W	0
	DC.L	19400				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	19460				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	19480				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	19480				* 11: MABN (SELLS CRAP)    
	DC.W	0
	DC.L	19480				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	19480				* 6:       * B . S . *    
	DC.W	0
	DC.L	19520				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	19520				* 11: MABN (SELLS CRAP)    
	DC.W	0
	DC.L	19520				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	19600				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	19600				* 6:       * B . S . *    
	DC.W	0
	DC.L	19640				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	19640				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	19680				* 6:       * B . S . *    
	DC.W	0
	DC.L	19720				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	19760				* 5: ADDITIONAL VOCALS BY:
	DC.W	0
	DC.L	19760				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	19760				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	19800				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	19800				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	19840				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	19840				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	19840				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	19840				* 6:       * B . S . *    
	DC.W	0
	DC.L	19920				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	19960				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	19960				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	19960				* 7: (HE HAS NO IDEA BTW) 
	DC.W	0
	DC.L	20000				* 6:       * B . S . *    
	DC.W	0
	DC.L	20020				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	20080				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	20100				* 10: MICROSOFT, INTEL,    
	DC.W	0
	DC.L	20120				* 12: ACN (SELLS PIRACY)   
	DC.W	0
	DC.L	20120				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	20120				* 6:       * B . S . *    
	DC.W	0
	DC.L	20160				* 12: ACN (SELLS PIRACY)   
	DC.W	0
	DC.L	20160				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	20160				* 8: GRTZ TO ALL ON #ATARI
	DC.W	0
	DC.L	20280				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	20320				* 14: KNARF (KGMD),        
	DC.W	0
	DC.L	20360				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	20400				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	20400				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	20440				* 1: MUSIC BY COMP7       
	DC.W	0
	DC.L	20480				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	20480				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	20480				* 14: KNARF (KGMD),        
	DC.W	0
	DC.L	20520				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	20560				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	20560				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	20600				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	20600				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	20640				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	20680				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	20680				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	20720				* 5: ADDITIONAL VOCALS BY:
	DC.W	0
	DC.L	20720				* 14: KNARF (KGMD),        
	DC.W	0
	DC.L	20760				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	20760				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	20800				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	20800				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	20880				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	20880				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	20920				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	20920				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	20960				* 14: KNARF (KGMD),        
	DC.W	0
	DC.L	21000				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	21000				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	21040				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	21040				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	21040				* 13: ADMIRATION TO:       
	DC.W	0
	DC.L	21060				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	21080				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	21120				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	21120				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	21120				* 14: KNARF (KGMD),        
	DC.W	0
	DC.L	21160				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	21200				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	21200				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	21240				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	21240				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	21320				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	21320				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	21360				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	21360				* 14: KNARF (KGMD),        
	DC.W	0
	DC.L	21400				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	21440				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	21440				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	21520				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	21520				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	21560				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	21560				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	21600				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	21600				* 14: KNARF (KGMD),        
	DC.W	0
	DC.L	21640				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	21660				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	21680				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	21680				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	21680				* 13: ADMIRATION TO:       
	DC.W	0
	DC.L	21720				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	21720				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	21760				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	21760				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	21760				* 14: KNARF (KGMD),        
	DC.W	0
	DC.L	21800				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	21840				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	21840				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	21880				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	21880				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	21920				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	21960				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	21960				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	22000				* 5: ADDITIONAL VOCALS BY:
	DC.W	0
	DC.L	22000				* 14: KNARF (KGMD),        
	DC.W	0
	DC.L	22040				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	22040				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	22080				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	22080				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	22160				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	22160				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	22200				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	22200				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	22240				* 14: KNARF (KGMD),        
	DC.W	0
	DC.L	22280				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	22280				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	22320				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	22320				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	22320				* 13: ADMIRATION TO:       
	DC.W	0
	DC.L	22340				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	22360				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	22400				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	22400				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	22400				* 14: KNARF (KGMD),        
	DC.W	0
	DC.L	22440				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	22480				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	22480				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	22520				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	22520				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	22600				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	22600				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	22640				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	22640				* 14: KNARF (KGMD),        
	DC.W	0
	DC.L	22680				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	22720				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	22720				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	22800				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	22800				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	22840				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	22840				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	22880				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	22880				* 14: KNARF (KGMD),        
	DC.W	0
	DC.L	22920				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	22940				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	22960				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	22960				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	22960				* 13: ADMIRATION TO:       
	DC.W	0
	DC.L	23000				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	23000				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	23040				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	23040				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	23040				* 14: KNARF (KGMD),        
	DC.W	0
	DC.L	23040				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	23080				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	23120				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	23120				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	23120				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	23160				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	23160				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	23200				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	23200				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	23240				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	23240				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	23240				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	23280				* 5: ADDITIONAL VOCALS BY:
	DC.W	0
	DC.L	23280				* 14: KNARF (KGMD),        
	DC.W	0
	DC.L	23280				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	23320				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	23320				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	23320				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	23360				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	23360				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	23400				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	23440				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	23440				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	23440				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	23480				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	23480				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	23480				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	23520				* 14: KNARF (KGMD),        
	DC.W	0
	DC.L	23560				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	23560				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	23560				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	23600				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	23600				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	23600				* 13: ADMIRATION TO:       
	DC.W	0
	DC.L	23620				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	23640				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	23680				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	23680				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	23680				* 14: KNARF (KGMD),        
	DC.W	0
	DC.L	23680				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	23720				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	23760				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	23760				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	23760				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	23800				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	23800				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	23840				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	23880				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	23880				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	23880				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	23920				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	23920				* 14: KNARF (KGMD),        
	DC.W	0
	DC.L	23920				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	23960				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	23960				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	24000				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	24000				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	24040				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	24080				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	24080				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	24080				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	24120				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	24120				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	24120				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	24160				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	24160				* 14: KNARF (KGMD),        
	DC.W	0
	DC.L	24160				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	24200				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	24220				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	24240				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	24240				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	24240				* 13: ADMIRATION TO:       
	DC.W	0
	DC.L	24280				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	24280				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	24320				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	24320				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	24320				* 14: KNARF (KGMD),        
	DC.W	0
	DC.L	24320				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	24360				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	24400				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	24400				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	24400				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	24440				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	24440				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	24480				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	24480				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	24520				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	24520				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	24520				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	24560				* 5: ADDITIONAL VOCALS BY:
	DC.W	0
	DC.L	24560				* 14: KNARF (KGMD),        
	DC.W	0
	DC.L	24560				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	24600				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	24600				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	24600				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	24640				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	24640				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	24680				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	24720				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	24720				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	24720				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	24760				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	24760				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	24760				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	24800				* 14: KNARF (KGMD),        
	DC.W	0
	DC.L	24840				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	24840				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	24840				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	24880				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	24880				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	24880				* 13: ADMIRATION TO:       
	DC.W	0
	DC.L	24900				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	24920				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	24960				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	24960				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	24960				* 14: KNARF (KGMD),        
	DC.W	0
	DC.L	24960				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	25000				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	25040				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	25040				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	25040				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	25080				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	25080				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	25120				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	25160				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	25160				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	25160				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	25200				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	25200				* 14: KNARF (KGMD),        
	DC.W	0
	DC.L	25200				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	25240				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	25240				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	25280				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	25280				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	25320				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	25360				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	25360				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	25360				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	25400				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	25400				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	25400				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	25440				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	25440				* 14: KNARF (KGMD),        
	DC.W	0
	DC.L	25440				* 15: THE FREEMINT "TEAM"  
	DC.W	0
	DC.L	25480				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	25500				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	25520				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	25520				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	25520				* 13: ADMIRATION TO:       
	DC.W	0
	DC.L	25560				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	25560				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	25600				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	25600				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	25600				* 14: KNARF (KGMD),        
	DC.W	0
	DC.L	25600				* 12: ACN (SELLS PIRACY)   
	DC.W	0
	DC.L	25640				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	25680				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	25680				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	25720				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	25720				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	25760				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	25800				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	25800				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	25840				* 5: ADDITIONAL VOCALS BY:
	DC.W	0
	DC.L	25840				* 14: KNARF (KGMD),        
	DC.W	0
	DC.L	25880				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	25880				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	25920				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	25920				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	25920				* 12: ACN (SELLS PIRACY)   
	DC.W	0
	DC.L	26000				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	26000				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	26040				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	26040				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	26080				* 14: KNARF (KGMD),        
	DC.W	0
	DC.L	26120				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	26120				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	26160				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	26160				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	26180				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	26200				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	26240				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	26240				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	26240				* 14: KNARF (KGMD),        
	DC.W	0
	DC.L	26240				* 12: ACN (SELLS PIRACY)   
	DC.W	0
	DC.L	26280				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	26320				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	26320				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	26360				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	26360				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	26440				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	26440				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	26480				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	26480				* 14: KNARF (KGMD),        
	DC.W	0
	DC.L	26520				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	26560				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	26560				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	26560				* 12: ACN (SELLS PIRACY)   
	DC.W	0
	DC.L	26640				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	26640				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	26680				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	26680				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	26720				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	26720				* 14: KNARF (KGMD),        
	DC.W	0
	DC.L	26760				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	26780				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	26800				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	26800				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	26840				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	26840				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	26880				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	26880				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	26880				* 14: KNARF (KGMD),        
	DC.W	0
	DC.L	26880				* 12: ACN (SELLS PIRACY)   
	DC.W	0
	DC.L	26920				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	26960				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	26960				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	27000				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	27000				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	27040				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	27080				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	27080				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	27120				* 5: ADDITIONAL VOCALS BY:
	DC.W	0
	DC.L	27120				* 14: KNARF (KGMD),        
	DC.W	0
	DC.L	27160				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	27160				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	27200				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	27200				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	27200				* 12: ACN (SELLS PIRACY)   
	DC.W	0
	DC.L	27280				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	27280				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	27320				* 4: EXCL. FOR --FUN--    
	DC.W	0
	DC.L	27320				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	27360				* 14: KNARF (KGMD),        
	DC.W	0
	DC.L	27400				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	27400				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	27440				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	27440				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	27460				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	27480				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	27520				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	27520				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	27520				* 14: KNARF (KGMD),        
	DC.W	0
	DC.L	27520				* 12: ACN (SELLS PIRACY)   
	DC.W	0
	DC.L	27560				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	27600				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	27600				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	27640				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	27640				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	27720				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	27720				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	27760				* 3: WWW.BASSMENT.DEMON.NL
	DC.W	0
	DC.L	27760				* 14: KNARF (KGMD),        
	DC.W	0
	DC.L	27800				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	27840				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	27840				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	27840				* 12: ACN (SELLS PIRACY)   
	DC.W	0
	DC.L	27860				* 31: 
	DC.W	0
	DC.L	27860				* 31: 
	DC.W	0
	DC.L	27860				* 31: 
	DC.W	0
	DC.L	28040				* 2: OF THE BASSMENT      
	DC.W	0
	DC.L	28040				* 6:       * B . S . *    
	DC.W	0
	DC.L	28080				* 8: GRTZ TO ALL ON #ATARI
	DC.W	0
	DC.L	28080				* 6:       * B . S . *    
	DC.W	0
	DC.L	28120				* 6:       * B . S . *    
	DC.W	0
	DC.L	28120				* 13: ADMIRATION TO:       
	DC.W	0