	IFND	temp_buf

temp_buf:
	DS.L	512*256

	ENDC