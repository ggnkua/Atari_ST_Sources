	dc.b -59
	dc.b -59
	dc.b -59
	dc.b -59
	dc.b -58
	dc.b -58
	dc.b -57
	dc.b -57
	dc.b -56
	dc.b -55
	dc.b -54
	dc.b -53
	dc.b -52
	dc.b -51
	dc.b -50
	dc.b -49
	dc.b -48
	dc.b -46
	dc.b -45
	dc.b -43
	dc.b -41
	dc.b -40
	dc.b -38
	dc.b -36
	dc.b -34
	dc.b -32
	dc.b -30
	dc.b -28
	dc.b -26
	dc.b -24
	dc.b -22
	dc.b -20
	dc.b -18
	dc.b -15
	dc.b -13
	dc.b -11
	dc.b -8
	dc.b -6
	dc.b -4
	dc.b -1
	dc.b 1
	dc.b -1
	dc.b -4
	dc.b -6
	dc.b -8
	dc.b -10
	dc.b -12
	dc.b -14
	dc.b -15
	dc.b -17
	dc.b -18
	dc.b -19
	dc.b -20
	dc.b -21
	dc.b -21
	dc.b -21
	dc.b -21
	dc.b -21
	dc.b -20
	dc.b -19
	dc.b -18
	dc.b -17
	dc.b -15
	dc.b -14
	dc.b -12
	dc.b -10
	dc.b -8
	dc.b -6
	dc.b -4
	dc.b -1
	dc.b 1
	dc.b 0
	dc.b -1
	dc.b -3
	dc.b -4
	dc.b -5
	dc.b -5
	dc.b -6
	dc.b -7
	dc.b -7
	dc.b -7
	dc.b -7
	dc.b -7
	dc.b -6
	dc.b -5
	dc.b -5
	dc.b -4
	dc.b -3
	dc.b -1
	dc.b 0
	dc.b 1
	dc.b 0
	dc.b -1
	dc.b -1
	dc.b -2
	dc.b -2
	dc.b -2
	dc.b -1
	dc.b -1
	dc.b 0
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 1
	dc.b 0
	dc.b 0
	dc.b -1
	dc.b -1
	dc.b -2
	dc.b -3
	dc.b -4
	dc.b -5
	dc.b -6
	dc.b -7
	dc.b -8
	dc.b -9
	dc.b -10
	dc.b -12
	dc.b -13
	dc.b -15
	dc.b -17
	dc.b -18
	dc.b -20
	dc.b -22
	dc.b -24
	dc.b -26
	dc.b -28
	dc.b -30
	dc.b -32
	dc.b -34
	dc.b -36
	dc.b -38
	dc.b -40
	dc.b -43
	dc.b -45
	dc.b -47
	dc.b -50
	dc.b -52
	dc.b -54
	dc.b -57
