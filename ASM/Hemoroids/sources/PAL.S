	dc.l $01800ACE,$01820CCC	dc.l $01840404,$01860426	dc.l $01880246,$018A024A	dc.l $018C026A,$018E046C	dc.l $0190028C,$0192068E	dc.l $019404AE,$019606CE	dc.l $01980A8E,$019A0EEE	dc.l $019C08AC,$019E0AAA