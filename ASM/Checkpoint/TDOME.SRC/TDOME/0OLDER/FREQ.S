;-------------------------------------------------------------------------------
FREQ            EQU 15650
_64BLK          EQU (FREQ/50/64)+1
;-------------------------------------------------------------------------------


