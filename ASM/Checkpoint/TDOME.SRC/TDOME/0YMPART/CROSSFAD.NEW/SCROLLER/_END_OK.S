123412341234
            XXXX
dc.b "                                        "
dc.b "                                        "
1234
      5678
        ABCD
;dc.b "0123456789012345678901234567890123456789"
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "             THUNDERDOME                " 
dc.b "                                        "
dc.b "                                        "
dc.b "              THE  DEMO                 "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "    A CHECKPOINT PRODUCTION IN 2014     "
dc.b "                                        "
dc.b "                                        "
dc.b "        RELEASED AT SILLYVENTURE        "
dc.b "           IN GDANSK/POLAND             "     
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "              CAST                      "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "IDEA          LSL/CHECKPOINT            "
dc.b "CODE                                    "
dc.b "DESIGN                                  "
dc.b "SCRIPT                                  "
dc.b "COORDINATION                            "
dc.b "                                        "
dc.b "                                        "
dc.b "ADDITIONAL    DEFJAM/CHECKPOINT         "
dc.b "PROGRAMMING                             "
dc.b "                                        "
dc.b "                                        "
dc.b "PACKER        M.F.X.J.OBERHUMER         "
dc.b "                                        "
dc.b "                                        "
dc.b "GREENSCREEN   SU                        "
dc.b "DANCER                                  "
dc.b "                                        "
dc.b "                                        "
dc.b "MUSIC         BERO/FARBRAUSCH           "
dc.b "DIGITAL PART                            "
dc.b "                                        "
dc.b "                                        "
dc.b "MUSIC         ULTRASYD                  "
dc.b "CHIP PART                               "
dc.b "                                        "
dc.b "                                        "
dc.b "ORIGINAL      VICTOR FEENSTRA           "
dc.b "GRAPHICS      M-DESIGN WORMERVEER       "
dc.b "DESIGN        ID&T                      "
dc.b "                                        "
dc.b "                                        "
dc.b "GRAPHICS      ST SURVIVOR               "
dc.b "DESIGN        MODMATE/CHECKPOINT        "
dc.b "              EXOCET/CHECKPOINT         "
dc.b "                                        "
dc.b "                                        "
dc.b "3D DESIGN     EXOCET/CHECKPOINT         "
dc.b "TEXTURING                               "
dc.b "                                        "
dc.b "                                        "
dc.b "SPECTRUM512   ALIEN/ST-cONNEXION        "
dc.b "DISPLAY                                 "
dc.b "TECHNIQUE                               "
dc.b "                                        "
dc.b "                                        "
dc.b "TRUECOLOR     CYG/BLABLA                "
dc.b "SPECTRUM512                             "
dc.b "CONVERTER                               "
dc.b "                                        "
dc.b "                                        "
dc.b "VQ AUDIO      ALGORITHM/ONSLAUGHT       "
dc.b "AND VIDEO                               "
dc.b "IDEAS                                   "
dc.b "                                        "
dc.b "                                        "
dc.b "GREENSCREEN   KRAUTMOVIES               "
dc.b "SHOOTING                                "
dc.b "                                        "
dc.b "                                        "
dc.b "VIDEO FOOTAGE THUNDERDOMEVIDEO          "
dc.b "              ID&T ENTERTAINMENT        "
dc.b "                                        "
dc.b "                                        "
dc.b "GREENSCREEN   BRAINHEADSINTERACTIVE     " 
dc.b "AND                                     "
dc.b "VECTORIZATION                           "
dc.b "SOFTWARE                                "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "   THIS DEMO IS NOT ENDORSED BY ID&T.   "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "  ALL EFFECTS IN THIS DEMO CAN RUN ON   "
dc.b "              HALF MEG STF.             "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "             SEE YOU AT THE             "
dc.b "         ST NEWS INTERNATIONAL          "
dc.b "    CHRISTMAS CODING CONFERENCE 2015    "
dc.b "     FOR A NEW LESSON IN ATARI STF      "
dc.b "              EXPLORATION               "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "             THUNDERDOME                "
dc.b "                                        "
dc.b "        TRADITIONS MUST GO ON           "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b "                                        "
dc.b 0




