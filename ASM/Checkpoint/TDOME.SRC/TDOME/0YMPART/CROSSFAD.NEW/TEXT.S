text:           >PART
*               DC.B "0123456789012345678901234567890123456789"
*               DC.B "ABCDEFGHIJKLMNOPQRSTUVWXYZ0123456789!-+*"

                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "              THUNDERDOME               "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "               THE  DEMO                "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "    A CHECKPOINT PRODUCTION IN 2014     "
                DC.B "             FOR ATARI STF              "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "       RELEASED AT SILLY VENTURE        "
                DC.B "           IN GDANSK/POLAND             "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B '                                        '
                DC.B "                                        "
                DC.B "                 CAST                   "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "IDEA          LSL/CHECKPOINT            "
                DC.B "CODE                                    "
                DC.B "DESIGN                                  "
                DC.B "SCRIPT                                  "
                DC.B "COORDINATION                            "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "ADDITIONAL    DEFJAM/CHECKPOINT         "
                DC.B "PROGRAMMING   MODMATE/CHECKPOINT        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "PACKER        M.F.X.J.OBERHUMER         "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "GREENSCREEN   SU                        "
                DC.B "DANCER                                  "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "MUSIC         BERO/FARBRAUSCH           "
                DC.B "DIGITAL PART                            "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "MUSIC         ULTRASYD/BRAINSTORM       "
                DC.B "CHIP PART                               "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "ORIGINAL      VICTOR FEENSTRA           "
                DC.B "GRAPHICS      M-DESIGN WORMERVEER       "
                DC.B "DESIGN        ID&T                      "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "GRAPHICS      ST SURVIVOR               "
                DC.B "DESIGN        MODMATE/CHECKPOINT        "
                DC.B "              EXOCET/CHECKPOINT         "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "3D DESIGN     EXOCET/CHECKPOINT         "
                DC.B "TEXTURING                               "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "SPECTRUM512   ALIEN/ST-CONNEXION        "
                DC.B "DISPLAY                                 "
                DC.B "TECHNIQUE                               "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "TRUECOLOR     CYG/BLABLA                "
                DC.B "SPECTRUM512                             "
                DC.B "CONVERTER                               "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "VQ AUDIO      ALGORITHM/ONSLAUGHT       "
                DC.B "VQ VIDEO                                "
                DC.B "IDEAS                                   "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "GREENSCREEN   KRAUTMOVIES               "
                DC.B "SHOOTING                                "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "VIDEO FOOTAGE THUNDERDOMEVIDEO          "
                DC.B "              ID&T ENTERTAINMENT        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "PICTURES      THUNDERDOME.COM           "
                DC.B "              INTERNET                  "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "GREENSCREEN   BRAINHEADSINTERACTIVE     "
                DC.B "VECTORIZATION                           "
                DC.B "SOFTWARE                                "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "   THIS DEMO IS NOT ENDORSED BY ID&T.   "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "  ALL EFFECTS IN THIS DEMO CAN RUN ON   "
                DC.B "              HALF MEG STF.             "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "         + C H E C K P O I N T +        "
                DC.B "                                        "
                DC.B "                   ARE                  "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "               DEFJAM (DE)              "
                DC.B "                                        "
                DC.B "          EXCELLENCE IN ART (SE)        "
                DC.B "                                        "
                DC.B "               EXOCET (FR)              "
                DC.B "                                        "
                DC.B "             FIVE'O'FIVE (DE)           "
                DC.B "                                        "
                DC.B "              JOE  COOL (DE)            "
                DC.B "                                        "
                DC.B "                 LSL (DE)               "
                DC.B "                                        "
                DC.B "               MODMATE (DE)             "
                DC.B "                                        "
                DC.B "               MR.COKE (DE)             "
                DC.B "                                        "
                DC.B "                SPKR (NL)               "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "               TRADITION                "
                DC.B "                                        "
                DC.B "                 MEANS                  "
                DC.B "                                        "
                DC.B "        KEEPING THE FIRE BURNING        "
                DC.B "                                        "
                DC.B "                  NOT                   "
                DC.B "                                        "
                DC.B "         WORSHIPING THE ASHES.          "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "             SEE YOU AT THE             "
                DC.B "         ST NEWS INTERNATIONAL          "
                DC.B "    CHRISTMAS CODING CONVENTION 2015    "
                DC.B "     FOR A NEW LESSON IN ATARI STF      "
                DC.B "              EXPLORATION!              "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "              THUNDERDOME               "
                DC.B "                                        "
                DC.B "         TRADITIONS MUST GO ON          "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
                DC.B "                                        "
;------------------------------------------------------------------
;-- END OF TEXT ---------------------------------------------------
;------------------------------------------------------------------
                DC.B 0
                EVEN
                ENDPART

