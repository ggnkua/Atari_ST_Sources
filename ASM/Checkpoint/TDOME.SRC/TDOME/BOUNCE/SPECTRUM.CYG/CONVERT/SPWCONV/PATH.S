                PATH 'C:\0NEW\TDOME\SPECTRUM.512\'
                PATH 'CYG\SPECTRUM.CYG\CONVERT\'
                PATH 'SPWCONV\'


