;                     5432109876543210
;    %......................YYYYXXXXoo
;    %..........XXXXooxxx.A.YYYYyyyyy.
;          ($800)address--^           

