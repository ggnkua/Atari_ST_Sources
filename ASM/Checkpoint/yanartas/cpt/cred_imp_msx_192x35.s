*
*  NEOchrome V2.24 cut buffer contents (left justified):
*  by Chaos, Inc. of the Delta Force (member of The Union)
*
*    pixels/scanline    = $00BA (bytes/scanline: $0060)
*  # scanlines (height) = $0024
*
*  Hardware color pallet  (color 0 to 15):
*
*      $0000,$0005,$0070,$0770,$0470,$0070,$0073,$0077
*      $0047,$0007,$0307,$0607,$0706,$0704,$0700,$0730
*
*
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$001E
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$007F
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$00FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$00FF
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$00FF
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$007F
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$007F
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$003C
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C007,$FCF8
		dc.w	$0F07,$FC7F
		dc.w	$C07F,$C0FF
		dc.w	$801F,$C000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$C007,$FDFE
		dc.w	$3FC7,$FC7F
		dc.w	$C1FF,$F8FF
		dc.w	$807F,$F000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$E007,$FFFF
		dc.w	$7FE7,$FC7F
		dc.w	$C3FF,$F0FF
		dc.w	$80FF,$F000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$5007,$FFFF
		dc.w	$FFE7,$FC7F
		dc.w	$C3FF,$F0FF
		dc.w	$81FF,$F000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$48C7,$FFFF
		dc.w	$FFF7,$FC7F
		dc.w	$C7FF,$E0FF
		dc.w	$83FF,$F000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$6647,$FFFF
		dc.w	$FFF7,$FC7F
		dc.w	$C7E0,$E0FF
		dc.w	$83FF,$F000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$2187,$FFFF
		dc.w	$FFF7,$FC7F
		dc.w	$C7F8,$00FF
		dc.w	$87FF,$F000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3007,$FDFF
		dc.w	$BFF7,$FC7F
		dc.w	$C3FF,$80FF
		dc.w	$87FE,$1000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1807,$FCFF
		dc.w	$9FF7,$FC7F
		dc.w	$C3FF,$E0FF
		dc.w	$87FC,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0C07,$FCFF
		dc.w	$9FF7,$FC7F
		dc.w	$C1FF,$F0FF
		dc.w	$87FC,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0607,$FCFF
		dc.w	$9FF7,$FC7F
		dc.w	$C07F,$F8FF
		dc.w	$87FE,$1000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0307,$FCFF
		dc.w	$9FF7,$FC7F
		dc.w	$C20F,$F8FF
		dc.w	$87FF,$F000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0187,$FCFF
		dc.w	$9FF7,$FEFF
		dc.w	$C783,$F8FF
		dc.w	$83FF,$F000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3EC7,$FCFF
		dc.w	$9FF3,$FFFF
		dc.w	$87FF,$F0FF
		dc.w	$83FF,$F000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7FC7,$FCFF
		dc.w	$9FF3,$FFFF
		dc.w	$8FFF,$F0FF
		dc.w	$81FF,$F000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7F87,$FCFF
		dc.w	$9FF1,$FFFF
		dc.w	$0FFF,$E0FF
		dc.w	$80FF,$F000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1E07,$FCFF
		dc.w	$9FF0,$7FFC
		dc.w	$07FF,$C0FF
		dc.w	$807F,$E3FF
		dc.w	$E000,$0000
		dc.w	$0000,$0000
		dc.w	$0007,$FCFF
		dc.w	$9FF0,$0FE0
		dc.w	$00FF,$00FF
		dc.w	$801F,$87FF
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		REPT 120
			dc.w	0
		ENDR