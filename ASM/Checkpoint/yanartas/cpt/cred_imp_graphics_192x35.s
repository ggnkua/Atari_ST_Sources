*
*  NEOchrome V2.24 cut buffer contents (left justified):
*  by Chaos, Inc. of the Delta Force (member of The Union)
*
*    pixels/scanline    = $00BA (bytes/scanline: $0060)
*  # scanlines (height) = $0024
*
*  Hardware color pallet  (color 0 to 15):
*
*      $0000,$0005,$0070,$0770,$0470,$0070,$0073,$0077
*      $0047,$0007,$0307,$0607,$0706,$0704,$0700,$0730
*
*
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3FE0,$0007
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3FE0,$001F
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3FE0,$003F
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3FE0,$003F
		dc.w	$E000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3FE0,$003F
		dc.w	$E000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3FE0,$001F
		dc.w	$E000,$0000
		dc.w	$0000,$0000
		dc.w	$0020,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3FE0,$001F
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0040,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3FE0,$000F
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0040,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3FE0,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$00C0,$7CFF
		dc.w	$BFE7,$81F1
		dc.w	$FF3F,$E3E0
		dc.w	$3FE1,$E03F
		dc.w	$E00F,$E007
		dc.w	$FC00,$0000
		dc.w	$0181,$FEFF
		dc.w	$BFEF,$87FD
		dc.w	$FF3F,$EFF8
		dc.w	$3FE7,$F83F
		dc.w	$E03F,$F81F
		dc.w	$FF80,$0000
		dc.w	$01C3,$FFFF
		dc.w	$BFFF,$8FFF
		dc.w	$FF3F,$FFFC
		dc.w	$3FEF,$FC3F
		dc.w	$E07F,$F83F
		dc.w	$FF00,$0000
		dc.w	$0387,$FFFF
		dc.w	$BFFF,$8FFF
		dc.w	$FF3F,$FFFE
		dc.w	$3FFF,$FC3F
		dc.w	$E0FF,$F83F
		dc.w	$FF00,$0000
		dc.w	$0387,$FFFF
		dc.w	$BFFF,$9FFF
		dc.w	$FF3F,$FFFE
		dc.w	$3FFF,$FE3F
		dc.w	$E1FF,$F87F
		dc.w	$FE00,$0000
		dc.w	$030F,$FFFF
		dc.w	$BFFF,$9FFF
		dc.w	$FF3F,$FFFF
		dc.w	$3FFF,$FE3F
		dc.w	$E1FF,$F87E
		dc.w	$0E00,$0000
		dc.w	$078F,$FFFF
		dc.w	$BFFF,$9FFF
		dc.w	$FF3F,$FFFF
		dc.w	$3FFF,$FE3F
		dc.w	$E3FF,$F87F
		dc.w	$8000,$0000
		dc.w	$070F,$FC7F
		dc.w	$BFF0,$BFF3
		dc.w	$FF3F,$F3FF
		dc.w	$3FE7,$FE3F
		dc.w	$E3FF,$083F
		dc.w	$F800,$0000
		dc.w	$070F,$F83F
		dc.w	$BFE0,$3FE1
		dc.w	$FF3F,$E1FF
		dc.w	$3FE3,$FE3F
		dc.w	$E3FE,$003F
		dc.w	$FE00,$0000
		dc.w	$0F0F,$F83F
		dc.w	$BFE0,$3FE1
		dc.w	$FF3F,$E1FF
		dc.w	$3FE3,$FE3F
		dc.w	$E3FE,$001F
		dc.w	$FF00,$0000
		dc.w	$060F,$FC7F
		dc.w	$BFE0,$3FF3
		dc.w	$FF3F,$F3FF
		dc.w	$3FE3,$FE3F
		dc.w	$E3FF,$0807
		dc.w	$FF80,$0000
		dc.w	$0F0F,$FFFF
		dc.w	$BFE0,$3FFF
		dc.w	$FF3F,$FFFF
		dc.w	$3FE3,$FE3F
		dc.w	$E3FF,$F820
		dc.w	$FF80,$0000
		dc.w	$0E0F,$FFFF
		dc.w	$BFE0,$1FFF
		dc.w	$FF3F,$FFFE
		dc.w	$3FE3,$FE3F
		dc.w	$E1FF,$F878
		dc.w	$3F80,$0000
		dc.w	$0E07,$FFFF
		dc.w	$BFE0,$1FFF
		dc.w	$FF3F,$FFFE
		dc.w	$3FE3,$FE3F
		dc.w	$E1FF,$F87F
		dc.w	$FF00,$0000
		dc.w	$0C07,$FFFF
		dc.w	$BFE0,$1FFF
		dc.w	$FF3F,$FFFC
		dc.w	$3FE3,$FE3F
		dc.w	$E0FF,$F8FF
		dc.w	$FF00,$0000
		dc.w	$0403,$FFFF
		dc.w	$BFE0,$0FFD
		dc.w	$FF3F,$FFFC
		dc.w	$3FE3,$FE3F
		dc.w	$E07F,$F8FF
		dc.w	$FE00,$0000
		dc.w	$0801,$FEFF
		dc.w	$BFE0,$07F9
		dc.w	$FF3F,$EFF8
		dc.w	$3FE3,$FE3F
		dc.w	$E03F,$F07F
		dc.w	$FC3F,$FE00
		dc.w	$0800,$7CFF
		dc.w	$BFE0,$01E1
		dc.w	$FF3F,$E3E0
		dc.w	$3FE3,$FE3F
		dc.w	$E00F,$C00F
		dc.w	$F07F,$FC00
		dc.w	$1C00,$00FF
		dc.w	$8000,$0000
		dc.w	$003F,$E000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1C01,$01FF
		dc.w	$8000,$0000
		dc.w	$003F,$E000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1803,$C3FF
		dc.w	$0000,$0000
		dc.w	$003F,$E000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1003,$FFFF
		dc.w	$0000,$0000
		dc.w	$003F,$E000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$2003,$FFFE
		dc.w	$0000,$0000
		dc.w	$003F,$E000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$8007,$FFFC
		dc.w	$0000,$0000
		dc.w	$003F,$E000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0007,$FFF0
		dc.w	$0000,$0000
		dc.w	$003F,$E000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0001,$FFC0
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		REPT 120
			dc.w	0
		ENDR