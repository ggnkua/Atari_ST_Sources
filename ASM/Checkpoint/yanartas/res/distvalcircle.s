	dc.w 30
	dc.w 29
	dc.w 29
	dc.w 29
	dc.w 29
	dc.w 29
	dc.w 29
	dc.w 29
	dc.w 29
	dc.w 28
	dc.w 28
	dc.w 28
	dc.w 27
	dc.w 27
	dc.w 27
	dc.w 26
	dc.w 26
	dc.w 25
	dc.w 25
	dc.w 24
	dc.w 24
	dc.w 23
	dc.w 23
	dc.w 22
	dc.w 21
	dc.w 21
	dc.w 20
	dc.w 19
	dc.w 19
	dc.w 18
	dc.w 17
	dc.w 16
	dc.w 16
	dc.w 15
	dc.w 14
	dc.w 13
	dc.w 12
	dc.w 11
	dc.w 11
	dc.w 10
	dc.w 9
	dc.w 8
	dc.w 7
	dc.w 6
	dc.w 5
	dc.w 4
	dc.w 3
	dc.w 2
	dc.w 1
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w -1
	dc.w -2
	dc.w -3
	dc.w -4
	dc.w -5
	dc.w -6
	dc.w -7
	dc.w -8
	dc.w -9
	dc.w -10
	dc.w -11
	dc.w -11
	dc.w -12
	dc.w -13
	dc.w -14
	dc.w -15
	dc.w -16
	dc.w -16
	dc.w -17
	dc.w -18
	dc.w -19
	dc.w -19
	dc.w -20
	dc.w -21
	dc.w -21
	dc.w -22
	dc.w -23
	dc.w -23
	dc.w -24
	dc.w -24
	dc.w -25
	dc.w -25
	dc.w -26
	dc.w -26
	dc.w -27
	dc.w -27
	dc.w -27
	dc.w -28
	dc.w -28
	dc.w -28
	dc.w -29
	dc.w -29
	dc.w -29
	dc.w -29
	dc.w -29
	dc.w -29
	dc.w -29
	dc.w -29
	dc.w -30
	dc.w -29
	dc.w -29
	dc.w -29
	dc.w -29
	dc.w -29
	dc.w -29
	dc.w -29
	dc.w -29
	dc.w -28
	dc.w -28
	dc.w -28
	dc.w -27
	dc.w -27
	dc.w -27
	dc.w -26
	dc.w -26
	dc.w -25
	dc.w -25
	dc.w -24
	dc.w -24
	dc.w -23
	dc.w -23
	dc.w -22
	dc.w -21
	dc.w -21
	dc.w -20
	dc.w -19
	dc.w -19
	dc.w -18
	dc.w -17
	dc.w -16
	dc.w -16
	dc.w -15
	dc.w -14
	dc.w -13
	dc.w -12
	dc.w -11
	dc.w -11
	dc.w -10
	dc.w -9
	dc.w -8
	dc.w -7
	dc.w -6
	dc.w -5
	dc.w -4
	dc.w -3
	dc.w -2
	dc.w -1
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 1
	dc.w 2
	dc.w 3
	dc.w 4
	dc.w 5
	dc.w 6
	dc.w 7
	dc.w 8
	dc.w 9
	dc.w 10
	dc.w 11
	dc.w 11
	dc.w 12
	dc.w 13
	dc.w 14
	dc.w 15
	dc.w 16
	dc.w 16
	dc.w 17
	dc.w 18
	dc.w 19
	dc.w 19
	dc.w 20
	dc.w 21
	dc.w 21
	dc.w 22
	dc.w 23
	dc.w 23
	dc.w 24
	dc.w 24
	dc.w 25
	dc.w 25
	dc.w 26
	dc.w 26
	dc.w 27
	dc.w 27
	dc.w 27
	dc.w 28
	dc.w 28
	dc.w 28
	dc.w 29
	dc.w 29
	dc.w 29
	dc.w 29
	dc.w 29
	dc.w 29
	dc.w 29
	dc.w 29
	dc.w 30
	dc.w 29
	dc.w 29
	dc.w 29
	dc.w 29
	dc.w 29
	dc.w 29
	dc.w 29
	dc.w 29
	dc.w 28
	dc.w 28
	dc.w 28
	dc.w 27
	dc.w 27
	dc.w 27
	dc.w 26
	dc.w 26
	dc.w 25
	dc.w 25
	dc.w 24
	dc.w 24
	dc.w 23
	dc.w 23
	dc.w 22
	dc.w 21
	dc.w 21
	dc.w 20
	dc.w 19
	dc.w 19
	dc.w 18
	dc.w 17
	dc.w 16
	dc.w 16
	dc.w 15
	dc.w 14
	dc.w 13
	dc.w 12
	dc.w 11
	dc.w 11
	dc.w 10
	dc.w 9
	dc.w 8
	dc.w 7
	dc.w 6
	dc.w 5
	dc.w 4
	dc.w 3
	dc.w 2
	dc.w 1
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w -1
	dc.w -2
	dc.w -3
	dc.w -4
	dc.w -5
	dc.w -6
	dc.w -7
	dc.w -8
	dc.w -9
	dc.w -10
	dc.w -11
	dc.w -11
	dc.w -12
	dc.w -13
	dc.w -14
	dc.w -15
	dc.w -16
	dc.w -16
	dc.w -17
	dc.w -18
	dc.w -19
	dc.w -19
	dc.w -20
	dc.w -21
	dc.w -21
	dc.w -22
	dc.w -23
	dc.w -23
	dc.w -24
	dc.w -24
	dc.w -25
	dc.w -25
	dc.w -26
	dc.w -26
	dc.w -27
	dc.w -27
	dc.w -27
	dc.w -28
	dc.w -28
	dc.w -28
	dc.w -29
	dc.w -29
	dc.w -29
	dc.w -29
	dc.w -29
	dc.w -29
	dc.w -29
	dc.w -29
	dc.w -30
	dc.w -29
	dc.w -29
	dc.w -29
	dc.w -29
	dc.w -29
	dc.w -29
	dc.w -29
	dc.w -29
	dc.w -28
	dc.w -28
	dc.w -28
	dc.w -27
	dc.w -27
	dc.w -27
	dc.w -26
	dc.w -26
	dc.w -25
	dc.w -25
	dc.w -24
	dc.w -24
	dc.w -23
	dc.w -23
	dc.w -22
	dc.w -21
	dc.w -21
	dc.w -20
	dc.w -19
	dc.w -19
	dc.w -18
	dc.w -17
	dc.w -16
	dc.w -16
	dc.w -15
	dc.w -14
	dc.w -13
	dc.w -12
	dc.w -11
	dc.w -11
	dc.w -10
	dc.w -9
	dc.w -8
	dc.w -7
	dc.w -6
	dc.w -5
	dc.w -4
	dc.w -3
	dc.w -2
	dc.w -1
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 1
	dc.w 2
	dc.w 3
	dc.w 4
	dc.w 5
	dc.w 6
	dc.w 7
	dc.w 8
	dc.w 9
	dc.w 10
	dc.w 11
	dc.w 11
	dc.w 12
	dc.w 13
	dc.w 14
	dc.w 15
	dc.w 16
	dc.w 16
	dc.w 17
	dc.w 18
	dc.w 19
	dc.w 19
	dc.w 20
	dc.w 21
	dc.w 21
	dc.w 22
	dc.w 23
	dc.w 23
	dc.w 24
	dc.w 24
	dc.w 25
	dc.w 25
	dc.w 26
	dc.w 26
	dc.w 27
	dc.w 27
	dc.w 27
	dc.w 28
	dc.w 28
	dc.w 28
	dc.w 29
	dc.w 29
	dc.w 29
	dc.w 29
	dc.w 29
	dc.w 29
	dc.w 29
	dc.w 29
	dc.w 30
	dc.w 29
	dc.w 29
	dc.w 29
	dc.w 29
	dc.w 29
	dc.w 29
	dc.w 29
	dc.w 29
	dc.w 28
	dc.w 28
	dc.w 28
	dc.w 27
	dc.w 27
	dc.w 27
	dc.w 26
	dc.w 26
	dc.w 25
	dc.w 25
	dc.w 24
	dc.w 24
	dc.w 23
	dc.w 23
	dc.w 22
	dc.w 21
	dc.w 21
	dc.w 20
	dc.w 19
	dc.w 19
	dc.w 18
	dc.w 17
	dc.w 16
	dc.w 16
	dc.w 15
	dc.w 14
	dc.w 13
	dc.w 12
	dc.w 11
	dc.w 11
	dc.w 10
	dc.w 9
	dc.w 8
	dc.w 7
	dc.w 6
	dc.w 5
	dc.w 4
	dc.w 3
	dc.w 2
	dc.w 1
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w -1
	dc.w -2
	dc.w -3
	dc.w -4
	dc.w -5
	dc.w -6
	dc.w -7
	dc.w -8
	dc.w -9
	dc.w -10
	dc.w -11
	dc.w -11
	dc.w -12
	dc.w -13
	dc.w -14
	dc.w -15
	dc.w -16
	dc.w -16
	dc.w -17
	dc.w -18
	dc.w -19
	dc.w -19
	dc.w -20
	dc.w -21
	dc.w -21
	dc.w -22
	dc.w -23
	dc.w -23
	dc.w -24
	dc.w -24
	dc.w -25
	dc.w -25
	dc.w -26
	dc.w -26
	dc.w -27
	dc.w -27
	dc.w -27
	dc.w -28
	dc.w -28
	dc.w -28
	dc.w -29
	dc.w -29
	dc.w -29
	dc.w -29
	dc.w -29
	dc.w -29
	dc.w -29
	dc.w -29
	dc.w -30
	dc.w -29
	dc.w -29
	dc.w -29
	dc.w -29
	dc.w -29
	dc.w -29
	dc.w -29
	dc.w -29
	dc.w -28
	dc.w -28
	dc.w -28
	dc.w -27
	dc.w -27
	dc.w -27
	dc.w -26
	dc.w -26
	dc.w -25
	dc.w -25
	dc.w -24
	dc.w -24
	dc.w -23
	dc.w -23
	dc.w -22
	dc.w -21
	dc.w -21
	dc.w -20
	dc.w -19
	dc.w -19
	dc.w -18
	dc.w -17
	dc.w -16
	dc.w -16
	dc.w -15
	dc.w -14
	dc.w -13
	dc.w -12
	dc.w -11
	dc.w -11
	dc.w -10
	dc.w -9
	dc.w -8
	dc.w -7
	dc.w -6
	dc.w -5
	dc.w -4
	dc.w -3
	dc.w -2
	dc.w -1
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 1
	dc.w 2
	dc.w 3
	dc.w 4
	dc.w 5
	dc.w 6
	dc.w 7
	dc.w 8
	dc.w 9
	dc.w 10
	dc.w 11
	dc.w 11
	dc.w 12
	dc.w 13
	dc.w 14
	dc.w 15
	dc.w 16
	dc.w 16
	dc.w 17
	dc.w 18
	dc.w 19
	dc.w 19
	dc.w 20
	dc.w 21
	dc.w 21
	dc.w 22
	dc.w 23
	dc.w 23
	dc.w 24
	dc.w 24
	dc.w 25
	dc.w 25
	dc.w 26
	dc.w 26
	dc.w 27
	dc.w 27
	dc.w 27
	dc.w 28
	dc.w 28
	dc.w 28
	dc.w 29
	dc.w 29
	dc.w 29
	dc.w 29
	dc.w 29
	dc.w 29
	dc.w 29
	dc.w 29
