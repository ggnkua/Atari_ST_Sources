	dc.w	160
	dc.w	162
	dc.w	165
	dc.w	167
	dc.w	170
	dc.w	172
	dc.w	175
	dc.w	177
	dc.w	179
	dc.w	182
	dc.w	184
	dc.w	186
	dc.w	189
	dc.w	191
	dc.w	193
	dc.w	195
	dc.w	198
	dc.w	200
	dc.w	202
	dc.w	204
	dc.w	206
	dc.w	208
	dc.w	210
	dc.w	212
	dc.w	213
	dc.w	215
	dc.w	217
	dc.w	219
	dc.w	220
	dc.w	222
	dc.w	223
	dc.w	225
	dc.w	226
	dc.w	227
	dc.w	228
	dc.w	229
	dc.w	231
	dc.w	232
	dc.w	233
	dc.w	233
	dc.w	234
	dc.w	235
	dc.w	236
	dc.w	236
	dc.w	237
	dc.w	237
	dc.w	237
	dc.w	238
	dc.w	238
	dc.w	238
	dc.w	238
	dc.w	238
	dc.w	238
	dc.w	238
	dc.w	237
	dc.w	237
	dc.w	237
	dc.w	236
	dc.w	236
	dc.w	235
	dc.w	234
	dc.w	233
	dc.w	233
	dc.w	232
	dc.w	231
	dc.w	229
	dc.w	228
	dc.w	227
	dc.w	226
	dc.w	225
	dc.w	223
	dc.w	222
	dc.w	220
	dc.w	219
	dc.w	217
	dc.w	215
	dc.w	213
	dc.w	212
	dc.w	210
	dc.w	208
	dc.w	206
	dc.w	204
	dc.w	202
	dc.w	200
	dc.w	198
	dc.w	195
	dc.w	193
	dc.w	191
	dc.w	189
	dc.w	186
	dc.w	184
	dc.w	182
	dc.w	179
	dc.w	177
	dc.w	175
	dc.w	172
	dc.w	170
	dc.w	167
	dc.w	165
	dc.w	162
	dc.w	160
	dc.w	158
	dc.w	155
	dc.w	153
	dc.w	150
	dc.w	148
	dc.w	145
	dc.w	143
	dc.w	141
	dc.w	138
	dc.w	136
	dc.w	134
	dc.w	131
	dc.w	129
	dc.w	127
	dc.w	125
	dc.w	122
	dc.w	120
	dc.w	118
	dc.w	116
	dc.w	114
	dc.w	112
	dc.w	110
	dc.w	108
	dc.w	107
	dc.w	105
	dc.w	103
	dc.w	101
	dc.w	100
	dc.w	98
	dc.w	97
	dc.w	95
	dc.w	94
	dc.w	93
	dc.w	92
	dc.w	91
	dc.w	89
	dc.w	88
	dc.w	87
	dc.w	87
	dc.w	86
	dc.w	85
	dc.w	84
	dc.w	84
	dc.w	83
	dc.w	83
	dc.w	83
	dc.w	82
	dc.w	82
	dc.w	82
	dc.w	82
	dc.w	82
	dc.w	82
	dc.w	82
	dc.w	83
	dc.w	83
	dc.w	83
	dc.w	84
	dc.w	84
	dc.w	85
	dc.w	86
	dc.w	87
	dc.w	87
	dc.w	88
	dc.w	89
	dc.w	91
	dc.w	92
	dc.w	93
	dc.w	94
	dc.w	95
	dc.w	97
	dc.w	98
	dc.w	100
	dc.w	101
	dc.w	103
	dc.w	105
	dc.w	107
	dc.w	108
	dc.w	110
	dc.w	112
	dc.w	114
	dc.w	116
	dc.w	118
	dc.w	120
	dc.w	122
	dc.w	125
	dc.w	127
	dc.w	129
	dc.w	131
	dc.w	134
	dc.w	136
	dc.w	138
	dc.w	141
	dc.w	143
	dc.w	145
	dc.w	148
	dc.w	150
	dc.w	153
	dc.w	155
	dc.w	158
