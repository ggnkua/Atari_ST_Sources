pathnew1:
	dc.l	160,135
	dc.l	160,135
	dc.l	161,135
	dc.l	161,135
	dc.l	162,135
	dc.l	162,135
	dc.l	162,134
	dc.l	163,134
	dc.l	163,134
	dc.l	164,134
	dc.l	164,133
	dc.l	164,133
	dc.l	165,133
	dc.l	165,132
	dc.l	165,132
	dc.l	166,131
	dc.l	166,131
	dc.l	167,130
	dc.l	167,130
	dc.l	167,129
	dc.l	168,128
	dc.l	168,128
	dc.l	168,127
	dc.l	169,126
	dc.l	169,126
	dc.l	170,125
	dc.l	170,124
	dc.l	170,123
	dc.l	171,122
	dc.l	171,121
	dc.l	171,121
	dc.l	172,120
	dc.l	172,119
	dc.l	172,118
	dc.l	173,117
	dc.l	173,116
	dc.l	173,115
	dc.l	174,114
	dc.l	174,113
	dc.l	174,112
	dc.l	175,111
	dc.l	175,110
	dc.l	175,109
	dc.l	176,108
	dc.l	176,107
	dc.l	176,105
	dc.l	177,104
	dc.l	177,103
	dc.l	177,102
	dc.l	177,101
	dc.l	178,100
	dc.l	178,99
	dc.l	178,98
	dc.l	178,97
	dc.l	179,96
	dc.l	179,95
	dc.l	179,93
	dc.l	180,92
	dc.l	180,91
	dc.l	180,90
	dc.l	180,89
	dc.l	180,88
	dc.l	181,87
	dc.l	181,86
	dc.l	181,85
	dc.l	181,84
	dc.l	182,83
	dc.l	182,82
	dc.l	182,81
	dc.l	182,80
	dc.l	182,79
	dc.l	182,79
	dc.l	183,78
	dc.l	183,77
	dc.l	183,76
	dc.l	183,75
	dc.l	183,74
	dc.l	183,74
	dc.l	184,73
	dc.l	184,72
	dc.l	184,72
	dc.l	184,71
	dc.l	184,70
	dc.l	184,70
	dc.l	184,69
	dc.l	184,69
	dc.l	184,68
	dc.l	184,68
	dc.l	185,67
	dc.l	185,67
	dc.l	185,67
	dc.l	185,66
	dc.l	185,66
	dc.l	185,66
	dc.l	185,66
	dc.l	185,65
	dc.l	185,65
	dc.l	185,65
	dc.l	185,65
	dc.l	185,65
	dc.l	185,65
	dc.l	185,65
	dc.l	185,65
	dc.l	185,65
	dc.l	185,65
	dc.l	185,65
	dc.l	185,66
	dc.l	185,66
	dc.l	185,66
	dc.l	185,66
	dc.l	185,67
	dc.l	185,67
	dc.l	185,67
	dc.l	184,68
	dc.l	184,68
	dc.l	184,69
	dc.l	184,69
	dc.l	184,70
	dc.l	184,70
	dc.l	184,71
	dc.l	184,72
	dc.l	184,72
	dc.l	184,73
	dc.l	183,74
	dc.l	183,74
	dc.l	183,75
	dc.l	183,76
	dc.l	183,77
	dc.l	183,78
	dc.l	182,79
	dc.l	182,79
	dc.l	182,80
	dc.l	182,81
	dc.l	182,82
	dc.l	182,83
	dc.l	181,84
	dc.l	181,85
	dc.l	181,86
	dc.l	181,87
	dc.l	180,88
	dc.l	180,89
	dc.l	180,90
	dc.l	180,91
	dc.l	180,92
	dc.l	179,93
	dc.l	179,95
	dc.l	179,96
	dc.l	178,97
	dc.l	178,98
	dc.l	178,99
	dc.l	178,100
	dc.l	177,101
	dc.l	177,102
	dc.l	177,103
	dc.l	177,104
	dc.l	176,105
	dc.l	176,107
	dc.l	176,108
	dc.l	175,109
	dc.l	175,110
	dc.l	175,111
	dc.l	174,112
	dc.l	174,113
	dc.l	174,114
	dc.l	173,115
	dc.l	173,116
	dc.l	173,117
	dc.l	172,118
	dc.l	172,119
	dc.l	172,120
	dc.l	171,121
	dc.l	171,121
	dc.l	171,122
	dc.l	170,123
	dc.l	170,124
	dc.l	170,125
	dc.l	169,126
	dc.l	169,126
	dc.l	168,127
	dc.l	168,128
	dc.l	168,128
	dc.l	167,129
	dc.l	167,130
	dc.l	167,130
	dc.l	166,131
	dc.l	166,131
	dc.l	165,132
	dc.l	165,132
	dc.l	165,133
	dc.l	164,133
	dc.l	164,133
	dc.l	164,134
	dc.l	163,134
	dc.l	163,134
	dc.l	162,134
	dc.l	162,135
	dc.l	162,135
	dc.l	161,135
	dc.l	161,135
	dc.l	160,135
	dc.l	160,135
	dc.l	160,135
	dc.l	159,135
	dc.l	159,135
	dc.l	158,135
	dc.l	158,135
	dc.l	158,134
	dc.l	157,134
	dc.l	157,134
	dc.l	156,134
	dc.l	156,133
	dc.l	156,133
	dc.l	155,133
	dc.l	155,132
	dc.l	155,132
	dc.l	154,131
	dc.l	154,131
	dc.l	153,130
	dc.l	153,130
	dc.l	153,129
	dc.l	152,128
	dc.l	152,128
	dc.l	152,127
	dc.l	151,126
	dc.l	151,126
	dc.l	150,125
	dc.l	150,124
	dc.l	150,123
	dc.l	149,122
	dc.l	149,121
	dc.l	149,121
	dc.l	148,120
	dc.l	148,119
	dc.l	148,118
	dc.l	147,117
	dc.l	147,116
	dc.l	147,115
	dc.l	146,114
	dc.l	146,113
	dc.l	146,112
	dc.l	145,111
	dc.l	145,110
	dc.l	145,109
	dc.l	144,108
	dc.l	144,107
	dc.l	144,105
	dc.l	143,104
	dc.l	143,103
	dc.l	143,102
	dc.l	143,101
	dc.l	142,100
	dc.l	142,99
	dc.l	142,98
	dc.l	142,97
	dc.l	141,96
	dc.l	141,95
	dc.l	141,93
	dc.l	140,92
	dc.l	140,91
	dc.l	140,90
	dc.l	140,89
	dc.l	140,88
	dc.l	139,87
	dc.l	139,86
	dc.l	139,85
	dc.l	139,84
	dc.l	138,83
	dc.l	138,82
	dc.l	138,81
	dc.l	138,80
	dc.l	138,79
	dc.l	138,79
	dc.l	137,78
	dc.l	137,77
	dc.l	137,76
	dc.l	137,75
	dc.l	137,74
	dc.l	137,74
	dc.l	136,73
	dc.l	136,72
	dc.l	136,72
	dc.l	136,71
	dc.l	136,70
	dc.l	136,70
	dc.l	136,69
	dc.l	136,69
	dc.l	136,68
	dc.l	136,68
	dc.l	135,67
	dc.l	135,67
	dc.l	135,67
	dc.l	135,66
	dc.l	135,66
	dc.l	135,66
	dc.l	135,66
	dc.l	135,65
	dc.l	135,65
	dc.l	135,65
	dc.l	135,65
	dc.l	135,65
	dc.l	135,65
	dc.l	135,65
	dc.l	135,65
	dc.l	135,65
	dc.l	135,65
	dc.l	135,65
	dc.l	135,66
	dc.l	135,66
	dc.l	135,66
	dc.l	135,66
	dc.l	135,67
	dc.l	135,67
	dc.l	135,67
	dc.l	136,68
	dc.l	136,68
	dc.l	136,69
	dc.l	136,69
	dc.l	136,70
	dc.l	136,70
	dc.l	136,71
	dc.l	136,72
	dc.l	136,72
	dc.l	136,73
	dc.l	137,74
	dc.l	137,74
	dc.l	137,75
	dc.l	137,76
	dc.l	137,77
	dc.l	137,78
	dc.l	138,79
	dc.l	138,79
	dc.l	138,80
	dc.l	138,81
	dc.l	138,82
	dc.l	138,83
	dc.l	139,84
	dc.l	139,85
	dc.l	139,86
	dc.l	139,87
	dc.l	140,88
	dc.l	140,89
	dc.l	140,90
	dc.l	140,91
	dc.l	140,92
	dc.l	141,93
	dc.l	141,95
	dc.l	141,96
	dc.l	142,97
	dc.l	142,98
	dc.l	142,99
	dc.l	142,100
	dc.l	143,101
	dc.l	143,102
	dc.l	143,103
	dc.l	143,104
	dc.l	144,105
	dc.l	144,107
	dc.l	144,108
	dc.l	145,109
	dc.l	145,110
	dc.l	145,111
	dc.l	146,112
	dc.l	146,113
	dc.l	146,114
	dc.l	147,115
	dc.l	147,116
	dc.l	147,117
	dc.l	148,118
	dc.l	148,119
	dc.l	148,120
	dc.l	149,121
	dc.l	149,121
	dc.l	149,122
	dc.l	150,123
	dc.l	150,124
	dc.l	150,125
	dc.l	151,126
	dc.l	151,126
	dc.l	152,127
	dc.l	152,128
	dc.l	152,128
	dc.l	153,129
	dc.l	153,130
	dc.l	153,130
	dc.l	154,131
	dc.l	154,131
	dc.l	155,132
	dc.l	155,132
	dc.l	155,133
	dc.l	156,133
	dc.l	156,133
	dc.l	156,134
	dc.l	157,134
	dc.l	157,134
	dc.l	158,134
	dc.l	158,135
	dc.l	158,135
	dc.l	159,135
	dc.l	159,135
	dc.l	160,135

pathnew2:
	dc.l	190,130
	dc.l	190,130
	dc.l	190,130
	dc.l	190,130
	dc.l	189,130
	dc.l	189,130
	dc.l	189,129
	dc.l	188,129
	dc.l	188,129
	dc.l	187,129
	dc.l	187,129
	dc.l	186,128
	dc.l	185,128
	dc.l	185,128
	dc.l	184,127
	dc.l	183,127
	dc.l	182,126
	dc.l	181,126
	dc.l	180,125
	dc.l	179,125
	dc.l	178,124
	dc.l	176,124
	dc.l	175,123
	dc.l	174,123
	dc.l	173,122
	dc.l	171,121
	dc.l	170,121
	dc.l	169,120
	dc.l	167,119
	dc.l	166,118
	dc.l	165,118
	dc.l	163,117
	dc.l	162,116
	dc.l	160,115
	dc.l	159,114
	dc.l	158,114
	dc.l	156,113
	dc.l	155,112
	dc.l	153,111
	dc.l	152,110
	dc.l	151,109
	dc.l	149,108
	dc.l	148,107
	dc.l	147,107
	dc.l	146,106
	dc.l	144,105
	dc.l	143,104
	dc.l	142,103
	dc.l	141,102
	dc.l	140,101
	dc.l	139,100
	dc.l	138,99
	dc.l	137,98
	dc.l	136,97
	dc.l	135,96
	dc.l	134,95
	dc.l	134,94
	dc.l	133,93
	dc.l	132,93
	dc.l	132,92
	dc.l	131,91
	dc.l	131,90
	dc.l	131,89
	dc.l	130,88
	dc.l	130,87
	dc.l	130,86
	dc.l	130,86
	dc.l	130,85
	dc.l	130,84
	dc.l	130,83
	dc.l	130,82
	dc.l	131,82
	dc.l	131,81
	dc.l	131,80
	dc.l	132,79
	dc.l	132,79
	dc.l	133,78
	dc.l	133,77
	dc.l	134,77
	dc.l	135,76
	dc.l	136,76
	dc.l	137,75
	dc.l	137,75
	dc.l	138,74
	dc.l	139,74
	dc.l	141,73
	dc.l	142,73
	dc.l	143,72
	dc.l	144,72
	dc.l	145,72
	dc.l	146,71
	dc.l	148,71
	dc.l	149,71
	dc.l	150,71
	dc.l	152,71
	dc.l	153,70
	dc.l	154,70
	dc.l	156,70
	dc.l	157,70
	dc.l	159,70
	dc.l	160,70
	dc.l	161,70
	dc.l	163,70
	dc.l	164,70
	dc.l	166,70
	dc.l	167,70
	dc.l	168,71
	dc.l	170,71
	dc.l	171,71
	dc.l	172,71
	dc.l	174,71
	dc.l	175,72
	dc.l	176,72
	dc.l	177,72
	dc.l	178,73
	dc.l	179,73
	dc.l	181,74
	dc.l	182,74
	dc.l	183,75
	dc.l	183,75
	dc.l	184,76
	dc.l	185,76
	dc.l	186,77
	dc.l	187,77
	dc.l	187,78
	dc.l	188,79
	dc.l	188,79
	dc.l	189,80
	dc.l	189,81
	dc.l	189,82
	dc.l	190,82
	dc.l	190,83
	dc.l	190,84
	dc.l	190,85
	dc.l	190,86
	dc.l	190,86
	dc.l	190,87
	dc.l	190,88
	dc.l	189,89
	dc.l	189,90
	dc.l	189,91
	dc.l	188,92
	dc.l	188,93
	dc.l	187,93
	dc.l	186,94
	dc.l	186,95
	dc.l	185,96
	dc.l	184,97
	dc.l	183,98
	dc.l	182,99
	dc.l	181,100
	dc.l	180,101
	dc.l	179,102
	dc.l	178,103
	dc.l	177,104
	dc.l	176,105
	dc.l	174,106
	dc.l	173,107
	dc.l	172,107
	dc.l	171,108
	dc.l	169,109
	dc.l	168,110
	dc.l	167,111
	dc.l	165,112
	dc.l	164,113
	dc.l	162,114
	dc.l	161,114
	dc.l	160,115
	dc.l	158,116
	dc.l	157,117
	dc.l	155,118
	dc.l	154,118
	dc.l	153,119
	dc.l	151,120
	dc.l	150,121
	dc.l	149,121
	dc.l	147,122
	dc.l	146,123
	dc.l	145,123
	dc.l	144,124
	dc.l	142,124
	dc.l	141,125
	dc.l	140,125
	dc.l	139,126
	dc.l	138,126
	dc.l	137,127
	dc.l	136,127
	dc.l	135,128
	dc.l	135,128
	dc.l	134,128
	dc.l	133,129
	dc.l	133,129
	dc.l	132,129
	dc.l	132,129
	dc.l	131,129
	dc.l	131,130
	dc.l	131,130
	dc.l	130,130
	dc.l	130,130
	dc.l	130,130
	dc.l	130,130
	dc.l	130,130
	dc.l	130,130
	dc.l	130,130
	dc.l	131,130
	dc.l	131,130
	dc.l	131,129
	dc.l	132,129
	dc.l	132,129
	dc.l	133,129
	dc.l	133,129
	dc.l	134,128
	dc.l	135,128
	dc.l	135,128
	dc.l	136,127
	dc.l	137,127
	dc.l	138,126
	dc.l	139,126
	dc.l	140,125
	dc.l	141,125
	dc.l	142,124
	dc.l	144,124
	dc.l	145,123
	dc.l	146,123
	dc.l	147,122
	dc.l	149,121
	dc.l	150,121
	dc.l	151,120
	dc.l	153,119
	dc.l	154,118
	dc.l	155,118
	dc.l	157,117
	dc.l	158,116
	dc.l	160,115
	dc.l	161,114
	dc.l	162,114
	dc.l	164,113
	dc.l	165,112
	dc.l	167,111
	dc.l	168,110
	dc.l	169,109
	dc.l	171,108
	dc.l	172,107
	dc.l	173,107
	dc.l	174,106
	dc.l	176,105
	dc.l	177,104
	dc.l	178,103
	dc.l	179,102
	dc.l	180,101
	dc.l	181,100
	dc.l	182,99
	dc.l	183,98
	dc.l	184,97
	dc.l	185,96
	dc.l	186,95
	dc.l	186,94
	dc.l	187,93
	dc.l	188,93
	dc.l	188,92
	dc.l	189,91
	dc.l	189,90
	dc.l	189,89
	dc.l	190,88
	dc.l	190,87
	dc.l	190,86
	dc.l	190,86
	dc.l	190,85
	dc.l	190,84
	dc.l	190,83
	dc.l	190,82
	dc.l	189,82
	dc.l	189,81
	dc.l	189,80
	dc.l	188,79
	dc.l	188,79
	dc.l	187,78
	dc.l	187,77
	dc.l	186,77
	dc.l	185,76
	dc.l	184,76
	dc.l	183,75
	dc.l	183,75
	dc.l	182,74
	dc.l	181,74
	dc.l	179,73
	dc.l	178,73
	dc.l	177,72
	dc.l	176,72
	dc.l	175,72
	dc.l	174,71
	dc.l	172,71
	dc.l	171,71
	dc.l	170,71
	dc.l	168,71
	dc.l	167,70
	dc.l	166,70
	dc.l	164,70
	dc.l	163,70
	dc.l	161,70
	dc.l	160,70
	dc.l	159,70
	dc.l	157,70
	dc.l	156,70
	dc.l	154,70
	dc.l	153,70
	dc.l	152,71
	dc.l	150,71
	dc.l	149,71
	dc.l	148,71
	dc.l	146,71
	dc.l	145,72
	dc.l	144,72
	dc.l	143,72
	dc.l	142,73
	dc.l	141,73
	dc.l	139,74
	dc.l	138,74
	dc.l	137,75
	dc.l	137,75
	dc.l	136,76
	dc.l	135,76
	dc.l	134,77
	dc.l	133,77
	dc.l	133,78
	dc.l	132,79
	dc.l	132,79
	dc.l	131,80
	dc.l	131,81
	dc.l	131,82
	dc.l	130,82
	dc.l	130,83
	dc.l	130,84
	dc.l	130,85
	dc.l	130,86
	dc.l	130,86
	dc.l	130,87
	dc.l	130,88
	dc.l	131,89
	dc.l	131,90
	dc.l	131,91
	dc.l	132,92
	dc.l	132,93
	dc.l	133,93
	dc.l	134,94
	dc.l	134,95
	dc.l	135,96
	dc.l	136,97
	dc.l	137,98
	dc.l	138,99
	dc.l	139,100
	dc.l	140,101
	dc.l	141,102
	dc.l	142,103
	dc.l	143,104
	dc.l	144,105
	dc.l	146,106
	dc.l	147,107
	dc.l	148,107
	dc.l	149,108
	dc.l	151,109
	dc.l	152,110
	dc.l	153,111
	dc.l	155,112
	dc.l	156,113
	dc.l	158,114
	dc.l	159,114
	dc.l	160,115
	dc.l	162,116
	dc.l	163,117
	dc.l	165,118
	dc.l	166,118
	dc.l	167,119
	dc.l	169,120
	dc.l	170,121
	dc.l	171,121
	dc.l	173,122
	dc.l	174,123
	dc.l	175,123
	dc.l	176,124
	dc.l	178,124
	dc.l	179,125
	dc.l	180,125
	dc.l	181,126
	dc.l	182,126
	dc.l	183,127
	dc.l	184,127
	dc.l	185,128
	dc.l	185,128
	dc.l	186,128
	dc.l	187,129
	dc.l	187,129
	dc.l	188,129
	dc.l	188,129
	dc.l	189,129
	dc.l	189,130
	dc.l	189,130
	dc.l	190,130
	dc.l	190,130
	dc.l	190,130
