	dc.w	478,120,0
	dc.w	492,120,0
	dc.w	492,98,0
	dc.w	492,80,0
	dc.w	492,62,0
	dc.w	492,48,0
	dc.w	490,36,0
	dc.w	490,24,0
	dc.w	488,14,0
	dc.w	486,6,0
	dc.w	484,0,0
	dc.w	482,506,0
	dc.w	480,498,0
	dc.w	476,492,0
	dc.w	472,486,0
	dc.w	466,478,0
	dc.w	462,472,0
	dc.w	454,466,0
	dc.w	448,460,0
	dc.w	440,454,0
	dc.w	432,450,0
	dc.w	422,444,0
	dc.w	414,442,0
	dc.w	406,438,0
	dc.w	396,436,0
	dc.w	388,434,0
	dc.w	388,434,0
	dc.w	388,434,0
	dc.w	388,434,0
	dc.w	388,434,0
	dc.w	388,434,0
	dc.w	388,434,0
	dc.w	388,434,0
	dc.w	388,434,0
	dc.w	388,434,0
	dc.w	388,434,0
	dc.w	388,434,0
	dc.w	388,434,0
	dc.w	388,466,0
	dc.w	394,466,0
	dc.w	400,468,0
	dc.w	408,470,0
	dc.w	414,472,0
	dc.w	418,476,0
	dc.w	424,480,0
	dc.w	430,484,0
	dc.w	436,488,0
	dc.w	442,494,0
	dc.w	446,500,0
	dc.w	452,506,0
	dc.w	458,0,0
	dc.w	462,8,0
	dc.w	466,18,0
	dc.w	468,28,0
	dc.w	472,40,0
	dc.w	474,52,0
	dc.w	474,64,0
	dc.w	476,76,0
	dc.w	476,86,0
	dc.w	478,98,0
	dc.w	478,106,0
	dc.w	478,114,0
	dc.w	498,120,0
	dc.w	498,434,0
	dc.w	498,102,0
	dc.w	498,84,0
	dc.w	498,66,0
	dc.w	498,48,0
	dc.w	498,30,0
	dc.w	498,12,0
	dc.w	498,508,0
	dc.w	498,490,0
	dc.w	498,472,0
	dc.w	498,452,0
	dc.w	506,120,0
	dc.w	498,110,0
	dc.w	498,444,0
	dc.w	498,92,0
	dc.w	498,74,0
	dc.w	498,56,0
	dc.w	498,38,0
	dc.w	498,20,0
	dc.w	498,2,0
	dc.w	498,498,0
	dc.w	498,480,0
	dc.w	498,462,0
	dc.w	506,434,0
	dc.w	388,442,0
	dc.w	388,450,0
	dc.w	388,458,0
	dc.w	484,120,0
	dc.w	34,120,0
	dc.w	20,120,0
	dc.w	20,98,0
	dc.w	20,80,0
	dc.w	20,62,0
	dc.w	20,48,0
	dc.w	22,36,0
	dc.w	22,24,0
	dc.w	24,14,0
	dc.w	26,6,0
	dc.w	28,0,0
	dc.w	30,506,0
	dc.w	32,498,0
	dc.w	36,492,0
	dc.w	40,486,0
	dc.w	46,478,0
	dc.w	50,472,0
	dc.w	58,466,0
	dc.w	64,460,0
	dc.w	72,454,0
	dc.w	80,450,0
	dc.w	90,444,0
	dc.w	98,442,0
	dc.w	106,438,0
	dc.w	116,436,0
	dc.w	124,434,0
	dc.w	124,434,0
	dc.w	124,434,0
	dc.w	124,434,0
	dc.w	124,434,0
	dc.w	124,434,0
	dc.w	124,434,0
	dc.w	124,434,0
	dc.w	124,434,0
	dc.w	124,434,0
	dc.w	124,434,0
	dc.w	124,434,0
	dc.w	124,434,0
	dc.w	124,466,0
	dc.w	118,466,0
	dc.w	112,468,0
	dc.w	104,470,0
	dc.w	98,472,0
	dc.w	94,476,0
	dc.w	88,480,0
	dc.w	82,484,0
	dc.w	76,488,0
	dc.w	70,494,0
	dc.w	66,500,0
	dc.w	60,506,0
	dc.w	54,0,0
	dc.w	50,8,0
	dc.w	46,18,0
	dc.w	44,28,0
	dc.w	40,40,0
	dc.w	38,52,0
	dc.w	38,64,0
	dc.w	36,76,0
	dc.w	36,86,0
	dc.w	34,98,0
	dc.w	34,106,0
	dc.w	34,114,0
	dc.w	0,434,0
	dc.w	0,120,0
	dc.w	14,120,0
	dc.w	14,434,0
	dc.w	14,102,0
	dc.w	14,84,0
	dc.w	14,66,0
	dc.w	14,48,0
	dc.w	14,30,0
	dc.w	14,12,0
	dc.w	14,508,0
	dc.w	14,490,0
	dc.w	14,472,0
	dc.w	14,452,0
	dc.w	6,120,0
	dc.w	14,110,0
	dc.w	14,444,0
	dc.w	14,92,0
	dc.w	14,74,0
	dc.w	14,56,0
	dc.w	14,38,0
	dc.w	14,20,0
	dc.w	14,2,0
	dc.w	14,498,0
	dc.w	14,480,0
	dc.w	14,462,0
	dc.w	6,434,0
	dc.w	124,442,0
	dc.w	124,450,0
	dc.w	124,458,0
	dc.w	28,120,0
	dc.w	492,110,0
	dc.w	20,110,0
	dc.w	492,88,0
	dc.w	20,88,0
	dc.w	20,88,0
	dc.w	20,88,0
	dc.w	20,88,0
	dc.w	20,88,0