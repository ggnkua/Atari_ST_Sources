	dc.w	140
	dc.w	138
	dc.w	136
	dc.w	133
	dc.w	131
	dc.w	129
	dc.w	127
	dc.w	125
	dc.w	123
	dc.w	121
	dc.w	119
	dc.w	117
	dc.w	115
	dc.w	113
	dc.w	111
	dc.w	110
	dc.w	108
	dc.w	107
	dc.w	105
	dc.w	104
	dc.w	103
	dc.w	101
	dc.w	100
	dc.w	99
	dc.w	98
	dc.w	98
	dc.w	97
	dc.w	96
	dc.w	96
	dc.w	95
	dc.w	95
	dc.w	95
	dc.w	95
	dc.w	95
	dc.w	95
	dc.w	95
	dc.w	96
	dc.w	96
	dc.w	97
	dc.w	98
	dc.w	98
	dc.w	99
	dc.w	100
	dc.w	101
	dc.w	103
	dc.w	104
	dc.w	105
	dc.w	107
	dc.w	108
	dc.w	110
	dc.w	111
	dc.w	113
	dc.w	115
	dc.w	117
	dc.w	119
	dc.w	121
	dc.w	123
	dc.w	125
	dc.w	127
	dc.w	129
	dc.w	131
	dc.w	133
	dc.w	136
	dc.w	138
	dc.w	140
	dc.w	138
	dc.w	136
	dc.w	133
	dc.w	131
	dc.w	129
	dc.w	127
	dc.w	125
	dc.w	123
	dc.w	121
	dc.w	119
	dc.w	117
	dc.w	115
	dc.w	113
	dc.w	111
	dc.w	110
	dc.w	108
	dc.w	107
	dc.w	105
	dc.w	104
	dc.w	103
	dc.w	101
	dc.w	100
	dc.w	99
	dc.w	98
	dc.w	98
	dc.w	97
	dc.w	96
	dc.w	96
	dc.w	95
	dc.w	95
	dc.w	95
	dc.w	95
	dc.w	95
	dc.w	95
	dc.w	95
	dc.w	96
	dc.w	96
	dc.w	97
	dc.w	98
	dc.w	98
	dc.w	99
	dc.w	100
	dc.w	101
	dc.w	103
	dc.w	104
	dc.w	105
	dc.w	107
	dc.w	108
	dc.w	110
	dc.w	111
	dc.w	113
	dc.w	115
	dc.w	117
	dc.w	119
	dc.w	121
	dc.w	123
	dc.w	125
	dc.w	127
	dc.w	129
	dc.w	131
	dc.w	133
	dc.w	136
	dc.w	138
