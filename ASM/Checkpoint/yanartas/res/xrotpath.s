	dc.w	0,0,0
	dc.w	1,0,0
	dc.w	2,0,0
	dc.w	3,0,0
	dc.w	4,0,0
	dc.w	5,0,0
	dc.w	6,0,0
	dc.w	7,0,0
	dc.w	8,0,0
	dc.w	9,0,0
	dc.w	10,0,0
	dc.w	11,0,0
	dc.w	12,0,0
	dc.w	13,0,0
	dc.w	14,0,0
	dc.w	15,0,0
	dc.w	16,0,0
	dc.w	17,0,0
	dc.w	18,0,0
	dc.w	19,0,0
	dc.w	20,0,0
	dc.w	21,0,0
	dc.w	22,0,0
	dc.w	23,0,0
	dc.w	24,0,0
	dc.w	25,0,0
	dc.w	26,0,0
	dc.w	27,0,0
	dc.w	28,0,0
	dc.w	29,0,0
	dc.w	30,0,0
	dc.w	31,0,0
	dc.w	32,0,0
	dc.w	33,0,0
	dc.w	34,0,0
	dc.w	35,0,0
	dc.w	36,0,0
	dc.w	37,0,0
	dc.w	38,0,0
	dc.w	39,0,0
	dc.w	40,0,0
	dc.w	41,0,0
	dc.w	42,0,0
	dc.w	43,0,0
	dc.w	44,0,0
	dc.w	45,0,0
	dc.w	46,0,0
	dc.w	47,0,0
	dc.w	48,0,0
	dc.w	49,0,0
	dc.w	50,0,0
	dc.w	51,0,0
	dc.w	52,0,0
	dc.w	53,0,0
	dc.w	54,0,0
	dc.w	55,0,0
	dc.w	56,0,0
	dc.w	57,0,0
	dc.w	58,0,0
	dc.w	59,0,0
	dc.w	60,0,0
	dc.w	61,0,0
	dc.w	62,0,0
	dc.w	63,0,0
	dc.w	64,0,0
	dc.w	65,0,0
	dc.w	66,0,0
	dc.w	67,0,0
	dc.w	68,0,0
	dc.w	69,0,0
	dc.w	70,0,0
	dc.w	71,0,0
	dc.w	72,0,0
	dc.w	73,0,0
	dc.w	74,0,0
	dc.w	75,0,0
	dc.w	76,0,0
	dc.w	77,0,0
	dc.w	78,0,0
	dc.w	79,0,0
	dc.w	80,0,0
	dc.w	81,0,0
	dc.w	82,0,0
	dc.w	83,0,0
	dc.w	84,0,0
	dc.w	85,0,0
	dc.w	86,0,0
	dc.w	87,0,0
	dc.w	88,0,0
	dc.w	89,0,0
	dc.w	90,0,0
	dc.w	91,0,0
	dc.w	92,0,0
	dc.w	93,0,0
	dc.w	94,0,0
	dc.w	95,0,0
	dc.w	96,0,0
	dc.w	97,0,0
	dc.w	98,0,0
	dc.w	99,0,0
	dc.w	100,0,0
	dc.w	101,0,0
	dc.w	102,0,0
	dc.w	103,0,0
	dc.w	104,0,0
	dc.w	105,0,0
	dc.w	106,0,0
	dc.w	107,0,0
	dc.w	108,0,0
	dc.w	109,0,0
	dc.w	110,0,0
	dc.w	111,0,0
	dc.w	112,0,0
	dc.w	113,0,0
	dc.w	114,0,0
	dc.w	115,0,0
	dc.w	116,0,0
	dc.w	117,0,0
	dc.w	118,0,0
	dc.w	119,0,0
	dc.w	120,0,0
	dc.w	121,0,0
	dc.w	122,0,0
	dc.w	123,0,0
	dc.w	124,0,0
	dc.w	125,0,0
	dc.w	126,0,0
	dc.w	127,0,0
	dc.w	128,0,0
	dc.w	129,0,0
	dc.w	130,0,0
	dc.w	131,0,0
	dc.w	132,0,0
	dc.w	133,0,0
	dc.w	134,0,0
	dc.w	135,0,0
	dc.w	136,0,0
	dc.w	137,0,0
	dc.w	138,0,0
	dc.w	139,0,0
	dc.w	140,0,0
	dc.w	141,0,0
	dc.w	142,0,0
	dc.w	143,0,0
	dc.w	144,0,0
	dc.w	145,0,0
	dc.w	146,0,0
	dc.w	147,0,0
	dc.w	148,0,0
	dc.w	149,0,0
	dc.w	150,0,0
	dc.w	151,0,0
	dc.w	152,0,0
	dc.w	153,0,0
	dc.w	154,0,0
	dc.w	155,0,0
	dc.w	156,0,0
	dc.w	157,0,0
	dc.w	158,0,0
	dc.w	159,0,0
	dc.w	160,0,0
	dc.w	161,0,0
	dc.w	162,0,0
	dc.w	163,0,0
	dc.w	164,0,0
	dc.w	165,0,0
	dc.w	166,0,0
	dc.w	167,0,0
	dc.w	168,0,0
	dc.w	169,0,0
	dc.w	170,0,0
	dc.w	171,0,0
	dc.w	172,0,0
	dc.w	173,0,0
	dc.w	174,0,0
	dc.w	175,0,0
	dc.w	176,0,0
	dc.w	177,0,0
	dc.w	178,0,0
	dc.w	179,0,0
	dc.w	180,0,0
	dc.w	181,0,0
	dc.w	182,0,0
	dc.w	183,0,0
	dc.w	184,0,0
	dc.w	185,0,0
	dc.w	186,0,0
	dc.w	187,0,0
	dc.w	188,0,0
	dc.w	189,0,0
	dc.w	190,0,0
	dc.w	191,0,0
	dc.w	192,0,0
	dc.w	193,0,0
	dc.w	194,0,0
	dc.w	195,0,0
	dc.w	196,0,0
	dc.w	197,0,0
	dc.w	198,0,0
	dc.w	199,0,0
	dc.w	200,0,0
	dc.w	201,0,0
	dc.w	202,0,0
	dc.w	203,0,0
	dc.w	204,0,0
	dc.w	205,0,0
	dc.w	206,0,0
	dc.w	207,0,0
	dc.w	208,0,0
	dc.w	209,0,0
	dc.w	210,0,0
	dc.w	211,0,0
	dc.w	212,0,0
	dc.w	213,0,0
	dc.w	214,0,0
	dc.w	215,0,0
	dc.w	216,0,0
	dc.w	217,0,0
	dc.w	218,0,0
	dc.w	219,0,0
	dc.w	220,0,0
	dc.w	221,0,0
	dc.w	222,0,0
	dc.w	223,0,0
	dc.w	224,0,0
	dc.w	225,0,0
	dc.w	226,0,0
	dc.w	227,0,0
	dc.w	228,0,0
	dc.w	229,0,0
	dc.w	230,0,0
	dc.w	231,0,0
	dc.w	232,0,0
	dc.w	233,0,0
	dc.w	234,0,0
	dc.w	235,0,0
	dc.w	236,0,0
	dc.w	237,0,0
	dc.w	238,0,0
	dc.w	239,0,0
	dc.w	240,0,0
	dc.w	241,0,0
	dc.w	242,0,0
	dc.w	243,0,0
	dc.w	244,0,0
	dc.w	245,0,0
	dc.w	246,0,0
	dc.w	247,0,0
	dc.w	248,0,0
	dc.w	249,0,0
	dc.w	250,0,0
	dc.w	251,0,0
	dc.w	252,0,0
	dc.w	253,0,0
	dc.w	254,0,0
	dc.w	255,0,0
	dc.w	256,0,0
	dc.w	257,0,0
	dc.w	258,0,0
	dc.w	259,0,0
	dc.w	260,0,0
	dc.w	261,0,0
	dc.w	262,0,0
	dc.w	263,0,0
	dc.w	264,0,0
	dc.w	265,0,0
	dc.w	266,0,0
	dc.w	267,0,0
	dc.w	268,0,0
	dc.w	269,0,0
	dc.w	270,0,0
	dc.w	271,0,0
	dc.w	272,0,0
	dc.w	273,0,0
	dc.w	274,0,0
	dc.w	275,0,0
	dc.w	276,0,0
	dc.w	277,0,0
	dc.w	278,0,0
	dc.w	279,0,0
	dc.w	280,0,0
	dc.w	281,0,0
	dc.w	282,0,0
	dc.w	283,0,0
	dc.w	284,0,0
	dc.w	285,0,0
	dc.w	286,0,0
	dc.w	287,0,0
	dc.w	288,0,0
	dc.w	289,0,0
	dc.w	290,0,0
	dc.w	291,0,0
	dc.w	292,0,0
	dc.w	293,0,0
	dc.w	294,0,0
	dc.w	295,0,0
	dc.w	296,0,0
	dc.w	297,0,0
	dc.w	298,0,0
	dc.w	299,0,0
	dc.w	300,0,0
	dc.w	301,0,0
	dc.w	302,0,0
	dc.w	303,0,0
	dc.w	304,0,0
	dc.w	305,0,0
	dc.w	306,0,0
	dc.w	307,0,0
	dc.w	308,0,0
	dc.w	309,0,0
	dc.w	310,0,0
	dc.w	311,0,0
	dc.w	312,0,0
	dc.w	313,0,0
	dc.w	314,0,0
	dc.w	315,0,0
	dc.w	316,0,0
	dc.w	317,0,0
	dc.w	318,0,0
	dc.w	319,0,0
	dc.w	320,0,0
	dc.w	321,0,0
	dc.w	322,0,0
	dc.w	323,0,0
	dc.w	324,0,0
	dc.w	325,0,0
	dc.w	326,0,0
	dc.w	327,0,0
	dc.w	328,0,0
	dc.w	329,0,0
	dc.w	330,0,0
	dc.w	331,0,0
	dc.w	332,0,0
	dc.w	333,0,0
	dc.w	334,0,0
	dc.w	335,0,0
	dc.w	336,0,0
	dc.w	337,0,0
	dc.w	338,0,0
	dc.w	339,0,0
	dc.w	340,0,0
	dc.w	341,0,0
	dc.w	342,0,0
	dc.w	343,0,0
	dc.w	344,0,0
	dc.w	345,0,0
	dc.w	346,0,0
	dc.w	347,0,0
	dc.w	348,0,0
	dc.w	349,0,0
	dc.w	350,0,0
	dc.w	351,0,0
	dc.w	352,0,0
	dc.w	353,0,0
	dc.w	354,0,0
	dc.w	355,0,0
	dc.w	356,0,0
	dc.w	357,0,0
	dc.w	358,0,0
	dc.w	359,0,0
	dc.w	360,0,0
	dc.w	361,0,0
	dc.w	362,0,0
	dc.w	363,0,0
	dc.w	364,0,0
	dc.w	365,0,0
	dc.w	366,0,0
	dc.w	367,0,0
	dc.w	368,0,0
	dc.w	369,0,0
	dc.w	370,0,0
	dc.w	371,0,0
	dc.w	372,0,0
	dc.w	373,0,0
	dc.w	374,0,0
	dc.w	375,0,0
	dc.w	376,0,0
	dc.w	377,0,0
	dc.w	378,0,0
	dc.w	379,0,0
	dc.w	380,0,0
	dc.w	381,0,0
	dc.w	382,0,0
	dc.w	383,0,0
	dc.w	384,0,0
	dc.w	385,0,0
	dc.w	386,0,0
	dc.w	387,0,0
	dc.w	388,0,0
	dc.w	389,0,0
	dc.w	390,0,0
	dc.w	391,0,0
	dc.w	392,0,0
	dc.w	393,0,0
	dc.w	394,0,0
	dc.w	395,0,0
	dc.w	396,0,0
	dc.w	397,0,0
	dc.w	398,0,0
	dc.w	399,0,0
	dc.w	400,0,0
	dc.w	401,0,0
	dc.w	402,0,0
	dc.w	403,0,0
	dc.w	404,0,0
	dc.w	405,0,0
	dc.w	406,0,0
	dc.w	407,0,0
	dc.w	408,0,0
	dc.w	409,0,0
	dc.w	410,0,0
	dc.w	411,0,0
	dc.w	412,0,0
	dc.w	413,0,0
	dc.w	414,0,0
	dc.w	415,0,0
	dc.w	416,0,0
	dc.w	417,0,0
	dc.w	418,0,0
	dc.w	419,0,0
	dc.w	420,0,0
	dc.w	421,0,0
	dc.w	422,0,0
	dc.w	423,0,0
	dc.w	424,0,0
	dc.w	425,0,0
	dc.w	426,0,0
	dc.w	427,0,0
	dc.w	428,0,0
	dc.w	429,0,0
	dc.w	430,0,0
	dc.w	431,0,0
	dc.w	432,0,0
	dc.w	433,0,0
	dc.w	434,0,0
	dc.w	435,0,0
	dc.w	436,0,0
	dc.w	437,0,0
	dc.w	438,0,0
	dc.w	439,0,0
	dc.w	440,0,0
	dc.w	441,0,0
	dc.w	442,0,0
	dc.w	443,0,0
	dc.w	444,0,0
	dc.w	445,0,0
	dc.w	446,0,0
	dc.w	447,0,0
	dc.w	448,0,0
	dc.w	449,0,0
	dc.w	450,0,0
	dc.w	451,0,0
	dc.w	452,0,0
	dc.w	453,0,0
	dc.w	454,0,0
	dc.w	455,0,0
	dc.w	456,0,0
	dc.w	457,0,0
	dc.w	458,0,0
	dc.w	459,0,0
	dc.w	460,0,0
	dc.w	461,0,0
	dc.w	462,0,0
	dc.w	463,0,0
	dc.w	464,0,0
	dc.w	465,0,0
	dc.w	466,0,0
	dc.w	467,0,0
	dc.w	468,0,0
	dc.w	469,0,0
	dc.w	470,0,0
	dc.w	471,0,0
	dc.w	472,0,0
	dc.w	473,0,0
	dc.w	474,0,0
	dc.w	475,0,0
	dc.w	476,0,0
	dc.w	477,0,0
	dc.w	478,0,0
	dc.w	479,0,0
	dc.w	480,0,0
	dc.w	481,0,0
	dc.w	482,0,0
	dc.w	483,0,0
	dc.w	484,0,0
	dc.w	485,0,0
	dc.w	486,0,0
	dc.w	487,0,0
	dc.w	488,0,0
	dc.w	489,0,0
	dc.w	490,0,0
	dc.w	491,0,0
	dc.w	492,0,0
	dc.w	493,0,0
	dc.w	494,0,0
	dc.w	495,0,0
	dc.w	496,0,0
	dc.w	497,0,0
	dc.w	498,0,0
	dc.w	499,0,0
	dc.w	500,0,0
	dc.w	501,0,0
	dc.w	502,0,0
	dc.w	503,0,0
	dc.w	504,0,0
	dc.w	505,0,0
	dc.w	506,0,0
	dc.w	507,0,0
	dc.w	508,0,0
	dc.w	509,0,0
	dc.w	510,0,0
	dc.w	511,0,0