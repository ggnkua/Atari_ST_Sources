;	 sinetable generated with ampl: 255, 
	dc.w 0	;0
	dc.w 3	;1
	dc.w 6	;2
	dc.w 9	;3
	dc.w 12	;4
	dc.w 15	;5
	dc.w 18	;6
	dc.w 21	;7
	dc.w 24	;8
	dc.w 28	;9
	dc.w 31	;10
	dc.w 34	;11
	dc.w 37	;12
	dc.w 40	;13
	dc.w 43	;14
	dc.w 46	;15
	dc.w 49	;16
	dc.w 52	;17
	dc.w 55	;18
	dc.w 58	;19
	dc.w 61	;20
	dc.w 64	;21
	dc.w 68	;22
	dc.w 71	;23
	dc.w 74	;24
	dc.w 77	;25
	dc.w 79	;26
	dc.w 82	;27
	dc.w 85	;28
	dc.w 88	;29
	dc.w 91	;30
	dc.w 94	;31
	dc.w 97	;32
	dc.w 100	;33
	dc.w 103	;34
	dc.w 106	;35
	dc.w 109	;36
	dc.w 111	;37
	dc.w 114	;38
	dc.w 117	;39
	dc.w 120	;40
	dc.w 122	;41
	dc.w 125	;42
	dc.w 128	;43
	dc.w 131	;44
	dc.w 133	;45
	dc.w 136	;46
	dc.w 139	;47
	dc.w 141	;48
	dc.w 144	;49
	dc.w 146	;50
	dc.w 149	;51
	dc.w 151	;52
	dc.w 154	;53
	dc.w 156	;54
	dc.w 159	;55
	dc.w 161	;56
	dc.w 164	;57
	dc.w 166	;58
	dc.w 168	;59
	dc.w 171	;60
	dc.w 173	;61
	dc.w 175	;62
	dc.w 178	;63
	dc.w 180	;64
	dc.w 182	;65
	dc.w 184	;66
	dc.w 186	;67
	dc.w 188	;68
	dc.w 191	;69
	dc.w 193	;70
	dc.w 195	;71
	dc.w 197	;72
	dc.w 199	;73
	dc.w 201	;74
	dc.w 202	;75
	dc.w 204	;76
	dc.w 206	;77
	dc.w 208	;78
	dc.w 210	;79
	dc.w 212	;80
	dc.w 213	;81
	dc.w 215	;82
	dc.w 217	;83
	dc.w 218	;84
	dc.w 220	;85
	dc.w 221	;86
	dc.w 223	;87
	dc.w 224	;88
	dc.w 226	;89
	dc.w 227	;90
	dc.w 229	;91
	dc.w 230	;92
	dc.w 231	;93
	dc.w 233	;94
	dc.w 234	;95
	dc.w 235	;96
	dc.w 236	;97
	dc.w 237	;98
	dc.w 239	;99
	dc.w 240	;100
	dc.w 241	;101
	dc.w 242	;102
	dc.w 243	;103
	dc.w 244	;104
	dc.w 244	;105
	dc.w 245	;106
	dc.w 246	;107
	dc.w 247	;108
	dc.w 248	;109
	dc.w 248	;110
	dc.w 249	;111
	dc.w 250	;112
	dc.w 250	;113
	dc.w 251	;114
	dc.w 251	;115
	dc.w 252	;116
	dc.w 252	;117
	dc.w 253	;118
	dc.w 253	;119
	dc.w 253	;120
	dc.w 254	;121
	dc.w 254	;122
	dc.w 254	;123
	dc.w 254	;124
	dc.w 254	;125
	dc.w 254	;126
	dc.w 254	;127
	dc.w 255	;128
	dc.w 254	;129
	dc.w 254	;130
	dc.w 254	;131
	dc.w 254	;132
	dc.w 254	;133
	dc.w 254	;134
	dc.w 254	;135
	dc.w 253	;136
	dc.w 253	;137
	dc.w 253	;138
	dc.w 252	;139
	dc.w 252	;140
	dc.w 251	;141
	dc.w 251	;142
	dc.w 250	;143
	dc.w 250	;144
	dc.w 249	;145
	dc.w 248	;146
	dc.w 248	;147
	dc.w 247	;148
	dc.w 246	;149
	dc.w 245	;150
	dc.w 244	;151
	dc.w 244	;152
	dc.w 243	;153
	dc.w 242	;154
	dc.w 241	;155
	dc.w 240	;156
	dc.w 239	;157
	dc.w 237	;158
	dc.w 236	;159
	dc.w 235	;160
	dc.w 234	;161
	dc.w 233	;162
	dc.w 231	;163
	dc.w 230	;164
	dc.w 229	;165
	dc.w 227	;166
	dc.w 226	;167
	dc.w 224	;168
	dc.w 223	;169
	dc.w 221	;170
	dc.w 220	;171
	dc.w 218	;172
	dc.w 217	;173
	dc.w 215	;174
	dc.w 213	;175
	dc.w 212	;176
	dc.w 210	;177
	dc.w 208	;178
	dc.w 206	;179
	dc.w 204	;180
	dc.w 202	;181
	dc.w 201	;182
	dc.w 199	;183
	dc.w 197	;184
	dc.w 195	;185
	dc.w 193	;186
	dc.w 191	;187
	dc.w 188	;188
	dc.w 186	;189
	dc.w 184	;190
	dc.w 182	;191
	dc.w 180	;192
	dc.w 178	;193
	dc.w 175	;194
	dc.w 173	;195
	dc.w 171	;196
	dc.w 168	;197
	dc.w 166	;198
	dc.w 164	;199
	dc.w 161	;200
	dc.w 159	;201
	dc.w 156	;202
	dc.w 154	;203
	dc.w 151	;204
	dc.w 149	;205
	dc.w 146	;206
	dc.w 144	;207
	dc.w 141	;208
	dc.w 139	;209
	dc.w 136	;210
	dc.w 133	;211
	dc.w 131	;212
	dc.w 128	;213
	dc.w 125	;214
	dc.w 122	;215
	dc.w 120	;216
	dc.w 117	;217
	dc.w 114	;218
	dc.w 111	;219
	dc.w 109	;220
	dc.w 106	;221
	dc.w 103	;222
	dc.w 100	;223
	dc.w 97	;224
	dc.w 94	;225
	dc.w 91	;226
	dc.w 88	;227
	dc.w 85	;228
	dc.w 82	;229
	dc.w 79	;230
	dc.w 77	;231
	dc.w 74	;232
	dc.w 71	;233
	dc.w 68	;234
	dc.w 64	;235
	dc.w 61	;236
	dc.w 58	;237
	dc.w 55	;238
	dc.w 52	;239
	dc.w 49	;240
	dc.w 46	;241
	dc.w 43	;242
	dc.w 40	;243
	dc.w 37	;244
	dc.w 34	;245
	dc.w 31	;246
	dc.w 28	;247
	dc.w 24	;248
	dc.w 21	;249
	dc.w 18	;250
	dc.w 15	;251
	dc.w 12	;252
	dc.w 9	;253
	dc.w 6	;254
	dc.w 3	;255
	dc.w 0	;256
	dc.w -3	;257
	dc.w -6	;258
	dc.w -9	;259
	dc.w -12	;260
	dc.w -15	;261
	dc.w -18	;262
	dc.w -21	;263
	dc.w -24	;264
	dc.w -28	;265
	dc.w -31	;266
	dc.w -34	;267
	dc.w -37	;268
	dc.w -40	;269
	dc.w -43	;270
	dc.w -46	;271
	dc.w -49	;272
	dc.w -52	;273
	dc.w -55	;274
	dc.w -58	;275
	dc.w -61	;276
	dc.w -64	;277
	dc.w -68	;278
	dc.w -71	;279
	dc.w -74	;280
	dc.w -77	;281
	dc.w -79	;282
	dc.w -82	;283
	dc.w -85	;284
	dc.w -88	;285
	dc.w -91	;286
	dc.w -94	;287
	dc.w -97	;288
	dc.w -100	;289
	dc.w -103	;290
	dc.w -106	;291
	dc.w -109	;292
	dc.w -111	;293
	dc.w -114	;294
	dc.w -117	;295
	dc.w -120	;296
	dc.w -122	;297
	dc.w -125	;298
	dc.w -128	;299
	dc.w -131	;300
	dc.w -133	;301
	dc.w -136	;302
	dc.w -139	;303
	dc.w -141	;304
	dc.w -144	;305
	dc.w -146	;306
	dc.w -149	;307
	dc.w -151	;308
	dc.w -154	;309
	dc.w -156	;310
	dc.w -159	;311
	dc.w -161	;312
	dc.w -164	;313
	dc.w -166	;314
	dc.w -168	;315
	dc.w -171	;316
	dc.w -173	;317
	dc.w -175	;318
	dc.w -178	;319
	dc.w -180	;320
	dc.w -182	;321
	dc.w -184	;322
	dc.w -186	;323
	dc.w -188	;324
	dc.w -191	;325
	dc.w -193	;326
	dc.w -195	;327
	dc.w -197	;328
	dc.w -199	;329
	dc.w -201	;330
	dc.w -202	;331
	dc.w -204	;332
	dc.w -206	;333
	dc.w -208	;334
	dc.w -210	;335
	dc.w -212	;336
	dc.w -213	;337
	dc.w -215	;338
	dc.w -217	;339
	dc.w -218	;340
	dc.w -220	;341
	dc.w -221	;342
	dc.w -223	;343
	dc.w -224	;344
	dc.w -226	;345
	dc.w -227	;346
	dc.w -229	;347
	dc.w -230	;348
	dc.w -231	;349
	dc.w -233	;350
	dc.w -234	;351
	dc.w -235	;352
	dc.w -236	;353
	dc.w -237	;354
	dc.w -239	;355
	dc.w -240	;356
	dc.w -241	;357
	dc.w -242	;358
	dc.w -243	;359
	dc.w -244	;360
	dc.w -244	;361
	dc.w -245	;362
	dc.w -246	;363
	dc.w -247	;364
	dc.w -248	;365
	dc.w -248	;366
	dc.w -249	;367
	dc.w -250	;368
	dc.w -250	;369
	dc.w -251	;370
	dc.w -251	;371
	dc.w -252	;372
	dc.w -252	;373
	dc.w -253	;374
	dc.w -253	;375
	dc.w -253	;376
	dc.w -254	;377
	dc.w -254	;378
	dc.w -254	;379
	dc.w -254	;380
	dc.w -254	;381
	dc.w -254	;382
	dc.w -254	;383
	dc.w -255	;384
	dc.w -254	;385
	dc.w -254	;386
	dc.w -254	;387
	dc.w -254	;388
	dc.w -254	;389
	dc.w -254	;390
	dc.w -254	;391
	dc.w -253	;392
	dc.w -253	;393
	dc.w -253	;394
	dc.w -252	;395
	dc.w -252	;396
	dc.w -251	;397
	dc.w -251	;398
	dc.w -250	;399
	dc.w -250	;400
	dc.w -249	;401
	dc.w -248	;402
	dc.w -248	;403
	dc.w -247	;404
	dc.w -246	;405
	dc.w -245	;406
	dc.w -244	;407
	dc.w -244	;408
	dc.w -243	;409
	dc.w -242	;410
	dc.w -241	;411
	dc.w -240	;412
	dc.w -239	;413
	dc.w -237	;414
	dc.w -236	;415
	dc.w -235	;416
	dc.w -234	;417
	dc.w -233	;418
	dc.w -231	;419
	dc.w -230	;420
	dc.w -229	;421
	dc.w -227	;422
	dc.w -226	;423
	dc.w -224	;424
	dc.w -223	;425
	dc.w -221	;426
	dc.w -220	;427
	dc.w -218	;428
	dc.w -217	;429
	dc.w -215	;430
	dc.w -213	;431
	dc.w -212	;432
	dc.w -210	;433
	dc.w -208	;434
	dc.w -206	;435
	dc.w -204	;436
	dc.w -202	;437
	dc.w -201	;438
	dc.w -199	;439
	dc.w -197	;440
	dc.w -195	;441
	dc.w -193	;442
	dc.w -191	;443
	dc.w -188	;444
	dc.w -186	;445
	dc.w -184	;446
	dc.w -182	;447
	dc.w -180	;448
	dc.w -178	;449
	dc.w -175	;450
	dc.w -173	;451
	dc.w -171	;452
	dc.w -168	;453
	dc.w -166	;454
	dc.w -164	;455
	dc.w -161	;456
	dc.w -159	;457
	dc.w -156	;458
	dc.w -154	;459
	dc.w -151	;460
	dc.w -149	;461
	dc.w -146	;462
	dc.w -144	;463
	dc.w -141	;464
	dc.w -139	;465
	dc.w -136	;466
	dc.w -133	;467
	dc.w -131	;468
	dc.w -128	;469
	dc.w -125	;470
	dc.w -122	;471
	dc.w -120	;472
	dc.w -117	;473
	dc.w -114	;474
	dc.w -111	;475
	dc.w -109	;476
	dc.w -106	;477
	dc.w -103	;478
	dc.w -100	;479
	dc.w -97	;480
	dc.w -94	;481
	dc.w -91	;482
	dc.w -88	;483
	dc.w -85	;484
	dc.w -82	;485
	dc.w -79	;486
	dc.w -77	;487
	dc.w -74	;488
	dc.w -71	;489
	dc.w -68	;490
	dc.w -64	;491
	dc.w -61	;492
	dc.w -58	;493
	dc.w -55	;494
	dc.w -52	;495
	dc.w -49	;496
	dc.w -46	;497
	dc.w -43	;498
	dc.w -40	;499
	dc.w -37	;500
	dc.w -34	;501
	dc.w -31	;502
	dc.w -28	;503
	dc.w -24	;504
	dc.w -21	;505
	dc.w -18	;506
	dc.w -15	;507
	dc.w -12	;508
	dc.w -9	;509
	dc.w -6	;510
	dc.w -3	;511
	dc.w 0	;512
	dc.w 3	;513
	dc.w 6	;514
	dc.w 9	;515
	dc.w 12	;516
	dc.w 15	;517
	dc.w 18	;518
	dc.w 21	;519
	dc.w 24	;520
	dc.w 28	;521
	dc.w 31	;522
	dc.w 34	;523
	dc.w 37	;524
	dc.w 40	;525
	dc.w 43	;526
	dc.w 46	;527
	dc.w 49	;528
	dc.w 52	;529
	dc.w 55	;530
	dc.w 58	;531
	dc.w 61	;532
	dc.w 64	;533
	dc.w 68	;534
	dc.w 71	;535
	dc.w 74	;536
	dc.w 77	;537
	dc.w 79	;538
	dc.w 82	;539
	dc.w 85	;540
	dc.w 88	;541
	dc.w 91	;542
	dc.w 94	;543
	dc.w 97	;544
	dc.w 100	;545
	dc.w 103	;546
	dc.w 106	;547
	dc.w 109	;548
	dc.w 111	;549
	dc.w 114	;550
	dc.w 117	;551
	dc.w 120	;552
	dc.w 122	;553
	dc.w 125	;554
	dc.w 128	;555
	dc.w 131	;556
	dc.w 133	;557
	dc.w 136	;558
	dc.w 139	;559
	dc.w 141	;560
	dc.w 144	;561
	dc.w 146	;562
	dc.w 149	;563
	dc.w 151	;564
	dc.w 154	;565
	dc.w 156	;566
	dc.w 159	;567
	dc.w 161	;568
	dc.w 164	;569
	dc.w 166	;570
	dc.w 168	;571
	dc.w 171	;572
	dc.w 173	;573
	dc.w 175	;574
	dc.w 178	;575
	dc.w 180	;576
	dc.w 182	;577
	dc.w 184	;578
	dc.w 186	;579
	dc.w 188	;580
	dc.w 191	;581
	dc.w 193	;582
	dc.w 195	;583
	dc.w 197	;584
	dc.w 199	;585
	dc.w 201	;586
	dc.w 202	;587
	dc.w 204	;588
	dc.w 206	;589
	dc.w 208	;590
	dc.w 210	;591
	dc.w 212	;592
	dc.w 213	;593
	dc.w 215	;594
	dc.w 217	;595
	dc.w 218	;596
	dc.w 220	;597
	dc.w 221	;598
	dc.w 223	;599
	dc.w 224	;600
	dc.w 226	;601
	dc.w 227	;602
	dc.w 229	;603
	dc.w 230	;604
	dc.w 231	;605
	dc.w 233	;606
	dc.w 234	;607
	dc.w 235	;608
	dc.w 236	;609
	dc.w 237	;610
	dc.w 239	;611
	dc.w 240	;612
	dc.w 241	;613
	dc.w 242	;614
	dc.w 243	;615
	dc.w 244	;616
	dc.w 244	;617
	dc.w 245	;618
	dc.w 246	;619
	dc.w 247	;620
	dc.w 248	;621
	dc.w 248	;622
	dc.w 249	;623
	dc.w 250	;624
	dc.w 250	;625
	dc.w 251	;626
	dc.w 251	;627
	dc.w 252	;628
	dc.w 252	;629
	dc.w 253	;630
	dc.w 253	;631
	dc.w 253	;632
	dc.w 254	;633
	dc.w 254	;634
	dc.w 254	;635
	dc.w 254	;636
	dc.w 254	;637
	dc.w 254	;638
	dc.w 254	;639


