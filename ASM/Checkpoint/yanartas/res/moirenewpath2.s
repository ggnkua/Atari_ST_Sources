path1:
	dc.l	160,135
	dc.l	160,135
	dc.l	161,135
	dc.l	161,135
	dc.l	162,135
	dc.l	162,135
	dc.l	163,134
	dc.l	163,134
	dc.l	164,134
	dc.l	164,134
	dc.l	165,133
	dc.l	165,133
	dc.l	166,133
	dc.l	166,132
	dc.l	167,132
	dc.l	167,131
	dc.l	167,131
	dc.l	168,130
	dc.l	168,130
	dc.l	169,129
	dc.l	169,128
	dc.l	170,128
	dc.l	170,127
	dc.l	171,126
	dc.l	171,126
	dc.l	171,125
	dc.l	172,124
	dc.l	172,123
	dc.l	173,122
	dc.l	173,121
	dc.l	174,121
	dc.l	174,120
	dc.l	174,119
	dc.l	175,118
	dc.l	175,117
	dc.l	176,116
	dc.l	176,115
	dc.l	176,114
	dc.l	177,113
	dc.l	177,112
	dc.l	178,111
	dc.l	178,110
	dc.l	178,109
	dc.l	179,108
	dc.l	179,107
	dc.l	179,105
	dc.l	180,104
	dc.l	180,103
	dc.l	181,102
	dc.l	181,101
	dc.l	181,100
	dc.l	182,99
	dc.l	182,98
	dc.l	182,97
	dc.l	183,96
	dc.l	183,95
	dc.l	183,93
	dc.l	183,92
	dc.l	184,91
	dc.l	184,90
	dc.l	184,89
	dc.l	185,88
	dc.l	185,87
	dc.l	185,86
	dc.l	185,85
	dc.l	186,84
	dc.l	186,83
	dc.l	186,82
	dc.l	186,81
	dc.l	187,80
	dc.l	187,79
	dc.l	187,79
	dc.l	187,78
	dc.l	187,77
	dc.l	188,76
	dc.l	188,75
	dc.l	188,74
	dc.l	188,74
	dc.l	188,73
	dc.l	188,72
	dc.l	189,72
	dc.l	189,71
	dc.l	189,70
	dc.l	189,70
	dc.l	189,69
	dc.l	189,69
	dc.l	189,68
	dc.l	189,68
	dc.l	189,67
	dc.l	190,67
	dc.l	190,67
	dc.l	190,66
	dc.l	190,66
	dc.l	190,66
	dc.l	190,66
	dc.l	190,65
	dc.l	190,65
	dc.l	190,65
	dc.l	190,65
	dc.l	190,65
	dc.l	190,65
	dc.l	190,65
	dc.l	190,65
	dc.l	190,65
	dc.l	190,65
	dc.l	190,65
	dc.l	190,66
	dc.l	190,66
	dc.l	190,66
	dc.l	190,66
	dc.l	190,67
	dc.l	190,67
	dc.l	189,67
	dc.l	189,68
	dc.l	189,68
	dc.l	189,69
	dc.l	189,69
	dc.l	189,70
	dc.l	189,70
	dc.l	189,71
	dc.l	189,72
	dc.l	188,72
	dc.l	188,73
	dc.l	188,74
	dc.l	188,74
	dc.l	188,75
	dc.l	188,76
	dc.l	187,77
	dc.l	187,78
	dc.l	187,79
	dc.l	187,79
	dc.l	187,80
	dc.l	186,81
	dc.l	186,82
	dc.l	186,83
	dc.l	186,84
	dc.l	185,85
	dc.l	185,86
	dc.l	185,87
	dc.l	185,88
	dc.l	184,89
	dc.l	184,90
	dc.l	184,91
	dc.l	183,92
	dc.l	183,93
	dc.l	183,95
	dc.l	183,96
	dc.l	182,97
	dc.l	182,98
	dc.l	182,99
	dc.l	181,100
	dc.l	181,101
	dc.l	181,102
	dc.l	180,103
	dc.l	180,104
	dc.l	179,105
	dc.l	179,107
	dc.l	179,108
	dc.l	178,109
	dc.l	178,110
	dc.l	178,111
	dc.l	177,112
	dc.l	177,113
	dc.l	176,114
	dc.l	176,115
	dc.l	176,116
	dc.l	175,117
	dc.l	175,118
	dc.l	174,119
	dc.l	174,120
	dc.l	174,121
	dc.l	173,121
	dc.l	173,122
	dc.l	172,123
	dc.l	172,124
	dc.l	171,125
	dc.l	171,126
	dc.l	171,126
	dc.l	170,127
	dc.l	170,128
	dc.l	169,128
	dc.l	169,129
	dc.l	168,130
	dc.l	168,130
	dc.l	167,131
	dc.l	167,131
	dc.l	167,132
	dc.l	166,132
	dc.l	166,133
	dc.l	165,133
	dc.l	165,133
	dc.l	164,134
	dc.l	164,134
	dc.l	163,134
	dc.l	163,134
	dc.l	162,135
	dc.l	162,135
	dc.l	161,135
	dc.l	161,135
	dc.l	160,135
	dc.l	160,135
	dc.l	160,135
	dc.l	159,135
	dc.l	159,135
	dc.l	158,135
	dc.l	158,135
	dc.l	157,134
	dc.l	157,134
	dc.l	156,134
	dc.l	156,134
	dc.l	155,133
	dc.l	155,133
	dc.l	154,133
	dc.l	154,132
	dc.l	153,132
	dc.l	153,131
	dc.l	153,131
	dc.l	152,130
	dc.l	152,130
	dc.l	151,129
	dc.l	151,128
	dc.l	150,128
	dc.l	150,127
	dc.l	149,126
	dc.l	149,126
	dc.l	149,125
	dc.l	148,124
	dc.l	148,123
	dc.l	147,122
	dc.l	147,121
	dc.l	146,121
	dc.l	146,120
	dc.l	146,119
	dc.l	145,118
	dc.l	145,117
	dc.l	144,116
	dc.l	144,115
	dc.l	144,114
	dc.l	143,113
	dc.l	143,112
	dc.l	142,111
	dc.l	142,110
	dc.l	142,109
	dc.l	141,108
	dc.l	141,107
	dc.l	141,105
	dc.l	140,104
	dc.l	140,103
	dc.l	139,102
	dc.l	139,101
	dc.l	139,100
	dc.l	138,99
	dc.l	138,98
	dc.l	138,97
	dc.l	137,96
	dc.l	137,95
	dc.l	137,93
	dc.l	137,92
	dc.l	136,91
	dc.l	136,90
	dc.l	136,89
	dc.l	135,88
	dc.l	135,87
	dc.l	135,86
	dc.l	135,85
	dc.l	134,84
	dc.l	134,83
	dc.l	134,82
	dc.l	134,81
	dc.l	133,80
	dc.l	133,79
	dc.l	133,79
	dc.l	133,78
	dc.l	133,77
	dc.l	132,76
	dc.l	132,75
	dc.l	132,74
	dc.l	132,74
	dc.l	132,73
	dc.l	132,72
	dc.l	131,72
	dc.l	131,71
	dc.l	131,70
	dc.l	131,70
	dc.l	131,69
	dc.l	131,69
	dc.l	131,68
	dc.l	131,68
	dc.l	131,67
	dc.l	130,67
	dc.l	130,67
	dc.l	130,66
	dc.l	130,66
	dc.l	130,66
	dc.l	130,66
	dc.l	130,65
	dc.l	130,65
	dc.l	130,65
	dc.l	130,65
	dc.l	130,65
	dc.l	130,65
	dc.l	130,65
	dc.l	130,65
	dc.l	130,65
	dc.l	130,65
	dc.l	130,65
	dc.l	130,66
	dc.l	130,66
	dc.l	130,66
	dc.l	130,66
	dc.l	130,67
	dc.l	130,67
	dc.l	131,67
	dc.l	131,68
	dc.l	131,68
	dc.l	131,69
	dc.l	131,69
	dc.l	131,70
	dc.l	131,70
	dc.l	131,71
	dc.l	131,72
	dc.l	132,72
	dc.l	132,73
	dc.l	132,74
	dc.l	132,74
	dc.l	132,75
	dc.l	132,76
	dc.l	133,77
	dc.l	133,78
	dc.l	133,79
	dc.l	133,79
	dc.l	133,80
	dc.l	134,81
	dc.l	134,82
	dc.l	134,83
	dc.l	134,84
	dc.l	135,85
	dc.l	135,86
	dc.l	135,87
	dc.l	135,88
	dc.l	136,89
	dc.l	136,90
	dc.l	136,91
	dc.l	137,92
	dc.l	137,93
	dc.l	137,95
	dc.l	137,96
	dc.l	138,97
	dc.l	138,98
	dc.l	138,99
	dc.l	139,100
	dc.l	139,101
	dc.l	139,102
	dc.l	140,103
	dc.l	140,104
	dc.l	141,105
	dc.l	141,107
	dc.l	141,108
	dc.l	142,109
	dc.l	142,110
	dc.l	142,111
	dc.l	143,112
	dc.l	143,113
	dc.l	144,114
	dc.l	144,115
	dc.l	144,116
	dc.l	145,117
	dc.l	145,118
	dc.l	146,119
	dc.l	146,120
	dc.l	146,121
	dc.l	147,121
	dc.l	147,122
	dc.l	148,123
	dc.l	148,124
	dc.l	149,125
	dc.l	149,126
	dc.l	149,126
	dc.l	150,127
	dc.l	150,128
	dc.l	151,128
	dc.l	151,129
	dc.l	152,130
	dc.l	152,130
	dc.l	153,131
	dc.l	153,131
	dc.l	153,132
	dc.l	154,132
	dc.l	154,133
	dc.l	155,133
	dc.l	155,133
	dc.l	156,134
	dc.l	156,134
	dc.l	157,134
	dc.l	157,134
	dc.l	158,135
	dc.l	158,135
	dc.l	159,135
	dc.l	159,135
	dc.l	160,135

path2:
	dc.l	160,130
	dc.l	162,130
	dc.l	163,130
	dc.l	165,130
	dc.l	167,130
	dc.l	168,130
	dc.l	170,129
	dc.l	171,129
	dc.l	173,129
	dc.l	174,129
	dc.l	176,129
	dc.l	177,128
	dc.l	179,128
	dc.l	180,128
	dc.l	181,127
	dc.l	183,127
	dc.l	184,126
	dc.l	185,126
	dc.l	186,125
	dc.l	187,125
	dc.l	188,124
	dc.l	189,124
	dc.l	190,123
	dc.l	191,123
	dc.l	192,122
	dc.l	192,121
	dc.l	193,121
	dc.l	193,120
	dc.l	194,119
	dc.l	194,118
	dc.l	195,118
	dc.l	195,117
	dc.l	195,116
	dc.l	195,115
	dc.l	195,114
	dc.l	195,114
	dc.l	195,113
	dc.l	194,112
	dc.l	194,111
	dc.l	194,110
	dc.l	193,109
	dc.l	193,108
	dc.l	192,107
	dc.l	191,107
	dc.l	191,106
	dc.l	190,105
	dc.l	189,104
	dc.l	188,103
	dc.l	187,102
	dc.l	186,101
	dc.l	185,100
	dc.l	184,99
	dc.l	182,98
	dc.l	181,97
	dc.l	180,96
	dc.l	178,95
	dc.l	177,94
	dc.l	175,93
	dc.l	174,93
	dc.l	172,92
	dc.l	171,91
	dc.l	169,90
	dc.l	168,89
	dc.l	166,88
	dc.l	164,87
	dc.l	163,86
	dc.l	161,86
	dc.l	159,85
	dc.l	158,84
	dc.l	156,83
	dc.l	155,82
	dc.l	153,82
	dc.l	151,81
	dc.l	150,80
	dc.l	148,79
	dc.l	147,79
	dc.l	145,78
	dc.l	144,77
	dc.l	142,77
	dc.l	141,76
	dc.l	139,76
	dc.l	138,75
	dc.l	137,75
	dc.l	136,74
	dc.l	134,74
	dc.l	133,73
	dc.l	132,73
	dc.l	131,72
	dc.l	130,72
	dc.l	130,72
	dc.l	129,71
	dc.l	128,71
	dc.l	127,71
	dc.l	127,71
	dc.l	126,71
	dc.l	126,70
	dc.l	126,70
	dc.l	125,70
	dc.l	125,70
	dc.l	125,70
	dc.l	125,70
	dc.l	125,70
	dc.l	125,70
	dc.l	125,70
	dc.l	126,70
	dc.l	126,70
	dc.l	126,71
	dc.l	127,71
	dc.l	127,71
	dc.l	128,71
	dc.l	129,71
	dc.l	130,72
	dc.l	130,72
	dc.l	131,72
	dc.l	132,73
	dc.l	133,73
	dc.l	134,74
	dc.l	136,74
	dc.l	137,75
	dc.l	138,75
	dc.l	139,76
	dc.l	141,76
	dc.l	142,77
	dc.l	144,77
	dc.l	145,78
	dc.l	147,79
	dc.l	148,79
	dc.l	150,80
	dc.l	151,81
	dc.l	153,82
	dc.l	155,82
	dc.l	156,83
	dc.l	158,84
	dc.l	159,85
	dc.l	161,86
	dc.l	163,86
	dc.l	164,87
	dc.l	166,88
	dc.l	168,89
	dc.l	169,90
	dc.l	171,91
	dc.l	172,92
	dc.l	174,93
	dc.l	175,93
	dc.l	177,94
	dc.l	178,95
	dc.l	180,96
	dc.l	181,97
	dc.l	182,98
	dc.l	184,99
	dc.l	185,100
	dc.l	186,101
	dc.l	187,102
	dc.l	188,103
	dc.l	189,104
	dc.l	190,105
	dc.l	191,106
	dc.l	191,107
	dc.l	192,107
	dc.l	193,108
	dc.l	193,109
	dc.l	194,110
	dc.l	194,111
	dc.l	194,112
	dc.l	195,113
	dc.l	195,114
	dc.l	195,114
	dc.l	195,115
	dc.l	195,116
	dc.l	195,117
	dc.l	195,118
	dc.l	194,118
	dc.l	194,119
	dc.l	193,120
	dc.l	193,121
	dc.l	192,121
	dc.l	192,122
	dc.l	191,123
	dc.l	190,123
	dc.l	189,124
	dc.l	188,124
	dc.l	187,125
	dc.l	186,125
	dc.l	185,126
	dc.l	184,126
	dc.l	183,127
	dc.l	181,127
	dc.l	180,128
	dc.l	179,128
	dc.l	177,128
	dc.l	176,129
	dc.l	174,129
	dc.l	173,129
	dc.l	171,129
	dc.l	170,129
	dc.l	168,130
	dc.l	167,130
	dc.l	165,130
	dc.l	163,130
	dc.l	162,130
	dc.l	160,130
	dc.l	158,130
	dc.l	157,130
	dc.l	155,130
	dc.l	153,130
	dc.l	152,130
	dc.l	150,129
	dc.l	149,129
	dc.l	147,129
	dc.l	146,129
	dc.l	144,129
	dc.l	143,128
	dc.l	141,128
	dc.l	140,128
	dc.l	139,127
	dc.l	137,127
	dc.l	136,126
	dc.l	135,126
	dc.l	134,125
	dc.l	133,125
	dc.l	132,124
	dc.l	131,124
	dc.l	130,123
	dc.l	129,123
	dc.l	128,122
	dc.l	128,121
	dc.l	127,121
	dc.l	127,120
	dc.l	126,119
	dc.l	126,118
	dc.l	125,118
	dc.l	125,117
	dc.l	125,116
	dc.l	125,115
	dc.l	125,114
	dc.l	125,114
	dc.l	125,113
	dc.l	126,112
	dc.l	126,111
	dc.l	126,110
	dc.l	127,109
	dc.l	127,108
	dc.l	128,107
	dc.l	129,107
	dc.l	129,106
	dc.l	130,105
	dc.l	131,104
	dc.l	132,103
	dc.l	133,102
	dc.l	134,101
	dc.l	135,100
	dc.l	136,99
	dc.l	138,98
	dc.l	139,97
	dc.l	140,96
	dc.l	142,95
	dc.l	143,94
	dc.l	145,93
	dc.l	146,93
	dc.l	148,92
	dc.l	149,91
	dc.l	151,90
	dc.l	152,89
	dc.l	154,88
	dc.l	156,87
	dc.l	157,86
	dc.l	159,86
	dc.l	161,85
	dc.l	162,84
	dc.l	164,83
	dc.l	165,82
	dc.l	167,82
	dc.l	169,81
	dc.l	170,80
	dc.l	172,79
	dc.l	173,79
	dc.l	175,78
	dc.l	176,77
	dc.l	178,77
	dc.l	179,76
	dc.l	181,76
	dc.l	182,75
	dc.l	183,75
	dc.l	184,74
	dc.l	186,74
	dc.l	187,73
	dc.l	188,73
	dc.l	189,72
	dc.l	190,72
	dc.l	190,72
	dc.l	191,71
	dc.l	192,71
	dc.l	193,71
	dc.l	193,71
	dc.l	194,71
	dc.l	194,70
	dc.l	194,70
	dc.l	195,70
	dc.l	195,70
	dc.l	195,70
	dc.l	195,70
	dc.l	195,70
	dc.l	195,70
	dc.l	195,70
	dc.l	194,70
	dc.l	194,70
	dc.l	194,71
	dc.l	193,71
	dc.l	193,71
	dc.l	192,71
	dc.l	191,71
	dc.l	190,72
	dc.l	190,72
	dc.l	189,72
	dc.l	188,73
	dc.l	187,73
	dc.l	186,74
	dc.l	184,74
	dc.l	183,75
	dc.l	182,75
	dc.l	181,76
	dc.l	179,76
	dc.l	178,77
	dc.l	176,77
	dc.l	175,78
	dc.l	173,79
	dc.l	172,79
	dc.l	170,80
	dc.l	169,81
	dc.l	167,82
	dc.l	165,82
	dc.l	164,83
	dc.l	162,84
	dc.l	161,85
	dc.l	159,86
	dc.l	157,86
	dc.l	156,87
	dc.l	154,88
	dc.l	152,89
	dc.l	151,90
	dc.l	149,91
	dc.l	148,92
	dc.l	146,93
	dc.l	145,93
	dc.l	143,94
	dc.l	142,95
	dc.l	140,96
	dc.l	139,97
	dc.l	138,98
	dc.l	136,99
	dc.l	135,100
	dc.l	134,101
	dc.l	133,102
	dc.l	132,103
	dc.l	131,104
	dc.l	130,105
	dc.l	129,106
	dc.l	129,107
	dc.l	128,107
	dc.l	127,108
	dc.l	127,109
	dc.l	126,110
	dc.l	126,111
	dc.l	126,112
	dc.l	125,113
	dc.l	125,114
	dc.l	125,114
	dc.l	125,115
	dc.l	125,116
	dc.l	125,117
	dc.l	125,118
	dc.l	126,118
	dc.l	126,119
	dc.l	127,120
	dc.l	127,121
	dc.l	128,121
	dc.l	128,122
	dc.l	129,123
	dc.l	130,123
	dc.l	131,124
	dc.l	132,124
	dc.l	133,125
	dc.l	134,125
	dc.l	135,126
	dc.l	136,126
	dc.l	137,127
	dc.l	139,127
	dc.l	140,128
	dc.l	141,128
	dc.l	143,128
	dc.l	144,129
	dc.l	146,129
	dc.l	147,129
	dc.l	149,129
	dc.l	150,129
	dc.l	152,130
	dc.l	153,130
	dc.l	155,130
	dc.l	157,130
	dc.l	158,130
