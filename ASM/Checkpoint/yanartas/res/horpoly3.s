	dc.w	160
	dc.w	165
	dc.w	170
	dc.w	175
	dc.w	180
	dc.w	185
	dc.w	190
	dc.w	195
	dc.w	200
	dc.w	205
	dc.w	209
	dc.w	214
	dc.w	219
	dc.w	224
	dc.w	228
	dc.w	233
	dc.w	237
	dc.w	241
	dc.w	246
	dc.w	250
	dc.w	254
	dc.w	258
	dc.w	262
	dc.w	266
	dc.w	270
	dc.w	273
	dc.w	277
	dc.w	280
	dc.w	283
	dc.w	286
	dc.w	289
	dc.w	292
	dc.w	295
	dc.w	298
	dc.w	300
	dc.w	303
	dc.w	305
	dc.w	307
	dc.w	309
	dc.w	311
	dc.w	312
	dc.w	314
	dc.w	315
	dc.w	316
	dc.w	317
	dc.w	318
	dc.w	319
	dc.w	319
	dc.w	320
	dc.w	320
	dc.w	320
	dc.w	320
	dc.w	320
	dc.w	319
	dc.w	319
	dc.w	318
	dc.w	317
	dc.w	316
	dc.w	315
	dc.w	314
	dc.w	312
	dc.w	311
	dc.w	309
	dc.w	307
	dc.w	305
	dc.w	303
	dc.w	300
	dc.w	298
	dc.w	295
	dc.w	292
	dc.w	289
	dc.w	286
	dc.w	283
	dc.w	280
	dc.w	277
	dc.w	273
	dc.w	270
	dc.w	266
	dc.w	262
	dc.w	258
	dc.w	254
	dc.w	250
	dc.w	246
	dc.w	241
	dc.w	237
	dc.w	233
	dc.w	228
	dc.w	224
	dc.w	219
	dc.w	214
	dc.w	209
	dc.w	205
	dc.w	200
	dc.w	195
	dc.w	190
	dc.w	185
	dc.w	180
	dc.w	175
	dc.w	170
	dc.w	165
	dc.w	160
	dc.w	155
	dc.w	150
	dc.w	145
	dc.w	140
	dc.w	135
	dc.w	130
	dc.w	125
	dc.w	120
	dc.w	115
	dc.w	111
	dc.w	106
	dc.w	101
	dc.w	96
	dc.w	92
	dc.w	87
	dc.w	83
	dc.w	79
	dc.w	74
	dc.w	70
	dc.w	66
	dc.w	62
	dc.w	58
	dc.w	54
	dc.w	50
	dc.w	47
	dc.w	43
	dc.w	40
	dc.w	37
	dc.w	34
	dc.w	31
	dc.w	28
	dc.w	25
	dc.w	22
	dc.w	20
	dc.w	17
	dc.w	15
	dc.w	13
	dc.w	11
	dc.w	9
	dc.w	8
	dc.w	6
	dc.w	5
	dc.w	4
	dc.w	3
	dc.w	2
	dc.w	1
	dc.w	1
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	1
	dc.w	1
	dc.w	2
	dc.w	3
	dc.w	4
	dc.w	5
	dc.w	6
	dc.w	8
	dc.w	9
	dc.w	11
	dc.w	13
	dc.w	15
	dc.w	17
	dc.w	20
	dc.w	22
	dc.w	25
	dc.w	28
	dc.w	31
	dc.w	34
	dc.w	37
	dc.w	40
	dc.w	43
	dc.w	47
	dc.w	50
	dc.w	54
	dc.w	58
	dc.w	62
	dc.w	66
	dc.w	70
	dc.w	74
	dc.w	79
	dc.w	83
	dc.w	87
	dc.w	92
	dc.w	96
	dc.w	101
	dc.w	106
	dc.w	111
	dc.w	115
	dc.w	120
	dc.w	125
	dc.w	130
	dc.w	135
	dc.w	140
	dc.w	145
	dc.w	150
	dc.w	155
