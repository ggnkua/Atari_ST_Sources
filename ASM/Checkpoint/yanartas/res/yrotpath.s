	dc.w	0,0,0
	dc.w	0,1,0
	dc.w	0,2,0
	dc.w	0,3,0
	dc.w	0,4,0
	dc.w	0,5,0
	dc.w	0,6,0
	dc.w	0,7,0
	dc.w	0,8,0
	dc.w	0,9,0
	dc.w	0,10,0
	dc.w	0,11,0
	dc.w	0,12,0
	dc.w	0,13,0
	dc.w	0,14,0
	dc.w	0,15,0
	dc.w	0,16,0
	dc.w	0,17,0
	dc.w	0,18,0
	dc.w	0,19,0
	dc.w	0,20,0
	dc.w	0,21,0
	dc.w	0,22,0
	dc.w	0,23,0
	dc.w	0,24,0
	dc.w	0,25,0
	dc.w	0,26,0
	dc.w	0,27,0
	dc.w	0,28,0
	dc.w	0,29,0
	dc.w	0,30,0
	dc.w	0,31,0
	dc.w	0,32,0
	dc.w	0,33,0
	dc.w	0,34,0
	dc.w	0,35,0
	dc.w	0,36,0
	dc.w	0,37,0
	dc.w	0,38,0
	dc.w	0,39,0
	dc.w	0,40,0
	dc.w	0,41,0
	dc.w	0,42,0
	dc.w	0,43,0
	dc.w	0,44,0
	dc.w	0,45,0
	dc.w	0,46,0
	dc.w	0,47,0
	dc.w	0,48,0
	dc.w	0,49,0
	dc.w	0,50,0
	dc.w	0,51,0
	dc.w	0,52,0
	dc.w	0,53,0
	dc.w	0,54,0
	dc.w	0,55,0
	dc.w	0,56,0
	dc.w	0,57,0
	dc.w	0,58,0
	dc.w	0,59,0
	dc.w	0,60,0
	dc.w	0,61,0
	dc.w	0,62,0
	dc.w	0,63,0
	dc.w	0,64,0
	dc.w	0,65,0
	dc.w	0,66,0
	dc.w	0,67,0
	dc.w	0,68,0
	dc.w	0,69,0
	dc.w	0,70,0
	dc.w	0,71,0
	dc.w	0,72,0
	dc.w	0,73,0
	dc.w	0,74,0
	dc.w	0,75,0
	dc.w	0,76,0
	dc.w	0,77,0
	dc.w	0,78,0
	dc.w	0,79,0
	dc.w	0,80,0
	dc.w	0,81,0
	dc.w	0,82,0
	dc.w	0,83,0
	dc.w	0,84,0
	dc.w	0,85,0
	dc.w	0,86,0
	dc.w	0,87,0
	dc.w	0,88,0
	dc.w	0,89,0
	dc.w	0,90,0
	dc.w	0,91,0
	dc.w	0,92,0
	dc.w	0,93,0
	dc.w	0,94,0
	dc.w	0,95,0
	dc.w	0,96,0
	dc.w	0,97,0
	dc.w	0,98,0
	dc.w	0,99,0
	dc.w	0,100,0
	dc.w	0,101,0
	dc.w	0,102,0
	dc.w	0,103,0
	dc.w	0,104,0
	dc.w	0,105,0
	dc.w	0,106,0
	dc.w	0,107,0
	dc.w	0,108,0
	dc.w	0,109,0
	dc.w	0,110,0
	dc.w	0,111,0
	dc.w	0,112,0
	dc.w	0,113,0
	dc.w	0,114,0
	dc.w	0,115,0
	dc.w	0,116,0
	dc.w	0,117,0
	dc.w	0,118,0
	dc.w	0,119,0
	dc.w	0,120,0
	dc.w	0,121,0
	dc.w	0,122,0
	dc.w	0,123,0
	dc.w	0,124,0
	dc.w	0,125,0
	dc.w	0,126,0
	dc.w	0,127,0
	dc.w	0,128,0
	dc.w	0,129,0
	dc.w	0,130,0
	dc.w	0,131,0
	dc.w	0,132,0
	dc.w	0,133,0
	dc.w	0,134,0
	dc.w	0,135,0
	dc.w	0,136,0
	dc.w	0,137,0
	dc.w	0,138,0
	dc.w	0,139,0
	dc.w	0,140,0
	dc.w	0,141,0
	dc.w	0,142,0
	dc.w	0,143,0
	dc.w	0,144,0
	dc.w	0,145,0
	dc.w	0,146,0
	dc.w	0,147,0
	dc.w	0,148,0
	dc.w	0,149,0
	dc.w	0,150,0
	dc.w	0,151,0
	dc.w	0,152,0
	dc.w	0,153,0
	dc.w	0,154,0
	dc.w	0,155,0
	dc.w	0,156,0
	dc.w	0,157,0
	dc.w	0,158,0
	dc.w	0,159,0
	dc.w	0,160,0
	dc.w	0,161,0
	dc.w	0,162,0
	dc.w	0,163,0
	dc.w	0,164,0
	dc.w	0,165,0
	dc.w	0,166,0
	dc.w	0,167,0
	dc.w	0,168,0
	dc.w	0,169,0
	dc.w	0,170,0
	dc.w	0,171,0
	dc.w	0,172,0
	dc.w	0,173,0
	dc.w	0,174,0
	dc.w	0,175,0
	dc.w	0,176,0
	dc.w	0,177,0
	dc.w	0,178,0
	dc.w	0,179,0
	dc.w	0,180,0
	dc.w	0,181,0
	dc.w	0,182,0
	dc.w	0,183,0
	dc.w	0,184,0
	dc.w	0,185,0
	dc.w	0,186,0
	dc.w	0,187,0
	dc.w	0,188,0
	dc.w	0,189,0
	dc.w	0,190,0
	dc.w	0,191,0
	dc.w	0,192,0
	dc.w	0,193,0
	dc.w	0,194,0
	dc.w	0,195,0
	dc.w	0,196,0
	dc.w	0,197,0
	dc.w	0,198,0
	dc.w	0,199,0
	dc.w	0,200,0
	dc.w	0,201,0
	dc.w	0,202,0
	dc.w	0,203,0
	dc.w	0,204,0
	dc.w	0,205,0
	dc.w	0,206,0
	dc.w	0,207,0
	dc.w	0,208,0
	dc.w	0,209,0
	dc.w	0,210,0
	dc.w	0,211,0
	dc.w	0,212,0
	dc.w	0,213,0
	dc.w	0,214,0
	dc.w	0,215,0
	dc.w	0,216,0
	dc.w	0,217,0
	dc.w	0,218,0
	dc.w	0,219,0
	dc.w	0,220,0
	dc.w	0,221,0
	dc.w	0,222,0
	dc.w	0,223,0
	dc.w	0,224,0
	dc.w	0,225,0
	dc.w	0,226,0
	dc.w	0,227,0
	dc.w	0,228,0
	dc.w	0,229,0
	dc.w	0,230,0
	dc.w	0,231,0
	dc.w	0,232,0
	dc.w	0,233,0
	dc.w	0,234,0
	dc.w	0,235,0
	dc.w	0,236,0
	dc.w	0,237,0
	dc.w	0,238,0
	dc.w	0,239,0
	dc.w	0,240,0
	dc.w	0,241,0
	dc.w	0,242,0
	dc.w	0,243,0
	dc.w	0,244,0
	dc.w	0,245,0
	dc.w	0,246,0
	dc.w	0,247,0
	dc.w	0,248,0
	dc.w	0,249,0
	dc.w	0,250,0
	dc.w	0,251,0
	dc.w	0,252,0
	dc.w	0,253,0
	dc.w	0,254,0