	dc.b	200
	dc.b	185
	dc.b	171
	dc.b	158
	dc.b	149
	dc.b	142
	dc.b	138
	dc.b	138
	dc.b	142
	dc.b	149
	dc.b	159
	dc.b	172
	dc.b	185
	dc.b	199
	dc.b	200
	dc.b	200
	dc.b	200
	dc.b	200
	dc.b	200
	dc.b	200
	dc.b	200
	dc.b	200
	dc.b	200
	dc.b	200
	dc.b	196
	dc.b	179
	dc.b	163
	dc.b	147
	dc.b	133
	dc.b	122
	dc.b	113
	dc.b	108
	dc.b	106
	dc.b	109
	dc.b	114
	dc.b	123
	dc.b	133
	dc.b	146
	dc.b	159
	dc.b	171
	dc.b	183
	dc.b	192
	dc.b	198
	dc.b	200
	dc.b	200
	dc.b	197
	dc.b	189
	dc.b	178
	dc.b	164
	dc.b	148
	dc.b	131
	dc.b	113
	dc.b	97
	dc.b	81
	dc.b	68
	dc.b	58
	dc.b	52
	dc.b	49
	dc.b	50
	dc.b	54
	dc.b	61
	dc.b	71
	dc.b	82
	dc.b	94
	dc.b	106
	dc.b	117
	dc.b	125
	dc.b	131
	dc.b	134
	dc.b	133
	dc.b	129
	dc.b	121
	dc.b	109
	dc.b	94
	dc.b	78
	dc.b	60
	dc.b	42
	dc.b	24
	dc.b	8
	dc.b	0
	dc.b	0
	dc.b	0
	dc.b	0
	dc.b	0
	dc.b	0
	dc.b	0
	dc.b	0
	dc.b	0
	dc.b	9
	dc.b	20
	dc.b	30
	dc.b	39
	dc.b	44
	dc.b	47
	dc.b	46
	dc.b	41
	dc.b	32
	dc.b	20
	dc.b	6
	dc.b	0
