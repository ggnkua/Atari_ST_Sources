	dc.w	176
	dc.w	176
	dc.w	184
	dc.w	184
	dc.w	184
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	200
	dc.w	200
	dc.w	200
	dc.w	208
	dc.w	208
	dc.w	208
	dc.w	216
	dc.w	216
	dc.w	216
	dc.w	224
	dc.w	224
	dc.w	224
	dc.w	224
	dc.w	232
	dc.w	232
	dc.w	232
	dc.w	240
	dc.w	240
	dc.w	240
	dc.w	248
	dc.w	248
	dc.w	248
	dc.w	256
	dc.w	256
	dc.w	256
	dc.w	256
	dc.w	264
	dc.w	264
	dc.w	264
	dc.w	272
	dc.w	272
	dc.w	272
	dc.w	272
	dc.w	280
	dc.w	280
	dc.w	280
	dc.w	280
	dc.w	288
	dc.w	288
	dc.w	288
	dc.w	288
	dc.w	296
	dc.w	296
	dc.w	296
	dc.w	296
	dc.w	304
	dc.w	304
	dc.w	304
	dc.w	304
	dc.w	304
	dc.w	312
	dc.w	312
	dc.w	312
	dc.w	312
	dc.w	312
	dc.w	320
	dc.w	320
	dc.w	320
	dc.w	320
	dc.w	320
	dc.w	320
	dc.w	328
	dc.w	328
	dc.w	328
	dc.w	328
	dc.w	328
	dc.w	328
	dc.w	328
	dc.w	336
	dc.w	336
	dc.w	336
	dc.w	336
	dc.w	336
	dc.w	336
	dc.w	336
	dc.w	336
	dc.w	336
	dc.w	336
	dc.w	336
	dc.w	344
	dc.w	344
	dc.w	344
	dc.w	344
	dc.w	344
	dc.w	344
	dc.w	344
	dc.w	344
	dc.w	344
	dc.w	344
	dc.w	344
	dc.w	344
	dc.w	344
	dc.w	344
	dc.w	344
	dc.w	344
	dc.w	344
	dc.w	344
	dc.w	344
	dc.w	344
	dc.w	344
	dc.w	344
	dc.w	344
	dc.w	344
	dc.w	344
	dc.w	344
	dc.w	344
	dc.w	336
	dc.w	336
	dc.w	336
	dc.w	336
	dc.w	336
	dc.w	336
	dc.w	336
	dc.w	336
	dc.w	336
	dc.w	336
	dc.w	336
	dc.w	328
	dc.w	328
	dc.w	328
	dc.w	328
	dc.w	328
	dc.w	328
	dc.w	328
	dc.w	320
	dc.w	320
	dc.w	320
	dc.w	320
	dc.w	320
	dc.w	320
	dc.w	312
	dc.w	312
	dc.w	312
	dc.w	312
	dc.w	312
	dc.w	304
	dc.w	304
	dc.w	304
	dc.w	304
	dc.w	304
	dc.w	296
	dc.w	296
	dc.w	296
	dc.w	296
	dc.w	288
	dc.w	288
	dc.w	288
	dc.w	288
	dc.w	280
	dc.w	280
	dc.w	280
	dc.w	280
	dc.w	272
	dc.w	272
	dc.w	272
	dc.w	272
	dc.w	264
	dc.w	264
	dc.w	264
	dc.w	256
	dc.w	256
	dc.w	256
	dc.w	256
	dc.w	248
	dc.w	248
	dc.w	248
	dc.w	240
	dc.w	240
	dc.w	240
	dc.w	232
	dc.w	232
	dc.w	232
	dc.w	224
	dc.w	224
	dc.w	224
	dc.w	224
	dc.w	216
	dc.w	216
	dc.w	216
	dc.w	208
	dc.w	208
	dc.w	208
	dc.w	200
	dc.w	200
	dc.w	200
	dc.w	192
	dc.w	192
	dc.w	192
	dc.w	184
	dc.w	184
	dc.w	184
	dc.w	176
	dc.w	176
	dc.w	176
	dc.w	168
	dc.w	168
	dc.w	168
	dc.w	160
	dc.w	160
	dc.w	160
	dc.w	152
	dc.w	152
	dc.w	152
	dc.w	144
	dc.w	144
	dc.w	144
	dc.w	136
	dc.w	136
	dc.w	136
	dc.w	128
	dc.w	128
	dc.w	128
	dc.w	128
	dc.w	120
	dc.w	120
	dc.w	120
	dc.w	112
	dc.w	112
	dc.w	112
	dc.w	104
	dc.w	104
	dc.w	104
	dc.w	96
	dc.w	96
	dc.w	96
	dc.w	96
	dc.w	88
	dc.w	88
	dc.w	88
	dc.w	80
	dc.w	80
	dc.w	80
	dc.w	80
	dc.w	72
	dc.w	72
	dc.w	72
	dc.w	72
	dc.w	64
	dc.w	64
	dc.w	64
	dc.w	64
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	48
	dc.w	48
	dc.w	48
	dc.w	48
	dc.w	48
	dc.w	40
	dc.w	40
	dc.w	40
	dc.w	40
	dc.w	40
	dc.w	32
	dc.w	32
	dc.w	32
	dc.w	32
	dc.w	32
	dc.w	32
	dc.w	24
	dc.w	24
	dc.w	24
	dc.w	24
	dc.w	24
	dc.w	24
	dc.w	24
	dc.w	16
	dc.w	16
	dc.w	16
	dc.w	16
	dc.w	16
	dc.w	16
	dc.w	16
	dc.w	16
	dc.w	16
	dc.w	16
	dc.w	16
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	16
	dc.w	16
	dc.w	16
	dc.w	16
	dc.w	16
	dc.w	16
	dc.w	16
	dc.w	16
	dc.w	16
	dc.w	16
	dc.w	16
	dc.w	24
	dc.w	24
	dc.w	24
	dc.w	24
	dc.w	24
	dc.w	24
	dc.w	24
	dc.w	32
	dc.w	32
	dc.w	32
	dc.w	32
	dc.w	32
	dc.w	32
	dc.w	40
	dc.w	40
	dc.w	40
	dc.w	40
	dc.w	40
	dc.w	48
	dc.w	48
	dc.w	48
	dc.w	48
	dc.w	48
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	56
	dc.w	64
	dc.w	64
	dc.w	64
	dc.w	64
	dc.w	72
	dc.w	72
	dc.w	72
	dc.w	72
	dc.w	80
	dc.w	80
	dc.w	80
	dc.w	80
	dc.w	88
	dc.w	88
	dc.w	88
	dc.w	96
	dc.w	96
	dc.w	96
	dc.w	96
	dc.w	104
	dc.w	104
	dc.w	104
	dc.w	112
	dc.w	112
	dc.w	112
	dc.w	120
	dc.w	120
	dc.w	120
	dc.w	128
	dc.w	128
	dc.w	128
	dc.w	128
	dc.w	136
	dc.w	136
	dc.w	136
	dc.w	144
	dc.w	144
	dc.w	144
	dc.w	152
	dc.w	152
	dc.w	152
	dc.w	160
	dc.w	160
	dc.w	160
	dc.w	168
	dc.w	168
	dc.w	168
	dc.w	176
