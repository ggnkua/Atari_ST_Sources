	dc.w	117
	dc.w	116
	dc.w	116
	dc.w	115
	dc.w	114
	dc.w	113
	dc.w	113
	dc.w	112
	dc.w	111
	dc.w	111
	dc.w	110
	dc.w	109
	dc.w	109
	dc.w	108
	dc.w	107
	dc.w	107
	dc.w	106
	dc.w	105
	dc.w	105
	dc.w	104
	dc.w	103
	dc.w	103
	dc.w	102
	dc.w	102
	dc.w	101
	dc.w	101
	dc.w	100
	dc.w	100
	dc.w	99
	dc.w	99
	dc.w	98
	dc.w	98
	dc.w	98
	dc.w	97
	dc.w	97
	dc.w	97
	dc.w	96
	dc.w	96
	dc.w	96
	dc.w	95
	dc.w	95
	dc.w	95
	dc.w	95
	dc.w	95
	dc.w	94
	dc.w	94
	dc.w	94
	dc.w	94
	dc.w	94
	dc.w	94
	dc.w	94
	dc.w	94
	dc.w	94
	dc.w	94
	dc.w	94
	dc.w	94
	dc.w	94
	dc.w	95
	dc.w	95
	dc.w	95
	dc.w	95
	dc.w	95
	dc.w	96
	dc.w	96
	dc.w	96
	dc.w	97
	dc.w	97
	dc.w	97
	dc.w	98
	dc.w	98
	dc.w	98
	dc.w	99
	dc.w	99
	dc.w	100
	dc.w	100
	dc.w	101
	dc.w	101
	dc.w	102
	dc.w	102
	dc.w	103
	dc.w	103
	dc.w	104
	dc.w	105
	dc.w	105
	dc.w	106
	dc.w	107
	dc.w	107
	dc.w	108
	dc.w	109
	dc.w	109
	dc.w	110
	dc.w	111
	dc.w	111
	dc.w	112
	dc.w	113
	dc.w	113
	dc.w	114
	dc.w	115
	dc.w	116
	dc.w	116
	dc.w	117
	dc.w	118
	dc.w	118
	dc.w	119
	dc.w	120
	dc.w	121
	dc.w	121
	dc.w	122
	dc.w	123
	dc.w	123
	dc.w	124
	dc.w	125
	dc.w	125
	dc.w	126
	dc.w	127
	dc.w	127
	dc.w	128
	dc.w	129
	dc.w	129
	dc.w	130
	dc.w	131
	dc.w	131
	dc.w	132
	dc.w	132
	dc.w	133
	dc.w	133
	dc.w	134
	dc.w	134
	dc.w	135
	dc.w	135
	dc.w	136
	dc.w	136
	dc.w	136
	dc.w	137
	dc.w	137
	dc.w	137
	dc.w	138
	dc.w	138
	dc.w	138
	dc.w	139
	dc.w	139
	dc.w	139
	dc.w	139
	dc.w	139
	dc.w	140
	dc.w	140
	dc.w	140
	dc.w	140
	dc.w	140
	dc.w	140
	dc.w	140
	dc.w	140
	dc.w	140
	dc.w	140
	dc.w	140
	dc.w	140
	dc.w	140
	dc.w	139
	dc.w	139
	dc.w	139
	dc.w	139
	dc.w	139
	dc.w	138
	dc.w	138
	dc.w	138
	dc.w	137
	dc.w	137
	dc.w	137
	dc.w	136
	dc.w	136
	dc.w	136
	dc.w	135
	dc.w	135
	dc.w	134
	dc.w	134
	dc.w	133
	dc.w	133
	dc.w	132
	dc.w	132
	dc.w	131
	dc.w	131
	dc.w	130
	dc.w	129
	dc.w	129
	dc.w	128
	dc.w	127
	dc.w	127
	dc.w	126
	dc.w	125
	dc.w	125
	dc.w	124
	dc.w	123
	dc.w	123
	dc.w	122
	dc.w	121
	dc.w	121
	dc.w	120
	dc.w	119
	dc.w	118
	dc.w	118
