	dc.w	0,0,0
	dc.w	1,1,1
	dc.w	2,2,2
	dc.w	3,3,3
	dc.w	4,4,4
	dc.w	5,5,5
	dc.w	6,6,6
	dc.w	7,7,7
	dc.w	8,8,8
	dc.w	9,9,9
	dc.w	10,10,10
	dc.w	11,11,11
	dc.w	12,12,12
	dc.w	13,13,13
	dc.w	14,14,14
	dc.w	15,15,15
	dc.w	16,16,16
	dc.w	17,17,17
	dc.w	18,18,18
	dc.w	19,19,19
	dc.w	20,20,20
	dc.w	21,21,21
	dc.w	22,22,22
	dc.w	23,23,23
	dc.w	24,24,24
	dc.w	25,25,25
	dc.w	26,26,26
	dc.w	27,27,27
	dc.w	28,28,28
	dc.w	29,29,29
	dc.w	30,30,30
	dc.w	31,31,31
	dc.w	32,32,32
	dc.w	33,33,33
	dc.w	34,34,34
	dc.w	35,35,35
	dc.w	36,36,36
	dc.w	37,37,37
	dc.w	38,38,38
	dc.w	39,39,39
	dc.w	40,40,40
	dc.w	41,41,41
	dc.w	42,42,42
	dc.w	43,43,43
	dc.w	44,44,44
	dc.w	45,45,45
	dc.w	46,46,46
	dc.w	47,47,47
	dc.w	48,48,48
	dc.w	49,49,49
	dc.w	50,50,50
	dc.w	51,51,51
	dc.w	52,52,52
	dc.w	53,53,53
	dc.w	54,54,54
	dc.w	55,55,55
	dc.w	56,56,56
	dc.w	57,57,57
	dc.w	58,58,58
	dc.w	59,59,59
	dc.w	60,60,60
	dc.w	61,61,61
	dc.w	62,62,62
	dc.w	63,63,63
	dc.w	64,64,64
	dc.w	65,65,65
	dc.w	66,66,66
	dc.w	67,67,67
	dc.w	68,68,68
	dc.w	69,69,69
	dc.w	70,70,70
	dc.w	71,71,71
	dc.w	72,72,72
	dc.w	73,73,73
	dc.w	74,74,74
	dc.w	75,75,75
	dc.w	76,76,76
	dc.w	77,77,77
	dc.w	78,78,78
	dc.w	79,79,79
	dc.w	80,80,80
	dc.w	81,81,81
	dc.w	82,82,82
	dc.w	83,83,83
	dc.w	84,84,84
	dc.w	85,85,85
	dc.w	86,86,86
	dc.w	87,87,87
	dc.w	88,88,88
	dc.w	89,89,89
	dc.w	90,90,90
	dc.w	91,91,91
	dc.w	92,92,92
	dc.w	93,93,93
	dc.w	94,94,94
	dc.w	95,95,95
	dc.w	96,96,96
	dc.w	97,97,97
	dc.w	98,98,98
	dc.w	99,99,99
	dc.w	100,100,100
	dc.w	101,101,101
	dc.w	102,102,102
	dc.w	103,103,103
	dc.w	104,104,104
	dc.w	105,105,105
	dc.w	106,106,106
	dc.w	107,107,107
	dc.w	108,108,108
	dc.w	109,109,109
	dc.w	110,110,110
	dc.w	111,111,111
	dc.w	112,112,112
	dc.w	113,113,113
	dc.w	114,114,114
	dc.w	115,115,115
	dc.w	116,116,116
	dc.w	117,117,117
	dc.w	118,118,118
	dc.w	119,119,119
	dc.w	120,120,120
	dc.w	121,121,121
	dc.w	122,122,122
	dc.w	123,123,123
	dc.w	124,124,124
	dc.w	125,125,125
	dc.w	126,126,126
	dc.w	127,127,127
	dc.w	128,128,128
	dc.w	129,129,129
	dc.w	130,130,130
	dc.w	131,131,131
	dc.w	132,132,132
	dc.w	133,133,133
	dc.w	134,134,134
	dc.w	135,135,135
	dc.w	136,136,136
	dc.w	137,137,137
	dc.w	138,138,138
	dc.w	139,139,139
	dc.w	140,140,140
	dc.w	141,141,141
	dc.w	142,142,142
	dc.w	143,143,143
	dc.w	144,144,144
	dc.w	145,145,145
	dc.w	146,146,146
	dc.w	147,147,147
	dc.w	148,148,148
	dc.w	149,149,149
	dc.w	150,150,150
	dc.w	151,151,151
	dc.w	152,152,152
	dc.w	153,153,153
	dc.w	154,154,154
	dc.w	155,155,155
	dc.w	156,156,156
	dc.w	157,157,157
	dc.w	158,158,158
	dc.w	159,159,159
	dc.w	160,160,160
	dc.w	161,161,161
	dc.w	162,162,162
	dc.w	163,163,163
	dc.w	164,164,164
	dc.w	165,165,165
	dc.w	166,166,166
	dc.w	167,167,167
	dc.w	168,168,168
	dc.w	169,169,169
	dc.w	170,170,170
	dc.w	171,171,171
	dc.w	172,172,172
	dc.w	173,173,173
	dc.w	174,174,174
	dc.w	175,175,175
	dc.w	176,176,176
	dc.w	177,177,177
	dc.w	178,178,178
	dc.w	179,179,179
	dc.w	180,180,180
	dc.w	181,181,181
	dc.w	182,182,182
	dc.w	183,183,183
	dc.w	184,184,184
	dc.w	185,185,185
	dc.w	186,186,186
	dc.w	187,187,187
	dc.w	188,188,188
	dc.w	189,189,189
	dc.w	190,190,190
	dc.w	191,191,191
	dc.w	192,192,192
	dc.w	193,193,193
	dc.w	194,194,194
	dc.w	195,195,195
	dc.w	196,196,196
	dc.w	197,197,197
	dc.w	198,198,198
	dc.w	199,199,199
	dc.w	200,200,200
	dc.w	201,201,201
	dc.w	202,202,202
	dc.w	203,203,203
	dc.w	204,204,204
	dc.w	205,205,205
	dc.w	206,206,206
	dc.w	207,207,207
	dc.w	208,208,208
	dc.w	209,209,209
	dc.w	210,210,210
	dc.w	211,211,211
	dc.w	212,212,212
	dc.w	213,213,213
	dc.w	214,214,214
	dc.w	215,215,215
	dc.w	216,216,216
	dc.w	217,217,217
	dc.w	218,218,218
	dc.w	219,219,219
	dc.w	220,220,220
	dc.w	221,221,221
	dc.w	222,222,222
	dc.w	223,223,223
	dc.w	224,224,224
	dc.w	225,225,225
	dc.w	226,226,226
	dc.w	227,227,227
	dc.w	228,228,228
	dc.w	229,229,229
	dc.w	230,230,230
	dc.w	231,231,231
	dc.w	232,232,232
	dc.w	233,233,233
	dc.w	234,234,234
	dc.w	235,235,235
	dc.w	236,236,236
	dc.w	237,237,237
	dc.w	238,238,238
	dc.w	239,239,239
	dc.w	240,240,240
	dc.w	241,241,241
	dc.w	242,242,242
	dc.w	243,243,243
	dc.w	244,244,244
	dc.w	245,245,245
	dc.w	246,246,246
	dc.w	247,247,247
	dc.w	248,248,248
	dc.w	249,249,249
	dc.w	250,250,250
	dc.w	251,251,251
	dc.w	252,252,252
	dc.w	253,253,253
	dc.w	254,254,254
	dc.w	255,255,255
	dc.w	256,256,256
	dc.w	257,257,257
	dc.w	258,258,258
	dc.w	259,259,259
	dc.w	260,260,260
	dc.w	261,261,261
	dc.w	262,262,262
	dc.w	263,263,263
	dc.w	264,264,264
	dc.w	265,265,265
	dc.w	266,266,266
	dc.w	267,267,267
	dc.w	268,268,268
	dc.w	269,269,269
	dc.w	270,270,270
	dc.w	271,271,271
	dc.w	272,272,272
	dc.w	273,273,273
	dc.w	274,274,274
	dc.w	275,275,275
	dc.w	276,276,276
	dc.w	277,277,277
	dc.w	278,278,278
	dc.w	279,279,279
	dc.w	280,280,280
	dc.w	281,281,281
	dc.w	282,282,282
	dc.w	283,283,283
	dc.w	284,284,284
	dc.w	285,285,285
	dc.w	286,286,286
	dc.w	287,287,287
	dc.w	288,288,288
	dc.w	289,289,289
	dc.w	290,290,290
	dc.w	291,291,291
	dc.w	292,292,292
	dc.w	293,293,293
	dc.w	294,294,294
	dc.w	295,295,295
	dc.w	296,296,296
	dc.w	297,297,297
	dc.w	298,298,298
	dc.w	299,299,299
	dc.w	300,300,300
	dc.w	301,301,301
	dc.w	302,302,302
	dc.w	303,303,303
	dc.w	304,304,304
	dc.w	305,305,305
	dc.w	306,306,306
	dc.w	307,307,307
	dc.w	308,308,308
	dc.w	309,309,309
	dc.w	310,310,310
	dc.w	311,311,311
	dc.w	312,312,312
	dc.w	313,313,313
	dc.w	314,314,314
	dc.w	315,315,315
	dc.w	316,316,316
	dc.w	317,317,317
	dc.w	318,318,318
	dc.w	319,319,319
	dc.w	320,320,320
	dc.w	321,321,321
	dc.w	322,322,322
	dc.w	323,323,323
	dc.w	324,324,324
	dc.w	325,325,325
	dc.w	326,326,326
	dc.w	327,327,327
	dc.w	328,328,328
	dc.w	329,329,329
	dc.w	330,330,330
	dc.w	331,331,331
	dc.w	332,332,332
	dc.w	333,333,333
	dc.w	334,334,334
	dc.w	335,335,335
	dc.w	336,336,336
	dc.w	337,337,337
	dc.w	338,338,338
	dc.w	339,339,339
	dc.w	340,340,340
	dc.w	341,341,341
	dc.w	342,342,342
	dc.w	343,343,343
	dc.w	344,344,344
	dc.w	345,345,345
	dc.w	346,346,346
	dc.w	347,347,347
	dc.w	348,348,348
	dc.w	349,349,349
	dc.w	350,350,350
	dc.w	351,351,351
	dc.w	352,352,352
	dc.w	353,353,353
	dc.w	354,354,354
	dc.w	355,355,355
	dc.w	356,356,356
	dc.w	357,357,357
	dc.w	358,358,358
	dc.w	359,359,359
	dc.w	360,360,360
	dc.w	361,361,361
	dc.w	362,362,362
	dc.w	363,363,363
	dc.w	364,364,364
	dc.w	365,365,365
	dc.w	366,366,366
	dc.w	367,367,367
	dc.w	368,368,368
	dc.w	369,369,369
	dc.w	370,370,370
	dc.w	371,371,371
	dc.w	372,372,372
	dc.w	373,373,373
	dc.w	374,374,374
	dc.w	375,375,375
	dc.w	376,376,376
	dc.w	377,377,377
	dc.w	378,378,378
	dc.w	379,379,379
	dc.w	380,380,380
	dc.w	381,381,381
	dc.w	382,382,382
	dc.w	383,383,383
	dc.w	384,384,384
	dc.w	385,385,385
	dc.w	386,386,386
	dc.w	387,387,387
	dc.w	388,388,388
	dc.w	389,389,389
	dc.w	390,390,390
	dc.w	391,391,391
	dc.w	392,392,392
	dc.w	393,393,393
	dc.w	394,394,394
	dc.w	395,395,395
	dc.w	396,396,396
	dc.w	397,397,397
	dc.w	398,398,398
	dc.w	399,399,399
	dc.w	400,400,400
	dc.w	401,401,401
	dc.w	402,402,402
	dc.w	403,403,403
	dc.w	404,404,404
	dc.w	405,405,405
	dc.w	406,406,406
	dc.w	407,407,407
	dc.w	408,408,408
	dc.w	409,409,409
	dc.w	410,410,410
	dc.w	411,411,411
	dc.w	412,412,412
	dc.w	413,413,413
	dc.w	414,414,414
	dc.w	415,415,415
	dc.w	416,416,416
	dc.w	417,417,417
	dc.w	418,418,418
	dc.w	419,419,419
	dc.w	420,420,420
	dc.w	421,421,421
	dc.w	422,422,422
	dc.w	423,423,423
	dc.w	424,424,424
	dc.w	425,425,425
	dc.w	426,426,426
	dc.w	427,427,427
	dc.w	428,428,428
	dc.w	429,429,429
	dc.w	430,430,430
	dc.w	431,431,431
	dc.w	432,432,432
	dc.w	433,433,433
	dc.w	434,434,434
	dc.w	435,435,435
	dc.w	436,436,436
	dc.w	437,437,437
	dc.w	438,438,438
	dc.w	439,439,439
	dc.w	440,440,440
	dc.w	441,441,441
	dc.w	442,442,442
	dc.w	443,443,443
	dc.w	444,444,444
	dc.w	445,445,445
	dc.w	446,446,446
	dc.w	447,447,447
	dc.w	448,448,448
	dc.w	449,449,449
	dc.w	450,450,450
	dc.w	451,451,451
	dc.w	452,452,452
	dc.w	453,453,453
	dc.w	454,454,454
	dc.w	455,455,455
	dc.w	456,456,456
	dc.w	457,457,457
	dc.w	458,458,458
	dc.w	459,459,459
	dc.w	460,460,460
	dc.w	461,461,461
	dc.w	462,462,462
	dc.w	463,463,463
	dc.w	464,464,464
	dc.w	465,465,465
	dc.w	466,466,466
	dc.w	467,467,467
	dc.w	468,468,468
	dc.w	469,469,469
	dc.w	470,470,470
	dc.w	471,471,471
	dc.w	472,472,472
	dc.w	473,473,473
	dc.w	474,474,474
	dc.w	475,475,475
	dc.w	476,476,476
	dc.w	477,477,477
	dc.w	478,478,478
	dc.w	479,479,479
	dc.w	480,480,480
	dc.w	481,481,481
	dc.w	482,482,482
	dc.w	483,483,483
	dc.w	484,484,484
	dc.w	485,485,485
	dc.w	486,486,486
	dc.w	487,487,487
	dc.w	488,488,488
	dc.w	489,489,489
	dc.w	490,490,490
	dc.w	491,491,491
	dc.w	492,492,492
	dc.w	493,493,493
	dc.w	494,494,494
	dc.w	495,495,495
	dc.w	496,496,496
	dc.w	497,497,497
	dc.w	498,498,498
	dc.w	499,499,499
	dc.w	500,500,500
	dc.w	501,501,501
	dc.w	502,502,502
	dc.w	503,503,503
	dc.w	504,504,504
	dc.w	505,505,505
	dc.w	506,506,506
	dc.w	507,507,507
	dc.w	508,508,508
	dc.w	509,509,509
	dc.w	510,510,510
	dc.w	511,511,511
