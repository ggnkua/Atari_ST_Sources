	dc.w	94
	dc.w	95
	dc.w	96
	dc.w	97
	dc.w	98
	dc.w	101
	dc.w	103
	dc.w	106
	dc.w	108
	dc.w	111
	dc.w	113
	dc.w	114
	dc.w	115
	dc.w	116
	dc.w	116
