	dc.b	1
	dc.b	15
	dc.b	29
	dc.b	42
	dc.b	51
	dc.b	58
	dc.b	62
	dc.b	62
	dc.b	58
	dc.b	51
	dc.b	41
	dc.b	28
	dc.b	15
	dc.b	1
	dc.b	1
	dc.b	1
	dc.b	1
	dc.b	1
	dc.b	1
	dc.b	1
	dc.b	1
	dc.b	1
	dc.b	1
	dc.b	1
	dc.b	4
	dc.b	21
	dc.b	37
	dc.b	53
	dc.b	67
	dc.b	78
	dc.b	87
	dc.b	92
	dc.b	94
	dc.b	91
	dc.b	86
	dc.b	77
	dc.b	67
	dc.b	54
	dc.b	41
	dc.b	29
	dc.b	17
	dc.b	8
	dc.b	2
	dc.b	1
	dc.b	1
	dc.b	3
	dc.b	11
	dc.b	22
	dc.b	36
	dc.b	52
	dc.b	69
	dc.b	87
	dc.b	103
	dc.b	119
	dc.b	132
	dc.b	142
	dc.b	148
	dc.b	151
	dc.b	150
	dc.b	146
	dc.b	139
	dc.b	129
	dc.b	118
	dc.b	106
	dc.b	94
	dc.b	83
	dc.b	75
	dc.b	69
	dc.b	66
	dc.b	67
	dc.b	71
	dc.b	79
	dc.b	91
	dc.b	106
	dc.b	122
	dc.b	140
	dc.b	158
	dc.b	176
	dc.b	192
	dc.b	206
	dc.b	218
	dc.b	225
	dc.b	230
	dc.b	230
	dc.b	227
	dc.b	221
	dc.b	212
	dc.b	202
	dc.b	191
	dc.b	180
	dc.b	170
	dc.b	161
	dc.b	156
	dc.b	153
	dc.b	154
	dc.b	159
	dc.b	168
	dc.b	180
	dc.b	194
	dc.b	212
