*
*  NEOchrome V2.24 cut buffer contents (left justified):
*  by Chaos, Inc. of the Delta Force (member of The Union)
*
*    pixels/scanline    = $0090 (bytes/scanline: $0048)
*  # scanlines (height) = $000E
*
*  Hardware color pallet  (color 0 to 15):
*
*      $0000,$0700,$0232,$0232,$0333,$0343,$0454,$0112
*      $0332,$0300,$0300,$0540,$0531,$0540,$0553,$0555
*
*
		dc.w	$FEFB,$03FE,$0202,$0000,$FF4F,$1F9F,$003E,$007F
		dc.w	$77DF,$9FF0,$1010,$C000,$BF7F,$7FC7,$0040,$0000
		dc.w	$EFDE,$DFBF,$003E,$001E,$FED6,$032F,$021F,$0006
		dc.w	$BDEB,$43F7,$83E7,$01E3,$DFB9,$E7C3,$CF87,$C781
		dc.w	$EFFF,$F000,$E000,$E000,$FF8F,$00F8,$0088,$0000
		dc.w	$E0CC,$1FE1,$00DE,$003F,$FC7F,$47C0,$4440,$A000
		dc.w	$E1F8,$3F87,$2180,$0000,$3040,$DFBF,$1000,$0000
		dc.w	$FF79,$068F,$0509,$0000,$FC08,$03F7,$0000,$0000
		dc.w	$103E,$EFC3,$0002,$0000,$0FFF,$F000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFF5,$052E,$0520,$005F
		dc.w	$FFFF,$D400,$D400,$0000,$FFFF,$0800,$0800,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FD7F,$0F80,$0900,$0000
		dc.w	$FFFF,$1000,$1000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$1095,$1095,$002A,$FFFF,$2200,$2200,$8000
		dc.w	$F7FF,$0C00,$0400,$0000,$FFFF,$000E,$000E,$0000
		dc.w	$F6FF,$2980,$2480,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0209,$0209,$0084
		dc.w	$FFFF,$0080,$0080,$1000,$F3FF,$1600,$1A00,$0000
		dc.w	$FFF9,$401B,$4015,$0000,$D3FF,$6E00,$4600,$0000
		dc.w	$FFBF,$4070,$4030,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0080,$0080,$0010,$FFFF,$4000,$4000,$0000
		dc.w	$F5FF,$1B38,$1D38,$0000,$BF76,$209D,$6006,$0000
		dc.w	$B9FE,$FA01,$9C00,$0000,$7CF3,$805E,$0022,$0300
		dc.w	$E17F,$0600,$0F00,$1F80,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0801,$0801,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FEDB,$05ED,$0ED9,$0408
		dc.w	$93EC,$FB6B,$D5FA,$0000,$EB96,$7332,$4533,$0078
		dc.w	$F977,$833B,$8395,$0780,$FAF7,$0094,$0294,$0708
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0020,$0020,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$F5A2,$14F3,$1F0E,$0000,$485D,$0FE9,$F2DB,$0000
		dc.w	$CFA6,$2787,$138C,$0058,$FC8E,$0031,$0442,$0740
		dc.w	$F5FB,$850A,$850A,$1E04,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FB3E,$1D4B,$10A6,$0000
		dc.w	$9CDB,$F550,$B3BC,$0010,$F101,$2B81,$3C37,$0078
		dc.w	$CB74,$187B,$2CE1,$04C0,$C451,$C810,$4E14,$3FEE
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$EB43,$38E5,$2759,$0000,$FF7E,$4B7A,$6FEB,$0000
		dc.w	$EFF4,$29FF,$3872,$0000,$E8B7,$A99D,$B393,$07C1
		dc.w	$FA33,$6022,$807A,$07FC,$7FFF,$C000,$4000,$8000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$EBFF,$3F38,$0B38,$0000
		dc.w	$F3B1,$24DB,$0815,$0000,$CEFC,$7A9E,$4B95,$0000
		dc.w	$87FF,$AA08,$7208,$0180,$AFCF,$50C8,$20C8,$0030
		dc.w	$AFFF,$5000,$8000,$D000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$7FFF,$E000,$6000,$0000,$FFFF,$280E,$280E,$0000
		dc.w	$FEFF,$7709,$7609,$0200,$5FFF,$F000,$1000,$0000
		dc.w	$E7FF,$3800,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$F9FF,$0A00,$0C00,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$3000,$3000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0002,$0002,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$F3FF,$0C00,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
