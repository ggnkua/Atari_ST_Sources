*
*  NEOchrome V2.24 cut buffer contents (left justified):
*  by Chaos, Inc. of the Delta Force (member of The Union)
*
*    pixels/scanline    = $0140 (bytes/scanline: $00A0)
*  # scanlines (height) = $0041
*
*  Hardware color pallet  (color 0 to 15):
*
*      $0000,$0777,$0070,$0770,$0470,$0070,$0073,$0077
*      $0047,$0007,$0307,$0607,$0706,$0704,$0700,$0730
*
*
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0FFF
		dc.w	$FFE0,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$01FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0FFF
		dc.w	$FFE0,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$01FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0FFF
		dc.w	$FFE0,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$01FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0FFF
		dc.w	$FFE0,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$01FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0FFF
		dc.w	$FFE0,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$01FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0FFF
		dc.w	$FFE0,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$01FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0FFF
		dc.w	$FFE0,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$01FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0FFF
		dc.w	$FFE0,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$01FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0FFF
		dc.w	$FFE0,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$01FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$3FE0
		dc.w	$0000,$0000
		dc.w	$0000,$07FF
		dc.w	$8000,$0FFF
		dc.w	$FFE0,$0000
		dc.w	$0007,$FF80
		dc.w	$0000,$0000
		dc.w	$0FF8,$01FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0001,$FFFC
		dc.w	$0FFF,$FFE0
		dc.w	$0000,$7FFF
		dc.w	$FC03,$FFFF
		dc.w	$FFFF,$E000
		dc.w	$00FF,$FFFC
		dc.w	$0000,$0000
		dc.w	$7FFF,$01FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0007,$FFFF
		dc.w	$0FFF,$FFE0
		dc.w	$0001,$FFFF
		dc.w	$FF03,$FFFF
		dc.w	$FFFF,$E000
		dc.w	$07FF,$FFFF
		dc.w	$8000,$0001
		dc.w	$FFFF,$81FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$000F,$FFFF
		dc.w	$8FFF,$FFE0
		dc.w	$0007,$FFFF
		dc.w	$FF83,$FFFF
		dc.w	$FFFF,$E000
		dc.w	$1FFF,$FFFF
		dc.w	$E000,$0003
		dc.w	$FFFF,$E1FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$003F,$FFFF
		dc.w	$CFFF,$FFE0
		dc.w	$001F,$FFFF
		dc.w	$FF83,$FFFF
		dc.w	$FFFF,$E000
		dc.w	$7FFF,$FFFF
		dc.w	$F800,$0007
		dc.w	$FFFF,$F1FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$007F,$FFFF
		dc.w	$EFFF,$FFE0
		dc.w	$003F,$FFFF
		dc.w	$FF83,$FFFF
		dc.w	$FFFF,$E001
		dc.w	$FFFF,$FFFF
		dc.w	$FE00,$000F
		dc.w	$FFFF,$F9FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$00FF,$FFFF
		dc.w	$F7FF,$FFE0
		dc.w	$007F,$FFFF
		dc.w	$FF83,$FFFF
		dc.w	$FFFF,$E003
		dc.w	$FFFF,$FFFF
		dc.w	$FF00,$001F
		dc.w	$FFFF,$FDFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$01FF,$FFFF
		dc.w	$FFFF,$FFE0
		dc.w	$00FF,$FFFF
		dc.w	$FF83,$FFFF
		dc.w	$FFFF,$E007
		dc.w	$FFFF,$FFFF
		dc.w	$FF80,$003F
		dc.w	$FFFF,$FEFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$01FF,$FFFF
		dc.w	$FFFF,$FFE0
		dc.w	$01FF,$FFFF
		dc.w	$FF83,$FFFF
		dc.w	$FFFF,$E00F
		dc.w	$FFFF,$FFFF
		dc.w	$FFC0,$007F
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$03FF,$FFFF
		dc.w	$FFFF,$FFE0
		dc.w	$03FF,$FFFF
		dc.w	$FF83,$FFFF
		dc.w	$FFFF,$E01F
		dc.w	$FFFF,$FFFF
		dc.w	$FFE0,$007F
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$03FF,$FFFF
		dc.w	$FFFF,$FFE0
		dc.w	$03FF,$FFFF
		dc.w	$FF83,$FFFF
		dc.w	$FFFF,$E03F
		dc.w	$FFFF,$FFFF
		dc.w	$FFE0,$00FF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$07FF,$FFFF
		dc.w	$FFFF,$FFE0
		dc.w	$07FF,$FFFF
		dc.w	$FF83,$FFFF
		dc.w	$FFFF,$E03F
		dc.w	$FFFF,$FFFF
		dc.w	$FFF0,$00FF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$07FF,$FFFF
		dc.w	$FFFF,$FFE0
		dc.w	$07FF,$FFFF
		dc.w	$FF83,$FFFF
		dc.w	$FFFF,$E07F
		dc.w	$FFFF,$FFFF
		dc.w	$FFF8,$01FF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0FFF,$FFFF
		dc.w	$FFFF,$FFE0
		dc.w	$0FFF,$FFFF
		dc.w	$FF83,$FFFF
		dc.w	$FFFF,$E07F
		dc.w	$FFFF,$FFFF
		dc.w	$FFF8,$01FF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0FFF,$FFFF
		dc.w	$FFFF,$FFE0
		dc.w	$0FFF,$FFFF
		dc.w	$FF83,$FFFF
		dc.w	$FFFF,$E0FF
		dc.w	$FFFF,$FFFF
		dc.w	$FFFC,$01FF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1FFF,$FFFF
		dc.w	$FFFF,$FFE0
		dc.w	$0FFF,$FFFF
		dc.w	$FF83,$FFFF
		dc.w	$FFFF,$E0FF
		dc.w	$FFFF,$FFFF
		dc.w	$FFFC,$03FF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1FFF,$FFFF
		dc.w	$FFFF,$FFE0
		dc.w	$1FFF,$FFFF
		dc.w	$FF83,$FFFF
		dc.w	$FFFF,$E1FF
		dc.w	$FFFF,$FFFF
		dc.w	$FFFE,$03FF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1FFF,$FFFF
		dc.w	$FFFF,$FFE0
		dc.w	$1FFF,$FFFF
		dc.w	$FF83,$FFFF
		dc.w	$FFFF,$E1FF
		dc.w	$FFFF,$FFFF
		dc.w	$FFFE,$03FF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1FFF,$FFF8
		dc.w	$7FFF,$FFE0
		dc.w	$1FFF,$FFF8
		dc.w	$0F83,$FFFF
		dc.w	$FFFF,$E1FF
		dc.w	$FFFF,$87FF
		dc.w	$FFFE,$03FF
		dc.w	$FFFF,$0FFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3FFF,$FFE0
		dc.w	$1FFF,$FFE0
		dc.w	$1FFF,$FFE0
		dc.w	$0380,$0FFF
		dc.w	$FFE0,$01FF
		dc.w	$FFFE,$01FF
		dc.w	$FFFE,$07FF
		dc.w	$FFFC,$03FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3FFF,$FFC0
		dc.w	$0FFF,$FFE0
		dc.w	$3FFF,$FFC0
		dc.w	$0080,$0FFF
		dc.w	$FFE0,$03FF
		dc.w	$FFFC,$00FF
		dc.w	$FFFF,$07FF
		dc.w	$FFF8,$01FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3FFF,$FFC0
		dc.w	$0FFF,$FFE0
		dc.w	$3FFF,$FFC0
		dc.w	$0000,$0FFF
		dc.w	$FFE0,$03FF
		dc.w	$FFFC,$00FF
		dc.w	$FFFF,$07FF
		dc.w	$FFF8,$01FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3FFF,$FF80
		dc.w	$07FF,$FFE0
		dc.w	$3FFF,$FF80
		dc.w	$0000,$0FFF
		dc.w	$FFE0,$03FF
		dc.w	$FFF8,$007F
		dc.w	$FFFF,$07FF
		dc.w	$FFF0,$00FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3FFF,$FF80
		dc.w	$07FF,$FFE0
		dc.w	$3FFF,$FF80
		dc.w	$0000,$0FFF
		dc.w	$FFE0,$03FF
		dc.w	$FFF8,$007F
		dc.w	$FFFF,$07FF
		dc.w	$FFF0,$00FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3FFF,$FF80
		dc.w	$07FF,$FFE0
		dc.w	$3FFF,$FF80
		dc.w	$0000,$0FFF
		dc.w	$FFE0,$03FF
		dc.w	$FFF8,$007F
		dc.w	$FFFF,$07FF
		dc.w	$FFF0,$00FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3FFF,$FF80
		dc.w	$07FF,$FFE0
		dc.w	$3FFF,$FF80
		dc.w	$0000,$0FFF
		dc.w	$FFE0,$03FF
		dc.w	$FFF8,$007F
		dc.w	$FFFF,$07FF
		dc.w	$FFF0,$00FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3FFF,$FF80
		dc.w	$07FF,$FFE0
		dc.w	$3FFF,$FF80
		dc.w	$0000,$0FFF
		dc.w	$FFE0,$03FF
		dc.w	$FFF8,$007F
		dc.w	$FFFF,$07FF
		dc.w	$FFF0,$00FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3FFF,$FFC0
		dc.w	$0FFF,$FFE0
		dc.w	$3FFF,$FFC0
		dc.w	$0080,$0FFF
		dc.w	$FFE0,$03FF
		dc.w	$FFFC,$00FF
		dc.w	$FFFF,$07FF
		dc.w	$FFF8,$01FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3FFF,$FFC0
		dc.w	$0FFF,$FFE0
		dc.w	$3FFF,$FFC0
		dc.w	$0180,$0FFF
		dc.w	$FFE0,$03FF
		dc.w	$FFFC,$00FF
		dc.w	$FFFF,$07FF
		dc.w	$FFF8,$01FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3FFF,$FFE0
		dc.w	$1FFF,$FFE0
		dc.w	$3FFF,$FFE0
		dc.w	$0780,$0FFF
		dc.w	$FFE0,$03FF
		dc.w	$FFFE,$01FF
		dc.w	$FFFF,$07FF
		dc.w	$FFFC,$03FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1FFF,$FFF8
		dc.w	$7FFF,$FFE0
		dc.w	$1FFF,$FFF8
		dc.w	$1F80,$0FFF
		dc.w	$FFE0,$01FF
		dc.w	$FFFF,$87FF
		dc.w	$FFFE,$03FF
		dc.w	$FFFF,$0FFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1FFF,$FFFF
		dc.w	$FFFF,$FFE0
		dc.w	$1FFF,$FFFF
		dc.w	$FF80,$0FFF
		dc.w	$FFE0,$01FF
		dc.w	$FFFF,$FFFF
		dc.w	$FFFE,$03FF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1FFF,$FFFF
		dc.w	$FFFF,$FFE0
		dc.w	$1FFF,$FFFF
		dc.w	$FF80,$0FFF
		dc.w	$FFE0,$01FF
		dc.w	$FFFF,$FFFF
		dc.w	$FFFE,$03FF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1FFF,$FFFF
		dc.w	$FFFF,$FFE0
		dc.w	$0FFF,$FFFF
		dc.w	$FF80,$0FFF
		dc.w	$FFE0,$00FF
		dc.w	$FFFF,$FFFF
		dc.w	$FFFC,$03FF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0FFF,$FFFF
		dc.w	$FFFF,$FFE0
		dc.w	$0FFF,$FFFF
		dc.w	$FF80,$0FFF
		dc.w	$FFE0,$00FF
		dc.w	$FFFF,$FFFF
		dc.w	$FFFC,$01FF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0FFF,$FFFF
		dc.w	$FFFF,$FFE0
		dc.w	$0FFF,$FFFF
		dc.w	$FF80,$0FFF
		dc.w	$FFE0,$007F
		dc.w	$FFFF,$FFFF
		dc.w	$FFFC,$01FF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0FFF,$FFFF
		dc.w	$FFFF,$FFE0
		dc.w	$07FF,$FFFF
		dc.w	$FF80,$0FFF
		dc.w	$FFE0,$007F
		dc.w	$FFFF,$FFFF
		dc.w	$FFF8,$01FF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$07FF,$FFFF
		dc.w	$FFFF,$FFE0
		dc.w	$07FF,$FFFF
		dc.w	$FF80,$0FFF
		dc.w	$FFE0,$003F
		dc.w	$FFFF,$FFFF
		dc.w	$FFF8,$00FF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$07FF,$FFFF
		dc.w	$FFFF,$FFE0
		dc.w	$03FF,$FFFF
		dc.w	$FF80,$0FFF
		dc.w	$FFE0,$003F
		dc.w	$FFFF,$FFFF
		dc.w	$FFF0,$00FF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$03FF,$FFFF
		dc.w	$FFFF,$FFE0
		dc.w	$03FF,$FFFF
		dc.w	$FF80,$0FFF
		dc.w	$FFE0,$001F
		dc.w	$FFFF,$FFFF
		dc.w	$FFE0,$007F
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$03FF,$FFFF
		dc.w	$FFFF,$FFE0
		dc.w	$01FF,$FFFF
		dc.w	$FF80,$0FFF
		dc.w	$FFE0,$000F
		dc.w	$FFFF,$FFFF
		dc.w	$FFC0,$007F
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$01FF,$FFFF
		dc.w	$FFFF,$FFE0
		dc.w	$00FF,$FFFF
		dc.w	$FF80,$0FFF
		dc.w	$FFE0,$0007
		dc.w	$FFFF,$FFFF
		dc.w	$FF80,$003F
		dc.w	$FFFF,$FF7F
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$00FF,$FFFF
		dc.w	$F7FF,$FFE0
		dc.w	$007F,$FFFF
		dc.w	$FF80,$0FFF
		dc.w	$FFE0,$0003
		dc.w	$FFFF,$FFFF
		dc.w	$FF00,$001F
		dc.w	$FFFF,$FE7F
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$007F,$FFFF
		dc.w	$E7FF,$FFE0
		dc.w	$003F,$FFFF
		dc.w	$FF80,$0FFF
		dc.w	$FFE0,$0001
		dc.w	$FFFF,$FFFF
		dc.w	$FC00,$000F
		dc.w	$FFFF,$FC7F
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$003F,$FFFF
		dc.w	$C7FF,$FFE0
		dc.w	$000F,$FFFF
		dc.w	$FF80,$0FFF
		dc.w	$FFE0,$0000
		dc.w	$7FFF,$FFFF
		dc.w	$F800,$0007
		dc.w	$FFFF,$F87F
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$001F,$FFFF
		dc.w	$87FF,$FFE0
		dc.w	$0007,$FFFF
		dc.w	$FF80,$0FFF
		dc.w	$FFE0,$0000
		dc.w	$1FFF,$FFFF
		dc.w	$E000,$0003
		dc.w	$FFFF,$F07F
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0007,$FFFE
		dc.w	$07FF,$FFE0
		dc.w	$0001,$FFFF
		dc.w	$FF00,$0FFF
		dc.w	$FFE0,$0000
		dc.w	$07FF,$FFFF
		dc.w	$8000,$0000
		dc.w	$FFFF,$C07F
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0001,$FFF8
		dc.w	$07FF,$FFE0
		dc.w	$0000,$3FFF
		dc.w	$F800,$0FFF
		dc.w	$FFE0,$0000
		dc.w	$00FF,$FFFC
		dc.w	$0000,$0000
		dc.w	$3FFF,$007F
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$3FC0
		dc.w	$0000,$0000
		dc.w	$0000,$03FF
		dc.w	$8000,$0000
		dc.w	$0000,$0000
		dc.w	$0007,$FF80
		dc.w	$0000,$0000
		dc.w	$0FF8,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000