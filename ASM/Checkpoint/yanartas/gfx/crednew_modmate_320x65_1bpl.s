*
*  NEOchrome V2.24 cut buffer contents (left justified):
*  by Chaos, Inc. of the Delta Force (member of The Union)
*
*    pixels/scanline    = $0140 (bytes/scanline: $00A0)
*  # scanlines (height) = $0041
*
*  Hardware color pallet  (color 0 to 15):
*
*      $0000,$0777,$0070,$0770,$0470,$0070,$0073,$0077
*      $0047,$0007,$0307,$0607,$0706,$0704,$0700,$0730
*
*
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$3FFF
		dc.w	$FFFF,$FFFF
		dc.w	$E000,$0000
		dc.w	$0003,$FFFF
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$7FFF
		dc.w	$FFFF,$FFFF
		dc.w	$F000,$0000
		dc.w	$0003,$FFFF
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$7FFF
		dc.w	$FFFF,$FFFF
		dc.w	$F000,$0000
		dc.w	$0003,$FFFF
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$F800,$0000
		dc.w	$0003,$FFFF
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0001,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$FC00,$0000
		dc.w	$0003,$FFFF
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0003,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$FE00,$0000
		dc.w	$0003,$FFFF
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0003,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$FE00,$0000
		dc.w	$0003,$FFFF
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0007,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$FF00,$0000
		dc.w	$0003,$FFFF
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0007,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$FF00,$0000
		dc.w	$0003,$FFFF
		dc.w	$C000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$003F
		dc.w	$8000,$3FE0
		dc.w	$000F,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$FF80,$0003
		dc.w	$F803,$FFFF
		dc.w	$C000,$0000
		dc.w	$01FC,$0001
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$81FF
		dc.w	$E001,$FFF8
		dc.w	$000F,$FFFF
		dc.w	$FE03,$FFFF
		dc.w	$FF80,$001F
		dc.w	$FF03,$FFFF
		dc.w	$C03F,$FFFC
		dc.w	$0FFF,$0007
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$87FF
		dc.w	$F803,$FFFE
		dc.w	$000F,$FFFF
		dc.w	$F800,$FFFF
		dc.w	$FF80,$007F
		dc.w	$FFC3,$FFFF
		dc.w	$C03F,$FFFC
		dc.w	$3FFF,$C01F
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$8FFF
		dc.w	$FC07,$FFFF
		dc.w	$001F,$FFFF
		dc.w	$F000,$7FFF
		dc.w	$FFC0,$00FF
		dc.w	$FFE3,$FFFF
		dc.w	$C03F,$FFFC
		dc.w	$7FFF,$E03F
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$9FFF
		dc.w	$FE0F,$FFFF
		dc.w	$801F,$FFFF
		dc.w	$E000,$3FFF
		dc.w	$FFC0,$01FF
		dc.w	$FFF3,$FFFF
		dc.w	$C03F,$FFFC
		dc.w	$FFFF,$F07F
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$BFFF
		dc.w	$FF1F,$FFFF
		dc.w	$C01F,$FFFF
		dc.w	$C000,$1FFF
		dc.w	$FFC0,$03FF
		dc.w	$FFFB,$FFFF
		dc.w	$C03F,$FFFD
		dc.w	$FFFF,$F8FF
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$BFFF
		dc.w	$FF1F,$FFFF
		dc.w	$E01F,$FFFF
		dc.w	$8000,$0FFF
		dc.w	$FFC0,$07FF
		dc.w	$FFFD,$FFFF
		dc.w	$C03F,$FFFD
		dc.w	$FFFF,$F8FF
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$FFFF
		dc.w	$FFBF,$FFFF
		dc.w	$E03F,$FFFF
		dc.w	$8000,$0FFF
		dc.w	$FFE0,$07FF
		dc.w	$FFFF,$FFFF
		dc.w	$C03F,$FFFF
		dc.w	$FFFF,$FDFF
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$FFFF
		dc.w	$FFBF,$FFFF
		dc.w	$F03F,$FFFF
		dc.w	$8000,$0FFF
		dc.w	$FFE0,$0FFF
		dc.w	$FFFF,$FFFF
		dc.w	$C03F,$FFFF
		dc.w	$FFFF,$FDFF
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$F03F,$FFFF
		dc.w	$0000,$07FF
		dc.w	$FFE0,$0FFF
		dc.w	$FFFF,$FFFF
		dc.w	$C03F,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$F03F,$FFFF
		dc.w	$0000,$07FF
		dc.w	$FFE0,$1FFF
		dc.w	$FFFF,$FFFF
		dc.w	$C03F,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$F03F,$FFFF
		dc.w	$0000,$07FF
		dc.w	$FFE0,$1FFF
		dc.w	$FFFF,$FFFF
		dc.w	$C03F,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$F83F,$FFFF
		dc.w	$0000,$07FF
		dc.w	$FFE0,$1FFF
		dc.w	$FFFF,$FFFF
		dc.w	$C03F,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$F83F,$FFFF
		dc.w	$0000,$07FF
		dc.w	$FFE0,$3FFF
		dc.w	$FFFF,$FFFF
		dc.w	$C03F,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$F83F,$FFFF
		dc.w	$0000,$07FF
		dc.w	$FFE0,$3FFF
		dc.w	$FFFF,$FFFF
		dc.w	$C03F,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$F83F,$FFFF
		dc.w	$0000,$07FF
		dc.w	$FFE0,$3FFF
		dc.w	$FFFF,$FFFF
		dc.w	$C03F,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$C3FF
		dc.w	$FFF0,$FFFF
		dc.w	$F83F,$FFFF
		dc.w	$8000,$0FFF
		dc.w	$FFE0,$3FFF
		dc.w	$FF0F,$FFFF
		dc.w	$C03F,$FFFE
		dc.w	$1FFF,$FF87
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$81FF
		dc.w	$FFE0,$7FFF
		dc.w	$F83F,$FFFF
		dc.w	$8000,$0FFF
		dc.w	$FFE0,$7FFF
		dc.w	$FC03,$FFFF
		dc.w	$C03F,$FFFC
		dc.w	$0FFF,$FF03
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$81FF
		dc.w	$FFE0,$7FFF
		dc.w	$F83F,$FFFF
		dc.w	$8000,$0FFF
		dc.w	$FFE0,$7FFF
		dc.w	$FC01,$FFFF
		dc.w	$C03F,$FFFC
		dc.w	$0FFF,$FF03
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$81FF
		dc.w	$FFE0,$7FFF
		dc.w	$F81F,$FFFF
		dc.w	$C000,$1FFF
		dc.w	$FFC0,$7FFF
		dc.w	$F801,$FFFF
		dc.w	$C03F,$FFFC
		dc.w	$0FFF,$FF03
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$81FF
		dc.w	$FFE0,$7FFF
		dc.w	$F81F,$FFFF
		dc.w	$E000,$3FFF
		dc.w	$FFC0,$7FFF
		dc.w	$F800,$FFFF
		dc.w	$C03F,$FFFC
		dc.w	$0FFF,$FF03
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$81FF
		dc.w	$FFE0,$7FFF
		dc.w	$F81F,$FFFF
		dc.w	$F000,$7FFF
		dc.w	$FFC0,$7FFF
		dc.w	$F800,$FFFF
		dc.w	$C03F,$FFFC
		dc.w	$0FFF,$FF03
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$81FF
		dc.w	$FFE0,$7FFF
		dc.w	$F81F,$FFFF
		dc.w	$F800,$FFFF
		dc.w	$FFC0,$7FFF
		dc.w	$F800,$FFFF
		dc.w	$C03F,$FFFC
		dc.w	$0FFF,$FF03
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$81FF
		dc.w	$FFE0,$7FFF
		dc.w	$F80F,$FFFF
		dc.w	$FE03,$FFFF
		dc.w	$FF80,$7FFF
		dc.w	$F801,$FFFF
		dc.w	$C03F,$FFFC
		dc.w	$0FFF,$FF03
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$81FF
		dc.w	$FFE0,$7FFF
		dc.w	$F80F,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$FF80,$7FFF
		dc.w	$FC01,$FFFF
		dc.w	$C03F,$FFFC
		dc.w	$0FFF,$FF03
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$81FF
		dc.w	$FFE0,$7FFF
		dc.w	$F807,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$FF00,$7FFF
		dc.w	$FC03,$FFFF
		dc.w	$C03F,$FFFC
		dc.w	$0FFF,$FF03
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$81FF
		dc.w	$FFE0,$7FFF
		dc.w	$F807,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$FF00,$7FFF
		dc.w	$FF0F,$FFFF
		dc.w	$C03F,$FFFC
		dc.w	$0FFF,$FF03
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$81FF
		dc.w	$FFE0,$7FFF
		dc.w	$F803,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$FE00,$3FFF
		dc.w	$FFFF,$FFFF
		dc.w	$C03F,$FFFC
		dc.w	$0FFF,$FF03
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$81FF
		dc.w	$FFE0,$7FFF
		dc.w	$F803,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$FE00,$3FFF
		dc.w	$FFFF,$FFFF
		dc.w	$C03F,$FFFC
		dc.w	$0FFF,$FF03
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$81FF
		dc.w	$FFE0,$7FFF
		dc.w	$F801,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$FC00,$3FFF
		dc.w	$FFFF,$FFFF
		dc.w	$C03F,$FFFC
		dc.w	$0FFF,$FF03
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$81FF
		dc.w	$FFE0,$7FFF
		dc.w	$F800,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$F800,$3FFF
		dc.w	$FFFF,$FFFF
		dc.w	$C03F,$FFFC
		dc.w	$0FFF,$FF03
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$81FF
		dc.w	$FFE0,$7FFF
		dc.w	$F800,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$F800,$1FFF
		dc.w	$FFFF,$FFFF
		dc.w	$C03F,$FFFC
		dc.w	$0FFF,$FF03
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$81FF
		dc.w	$FFE0,$7FFF
		dc.w	$F800,$7FFF
		dc.w	$FFFF,$FFFF
		dc.w	$F000,$1FFF
		dc.w	$FFFF,$FFFF
		dc.w	$C03F,$FFFC
		dc.w	$0FFF,$FF03
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$81FF
		dc.w	$FFE0,$7FFF
		dc.w	$F800,$3FFF
		dc.w	$FFFF,$FFFF
		dc.w	$E000,$0FFF
		dc.w	$FFFF,$FFFF
		dc.w	$C03F,$FFFC
		dc.w	$0FFF,$FF03
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$81FF
		dc.w	$FFE0,$7FFF
		dc.w	$F800,$1FFF
		dc.w	$FFFF,$FFFF
		dc.w	$C000,$0FFF
		dc.w	$FFFF,$FFFF
		dc.w	$C03F,$FFFC
		dc.w	$0FFF,$FF03
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$81FF
		dc.w	$FFE0,$7FFF
		dc.w	$F800,$0FFF
		dc.w	$FFFF,$FFFF
		dc.w	$8000,$07FF
		dc.w	$FFFF,$FFFF
		dc.w	$C03F,$FFFC
		dc.w	$0FFF,$FF03
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$81FF
		dc.w	$FFE0,$7FFF
		dc.w	$F800,$07FF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$07FF
		dc.w	$FFFF,$FFFF
		dc.w	$C03F,$FFFC
		dc.w	$0FFF,$FF03
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$81FF
		dc.w	$FFE0,$7FFF
		dc.w	$F800,$01FF
		dc.w	$FFFF,$FFFE
		dc.w	$0000,$03FF
		dc.w	$FFFD,$FFFF
		dc.w	$C03F,$FFFC
		dc.w	$0FFF,$FF03
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$81FF
		dc.w	$FFE0,$7FFF
		dc.w	$F800,$007F
		dc.w	$FFFF,$FFF8
		dc.w	$0000,$01FF
		dc.w	$FFF9,$FFFF
		dc.w	$C03F,$FFFC
		dc.w	$0FFF,$FF03
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$81FF
		dc.w	$FFE0,$7FFF
		dc.w	$F800,$003F
		dc.w	$FFFF,$FFE0
		dc.w	$0000,$00FF
		dc.w	$FFF1,$FFFF
		dc.w	$C03F,$FFFC
		dc.w	$0FFF,$FF03
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$81FF
		dc.w	$FFE0,$7FFF
		dc.w	$F800,$0007
		dc.w	$FFFF,$FF00
		dc.w	$0000,$007F
		dc.w	$FFC1,$FFFF
		dc.w	$C03F,$FFFC
		dc.w	$0FFF,$FF03
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$81FF
		dc.w	$FFE0,$7FFF
		dc.w	$F800,$0000
		dc.w	$FFFF,$F800
		dc.w	$0000,$001F
		dc.w	$FF01,$FFFF
		dc.w	$C03F,$FFFC
		dc.w	$0FFF,$FF03
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0FFF,$8000
		dc.w	$0000,$0003
		dc.w	$FC00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
