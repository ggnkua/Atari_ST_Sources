*
*  NEOchrome V2.24 cut buffer contents (left justified):
*  by Chaos, Inc. of the Delta Force (member of The Union)
*
*    pixels/scanline    = $0027 (bytes/scanline: $0018)
*  # scanlines (height) = $0038
*
*  Hardware color pallet  (color 0 to 15):
*
*      $0453,$0777,$0EEE,$0666,$0DDD,$0555,$0CCC,$0444
*      $0BBB,$0333,$0AAA,$0222,$0999,$0111,$0888,$0000
*
*
		dc.w	$0006,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$001E,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$007F,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$03FF,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0FFF,$0000,$0000,$0000,$8000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$3FFF,$0000,$0000,$0000
		dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$C000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$C000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$7FFF,$0000,$0000,$0000,$E000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$7FFF,$0000,$0000,$0000
		dc.w	$E000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$3FFF,$0000,$0000,$0000,$F000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$3FFF,$0000,$0000,$0000
		dc.w	$F000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$1FFF,$0000,$0000,$0000,$F800,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$1FFF,$0000,$0000,$0000
		dc.w	$F800,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0FFF,$0000,$0000,$0000,$FC00,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0FFF,$0000,$0000,$0000
		dc.w	$FC00,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$07FF,$0000,$0000,$0000,$FE00,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$07FF,$0000,$0000,$0000
		dc.w	$FE00,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$03FF,$0000,$0000,$0000,$FF00,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$03FF,$0000,$0000,$0000
		dc.w	$FF00,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$01FF,$0000,$0000,$0000,$FF80,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$01FF,$0000,$0000,$0000
		dc.w	$FF80,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$00FF,$0000,$0000,$0000,$FFC0,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$00FF,$0000,$0000,$0000
		dc.w	$FFC0,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$007F,$0000,$0000,$0000,$FFE0,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$007F,$0000,$0000,$0000
		dc.w	$FFE0,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$003F,$0000,$0000,$0000,$FFF0,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$003F,$0000,$0000,$0000
		dc.w	$FFF0,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$001F,$0000,$0000,$0000,$FFF8,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$001F,$0000,$0000,$0000
		dc.w	$FFF8,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$000F,$0000,$0000,$0000,$FFFC,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$000F,$0000,$0000,$0000
		dc.w	$FFFC,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0007,$0000,$0000,$0000,$FFFE,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0007,$0000,$0000,$0000
		dc.w	$FFFE,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0003,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0003,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0001,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$8000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$8000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$C000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$C000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$7FFF,$0000,$0000,$0000
		dc.w	$E000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$7FFF,$0000,$0000,$0000,$E000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$3FFF,$0000,$0000,$0000
		dc.w	$F000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$3FFF,$0000,$0000,$0000,$F000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$1FFF,$0000,$0000,$0000
		dc.w	$F800,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$1FFF,$0000,$0000,$0000,$F800,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0FFF,$0000,$0000,$0000
		dc.w	$FC00,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0FFF,$0000,$0000,$0000,$FE00,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$07FF,$0000,$0000,$0000
		dc.w	$FC00,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$07FF,$0000,$0000,$0000,$F000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$03FF,$0000,$0000,$0000
		dc.w	$C000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$03FF,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$01FE,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$01F8,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$00E0,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0080,$0000,$0000,$0000,$0000,$0000,$0000,$0000
