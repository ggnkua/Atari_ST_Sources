*
*  NEOchrome V2.24 cut buffer contents (left justified):
*  by Chaos, Inc. of the Delta Force (member of The Union)
*
*    pixels/scanline    = $000F (bytes/scanline: $0008)
*  # scanlines (height) = $002F
*
*  Hardware color pallet  (color 0 to 15):
*
*      $0453,$0777,$0000,$0000,$0000,$0000,$0000,$0000
*      $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
*
*
		dc.w	$0006,$0000,$0000,$0000,$001E,$0000,$0000,$0000
		dc.w	$007E,$0000,$0000,$0000,$03FE,$0000,$0000,$0000
		dc.w	$0FFE,$0000,$0000,$0000,$3FFE,$0000,$0000,$0000
		dc.w	$FFFE,$0000,$0000,$0000,$FFFE,$0000,$0000,$0000
		dc.w	$FFFE,$0000,$0000,$0000,$FFFE,$0000,$0000,$0000
		dc.w	$FFFE,$0000,$0000,$0000,$FFFE,$0000,$0000,$0000
		dc.w	$FFFE,$0000,$0000,$0000,$FFFE,$0000,$0000,$0000
		dc.w	$FFFE,$0000,$0000,$0000,$FFFE,$0000,$0000,$0000
		dc.w	$FFFE,$0000,$0000,$0000,$FFFE,$0000,$0000,$0000
		dc.w	$FFFE,$0000,$0000,$0000,$FFFE,$0000,$0000,$0000
		dc.w	$FFFE,$0000,$0000,$0000,$FFFE,$0000,$0000,$0000
		dc.w	$FFFE,$0000,$0000,$0000,$FFFE,$0000,$0000,$0000
		dc.w	$FFFE,$0000,$0000,$0000,$FFFE,$0000,$0000,$0000
		dc.w	$FFFE,$0000,$0000,$0000,$FFFE,$0000,$0000,$0000
		dc.w	$FFFE,$0000,$0000,$0000,$FFFE,$0000,$0000,$0000
		dc.w	$FFFE,$0000,$0000,$0000,$FFFE,$0000,$0000,$0000
		dc.w	$FFFE,$0000,$0000,$0000,$FFFE,$0000,$0000,$0000
		dc.w	$FFFE,$0000,$0000,$0000,$FFFE,$0000,$0000,$0000
		dc.w	$FFFE,$0000,$0000,$0000,$FFFE,$0000,$0000,$0000
		dc.w	$FFFE,$0000,$0000,$0000,$FFFE,$0000,$0000,$0000
		dc.w	$FFF8,$0000,$0000,$0000,$FFE0,$0000,$0000,$0000
		dc.w	$FF80,$0000,$0000,$0000,$FE00,$0000,$0000,$0000
		dc.w	$F800,$0000,$0000,$0000,$E000,$0000,$0000,$0000
		dc.w	$8000,$0000,$0000,$0000
