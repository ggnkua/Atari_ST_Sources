*
*  NEOchrome V2.24 cut buffer contents (left justified):
*  by Chaos, Inc. of the Delta Force (member of The Union)
*
*    pixels/scanline    = $0019 (bytes/scanline: $0010)
*  # scanlines (height) = $001C
*
*  Hardware color pallet  (color 0 to 15):
*
*      $0453,$0777,$0000,$0000,$0000,$0000,$0000,$0000
*      $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
*
*
		dc.w	$0006,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$001E,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$007F,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$03FF,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0FFF,$0000,$0000,$0000,$8000,$0000,$0000,$0000
		dc.w	$3FFF,$0000,$0000,$0000,$8000,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$C000,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$C000,$0000,$0000,$0000
		dc.w	$7FFF,$0000,$0000,$0000,$E000,$0000,$0000,$0000
		dc.w	$7FFF,$0000,$0000,$0000,$E000,$0000,$0000,$0000
		dc.w	$3FFF,$0000,$0000,$0000,$F000,$0000,$0000,$0000
		dc.w	$3FFF,$0000,$0000,$0000,$F000,$0000,$0000,$0000
		dc.w	$1FFF,$0000,$0000,$0000,$F800,$0000,$0000,$0000
		dc.w	$1FFF,$0000,$0000,$0000,$F800,$0000,$0000,$0000
		dc.w	$0FFF,$0000,$0000,$0000,$FC00,$0000,$0000,$0000
		dc.w	$0FFF,$0000,$0000,$0000,$FC00,$0000,$0000,$0000
		dc.w	$07FF,$0000,$0000,$0000,$FE00,$0000,$0000,$0000
		dc.w	$07FF,$0000,$0000,$0000,$FE00,$0000,$0000,$0000
		dc.w	$03FF,$0000,$0000,$0000,$FF00,$0000,$0000,$0000
		dc.w	$03FF,$0000,$0000,$0000,$FF00,$0000,$0000,$0000
		dc.w	$01FF,$0000,$0000,$0000,$FF80,$0000,$0000,$0000
		dc.w	$01FF,$0000,$0000,$0000,$FF00,$0000,$0000,$0000
		dc.w	$00FF,$0000,$0000,$0000,$FC00,$0000,$0000,$0000
		dc.w	$00FF,$0000,$0000,$0000,$F000,$0000,$0000,$0000
		dc.w	$007F,$0000,$0000,$0000,$C000,$0000,$0000,$0000
		dc.w	$007F,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$003C,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0030,$0000,$0000,$0000,$0000,$0000,$0000,$0000
