*
*  NEOchrome V2.24 cut buffer contents (left justified):
*  by Chaos, Inc. of the Delta Force (member of The Union)
*
*    pixels/scanline    = $001C (bytes/scanline: $0010)
*  # scanlines (height) = $001C
*
*  Hardware color pallet  (color 0 to 15):
*
*      $0453,$0777,$0EEE,$0666,$0DDD,$0555,$0CCC,$0444
*      $0BBB,$0333,$0AAA,$0222,$0999,$0111,$0888,$0000
*
*
		dc.w	$FFFF,$0000,$0000,$0000,$C000,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$C000,$0000,$0000,$0000
		dc.w	$7FFF,$0000,$0000,$0000,$E000,$0000,$0000,$0000
		dc.w	$7FFF,$0000,$0000,$0000,$E000,$0000,$0000,$0000
		dc.w	$3FFF,$0000,$0000,$0000,$F000,$0000,$0000,$0000
		dc.w	$3FFF,$0000,$0000,$0000,$F000,$0000,$0000,$0000
		dc.w	$1FFF,$0000,$0000,$0000,$F800,$0000,$0000,$0000
		dc.w	$1FFF,$0000,$0000,$0000,$F800,$0000,$0000,$0000
		dc.w	$0FFF,$0000,$0000,$0000,$FC00,$0000,$0000,$0000
		dc.w	$0FFF,$0000,$0000,$0000,$FC00,$0000,$0000,$0000
		dc.w	$07FF,$0000,$0000,$0000,$FE00,$0000,$0000,$0000
		dc.w	$07FF,$0000,$0000,$0000,$FE00,$0000,$0000,$0000
		dc.w	$03FF,$0000,$0000,$0000,$FF00,$0000,$0000,$0000
		dc.w	$03FF,$0000,$0000,$0000,$FF00,$0000,$0000,$0000
		dc.w	$01FF,$0000,$0000,$0000,$FF80,$0000,$0000,$0000
		dc.w	$01FF,$0000,$0000,$0000,$FF80,$0000,$0000,$0000
		dc.w	$00FF,$0000,$0000,$0000,$FFC0,$0000,$0000,$0000
		dc.w	$00FF,$0000,$0000,$0000,$FFC0,$0000,$0000,$0000
		dc.w	$007F,$0000,$0000,$0000,$FFE0,$0000,$0000,$0000
		dc.w	$007F,$0000,$0000,$0000,$FFF0,$0000,$0000,$0000
		dc.w	$003F,$0000,$0000,$0000,$FFE0,$0000,$0000,$0000
		dc.w	$003F,$0000,$0000,$0000,$FF80,$0000,$0000,$0000
		dc.w	$001F,$0000,$0000,$0000,$FE00,$0000,$0000,$0000
		dc.w	$001F,$0000,$0000,$0000,$F800,$0000,$0000,$0000
		dc.w	$000F,$0000,$0000,$0000,$F000,$0000,$0000,$0000
		dc.w	$000F,$0000,$0000,$0000,$C000,$0000,$0000,$0000
		dc.w	$0007,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0004,$0000,$0000,$0000,$0000,$0000,$0000,$0000
