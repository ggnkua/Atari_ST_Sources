*
*  NEOchrome V2.24 cut buffer contents (left justified):
*  by Chaos, Inc. of the Delta Force (member of The Union)
*
*    pixels/scanline    = $0020 (bytes/scanline: $0010)
*  # scanlines (height) = $0013
*
*  Hardware color pallet  (color 0 to 15):
*
*      $0453,$0777,$0000,$0000,$0000,$0000,$0000,$0000
*      $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
*
*
		dc.w	$0FFE,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$7FFF,$0000,$0000,$0000,$C000,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$F800,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FE00,$0000,$0000,$0000
		dc.w	$7FFF,$0000,$0000,$0000,$FF00,$0000,$0000,$0000
		dc.w	$7FFF,$0000,$0000,$0000,$FFC0,$0000,$0000,$0000
		dc.w	$7FFF,$0000,$0000,$0000,$FFE0,$0000,$0000,$0000
		dc.w	$3FFF,$0000,$0000,$0000,$FFF0,$0000,$0000,$0000
		dc.w	$3FFF,$0000,$0000,$0000,$FFF8,$0000,$0000,$0000
		dc.w	$1FFF,$0000,$0000,$0000,$FFFC,$0000,$0000,$0000
		dc.w	$1FFF,$0000,$0000,$0000,$FFFE,$0000,$0000,$0000
		dc.w	$1FFF,$0000,$0000,$0000,$FFFE,$0000,$0000,$0000
		dc.w	$0FFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$0E0F,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$0001,$0000,$0000,$0000,$FFFE,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$7FF8,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$1FE0,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0F00,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0C00,$0000,$0000,$0000
