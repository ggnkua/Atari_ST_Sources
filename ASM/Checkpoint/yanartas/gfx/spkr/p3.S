*
*  NEOchrome V2.24 cut buffer contents (left justified):
*  by Chaos, Inc. of the Delta Force (member of The Union)
*
*    pixels/scanline    = $0018 (bytes/scanline: $0010)
*  # scanlines (height) = $0023
*
*  Hardware color pallet  (color 0 to 15):
*
*      $0453,$0777,$0000,$0000,$0000,$0000,$0000,$0000
*      $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
*
*
		dc.w	$0000,$0000,$0000,$0000,$0C00,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$7E00,$0000,$0000,$0000
		dc.w	$0001,$0000,$0000,$0000,$FE00,$0000,$0000,$0000
		dc.w	$0003,$0000,$0000,$0000,$FE00,$0000,$0000,$0000
		dc.w	$000F,$0000,$0000,$0000,$FF00,$0000,$0000,$0000
		dc.w	$003F,$0000,$0000,$0000,$FF00,$0000,$0000,$0000
		dc.w	$003F,$0000,$0000,$0000,$FF00,$0000,$0000,$0000
		dc.w	$001F,$0000,$0000,$0000,$FF00,$0000,$0000,$0000
		dc.w	$001F,$0000,$0000,$0000,$FF00,$0000,$0000,$0000
		dc.w	$001F,$0000,$0000,$0000,$FF00,$0000,$0000,$0000
		dc.w	$001F,$0000,$0000,$0000,$FF00,$0000,$0000,$0000
		dc.w	$001F,$0000,$0000,$0000,$FF00,$0000,$0000,$0000
		dc.w	$003F,$0000,$0000,$0000,$FF00,$0000,$0000,$0000
		dc.w	$003F,$0000,$0000,$0000,$FF00,$0000,$0000,$0000
		dc.w	$003F,$0000,$0000,$0000,$FF00,$0000,$0000,$0000
		dc.w	$007F,$0000,$0000,$0000,$FE00,$0000,$0000,$0000
		dc.w	$007F,$0000,$0000,$0000,$FE00,$0000,$0000,$0000
		dc.w	$00FF,$0000,$0000,$0000,$FE00,$0000,$0000,$0000
		dc.w	$00FF,$0000,$0000,$0000,$FC00,$0000,$0000,$0000
		dc.w	$01FF,$0000,$0000,$0000,$FC00,$0000,$0000,$0000
		dc.w	$07FF,$0000,$0000,$0000,$FC00,$0000,$0000,$0000
		dc.w	$1FFF,$0000,$0000,$0000,$F800,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$F800,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$F000,$0000,$0000,$0000
		dc.w	$7FFF,$0000,$0000,$0000,$E000,$0000,$0000,$0000
		dc.w	$7FFF,$0000,$0000,$0000,$E000,$0000,$0000,$0000
		dc.w	$3FFF,$0000,$0000,$0000,$C000,$0000,$0000,$0000
		dc.w	$3FFF,$0000,$0000,$0000,$8000,$0000,$0000,$0000
		dc.w	$1FFF,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$1FFE,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0FFC,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0FF8,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$07E0,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$07C0,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0300,$0000,$0000,$0000,$0000,$0000,$0000,$0000
