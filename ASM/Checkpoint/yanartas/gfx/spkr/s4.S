*
*  NEOchrome V2.24 cut buffer contents (left justified):
*  by Chaos, Inc. of the Delta Force (member of The Union)
*
*    pixels/scanline    = $0020 (bytes/scanline: $0010)
*  # scanlines (height) = $0013
*
*  Hardware color pallet  (color 0 to 15):
*
*      $0453,$0777,$0710,$0000,$0000,$0000,$0000,$0000
*      $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
*
*
		dc.w	$0030,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$00F0,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$07F8,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$1FFE,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$7FFF,$0000,$0000,$0000,$8000,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$F070,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFF0,$0000,$0000,$0000
		dc.w	$7FFF,$0000,$0000,$0000,$FFF8,$0000,$0000,$0000
		dc.w	$7FFF,$0000,$0000,$0000,$FFF8,$0000,$0000,$0000
		dc.w	$3FFF,$0000,$0000,$0000,$FFF8,$0000,$0000,$0000
		dc.w	$1FFF,$0000,$0000,$0000,$FFFC,$0000,$0000,$0000
		dc.w	$0FFF,$0000,$0000,$0000,$FFFC,$0000,$0000,$0000
		dc.w	$07FF,$0000,$0000,$0000,$FFFE,$0000,$0000,$0000
		dc.w	$03FF,$0000,$0000,$0000,$FFFE,$0000,$0000,$0000
		dc.w	$00FF,$0000,$0000,$0000,$FFFE,$0000,$0000,$0000
		dc.w	$007F,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$001F,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$0003,$0000,$0000,$0000,$FFFE,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$7FF0,$0000,$0000,$0000
