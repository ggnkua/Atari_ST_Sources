*
*  NEOchrome V2.24 cut buffer contents (left justified):
*  by Chaos, Inc. of the Delta Force (member of The Union)
*
*    pixels/scanline    = $0023 (bytes/scanline: $0018)
*  # scanlines (height) = $002E
*
*  Hardware color pallet  (color 0 to 15):
*
*      $0453,$0777,$0000,$0000,$0000,$0000,$0000,$0000
*      $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
*
*
		dc.w	$1FFC,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$7FFF,$0000,$0000,$0000,$F000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$7FFF,$0000,$0000,$0000
		dc.w	$FC00,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$3FFF,$0000,$0000,$0000,$FE00,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$3FFF,$0000,$0000,$0000
		dc.w	$FF80,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$1FFF,$0000,$0000,$0000,$FFC0,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$1FFF,$0000,$0000,$0000
		dc.w	$FFE0,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0FFF,$0000,$0000,$0000,$FFF0,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0FFF,$0000,$0000,$0000
		dc.w	$FFF8,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$07FF,$0000,$0000,$0000,$FFFC,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$07FF,$0000,$0000,$0000
		dc.w	$FFFC,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$03FF,$0000,$0000,$0000,$FFFE,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$001F,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0003,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$8000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$3FFF,$0000,$0000,$0000
		dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$1FFF,$0000,$0000,$0000,$C000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0FFF,$0000,$0000,$0000
		dc.w	$C000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0FFF,$0000,$0000,$0000,$C000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$07FF,$0000,$0000,$0000
		dc.w	$C000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$07FF,$0000,$0000,$0000,$C000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$07FF,$0000,$0000,$0000
		dc.w	$C000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$07FF,$0000,$0000,$0000,$C000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$07FF,$0000,$0000,$0000
		dc.w	$C000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0FFF,$0000,$0000,$0000,$C000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0FFF,$0000,$0000,$0000
		dc.w	$C000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0FFF,$0000,$0000,$0000,$C000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$1FFF,$0000,$0000,$0000
		dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$1FFF,$0000,$0000,$0000,$8000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$3FFF,$0000,$0000,$0000
		dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$3FFF,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$7FFF,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0003,$0000,$0000,$0000,$FFFE,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0001,$0000,$0000,$0000
		dc.w	$FFFE,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0001,$0000,$0000,$0000,$FFFC,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$FFF8,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$FFF8,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$7FF0,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$7FE0,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$3FC0,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$3F80,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$1F00,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$1C00,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0800,$0000,$0000,$0000,$0000,$0000,$0000,$0000
