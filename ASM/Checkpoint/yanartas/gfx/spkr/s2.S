*
*  NEOchrome V2.24 cut buffer contents (left justified):
*  by Chaos, Inc. of the Delta Force (member of The Union)
*
*    pixels/scanline    = $0023 (bytes/scanline: $0018)
*  # scanlines (height) = $002E
*
*  Hardware color pallet  (color 0 to 15):
*
*      $0453,$0777,$0710,$0000,$0000,$0000,$0000,$0000
*      $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
*
*
		dc.w	$0006,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$000F,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$003F,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$007F,$0000,$0000,$0000
		dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$00FF,$0000,$0000,$0000,$8000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$01FF,$0000,$0000,$0000
		dc.w	$C000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$03FF,$0000,$0000,$0000,$C000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$07FF,$0000,$0000,$0000
		dc.w	$E000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$07FF,$0000,$0000,$0000,$E000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0FFF,$0000,$0000,$0000
		dc.w	$E000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$1FFF,$0000,$0000,$0000,$F000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$1FFF,$0000,$0000,$0000
		dc.w	$F000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$3FFF,$0000,$0000,$0000,$E000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$3FFF,$0000,$0000,$0000
		dc.w	$8000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$3FFF,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$7FFF,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$7FFE,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$7FFE,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$FFFC,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$FFFC,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$FFFC,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$FFF8,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$FFF8,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$FFF8,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$FFF8,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$FFF8,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$FFFC,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$FFFC,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$FFFC,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$7FFE,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$7FFF,$0000,$0000,$0000,$000C,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$7FFF,$0000,$0000,$0000
		dc.w	$C03C,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$7FFF,$0000,$0000,$0000,$F8FE,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$7FFF,$0000,$0000,$0000
		dc.w	$FFFE,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$3FFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$3FFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$1FFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$8000,$0000,$0000,$0000,$0FFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$8000,$0000,$0000,$0000
		dc.w	$07FF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$C000,$0000,$0000,$0000,$03FF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$C000,$0000,$0000,$0000
		dc.w	$01FF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$E000,$0000,$0000,$0000,$007F,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$E000,$0000,$0000,$0000
		dc.w	$003F,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$C000,$0000,$0000,$0000,$000F,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0001,$0000,$0000,$0000,$FFFC,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$1FE0,$0000,$0000,$0000,$0000,$0000,$0000,$0000
