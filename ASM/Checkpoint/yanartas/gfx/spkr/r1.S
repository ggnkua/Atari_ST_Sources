*
*  NEOchrome V2.24 cut buffer contents (left justified):
*  by Chaos, Inc. of the Delta Force (member of The Union)
*
*    pixels/scanline    = $0027 (bytes/scanline: $0018)
*  # scanlines (height) = $0014
*
*  Hardware color pallet  (color 0 to 15):
*
*      $0453,$0777,$0000,$0000,$0000,$0000,$0000,$0000
*      $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
*
*
		dc.w	$003F,$0000,$0000,$0000,$F800,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$01FF,$0000,$0000,$0000
		dc.w	$FF00,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$0FFF,$0000,$0000,$0000,$FFE0,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$3FFF,$0000,$0000,$0000
		dc.w	$FFF8,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFC,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$7FFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$7FFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$8000,$0000,$0000,$0000,$3FFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$C000,$0000,$0000,$0000
		dc.w	$3FFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$E000,$0000,$0000,$0000,$1FFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$F000,$0000,$0000,$0000
		dc.w	$1FFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$F800,$0000,$0000,$0000,$0FFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$F800,$0000,$0000,$0000
		dc.w	$0FFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FC00,$0000,$0000,$0000,$07F8,$0000,$0000,$0000
		dc.w	$3FFF,$0000,$0000,$0000,$FE00,$0000,$0000,$0000
		dc.w	$07C0,$0000,$0000,$0000,$07FF,$0000,$0000,$0000
		dc.w	$FE00,$0000,$0000,$0000,$0300,$0000,$0000,$0000
		dc.w	$01FF,$0000,$0000,$0000,$FC00,$0000,$0000,$0000
		dc.w	$0200,$0000,$0000,$0000,$007F,$0000,$0000,$0000
		dc.w	$F000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$003F,$0000,$0000,$0000,$C000,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$003F,$0000,$0000,$0000
		dc.w	$0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
		dc.w	$001C,$0000,$0000,$0000,$0000,$0000,$0000,$0000
