*
*  NEOchrome V2.24 cut buffer contents (left justified):
*  by Chaos, Inc. of the Delta Force (member of The Union)
*
*    pixels/scanline    = $0090 (bytes/scanline: $0048)
*  # scanlines (height) = $0027
*
*  Hardware color pallet  (color 0 to 15):
*
*      $0000,$0700,$0232,$0232,$0333,$0343,$0454,$0112
*      $0332,$0300,$0300,$0540,$0531,$0540,$0553,$0555
*
*
		dc.w	$0000,$0000,$0000,$0000,$000F,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FF80,$0000,$0000,$0000
		dc.w	$0003,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$8000,$0000,$0000,$0000,$0FFF,$0000,$0000,$0000
		dc.w	$C000,$0000,$0000,$0000,$07FC,$0000,$0000,$0000
		dc.w	$000F,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFBF,$0000,$0000,$0000,$E00F,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$E000,$0000,$0000,$0000
		dc.w	$1FFF,$0000,$0000,$0000,$E000,$0000,$0000,$0000
		dc.w	$3FFF,$0000,$0000,$0000,$801F,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$F81F,$4000,$4000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$F000,$0000,$0000,$0000,$1FFF,$0000,$0000,$0000
		dc.w	$E000,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$E03F,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0008,$0008,$0000,$FE3F,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$F800,$0000,$0000,$0000
		dc.w	$3FFF,$0000,$0000,$0000,$F000,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$F1FF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$9000,$9000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FC3F,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$F000,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0024,$0024,$0001,$FFFF,$4000,$4000,$0400
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$F800,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0115,$0115,$000A
		dc.w	$FFFF,$4820,$4820,$A000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$F800,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFC,$002B,$0028,$0057,$7FFF,$B500,$3500,$C000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$F800,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFC,$0014,$0013,$002F
		dc.w	$7FFF,$5000,$9000,$E800,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$F800,$0000,$0000,$0000,$FFFF,$00F0,$00F0,$0000
		dc.w	$FAFF,$1F80,$0080,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFF4,$0063,$006F,$011F,$5FC1,$88BF,$E881,$F200
		dc.w	$7FFF,$E000,$6000,$0000,$FFFF,$03F0,$03F0,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFF8,$0000,$0000,$0000
		dc.w	$FE6F,$02F6,$03FA,$0060,$EE7F,$1F80,$1F00,$0E00
		dc.w	$FFFF,$0000,$0000,$0000,$FFEF,$0017,$000F,$003F
		dc.w	$EFDA,$D400,$E43F,$F800,$9FFF,$1800,$E800,$0000
		dc.w	$FC0F,$0010,$03E0,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$F9FC,$07FF,$03FE,$01FC
		dc.w	$EFFF,$1F80,$1F00,$0F00,$FFFF,$0000,$0000,$0000
		dc.w	$FFE8,$0237,$022F,$005F,$0FDF,$D900,$E93F,$F400
		dc.w	$57FF,$0400,$FC00,$0000,$FD6F,$0010,$03E0,$0000
		dc.w	$FFFF,$000F,$000F,$0000,$FFFF,$C000,$C000,$0000
		dc.w	$FBFE,$0FFF,$0FFF,$03FE,$EF7F,$9F80,$9F00,$0F00
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$00C8,$00C7,$003F
		dc.w	$BFCB,$2414,$C43F,$FA00,$DBFF,$2200,$FE00,$0000
		dc.w	$FFCF,$0030,$03E0,$0000,$FFFB,$0004,$000F,$0000
		dc.w	$BFFF,$4000,$8000,$0000,$F7FF,$07AF,$0FFF,$078F
		dc.w	$6FE7,$1FBC,$9F24,$0F00,$FCFF,$0780,$0480,$0000
		dc.w	$F3F4,$1E6C,$1263,$001F,$5FF5,$6B8B,$8BBE,$F400
		dc.w	$29F0,$561F,$FC10,$0000,$FEAF,$8157,$83E7,$0000
		dc.w	$F1F5,$9F0A,$910F,$0000,$3FFF,$C000,$8000,$0000
		dc.w	$F7FF,$1FDF,$1F8F,$078F,$7F91,$8FBA,$9F7C,$0F10
		dc.w	$E35F,$17A0,$0FC0,$0300,$CCFB,$5E97,$7F90,$0C2F
		dc.w	$BC4A,$DB15,$17BE,$E000,$D7CA,$AA25,$FC1F,$0000
		dc.w	$BC1E,$43F1,$8017,$0000,$EAF2,$248D,$DF9F,$0000
		dc.w	$9FFF,$6000,$E000,$0000,$EFAF,$1FDF,$0F8F,$0F8F
		dc.w	$6F7F,$9FFC,$9FFE,$0F7C,$EFCF,$3FE0,$1FF0,$0FC0
		dc.w	$BF7E,$FFE9,$7FA8,$3F17,$5AF0,$B78F,$0F3E,$C200
		dc.w	$C9B5,$344A,$7E3F,$0000,$7EAD,$A152,$C3E7,$0000
		dc.w	$5474,$AB4B,$FFDF,$0000,$1FFF,$E000,$E000,$0000
		dc.w	$FFAF,$1FDF,$0F8F,$0F8F,$E7FD,$9FFF,$9FFF,$87FC
		dc.w	$9FEE,$7FF9,$3FF0,$1FE0,$7FBB,$FFE0,$FFE0,$7F8F
		dc.w	$9760,$2E9F,$1F3E,$C600,$C1C0,$3CBF,$7EFF,$0000
		dc.w	$AE5E,$51B1,$E3F7,$0000,$8070,$7FCF,$FFDF,$0000
		dc.w	$1FFF,$E000,$E000,$0000,$EFAF,$0FDF,$1F8F,$0F8F
		dc.w	$FF3E,$8F7F,$9FFE,$8F3E,$BCFE,$3DF0,$7EF9,$3CF0
		dc.w	$F3DC,$F3D0,$FFF6,$F3C1,$6FC0,$3F3F,$5E3E,$8E00
		dc.w	$D105,$3C78,$7EFF,$1000,$0E0C,$E1F3,$F3E7,$0000
		dc.w	$3038,$EFD7,$DF9F,$0000,$7FFF,$E000,$A000,$0000
		dc.w	$FFAF,$0FDF,$1F8F,$0F8F,$E71E,$9FBF,$9F7E,$871E
		dc.w	$FDF7,$3EFC,$7CFD,$3CF0,$F2DD,$FDE2,$F3E7,$F0C0
		dc.w	$3DE8,$5F1F,$7F3E,$9C08,$EA83,$BF7C,$FCF9,$2800
		dc.w	$0C08,$FBF7,$FBE7,$0000,$1078,$FFC7,$CFCF,$0000
		dc.w	$3FFF,$C000,$8000,$0000,$FDB0,$0FDF,$1F90,$0D80
		dc.w	$7A5E,$8FFF,$1F3E,$0A1E,$BDEA,$3EFC,$7CF9,$3CE8
		dc.w	$AB7F,$FDEB,$FBEF,$A163,$DBF1,$7C1F,$FE3E,$5810
		dc.w	$1293,$7F7C,$FEF9,$1010,$871C,$F9F3,$F3F7,$8100
		dc.w	$98B9,$F7C7,$DF8F,$8081,$3FFF,$C000,$8000,$0000
		dc.w	$FEBF,$0FC0,$1F80,$0E80,$E72E,$1FDF,$1F3E,$070E
		dc.w	$D7D3,$3FFC,$7FF9,$17D0,$5ABD,$FDE3,$FBE7,$50A1
		dc.w	$75CA,$FC3F,$FE3F,$740A,$AE8A,$F97D,$FCF9,$A808
		dc.w	$5C08,$FBF7,$FBE7,$5000,$5D32,$E7CF,$CF8F,$4502
		dc.w	$BFFF,$C000,$8000,$8000,$F53F,$0FC0,$1F80,$0500
		dc.w	$FA54,$0FBF,$1F3E,$0A14,$AAAA,$3FFC,$7FF9,$2AA8
		dc.w	$AFFE,$F803,$F807,$A002,$ABF5,$FE1F,$FC3F,$A815
		dc.w	$7A53,$F5FC,$F8F9,$7050,$E74E,$F9F3,$F3E7,$E142
		dc.w	$9AFF,$E7C7,$CFCF,$8287,$3FFF,$C000,$8000,$0000
		dc.w	$FA3F,$0FC0,$1F80,$0A00,$F56A,$0F9D,$1F3E,$0508
		dc.w	$D143,$3FFC,$7FF9,$1140,$1FFD,$F803,$F807,$1001
		dc.w	$45CE,$FC3F,$FE3F,$440E,$CEAA,$E97D,$F8F9,$C028
		dc.w	$54A9,$FBF7,$F3E7,$50A1,$5DB2,$E7CF,$CF8F,$4582
		dc.w	$BFFF,$C000,$8000,$8000,$F12F,$0FD0,$1F8F,$0100
		dc.w	$EE62,$1F9D,$9F3E,$0E00,$E3FF,$BFFC,$FDFD,$2000
		dc.w	$2FFE,$F803,$F807,$2002,$8BFE,$FD1F,$FF3E,$881E
		dc.w	$1E73,$F1FC,$10F9,$0070,$F5CB,$FBF7,$F3E7,$F1C3
		dc.w	$9BBF,$E7C7,$CF8F,$8387,$3FFF,$C000,$8000,$0000
		dc.w	$E020,$0FDF,$1F8F,$0000,$7474,$8F89,$9F3C,$0402
		dc.w	$D1FA,$3E04,$7CF9,$1000,$0C1C,$FC03,$FFE7,$0000
		dc.w	$00DE,$FF3F,$FE3E,$001E,$FEFA,$017D,$00F9,$0078
		dc.w	$F7AF,$F9F3,$F3E7,$F1A3,$55B7,$EFCF,$CF8F,$4587
		dc.w	$BFFF,$C000,$8000,$8000,$F024,$1FDB,$0F8F,$0000
		dc.w	$706A,$8FD1,$9F78,$0006,$C103,$BEFC,$FCF9,$0000
		dc.w	$181C,$EFE3,$FBE7,$0000,$21DE,$DF3F,$FE3E,$001E
		dc.w	$FE7A,$01FD,$00F9,$0078,$F5EB,$FBF7,$F3E7,$F1E3
		dc.w	$DFB7,$E7CF,$CF8F,$C787,$BFFF,$C000,$8000,$8000
		dc.w	$EAAA,$1555,$0F8F,$0000,$E165,$0E82,$9F20,$001F
		dc.w	$D5AB,$2A54,$7CF9,$0000,$215D,$DEA2,$F3E7,$0000
		dc.w	$00DE,$DE3F,$FF3E,$001E,$FE7A,$01FD,$00F9,$0078
		dc.w	$FDEB,$FBF7,$FBE7,$F1E3,$DFBF,$E7C7,$CF8F,$C787
		dc.w	$BFFF,$C000,$8000,$8000,$F575,$12DA,$1F8F,$0000
		dc.w	$7A58,$05C7,$9F40,$003F,$A95A,$96A4,$FCF9,$0000
		dc.w	$52BE,$AD41,$F3E7,$0000,$95DE,$6ABF,$DFBE,$001E
		dc.w	$FF7A,$01FD,$01F9,$0078,$F5EB,$FBF7,$F3E7,$F1E3
		dc.w	$D7B7,$EFCF,$CF8F,$C787,$BFFF,$C000,$8000,$8000
		dc.w	$FEFB,$0924,$07FF,$0000,$E46E,$8B9F,$1F00,$003F
		dc.w	$F5B7,$C941,$BEF8,$0000,$B15F,$4280,$FFE7,$0000
		dc.w	$5A5E,$A5BF,$DF3E,$001E,$FFFD,$007B,$00FD,$0079
		dc.w	$EDEB,$FBF7,$FBE7,$E1E3,$DFB7,$E7CF,$CF8F,$C787
		dc.w	$BFFF,$8000,$C000,$8000,$FAEA,$0800,$0FFF,$0000
		dc.w	$FE4D,$81E1,$9F5E,$003F,$DAFE,$4009,$7FF0,$8000
		dc.w	$D55D,$0020,$FFC7,$0000,$EDDE,$22BF,$FF3E,$001E
		dc.w	$FF7F,$00FF,$007F,$007F,$EDEB,$E3F7,$F3E7,$E1E3
		dc.w	$D7B7,$EFCF,$CF8F,$C787,$CFFF,$F000,$E000,$C000
		dc.w	$F954,$0401,$03FE,$0000,$EB54,$008E,$1F3F,$007F
		dc.w	$755F,$B018,$2FE8,$8000,$A27A,$8060,$7FA7,$0000
		dc.w	$B55E,$303F,$EFBE,$001E,$FFBF,$003F,$007F,$003F
		dc.w	$DDEB,$C3F7,$E3E7,$C1E3,$DFB7,$E7C7,$CF8F,$C787
		dc.w	$EFFF,$F000,$E000,$E000,$FEFB,$03FE,$0202,$0000
		dc.w	$FF4F,$1F9F,$003E,$007F,$77DF,$9FF0,$1010,$C000
		dc.w	$BF7F,$7FC7,$0040,$0000,$EFDE,$DFBF,$003E,$001E
		dc.w	$FFD6,$002F,$001F,$0006,$BDEB,$43F7,$83E7,$01E3
		dc.w	$DFB9,$E7C3,$CF87,$C781,$EFFF,$F000,$E000,$E000
		dc.w	$FF8F,$00F8,$0088,$0000,$E0CC,$1FE1,$00DE,$003F
		dc.w	$FC7F,$47C0,$4440,$A000,$E1F8,$3F87,$2180,$0000
		dc.w	$3040,$DFBF,$1000,$0000,$FFF9,$000F,$0009,$0000
		dc.w	$FC08,$03F7,$0000,$0000,$103E,$EFC3,$0002,$0000
		dc.w	$0FFF,$F000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFF5,$052E,$0520,$005F,$FFFF,$D400,$D400,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$1095,$1095,$002A
		dc.w	$FFFF,$2200,$2200,$8000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0209,$0209,$0084,$FFFF,$0080,$0080,$1000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0080,$0080,$0010
		dc.w	$FFFF,$4000,$4000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0801,$0801,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0020,$0020,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000,$FFFF,$0000,$0000,$0000
		dc.w	$FFFF,$0000,$0000,$0000
