*
*  NEOchrome V2.24 cut buffer contents (left justified):
*  by Chaos, Inc. of the Delta Force (member of The Union)
*
*    pixels/scanline    = $0140 (bytes/scanline: $00A0)
*  # scanlines (height) = $0041
*
*  Hardware color pallet  (color 0 to 15):
*
*      $0000,$0777,$0070,$0770,$0470,$0070,$0073,$0077
*      $0047,$0007,$0307,$0607,$0706,$0704,$0700,$0730
*
*
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$03FF
		dc.w	$FFFF,$E000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0001,$FFFF
		dc.w	$FFF0,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$03FF
		dc.w	$FFFF,$E000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0001,$FFFF
		dc.w	$FFF0,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$03FF
		dc.w	$FFFF,$E000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0001,$FFFF
		dc.w	$FFF0,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$03FF
		dc.w	$FFFF,$E000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0001,$FFFF
		dc.w	$FFF0,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$03FF
		dc.w	$FFFF,$E000
		dc.w	$0000,$003F
		dc.w	$FF80,$0000
		dc.w	$0001,$FFFF
		dc.w	$FFF0,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$03FF
		dc.w	$FFFF,$E000
		dc.w	$0000,$07FF
		dc.w	$FFFC,$0000
		dc.w	$0001,$FFFF
		dc.w	$FFF0,$00FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$03FF
		dc.w	$FFFF,$E000
		dc.w	$0000,$3FFF
		dc.w	$FFFF,$8000
		dc.w	$0001,$FFFF
		dc.w	$FFF0,$01FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$03FF
		dc.w	$FFFF,$E000
		dc.w	$0000,$FFFF
		dc.w	$FFFF,$E000
		dc.w	$0001,$FFFF
		dc.w	$FFF0,$01FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$03FF
		dc.w	$FFFF,$E000
		dc.w	$0003,$FFFF
		dc.w	$FFFF,$F800
		dc.w	$0001,$FFFF
		dc.w	$FFF0,$03FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$03FF
		dc.w	$FFFF,$E000
		dc.w	$000F,$FFFF
		dc.w	$FFFF,$FE00
		dc.w	$0001,$FFFF
		dc.w	$FFF0,$03FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$03FF
		dc.w	$FFFF,$E000
		dc.w	$003F,$FFFF
		dc.w	$FFFF,$FF80
		dc.w	$0001,$FFFF
		dc.w	$FFF0,$07FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$03FF
		dc.w	$FFFF,$E000
		dc.w	$007F,$FFFF
		dc.w	$FFFF,$FFC0
		dc.w	$0001,$FFFF
		dc.w	$FFF0,$0FFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$03FF
		dc.w	$FFFF,$E000
		dc.w	$00FF,$FFFF
		dc.w	$FFFF,$FFE0
		dc.w	$0001,$FFFF
		dc.w	$FFF0,$0FFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$03FF
		dc.w	$FFFF,$E000
		dc.w	$01FF,$FFFF
		dc.w	$FFFF,$FFF0
		dc.w	$0001,$FFFF
		dc.w	$FFF0,$1FFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$03FF
		dc.w	$FFFF,$E000
		dc.w	$03FF,$FFFF
		dc.w	$FFFF,$FFF8
		dc.w	$0001,$FFFF
		dc.w	$FFF0,$1FFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$03FF
		dc.w	$FFFF,$E000
		dc.w	$07FF,$FFFF
		dc.w	$FFFF,$FFFC
		dc.w	$0001,$FFFF
		dc.w	$FFF0,$3FFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$03FF
		dc.w	$FFFF,$E000
		dc.w	$0FFF,$FFFF
		dc.w	$FFFF,$FFFE
		dc.w	$0001,$FFFF
		dc.w	$FFF0,$3FFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$03FF
		dc.w	$FFFF,$E000
		dc.w	$1FFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0001,$FFFF
		dc.w	$FFF0,$7FFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$03FF
		dc.w	$FFFF,$E000
		dc.w	$1FFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0001,$FFFF
		dc.w	$FFF0,$7FFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$03FF
		dc.w	$FFFF,$E000
		dc.w	$3FFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$8001,$FFFF
		dc.w	$FFF0,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$03FF
		dc.w	$FFFF,$E000
		dc.w	$7FFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$C001,$FFFF
		dc.w	$FFF0,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$03FF
		dc.w	$FFFF,$E000
		dc.w	$7FFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$C001,$FFFF
		dc.w	$FFF1,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$03FF
		dc.w	$FFFF,$E000
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$E001,$FFFF
		dc.w	$FFF1,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$03FF
		dc.w	$FFFF,$E000
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$E001,$FFFF
		dc.w	$FFF3,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$03FF
		dc.w	$FFFF,$E000
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$E001,$FFFF
		dc.w	$FFF3,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$03FF
		dc.w	$FFFF,$E001
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$F001,$FFFF
		dc.w	$FFF7,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$03FF
		dc.w	$FFFF,$E001
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$F001,$FFFF
		dc.w	$FFF7,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$03FF
		dc.w	$FFFF,$E001
		dc.w	$FFFF,$FFFE
		dc.w	$0FFF,$FFFF
		dc.w	$F001,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$03FF
		dc.w	$FFFF,$E001
		dc.w	$FFFF,$FFF8
		dc.w	$03FF,$FFFF
		dc.w	$F001,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$03FF
		dc.w	$FFFF,$E003
		dc.w	$FFFF,$FFF0
		dc.w	$01FF,$FFFF
		dc.w	$F801,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$03FF
		dc.w	$FFFF,$E003
		dc.w	$FFFF,$FFE0
		dc.w	$00FF,$FFFF
		dc.w	$F801,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0080,$03FF
		dc.w	$FFFF,$E003
		dc.w	$FFFF,$FFE0
		dc.w	$00FF,$FFFF
		dc.w	$F801,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0080,$03FF
		dc.w	$FFFF,$E003
		dc.w	$FFFF,$FFC0
		dc.w	$007F,$FFFF
		dc.w	$F801,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$01C0,$03FF
		dc.w	$FFFF,$E003
		dc.w	$FFFF,$FFC0
		dc.w	$007F,$FFFF
		dc.w	$F801,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$01C0,$03FF
		dc.w	$FFFF,$E003
		dc.w	$FFFF,$FFC0
		dc.w	$007F,$FFFF
		dc.w	$F801,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$03E0,$07FF
		dc.w	$FFFF,$E003
		dc.w	$FFFF,$FFC0
		dc.w	$007F,$FFFF
		dc.w	$F801,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$03F0,$07FF
		dc.w	$FFFF,$E003
		dc.w	$FFFF,$FFC0
		dc.w	$007F,$FFFF
		dc.w	$F801,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$03F8,$0FFF
		dc.w	$FFFF,$E003
		dc.w	$FFFF,$FFC0
		dc.w	$007F,$FFFF
		dc.w	$F801,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$07FE,$3FFF
		dc.w	$FFFF,$E003
		dc.w	$FFFF,$FFE0
		dc.w	$00FF,$FFFF
		dc.w	$F801,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$07FF,$FFFF
		dc.w	$FFFF,$E003
		dc.w	$FFFF,$FFF0
		dc.w	$01FF,$FFFF
		dc.w	$F801,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0FFF,$FFFF
		dc.w	$FFFF,$E003
		dc.w	$FFFF,$FFF8
		dc.w	$03FF,$FFFF
		dc.w	$F801,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0FFF,$FFFF
		dc.w	$FFFF,$E001
		dc.w	$FFFF,$FFFE
		dc.w	$0FFF,$FFFF
		dc.w	$F001,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0FFF,$FFFF
		dc.w	$FFFF,$C001
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$F001,$FFFF
		dc.w	$FFF7,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1FFF,$FFFF
		dc.w	$FFFF,$C001
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$F001,$FFFF
		dc.w	$FFF7,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1FFF,$FFFF
		dc.w	$FFFF,$C001
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$F001,$FFFF
		dc.w	$FFF3,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3FFF,$FFFF
		dc.w	$FFFF,$C000
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$E001,$FFFF
		dc.w	$FFF3,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3FFF,$FFFF
		dc.w	$FFFF,$8000
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$E001,$FFFF
		dc.w	$FFF1,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3FFF,$FFFF
		dc.w	$FFFF,$8000
		dc.w	$7FFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$C001,$FFFF
		dc.w	$FFF0,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7FFF,$FFFF
		dc.w	$FFFF,$8000
		dc.w	$7FFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$C001,$FFFF
		dc.w	$FFF0,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7FFF,$FFFF
		dc.w	$FFFF,$8000
		dc.w	$3FFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$8001,$FFFF
		dc.w	$FFF0,$7FFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$0000
		dc.w	$3FFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$8001,$FFFF
		dc.w	$FFF0,$7FFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$0000
		dc.w	$1FFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0001,$FFFF
		dc.w	$FFF0,$3FFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$FFFF,$FFFF
		dc.w	$FFFE,$0000
		dc.w	$0FFF,$FFFF
		dc.w	$FFFF,$FFFE
		dc.w	$0001,$FFFF
		dc.w	$FFF0,$3FFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0001
		dc.w	$FFFF,$FFFF
		dc.w	$FFFE,$0000
		dc.w	$07FF,$FFFF
		dc.w	$FFFF,$FFFC
		dc.w	$0001,$FFFF
		dc.w	$FFF0,$1FFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0001
		dc.w	$FFFF,$FFFF
		dc.w	$FFFC,$0000
		dc.w	$03FF,$FFFF
		dc.w	$FFFF,$FFF8
		dc.w	$0001,$FFFF
		dc.w	$FFF0,$1FFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0003
		dc.w	$FFFF,$FFFF
		dc.w	$FFF8,$0000
		dc.w	$01FF,$FFFF
		dc.w	$FFFF,$FFF0
		dc.w	$0001,$FFFF
		dc.w	$FFF0,$0FFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0001
		dc.w	$FFFF,$FFFF
		dc.w	$FFF0,$0000
		dc.w	$00FF,$FFFF
		dc.w	$FFFF,$FFE0
		dc.w	$0001,$FFFF
		dc.w	$FFF0,$07FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$FFFF,$FFFF
		dc.w	$FFE0,$0000
		dc.w	$007F,$FFFF
		dc.w	$FFFF,$FFC0
		dc.w	$0001,$FFFF
		dc.w	$FFF0,$07FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3FFF,$FFFF
		dc.w	$FFC0,$0000
		dc.w	$001F,$FFFF
		dc.w	$FFFF,$FF80
		dc.w	$0001,$FFFF
		dc.w	$FFF0,$03FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0FFF,$FFFF
		dc.w	$FF00,$0000
		dc.w	$000F,$FFFF
		dc.w	$FFFF,$FE00
		dc.w	$0001,$FFFF
		dc.w	$FFF0,$03FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$03FF,$FFFF
		dc.w	$FE00,$0000
		dc.w	$0003,$FFFF
		dc.w	$FFFF,$F800
		dc.w	$0001,$FFFF
		dc.w	$FFF0,$01FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$00FF,$FFFF
		dc.w	$F800,$0000
		dc.w	$0000,$FFFF
		dc.w	$FFFF,$E000
		dc.w	$0001,$FFFF
		dc.w	$FFF0,$01FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$003F,$FFFF
		dc.w	$E000,$0000
		dc.w	$0000,$1FFF
		dc.w	$FFFF,$8000
		dc.w	$0001,$FFFF
		dc.w	$FFF0,$00FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0007,$FFFF
		dc.w	$8000,$0000
		dc.w	$0000,$03FF
		dc.w	$FFF8,$0000
		dc.w	$0001,$FFFF
		dc.w	$FFF0,$00FF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$7FF8
		dc.w	$0000,$0000
		dc.w	$0000,$001F
		dc.w	$FF00,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
