*
*  NEOchrome V2.24 cut buffer contents (left justified):
*  by Chaos, Inc. of the Delta Force (member of The Union)
*
*    pixels/scanline    = $0140 (bytes/scanline: $00A0)
*  # scanlines (height) = $0041
*
*  Hardware color pallet  (color 0 to 15):
*
*      $0000,$0777,$0000,$0000,$0000,$0000,$0000,$0000
*      $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0710
*
*
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$01FF,$FFFF
		dc.w	$E7FF,$FFFF
		dc.w	$8000,$07FF
		dc.w	$FFFF,$0000
		dc.w	$001F,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$00FF,$FFFF
		dc.w	$F7FF,$FFFF
		dc.w	$8000,$07FF
		dc.w	$FFFF,$0000
		dc.w	$003F,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$00FF,$FFFF
		dc.w	$F7FF,$FFFF
		dc.w	$0000,$07FF
		dc.w	$FFFF,$0000
		dc.w	$003F,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$007F,$FFFF
		dc.w	$FFFF,$FFFE
		dc.w	$0000,$07FF
		dc.w	$FFFF,$0000
		dc.w	$007F,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$003F,$FFFF
		dc.w	$FFFF,$FFFE
		dc.w	$0000,$07FF
		dc.w	$FFFF,$0000
		dc.w	$007F,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$003F,$FFFF
		dc.w	$FFFF,$FFFC
		dc.w	$0000,$07FF
		dc.w	$FFFF,$0000
		dc.w	$007F,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$001F,$FFFF
		dc.w	$FFFF,$FFF8
		dc.w	$0000,$07FF
		dc.w	$FFFF,$0000
		dc.w	$00FF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$000F,$FFFF
		dc.w	$FFFF,$FFF8
		dc.w	$0000,$07FF
		dc.w	$FFFF,$0000
		dc.w	$00FF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$000F,$FFFF
		dc.w	$FFFF,$FFF0
		dc.w	$0000,$07FF
		dc.w	$FFFF,$0000
		dc.w	$00FF,$FFFE
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0007,$FFFF
		dc.w	$FFFF,$FFE0
		dc.w	$0000,$07FF
		dc.w	$FFFF,$0000
		dc.w	$01FF,$FFFE
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0003,$FFFF
		dc.w	$FFFF,$FFE0
		dc.w	$0000,$07FF
		dc.w	$FFFF,$0000
		dc.w	$01FF,$FFFE
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0001,$FFFF
		dc.w	$FFFF,$FFC0
		dc.w	$0000,$07FF
		dc.w	$FFFF,$0000
		dc.w	$01FF,$FFFC
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0001,$FFFF
		dc.w	$FFFF,$FF80
		dc.w	$0000,$07FF
		dc.w	$FFFF,$0000
		dc.w	$03FF,$FFFC
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$FFFF
		dc.w	$FFFF,$FF80
		dc.w	$0000,$07FF
		dc.w	$FFFF,$0000
		dc.w	$03FF,$FFFC
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$7FFF
		dc.w	$FFFF,$FF00
		dc.w	$0000,$07FF
		dc.w	$FFFF,$0000
		dc.w	$03FF,$FFFC
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$7FFF
		dc.w	$FFFF,$FE00
		dc.w	$0000,$07FF
		dc.w	$FFFF,$0000
		dc.w	$07FF,$FFFC
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$3FFF
		dc.w	$FFFF,$FE00
		dc.w	$0000,$07FF
		dc.w	$FFFF,$0000
		dc.w	$07FF,$FFF8
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$1FFF
		dc.w	$FFFF,$FC00
		dc.w	$0000,$07FF
		dc.w	$FFFF,$0000
		dc.w	$07FF,$FFF8
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$1FFF
		dc.w	$FFFF,$F800
		dc.w	$0000,$07FF
		dc.w	$FFFF,$0000
		dc.w	$0FFF,$FFF8
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0FFF
		dc.w	$FFFF,$F800
		dc.w	$0000,$07FF
		dc.w	$FFFF,$0000
		dc.w	$0FFF,$FFF8
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$07FF
		dc.w	$FFFF,$F000
		dc.w	$0000,$07FF
		dc.w	$FFFF,$0000
		dc.w	$0FFF,$FFF0
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$07FF
		dc.w	$FFFF,$F000
		dc.w	$0000,$07FF
		dc.w	$FFFF,$0000
		dc.w	$1FFF,$FFF0
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0FFF
		dc.w	$FFFF,$F800
		dc.w	$0000,$07FF
		dc.w	$FFFF,$0000
		dc.w	$1FFF,$FFF0
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$1FFF
		dc.w	$FFFF,$F800
		dc.w	$0000,$07FF
		dc.w	$FFFF,$0000
		dc.w	$3FFF,$FFF0
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$1FFF
		dc.w	$FFFF,$FC00
		dc.w	$0000,$07FF
		dc.w	$FFFF,$0000
		dc.w	$3FFF,$FFF0
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$3FFF
		dc.w	$FFFF,$FE00
		dc.w	$0000,$07FF
		dc.w	$FFFF,$0000
		dc.w	$3FFF,$FFE0
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$7FFF
		dc.w	$FFFF,$FE00
		dc.w	$0000,$07FF
		dc.w	$FFFF,$0000
		dc.w	$7FFF,$FFE0
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$7FFF
		dc.w	$FFFF,$FF00
		dc.w	$0000,$07FF
		dc.w	$FFFF,$0000
		dc.w	$7FFF,$FFE0
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$FFFF
		dc.w	$FFFF,$FF80
		dc.w	$0000,$07FF
		dc.w	$FFFF,$0000
		dc.w	$7FFF,$FFE0
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0001,$FFFF
		dc.w	$FFFF,$FF80
		dc.w	$0000,$07FF
		dc.w	$FFFF,$0000
		dc.w	$FFFF,$FFC0
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0001,$FFFF
		dc.w	$FFFF,$FFC0
		dc.w	$0000,$07FF
		dc.w	$FFFF,$0000
		dc.w	$FFFF,$FFC0
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0003,$FFFF
		dc.w	$FFFF,$FFE0
		dc.w	$0000,$07FF
		dc.w	$FFFF,$0000
		dc.w	$FFFF,$FFC0
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0007,$FFFF
		dc.w	$FFFF,$FFE0
		dc.w	$0000,$07FF
		dc.w	$FFFF,$0001
		dc.w	$FFFF,$FFC0
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0007,$FFFF
		dc.w	$FFFF,$FFF0
		dc.w	$0000,$07FF
		dc.w	$FFFF,$0001
		dc.w	$FFFF,$FFC0
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$000F,$FFFF
		dc.w	$FFFF,$FFF8
		dc.w	$0000,$07FF
		dc.w	$FFFF,$0001
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$001F,$FFFF
		dc.w	$FFFF,$FFF8
		dc.w	$0000,$07FF
		dc.w	$FFFF,$0003
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$001F,$FFFF
		dc.w	$FFFF,$FFFC
		dc.w	$0000,$07FF
		dc.w	$FFFF,$0003
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$003F,$FFFF
		dc.w	$FFFF,$FFFE
		dc.w	$0000,$07FF
		dc.w	$FFFF,$0003
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$007F,$FFFF
		dc.w	$FFFF,$FFFE
		dc.w	$0000,$07FF
		dc.w	$FFFF,$0007
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$007F,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$07FF
		dc.w	$FFFF,$0007
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$00FF,$FFFF
		dc.w	$F7FF,$FFFF
		dc.w	$8000,$07FF
		dc.w	$FFFF,$0007
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$00FF,$FFFF
		dc.w	$F7FF,$FFFF
		dc.w	$8000,$07FF
		dc.w	$FFFF,$000F
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$01FF,$FFFF
		dc.w	$F3FF,$FFFF
		dc.w	$C000,$07FF
		dc.w	$FFFF,$000F
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$03FF,$FFFF
		dc.w	$E3FF,$FFFF
		dc.w	$E000,$07FF
		dc.w	$FFFF,$000F
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$03FF,$FFFF
		dc.w	$E1FF,$FFFF
		dc.w	$E000,$07FF
		dc.w	$FFFF,$001F
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$07FF,$FFFF
		dc.w	$C1FF,$FFFF
		dc.w	$F000,$07FF
		dc.w	$FFFF,$001F
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0FFF,$FFFF
		dc.w	$C0FF,$FFFF
		dc.w	$F800,$07FF
		dc.w	$FFFF,$003F
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0FFF,$FFFF
		dc.w	$80FF,$FFFF
		dc.w	$F800,$07FF
		dc.w	$FFFF,$003F
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$1FFF,$FFFF
		dc.w	$807F,$FFFF
		dc.w	$FC00,$07FF
		dc.w	$FFFF,$003F
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3FFF,$FFFF
		dc.w	$007F,$FFFF
		dc.w	$FE00,$07FF
		dc.w	$FFFF,$007F
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$3FFF,$FFFF
		dc.w	$003F,$FFFF
		dc.w	$FE00,$07FF
		dc.w	$FFFF,$007F
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$7FFF,$FFFE
		dc.w	$003F,$FFFF
		dc.w	$FF00,$07FF
		dc.w	$FFFF,$007F
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$FFFF,$FFFC
		dc.w	$001F,$FFFF
		dc.w	$FF80,$07FF
		dc.w	$FFFF,$00FF
		dc.w	$FFFF,$F000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$FFFF,$FFFC
		dc.w	$001F,$FFFF
		dc.w	$FF80,$07FF
		dc.w	$FFFF,$00FF
		dc.w	$FFFF,$F000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0001
		dc.w	$FFFF,$FFF8
		dc.w	$000F,$FFFF
		dc.w	$FFC0,$07FF
		dc.w	$FFFF,$00FF
		dc.w	$FFFF,$F000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0003
		dc.w	$FFFF,$FFF8
		dc.w	$000F,$FFFF
		dc.w	$FFE0,$07FF
		dc.w	$FFFF,$01FF
		dc.w	$FFFF,$F000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0003
		dc.w	$FFFF,$FFF0
		dc.w	$0007,$FFFF
		dc.w	$FFE0,$07FF
		dc.w	$FFFF,$01FF
		dc.w	$FFFF,$F000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0007
		dc.w	$FFFF,$FFF0
		dc.w	$0007,$FFFF
		dc.w	$FFF0,$07FF
		dc.w	$FFFF,$01FF
		dc.w	$FFFF,$E000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$000F
		dc.w	$FFFF,$FFE0
		dc.w	$0003,$FFFF
		dc.w	$FFF8,$07FF
		dc.w	$FFFF,$03FF
		dc.w	$FFFF,$E000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$000F
		dc.w	$FFFF,$FFE0
		dc.w	$0003,$FFFF
		dc.w	$FFF8,$07FF
		dc.w	$FFFF,$03FF
		dc.w	$FFFF,$E000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$001F
		dc.w	$FFFF,$FFC0
		dc.w	$0001,$FFFF
		dc.w	$FFFC,$07FF
		dc.w	$FFFF,$07FF
		dc.w	$FFFF,$E000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000