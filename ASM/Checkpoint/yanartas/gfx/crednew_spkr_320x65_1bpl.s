*
*  NEOchrome V2.24 cut buffer contents (left justified):
*  by Chaos, Inc. of the Delta Force (member of The Union)
*
*    pixels/scanline    = $0140 (bytes/scanline: $00A0)
*  # scanlines (height) = $0041
*
*  Hardware color pallet  (color 0 to 15):
*
*      $0000,$0777,$0070,$0770,$0470,$0070,$0073,$0077
*      $0047,$0007,$0307,$0607,$0706,$0704,$0700,$0730
*
*
		dc.w	$0000,$007F
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$8000
		dc.w	$0FFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$FFF0,$07FF
		dc.w	$FFFF,$C03F
		dc.w	$FFFF,$FFC0
		dc.w	$0000,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$007F
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$8000
		dc.w	$0FFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$FFF0,$07FF
		dc.w	$FFFF,$C03F
		dc.w	$FFFF,$FF80
		dc.w	$0000,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$007F
		dc.w	$FFFF,$FF80
		dc.w	$3FFF,$0000
		dc.w	$0FFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$FFF0,$07FF
		dc.w	$FFFF,$C07F
		dc.w	$FFFF,$FF00
		dc.w	$0000,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$007F
		dc.w	$FFFF,$FE00
		dc.w	$07FF,$0000
		dc.w	$0FFF,$FFFF
		dc.w	$807F,$FFFF
		dc.w	$FFF0,$07FF
		dc.w	$FFFF,$C07F
		dc.w	$FFFF,$FF00
		dc.w	$0000,$FFFF
		dc.w	$FFF8,$07FF
		dc.w	$0000,$00FF
		dc.w	$FFFF,$FC00
		dc.w	$01FF,$0000
		dc.w	$0FFF,$FFFF
		dc.w	$800F,$FFFF
		dc.w	$FFF8,$07FF
		dc.w	$FFFF,$C0FF
		dc.w	$FFFF,$FE00
		dc.w	$0000,$FFFF
		dc.w	$FFF8,$01FF
		dc.w	$0000,$00FF
		dc.w	$FFFF,$FC00
		dc.w	$007E,$0000
		dc.w	$0FFF,$FFFF
		dc.w	$8003,$FFFF
		dc.w	$FFF8,$07FF
		dc.w	$FFFF,$C0FF
		dc.w	$FFFF,$FC00
		dc.w	$0000,$FFFF
		dc.w	$FFF8,$00FF
		dc.w	$0000,$00FF
		dc.w	$FFFF,$FC00
		dc.w	$001E,$0000
		dc.w	$0FFF,$FFFF
		dc.w	$8001,$FFFF
		dc.w	$FFF8,$07FF
		dc.w	$FFFF,$C1FF
		dc.w	$FFFF,$FC00
		dc.w	$0000,$FFFF
		dc.w	$FFF8,$007F
		dc.w	$0000,$00FF
		dc.w	$FFFF,$FC00
		dc.w	$0004,$0000
		dc.w	$0FFF,$FFFF
		dc.w	$8001,$FFFF
		dc.w	$FFF8,$07FF
		dc.w	$FFFF,$C1FF
		dc.w	$FFFF,$F800
		dc.w	$0000,$FFFF
		dc.w	$FFF8,$007F
		dc.w	$0000,$00FF
		dc.w	$FFFF,$FE00
		dc.w	$0000,$0000
		dc.w	$0FFF,$FFFF
		dc.w	$8000,$FFFF
		dc.w	$FFF8,$07FF
		dc.w	$FFFF,$C3FF
		dc.w	$FFFF,$F000
		dc.w	$0000,$FFFF
		dc.w	$FFF8,$003F
		dc.w	$0000,$00FF
		dc.w	$FFFF,$FF80
		dc.w	$0000,$0000
		dc.w	$0FFF,$FFFF
		dc.w	$8000,$FFFF
		dc.w	$FFF8,$07FF
		dc.w	$FFFF,$C3FF
		dc.w	$FFFF,$F000
		dc.w	$0000,$FFFF
		dc.w	$FFF8,$003F
		dc.w	$0000,$00FF
		dc.w	$FFFF,$FFF8
		dc.w	$0000,$0000
		dc.w	$0FFF,$FFFF
		dc.w	$8000,$FFFF
		dc.w	$FFF8,$07FF
		dc.w	$FFFF,$C7FF
		dc.w	$FFFF,$E000
		dc.w	$0000,$FFFF
		dc.w	$FFF8,$003F
		dc.w	$0000,$00FF
		dc.w	$FFFF,$FFFF
		dc.w	$8000,$0000
		dc.w	$0FFF,$FFFF
		dc.w	$8000,$FFFF
		dc.w	$FFF8,$07FF
		dc.w	$FFFF,$C7FF
		dc.w	$FFFF,$E000
		dc.w	$0000,$FFFF
		dc.w	$FFF8,$003F
		dc.w	$0000,$00FF
		dc.w	$FFFF,$FFFF
		dc.w	$FC00,$0000
		dc.w	$0FFF,$FFFF
		dc.w	$8000,$FFFF
		dc.w	$FFF8,$07FF
		dc.w	$FFFF,$CFFF
		dc.w	$FFFF,$C000
		dc.w	$0000,$FFFF
		dc.w	$FFF8,$003F
		dc.w	$0000,$00FF
		dc.w	$FFFF,$FFFF
		dc.w	$FF80,$0000
		dc.w	$0FFF,$FFFF
		dc.w	$8001,$FFFF
		dc.w	$FFF8,$07FF
		dc.w	$FFFF,$CFFF
		dc.w	$FFFF,$8000
		dc.w	$0000,$FFFF
		dc.w	$FFF8,$007F
		dc.w	$0000,$007F
		dc.w	$FFFF,$FFFF
		dc.w	$FFF0,$0000
		dc.w	$0FFF,$FFFF
		dc.w	$8001,$FFFF
		dc.w	$FFF8,$07FF
		dc.w	$FFFF,$DFFF
		dc.w	$FFFF,$8000
		dc.w	$0000,$FFFF
		dc.w	$FFF8,$007F
		dc.w	$0000,$007F
		dc.w	$FFFF,$FFFF
		dc.w	$FFFC,$0000
		dc.w	$0FFF,$FFFF
		dc.w	$8003,$FFFF
		dc.w	$FFF8,$07FF
		dc.w	$FFFF,$DFFF
		dc.w	$FFFF,$0000
		dc.w	$0000,$FFFF
		dc.w	$FFF8,$00FF
		dc.w	$0000,$007F
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$0000
		dc.w	$0FFF,$FFFF
		dc.w	$8007,$FFFF
		dc.w	$FFF8,$07FF
		dc.w	$FFFF,$FFFF
		dc.w	$FFFE,$0000
		dc.w	$0000,$FFFF
		dc.w	$FFF8,$03FF
		dc.w	$0000,$007F
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$C000
		dc.w	$0FFF,$FFFF
		dc.w	$803F,$FFFF
		dc.w	$FFF8,$07FF
		dc.w	$FFFF,$FFFF
		dc.w	$FFFE,$0000
		dc.w	$0000,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$003F
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$E000
		dc.w	$0FFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$FFF0,$07FF
		dc.w	$FFFF,$FFFF
		dc.w	$FFFC,$0000
		dc.w	$0000,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$003F
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$F000
		dc.w	$0FFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$FFF0,$07FF
		dc.w	$FFFF,$FFFF
		dc.w	$FFF8,$0000
		dc.w	$0000,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$001F
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$F800
		dc.w	$0FFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$FFF0,$07FF
		dc.w	$FFFF,$FFFF
		dc.w	$FFF8,$0000
		dc.w	$0000,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$001F
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$FC00
		dc.w	$0FFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$FFF0,$07FF
		dc.w	$FFFF,$FFFF
		dc.w	$FFF8,$0000
		dc.w	$0000,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$000F
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$FC00
		dc.w	$0FFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$FFE0,$07FF
		dc.w	$FFFF,$FFFF
		dc.w	$FFFC,$0000
		dc.w	$0000,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0007
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$FE00
		dc.w	$0FFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$FFE0,$07FF
		dc.w	$FFFF,$FFFF
		dc.w	$FFFC,$0000
		dc.w	$0000,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0003
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$FE00
		dc.w	$0FFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$FFE0,$07FF
		dc.w	$FFFF,$FFFF
		dc.w	$FFFE,$0000
		dc.w	$0000,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0001
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$FF00
		dc.w	$0FFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$FFC0,$07FF
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$0000
		dc.w	$0000,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$7FFF,$FFFF
		dc.w	$FFFF,$FF00
		dc.w	$0FFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$FFC0,$07FF
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$0000
		dc.w	$0000,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$1FFF,$FFFF
		dc.w	$FFFF,$FF80
		dc.w	$0FFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$FF80,$07FF
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$8000
		dc.w	$0000,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$07FF,$FFFF
		dc.w	$FFFF,$FF80
		dc.w	$0FFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$FF80,$07FF
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$C000
		dc.w	$0000,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$01FF,$FFFF
		dc.w	$FFFF,$FF80
		dc.w	$0FFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$FF00,$07FF
		dc.w	$FFFF,$DFFF
		dc.w	$FFFF,$C000
		dc.w	$0000,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$003F,$FFFF
		dc.w	$FFFF,$FFC0
		dc.w	$0FFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$FE00,$07FF
		dc.w	$FFFF,$DFFF
		dc.w	$FFFF,$E000
		dc.w	$0000,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0001,$FFFF
		dc.w	$FFFF,$FFC0
		dc.w	$0FFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$FC00,$07FF
		dc.w	$FFFF,$CFFF
		dc.w	$FFFF,$F000
		dc.w	$0000,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$0FFF
		dc.w	$FFFF,$FFC0
		dc.w	$0FFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$F800,$07FF
		dc.w	$FFFF,$CFFF
		dc.w	$FFFF,$F000
		dc.w	$0000,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0000
		dc.w	$0000,$00FF
		dc.w	$FFFF,$FFC0
		dc.w	$0FFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$E000,$07FF
		dc.w	$FFFF,$C7FF
		dc.w	$FFFF,$F800
		dc.w	$0000,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0002
		dc.w	$0000,$003F
		dc.w	$FFFF,$FFC0
		dc.w	$0FFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$C000,$07FF
		dc.w	$FFFF,$C7FF
		dc.w	$FFFF,$FC00
		dc.w	$0000,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0003
		dc.w	$8000,$001F
		dc.w	$FFFF,$FFC0
		dc.w	$0FFF,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$07FF
		dc.w	$FFFF,$C3FF
		dc.w	$FFFF,$FC00
		dc.w	$0000,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0007
		dc.w	$C000,$001F
		dc.w	$FFFF,$FFC0
		dc.w	$0FFF,$FFFF
		dc.w	$FFFF,$FFFC
		dc.w	$0000,$07FF
		dc.w	$FFFF,$C1FF
		dc.w	$FFFF,$FE00
		dc.w	$0000,$FFFF
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$0007
		dc.w	$F000,$001F
		dc.w	$FFFF,$FFC0
		dc.w	$0FFF,$FFFF
		dc.w	$FFFF,$FFE0
		dc.w	$0000,$07FF
		dc.w	$FFFF,$C1FF
		dc.w	$FFFF,$FF00
		dc.w	$0000,$FFFF
		dc.w	$FFFB,$FFFF
		dc.w	$0000,$000F
		dc.w	$FC00,$001F
		dc.w	$FFFF,$FFC0
		dc.w	$0FFF,$FFFF
		dc.w	$FFFF,$FE00
		dc.w	$0000,$07FF
		dc.w	$FFFF,$C0FF
		dc.w	$FFFF,$FF00
		dc.w	$0000,$FFFF
		dc.w	$FFF9,$FFFF
		dc.w	$0000,$000F
		dc.w	$FF00,$003F
		dc.w	$FFFF,$FFC0
		dc.w	$0FFF,$FFFF
		dc.w	$8000,$0000
		dc.w	$0000,$07FF
		dc.w	$FFFF,$C0FF
		dc.w	$FFFF,$FF80
		dc.w	$0000,$FFFF
		dc.w	$FFF9,$FFFF
		dc.w	$0000,$000F
		dc.w	$FFC0,$007F
		dc.w	$FFFF,$FFC0
		dc.w	$0FFF,$FFFF
		dc.w	$8000,$0000
		dc.w	$0000,$07FF
		dc.w	$FFFF,$C07F
		dc.w	$FFFF,$FFC0
		dc.w	$0000,$FFFF
		dc.w	$FFF8,$FFFF
		dc.w	$0000,$001F
		dc.w	$FFFC,$01FF
		dc.w	$FFFF,$FF80
		dc.w	$0FFF,$FFFF
		dc.w	$8000,$0000
		dc.w	$0000,$07FF
		dc.w	$FFFF,$C07F
		dc.w	$FFFF,$FFC0
		dc.w	$0000,$FFFF
		dc.w	$FFF8,$FFFF
		dc.w	$0000,$001F
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$FF80
		dc.w	$0FFF,$FFFF
		dc.w	$8000,$0000
		dc.w	$0000,$07FF
		dc.w	$FFFF,$C03F
		dc.w	$FFFF,$FFE0
		dc.w	$0000,$FFFF
		dc.w	$FFF8,$7FFF
		dc.w	$0000,$001F
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$FF80
		dc.w	$0FFF,$FFFF
		dc.w	$8000,$0000
		dc.w	$0000,$07FF
		dc.w	$FFFF,$C01F
		dc.w	$FFFF,$FFF0
		dc.w	$0000,$FFFF
		dc.w	$FFF8,$7FFF
		dc.w	$0000,$003F
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$FF80
		dc.w	$0FFF,$FFFF
		dc.w	$8000,$0000
		dc.w	$0000,$07FF
		dc.w	$FFFF,$C01F
		dc.w	$FFFF,$FFF0
		dc.w	$0000,$FFFF
		dc.w	$FFF8,$3FFF
		dc.w	$0000,$003F
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$FF00
		dc.w	$0FFF,$FFFF
		dc.w	$8000,$0000
		dc.w	$0000,$07FF
		dc.w	$FFFF,$C00F
		dc.w	$FFFF,$FFF8
		dc.w	$0000,$FFFF
		dc.w	$FFF8,$3FFF
		dc.w	$0000,$007F
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$FF00
		dc.w	$0FFF,$FFFF
		dc.w	$8000,$0000
		dc.w	$0000,$07FF
		dc.w	$FFFF,$C00F
		dc.w	$FFFF,$FFFC
		dc.w	$0000,$FFFF
		dc.w	$FFF8,$1FFF
		dc.w	$0000,$007F
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$FE00
		dc.w	$0FFF,$FFFF
		dc.w	$8000,$0000
		dc.w	$0000,$07FF
		dc.w	$FFFF,$C007
		dc.w	$FFFF,$FFFC
		dc.w	$0000,$FFFF
		dc.w	$FFF8,$1FFF
		dc.w	$0000,$007F
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$FE00
		dc.w	$0FFF,$FFFF
		dc.w	$8000,$0000
		dc.w	$0000,$07FF
		dc.w	$FFFF,$C007
		dc.w	$FFFF,$FFFE
		dc.w	$0000,$FFFF
		dc.w	$FFF8,$0FFF
		dc.w	$0000,$00FF
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$FC00
		dc.w	$0FFF,$FFFF
		dc.w	$8000,$0000
		dc.w	$0000,$07FF
		dc.w	$FFFF,$C003
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$FFFF
		dc.w	$FFF8,$0FFF
		dc.w	$0000,$00FF
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$FC00
		dc.w	$0FFF,$FFFF
		dc.w	$8000,$0000
		dc.w	$0000,$07FF
		dc.w	$FFFF,$C001
		dc.w	$FFFF,$FFFF
		dc.w	$0000,$FFFF
		dc.w	$FFF8,$07FF
		dc.w	$0000,$01FF
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$F800
		dc.w	$0FFF,$FFFF
		dc.w	$8000,$0000
		dc.w	$0000,$07FF
		dc.w	$FFFF,$C001
		dc.w	$FFFF,$FFFF
		dc.w	$8000,$FFFF
		dc.w	$FFF8,$07FF
		dc.w	$0000,$01FF
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$F000
		dc.w	$0FFF,$FFFF
		dc.w	$8000,$0000
		dc.w	$0000,$07FF
		dc.w	$FFFF,$C000
		dc.w	$FFFF,$FFFF
		dc.w	$C000,$FFFF
		dc.w	$FFF8,$03FF
		dc.w	$0000,$01FF
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$E000
		dc.w	$0FFF,$FFFF
		dc.w	$8000,$0000
		dc.w	$0000,$07FF
		dc.w	$FFFF,$C000
		dc.w	$FFFF,$FFFF
		dc.w	$C000,$FFFF
		dc.w	$FFF8,$03FF
		dc.w	$0000,$03FF
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$C000
		dc.w	$0FFF,$FFFF
		dc.w	$8000,$0000
		dc.w	$0000,$07FF
		dc.w	$FFFF,$C000
		dc.w	$7FFF,$FFFF
		dc.w	$E000,$FFFF
		dc.w	$FFF8,$01FF
		dc.w	$0000,$03FF
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$8000
		dc.w	$0FFF,$FFFF
		dc.w	$8000,$0000
		dc.w	$0000,$07FF
		dc.w	$FFFF,$C000
		dc.w	$7FFF,$FFFF
		dc.w	$F000,$FFFF
		dc.w	$FFF8,$01FF
		dc.w	$0000,$07FF
		dc.w	$FFFF,$FFFF
		dc.w	$FFFF,$0000
		dc.w	$0FFF,$FFFF
		dc.w	$8000,$0000
		dc.w	$0000,$07FF
		dc.w	$FFFF,$C000
		dc.w	$3FFF,$FFFF
		dc.w	$F000,$FFFF
		dc.w	$FFF8,$00FF
		dc.w	$0000,$07FF
		dc.w	$FFFF,$FFFF
		dc.w	$FFFE,$0000
		dc.w	$0FFF,$FFFF
		dc.w	$8000,$0000
		dc.w	$0000,$07FF
		dc.w	$FFFF,$C000
		dc.w	$1FFF,$FFFF
		dc.w	$F800,$FFFF
		dc.w	$FFF8,$00FF
		dc.w	$0000,$01FF
		dc.w	$FFFF,$FFFF
		dc.w	$FFF8,$0000
		dc.w	$0FFF,$FFFF
		dc.w	$8000,$0000
		dc.w	$0000,$07FF
		dc.w	$FFFF,$C000
		dc.w	$1FFF,$FFFF
		dc.w	$FC00,$FFFF
		dc.w	$FFF8,$007F
		dc.w	$0000,$003F
		dc.w	$FFFF,$FFFF
		dc.w	$FFF0,$0000
		dc.w	$0FFF,$FFFF
		dc.w	$8000,$0000
		dc.w	$0000,$07FF
		dc.w	$FFFF,$C000
		dc.w	$0FFF,$FFFF
		dc.w	$FC00,$FFFF
		dc.w	$FFF8,$007F
		dc.w	$0000,$000F
		dc.w	$FFFF,$FFFF
		dc.w	$FFC0,$0000
		dc.w	$0FFF,$FFFF
		dc.w	$8000,$0000
		dc.w	$0000,$07FF
		dc.w	$FFFF,$C000
		dc.w	$0FFF,$FFFF
		dc.w	$FE00,$FFFF
		dc.w	$FFF8,$003F
		dc.w	$0000,$0001
		dc.w	$FFFF,$FFFF
		dc.w	$FF00,$0000
		dc.w	$0FFF,$FFFF
		dc.w	$8000,$0000
		dc.w	$0000,$07FF
		dc.w	$FFFF,$C000
		dc.w	$07FF,$FFFF
		dc.w	$FF00,$FFFF
		dc.w	$FFF8,$003F
		dc.w	$0000,$0000
		dc.w	$1FFF,$FFFF
		dc.w	$F800,$0000
		dc.w	$0FFF,$FFFF
		dc.w	$8000,$0000
		dc.w	$0000,$07FF
		dc.w	$FFFF,$C000
		dc.w	$07FF,$FFFF
		dc.w	$FF00,$FFFF
		dc.w	$FFF8,$001F
		dc.w	$0000,$0000
		dc.w	$01FF,$FFFF
		dc.w	$C000,$0000
		dc.w	$0FFF,$FFFF
		dc.w	$8000,$0000
		dc.w	$0000,$07FF
		dc.w	$FFFF,$C000
		dc.w	$03FF,$FFFF
		dc.w	$FF80,$FFFF
		dc.w	$FFF8,$001F
		dc.w	$0000,$0000
		dc.w	$0007,$FFF8
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
		dc.w	$0000,$0000
