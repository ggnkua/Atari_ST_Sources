col1:
	dc.w	$302,$203,$032,$201
	dc.w	$403,$304,$043,$211
	dc.w	$413,$314,$143,$212
	dc.w	$513,$315,$153,$312
	dc.w	$522,$225,$252,$313
	dc.w	$621,$126,$251,$413
	dc.w	$631,$136,$361,$423
	dc.w	$740,$047,$470,$424
	dc.w	$777,$777,$777,$777
	dc.w	$760,$067,$670,$545
	dc.w	$750,$057,$570,$534
	dc.w	$760,$067,$670,$545
	dc.w	$750,$057,$570,$534
	dc.w	$760,$067,$670,$545
	dc.w	$750,$057,$570,$534
	dc.w	$740,$047,$470,$424
	dc.w	$750,$057,$570,$534
	dc.w	$740,$047,$470,$424
	dc.w	$631,$136,$361,$423
	dc.w	$740,$047,$470,$424
	dc.w	$631,$136,$361,$423
	dc.w	$740,$047,$470,$424
	dc.w	$631,$136,$361,$423
	dc.w	$621,$126,$251,$413
	dc.w	$631,$136,$361,$423
	dc.w	$621,$126,$251,$413
	dc.w	$631,$136,$361,$423
	dc.w	$621,$126,$251,$413
	dc.w	$631,$136,$361,$423
	dc.w	$621,$126,$251,$413
	dc.w	$631,$136,$361,$423
	dc.w	$621,$126,$251,$413
	dc.w	$631,$136,$361,$423
	dc.w	$621,$126,$251,$413
	dc.w	$631,$136,$361,$423
	dc.w	$740,$047,$470,$424
	dc.w	$631,$136,$361,$423
	dc.w	$740,$047,$470,$424
	dc.w	$631,$136,$361,$423
	dc.w	$740,$047,$470,$424
	dc.w	$631,$136,$361,$423
	dc.w	$740,$047,$470,$424
	dc.w	$750,$057,$570,$534
	dc.w	$740,$047,$470,$424
	dc.w	$750,$057,$570,$534
	dc.w	$760,$067,$670,$545
	dc.w	$770,$077,$770,$757
	dc.w	$760,$067,$670,$545
	dc.w	$770,$077,$770,$757
	dc.w	$777,$777,$777,$777
	dc.w	$770,$077,$770,$757
	dc.w	$760,$067,$670,$545
	dc.w	$770,$077,$770,$757
	dc.w	$760,$067,$670,$545
	dc.w	$770,$077,$770,$757
	dc.w	$760,$067,$670,$545
	dc.w	$770,$077,$770,$757
	dc.w	$777,$777,$777,$777
	dc.w	$770,$077,$770,$757
	dc.w	$760,$067,$670,$545
	dc.w	$770,$077,$770,$757
	dc.w	$760,$067,$670,$545
	dc.w	$750,$057,$570,$534
	dc.w	$740,$047,$470,$424
	dc.w	$750,$057,$570,$534
	dc.w	$740,$047,$470,$424
	dc.w	$750,$057,$570,$534
	dc.w	$740,$047,$470,$424
	dc.w	$750,$057,$570,$534
	dc.w	$740,$047,$470,$424
	dc.w	$750,$057,$570,$534
	dc.w	$740,$047,$470,$424
	dc.w	$750,$057,$570,$534
	dc.w	$740,$047,$470,$424
	dc.w	$750,$057,$570,$534
	dc.w	$740,$047,$470,$424
	dc.w	$750,$057,$570,$534
	dc.w	$760,$067,$670,$545
	dc.w	$750,$057,$570,$534
	dc.w	$760,$067,$670,$545
	dc.w	$750,$057,$570,$534
	dc.w	$760,$067,$670,$545
	dc.w	$777,$777,$777,$777
	dc.w	$740,$047,$470,$424
	dc.w	$631,$136,$361,$423
	dc.w	$621,$126,$251,$413
	dc.w	$522,$225,$252,$313
	dc.w	$513,$315,$153,$312
	dc.w	$413,$314,$143,$212
	dc.w	$403,$304,$043,$211
	dc.w	$302,$203,$032,$201
col2:
	dc.w	$201,$302,$203,$032
	dc.w	$211,$403,$304,$043
	dc.w	$212,$413,$314,$143
	dc.w	$312,$513,$315,$153
	dc.w	$313,$522,$225,$252
	dc.w	$413,$621,$126,$251
	dc.w	$423,$631,$136,$361
	dc.w	$424,$740,$047,$470
	dc.w	$777,$777,$777,$777
	dc.w	$545,$760,$067,$670
	dc.w	$534,$750,$057,$570
	dc.w	$545,$760,$067,$670
	dc.w	$534,$750,$057,$570
	dc.w	$545,$760,$067,$670
	dc.w	$534,$750,$057,$570
	dc.w	$424,$740,$047,$470
	dc.w	$534,$750,$057,$570
	dc.w	$424,$740,$047,$470
	dc.w	$423,$631,$136,$361
	dc.w	$424,$740,$047,$470
	dc.w	$423,$631,$136,$361
	dc.w	$424,$740,$047,$470
	dc.w	$423,$631,$136,$361
	dc.w	$413,$621,$126,$251
	dc.w	$423,$631,$136,$361
	dc.w	$413,$621,$126,$251
	dc.w	$423,$631,$136,$361
	dc.w	$413,$621,$126,$251
	dc.w	$423,$631,$136,$361
	dc.w	$413,$621,$126,$251
	dc.w	$423,$631,$136,$361
	dc.w	$413,$621,$126,$251
	dc.w	$423,$631,$136,$361
	dc.w	$413,$621,$126,$251
	dc.w	$423,$631,$136,$361
	dc.w	$424,$740,$047,$470
	dc.w	$423,$631,$136,$361
	dc.w	$424,$740,$047,$470
	dc.w	$423,$631,$136,$361
	dc.w	$424,$740,$047,$470
	dc.w	$423,$631,$136,$361
	dc.w	$424,$740,$047,$470
	dc.w	$534,$750,$057,$570
	dc.w	$424,$740,$047,$470
	dc.w	$534,$750,$057,$570
	dc.w	$545,$760,$067,$670
	dc.w	$757,$770,$077,$770
	dc.w	$545,$760,$067,$670
	dc.w	$757,$770,$077,$770
	dc.w	$777,$777,$777,$777
	dc.w	$757,$770,$077,$770
	dc.w	$545,$760,$067,$670
	dc.w	$757,$770,$077,$770
	dc.w	$545,$760,$067,$670
	dc.w	$757,$770,$077,$770
	dc.w	$545,$760,$067,$670
	dc.w	$757,$770,$077,$770
	dc.w	$777,$777,$777,$777
	dc.w	$757,$770,$077,$770
	dc.w	$545,$760,$067,$670
	dc.w	$757,$770,$077,$770
	dc.w	$545,$760,$067,$670
	dc.w	$534,$750,$057,$570
	dc.w	$424,$740,$047,$470
	dc.w	$534,$750,$057,$570
	dc.w	$424,$740,$047,$470
	dc.w	$534,$750,$057,$570
	dc.w	$424,$740,$047,$470
	dc.w	$534,$750,$057,$570
	dc.w	$424,$740,$047,$470
	dc.w	$534,$750,$057,$570
	dc.w	$424,$740,$047,$470
	dc.w	$534,$750,$057,$570
	dc.w	$424,$740,$047,$470
	dc.w	$534,$750,$057,$570
	dc.w	$424,$740,$047,$470
	dc.w	$534,$750,$057,$570
	dc.w	$545,$760,$067,$670
	dc.w	$534,$750,$057,$570
	dc.w	$545,$760,$067,$670
	dc.w	$534,$750,$057,$570
	dc.w	$545,$760,$067,$670
	dc.w	$777,$777,$777,$777
	dc.w	$424,$740,$047,$470
	dc.w	$423,$631,$136,$361
	dc.w	$413,$621,$126,$251
	dc.w	$313,$522,$225,$252
	dc.w	$312,$513,$315,$153
	dc.w	$212,$413,$314,$143
	dc.w	$211,$403,$304,$043
	dc.w	$201,$302,$203,$032
col3:
	dc.w	$032,$201,$302,$203
	dc.w	$043,$211,$403,$304
	dc.w	$143,$212,$413,$314
	dc.w	$153,$312,$513,$315
	dc.w	$252,$313,$522,$225
	dc.w	$251,$413,$621,$126
	dc.w	$361,$423,$631,$136
	dc.w	$470,$424,$740,$047
	dc.w	$777,$777,$777,$777
	dc.w	$670,$545,$760,$067
	dc.w	$570,$534,$750,$057
	dc.w	$670,$545,$760,$067
	dc.w	$570,$534,$750,$057
	dc.w	$670,$545,$760,$067
	dc.w	$570,$534,$750,$057
	dc.w	$470,$424,$740,$047
	dc.w	$570,$534,$750,$057
	dc.w	$470,$424,$740,$047
	dc.w	$361,$423,$631,$136
	dc.w	$470,$424,$740,$047
	dc.w	$361,$423,$631,$136
	dc.w	$470,$424,$740,$047
	dc.w	$361,$423,$631,$136
	dc.w	$251,$413,$621,$126
	dc.w	$361,$423,$631,$136
	dc.w	$251,$413,$621,$126
	dc.w	$361,$423,$631,$136
	dc.w	$251,$413,$621,$126
	dc.w	$361,$423,$631,$136
	dc.w	$251,$413,$621,$126
	dc.w	$361,$423,$631,$136
	dc.w	$251,$413,$621,$126
	dc.w	$361,$423,$631,$136
	dc.w	$251,$413,$621,$126
	dc.w	$361,$423,$631,$136
	dc.w	$470,$424,$740,$047
	dc.w	$361,$423,$631,$136
	dc.w	$470,$424,$740,$047
	dc.w	$361,$423,$631,$136
	dc.w	$470,$424,$740,$047
	dc.w	$361,$423,$631,$136
	dc.w	$470,$424,$740,$047
	dc.w	$570,$534,$750,$057
	dc.w	$470,$424,$740,$047
	dc.w	$570,$534,$750,$057
	dc.w	$670,$545,$760,$067
	dc.w	$770,$757,$770,$077
	dc.w	$670,$545,$760,$067
	dc.w	$770,$757,$770,$077
	dc.w	$777,$777,$777,$777
	dc.w	$770,$757,$770,$077
	dc.w	$670,$545,$760,$067
	dc.w	$770,$757,$770,$077
	dc.w	$670,$545,$760,$067
	dc.w	$770,$757,$770,$077
	dc.w	$670,$545,$760,$067
	dc.w	$770,$757,$770,$077
	dc.w	$777,$777,$777,$777
	dc.w	$770,$757,$770,$077
	dc.w	$670,$545,$760,$067
	dc.w	$770,$757,$770,$077
	dc.w	$670,$545,$760,$067
	dc.w	$570,$534,$750,$057
	dc.w	$470,$424,$740,$047
	dc.w	$570,$534,$750,$057
	dc.w	$470,$424,$740,$047
	dc.w	$570,$534,$750,$057
	dc.w	$470,$424,$740,$047
	dc.w	$570,$534,$750,$057
	dc.w	$470,$424,$740,$047
	dc.w	$570,$534,$750,$057
	dc.w	$470,$424,$740,$047
	dc.w	$570,$534,$750,$057
	dc.w	$470,$424,$740,$047
	dc.w	$570,$534,$750,$057
	dc.w	$470,$424,$740,$047
	dc.w	$570,$534,$750,$057
	dc.w	$670,$545,$760,$067
	dc.w	$570,$534,$750,$057
	dc.w	$670,$545,$760,$067
	dc.w	$570,$534,$750,$057
	dc.w	$670,$545,$760,$067
	dc.w	$777,$777,$777,$777
	dc.w	$470,$424,$740,$047
	dc.w	$361,$423,$631,$136
	dc.w	$251,$413,$621,$126
	dc.w	$252,$313,$522,$225
	dc.w	$153,$312,$513,$315
	dc.w	$143,$212,$413,$314
	dc.w	$043,$211,$403,$304
	dc.w	$032,$201,$302,$203
col4:
	dc.w	$203,$032,$201,$302
	dc.w	$304,$043,$211,$403
	dc.w	$314,$143,$212,$413
	dc.w	$315,$153,$312,$513
	dc.w	$225,$252,$313,$522
	dc.w	$126,$251,$413,$621
	dc.w	$136,$361,$423,$631
	dc.w	$047,$470,$424,$740
	dc.w	$777,$777,$777,$777
	dc.w	$067,$670,$545,$760
	dc.w	$057,$570,$534,$750
	dc.w	$067,$670,$545,$760
	dc.w	$057,$570,$534,$750
	dc.w	$067,$670,$545,$760
	dc.w	$057,$570,$534,$750
	dc.w	$047,$470,$424,$740
	dc.w	$057,$570,$534,$750
	dc.w	$047,$470,$424,$740
	dc.w	$136,$361,$423,$631
	dc.w	$047,$470,$424,$740
	dc.w	$136,$361,$423,$631
	dc.w	$047,$470,$424,$740
	dc.w	$136,$361,$423,$631
	dc.w	$126,$251,$413,$621
	dc.w	$136,$361,$423,$631
	dc.w	$126,$251,$413,$621
	dc.w	$136,$361,$423,$631
	dc.w	$126,$251,$413,$621
	dc.w	$136,$361,$423,$631
	dc.w	$126,$251,$413,$621
	dc.w	$136,$361,$423,$631
	dc.w	$126,$251,$413,$621
	dc.w	$136,$361,$423,$631
	dc.w	$126,$251,$413,$621
	dc.w	$136,$361,$423,$631
	dc.w	$047,$470,$424,$740
	dc.w	$136,$361,$423,$631
	dc.w	$047,$470,$424,$740
	dc.w	$136,$361,$423,$631
	dc.w	$047,$470,$424,$740
	dc.w	$136,$361,$423,$631
	dc.w	$047,$470,$424,$740
	dc.w	$057,$570,$534,$750
	dc.w	$047,$470,$424,$740
	dc.w	$057,$570,$534,$750
	dc.w	$067,$670,$545,$760
	dc.w	$077,$770,$757,$770
	dc.w	$067,$670,$545,$760
	dc.w	$077,$770,$757,$770
	dc.w	$777,$777,$777,$777
	dc.w	$077,$770,$757,$770
	dc.w	$067,$670,$545,$760
	dc.w	$077,$770,$757,$770
	dc.w	$067,$670,$545,$760
	dc.w	$077,$770,$757,$770
	dc.w	$067,$670,$545,$760
	dc.w	$077,$770,$757,$770
	dc.w	$777,$777,$777,$777
	dc.w	$077,$770,$757,$770
	dc.w	$067,$670,$545,$760
	dc.w	$077,$770,$757,$770
	dc.w	$067,$670,$545,$760
	dc.w	$057,$570,$534,$750
	dc.w	$047,$470,$424,$740
	dc.w	$057,$570,$534,$750
	dc.w	$047,$470,$424,$740
	dc.w	$057,$570,$534,$750
	dc.w	$047,$470,$424,$740
	dc.w	$057,$570,$534,$750
	dc.w	$047,$470,$424,$740
	dc.w	$057,$570,$534,$750
	dc.w	$047,$470,$424,$740
	dc.w	$057,$570,$534,$750
	dc.w	$047,$470,$424,$740
	dc.w	$057,$570,$534,$750
	dc.w	$047,$470,$424,$740
	dc.w	$057,$570,$534,$750
	dc.w	$067,$670,$545,$760
	dc.w	$057,$570,$534,$750
	dc.w	$067,$670,$545,$760
	dc.w	$057,$570,$534,$750
	dc.w	$067,$670,$545,$760
	dc.w	$777,$777,$777,$777
	dc.w	$047,$470,$424,$740
	dc.w	$136,$361,$423,$631
	dc.w	$126,$251,$413,$621
	dc.w	$225,$252,$313,$522
	dc.w	$315,$153,$312,$513
	dc.w	$314,$143,$212,$413
	dc.w	$304,$043,$211,$403
	dc.w	$203,$032,$201,$302
