	dc.w	140,0,139,16,187,16,184,0
	dc.w	139,16,149,76,173,76,187,16
	dc.w	149,76,149,123,173,123,173,76
	dc.w	149,123,139,182,187,182,173,123
	dc.w	139,182,140,199,184,199,187,182
	dc.l	-1,-1,-1,-1

	dc.w	132,0,129,16,177,16,176,0
	dc.w	129,16,144,76,168,76,177,16
	dc.w	144,76,144,123,168,123,168,76
	dc.w	144,123,129,182,177,182,168,123
	dc.w	129,182,132,199,176,199,177,182
	dc.l	-1,-1,-1,-1

	dc.w	123,0,119,16,167,16,167,0
	dc.w	119,16,139,76,163,76,167,16
	dc.w	139,76,139,123,163,123,163,76
	dc.w	139,123,119,182,167,182,163,123
	dc.w	119,182,123,199,167,199,167,182
	dc.l	-1,-1,-1,-1

	dc.w	114,0,109,16,157,16,158,0
	dc.w	109,16,134,76,158,76,157,16
	dc.w	134,76,134,123,158,123,158,76
	dc.w	134,123,109,182,157,182,158,123
	dc.w	109,182,114,199,158,199,157,182
	dc.l	-1,-1,-1,-1

	dc.w	106,0,99,16,147,16,150,0
	dc.w	99,16,129,76,153,76,147,16
	dc.w	129,76,129,123,153,123,153,76
	dc.w	129,123,99,182,147,182,153,123
	dc.w	99,182,106,199,150,199,147,182
	dc.l	-1,-1,-1,-1

	dc.w	97,0,89,16,137,16,141,0
	dc.w	89,16,124,76,148,76,137,16
	dc.w	124,76,124,123,148,123,148,76
	dc.w	124,123,89,182,137,182,148,123
	dc.w	89,182,97,199,141,199,137,182
	dc.l	-1,-1,-1,-1

	dc.w	88,0,79,16,127,16,132,0
	dc.w	79,16,119,76,143,76,127,16
	dc.w	119,76,119,123,143,123,143,76
	dc.w	119,123,79,182,127,182,143,123
	dc.w	79,182,88,199,132,199,127,182
	dc.l	-1,-1,-1,-1

	dc.w	80,0,70,16,118,16,124,0
	dc.w	70,16,114,76,138,76,118,16
	dc.w	114,76,114,123,138,123,138,76
	dc.w	114,123,70,182,118,182,138,123
	dc.w	70,182,80,199,124,199,118,182
	dc.l	-1,-1,-1,-1

	dc.w	71,0,60,16,108,16,115,0
	dc.w	60,16,109,76,133,76,108,16
	dc.w	109,76,109,123,133,123,133,76
	dc.w	109,123,60,182,108,182,133,123
	dc.w	60,182,71,199,115,199,108,182
	dc.l	-1,-1,-1,-1

	dc.w	62,0,50,16,98,16,106,0
	dc.w	50,16,104,76,128,76,98,16
	dc.w	104,76,104,123,128,123,128,76
	dc.w	104,123,50,182,98,182,128,123
	dc.w	50,182,62,199,106,199,98,182
	dc.l	-1,-1,-1,-1

	dc.w	54,0,40,16,88,16,98,0
	dc.w	40,16,99,76,123,76,88,16
	dc.w	99,76,99,123,123,123,123,76
	dc.w	99,123,40,182,88,182,123,123
	dc.w	40,182,54,199,98,199,88,182
	dc.l	-1,-1,-1,-1

	dc.w	45,0,30,16,78,16,89,0
	dc.w	30,16,94,76,118,76,78,16
	dc.w	94,76,94,123,118,123,118,76
	dc.w	94,123,30,182,78,182,118,123
	dc.w	30,182,45,199,89,199,78,182
	dc.l	-1,-1,-1,-1

	dc.w	36,0,20,16,68,16,80,0
	dc.w	20,16,89,76,113,76,68,16
	dc.w	89,76,89,123,113,123,113,76
	dc.w	89,123,20,182,68,182,113,123
	dc.w	20,182,36,199,80,199,68,182
	dc.l	-1,-1,-1,-1

	dc.w	27,0,10,16,58,16,71,0
	dc.w	10,16,84,76,108,76,58,16
	dc.w	84,76,84,123,108,123,108,76
	dc.w	84,123,10,182,58,182,108,123
	dc.w	10,182,27,199,71,199,58,182
	dc.l	-1,-1,-1,-1

	dc.w	19,0,0,16,48,16,63,0
	dc.w	0,16,79,76,103,76,48,16
	dc.w	79,76,79,123,103,123,103,76
	dc.w	79,123,0,182,48,182,103,123
	dc.w	0,182,19,199,63,199,48,182
	dc.l	-1,-1,-1,-1

	dc.w	10,0,0,8,46,8,54,0
	dc.w	0,8,0,16,38,16,46,8
	dc.w	0,16,0,23,45,23,38,16
	dc.w	0,23,74,76,98,76,45,23
	dc.w	74,76,74,123,98,123,98,76
	dc.w	74,123,0,175,45,175,98,123
	dc.w	0,175,0,182,38,182,45,175
	dc.w	0,182,0,191,46,191,38,182
	dc.w	0,191,10,199,54,199,46,191
	dc.l	-1,-1,-1,-1

	dc.w	1,0,0,1,44,1,45,0
	dc.w	0,1,0,16,28,16,44,1
	dc.w	0,16,0,29,42,29,28,16
	dc.w	0,29,69,76,93,76,42,29
	dc.w	69,76,69,123,93,123,93,76
	dc.w	69,123,0,169,42,169,93,123
	dc.w	0,169,0,182,28,182,42,169
	dc.w	0,182,0,198,44,198,28,182
	dc.w	0,198,1,199,45,199,44,198
	dc.l	-1,-1,-1,-1

	dc.w	0,0,0,16,18,16,37,0
	dc.w	0,16,0,35,40,35,18,16
	dc.w	0,35,64,76,88,76,40,35
	dc.w	64,76,64,123,88,123,88,76
	dc.w	64,123,0,163,41,163,88,123
	dc.w	0,163,0,182,18,182,41,163
	dc.w	0,182,0,199,37,199,18,182
	dc.l	-1,-1,-1,-1

	dc.w	0,0,0,16,8,16,28,0
	dc.w	0,16,0,40,38,40,8,16
	dc.w	0,40,59,76,83,76,38,40
	dc.w	59,76,59,123,83,123,83,76
	dc.w	59,123,0,158,39,158,83,123
	dc.w	0,158,0,182,8,182,39,158
	dc.w	0,182,0,199,28,199,8,182
	dc.l	-1,-1,-1,-1

	dc.w	0,0,0,14,0,14,19,0
	dc.w	0,14,0,18,1,18,0,14
	dc.w	0,18,0,45,37,45,1,18
	dc.w	0,45,54,76,78,76,37,45
	dc.w	54,76,54,123,78,123,78,76
	dc.w	54,123,0,154,36,154,78,123
	dc.w	0,154,0,181,0,181,36,154
	dc.w	0,181,0,184,1,184,0,181
	dc.w	0,184,0,199,19,199,1,184
	dc.l	-1,-1,-1,-1

	dc.w	0,0,0,8,0,8,11,0
;	dc.w	0,8,0,24,1,24,0,8
	dc.w	0,24,0,49,35,49,1,24
	dc.w	0,49,49,76,73,76,35,49
	dc.w	49,76,49,123,73,123,73,76
	dc.w	49,123,0,150,35,150,73,123
	dc.w	0,150,0,174,0,174,35,150
;	dc.w	0,174,0,191,1,191,0,174
	dc.w	0,191,0,199,11,199,1,191
	dc.l	-1,-1,-1,-1

	dc.w	0,0,0,1,0,1,2,0
;	dc.w	0,1,0,30,1,30,0,1
	dc.w	0,30,0,53,34,53,1,30
	dc.w	0,53,44,76,68,76,34,53
	dc.w	44,76,44,123,68,123,68,76
	dc.w	44,123,0,146,33,146,68,123
	dc.w	0,146,0,168,0,168,33,146
;	dc.w	0,168,0,198,1,198,0,168
	dc.w	0,198,0,199,2,199,1,198
	dc.l	-1,-1,-1,-1

	dc.w	0,36,0,56,32,56,1,36
	dc.w	0,56,39,76,63,76,32,56
	dc.w	39,76,39,123,63,123,63,76
	dc.w	39,123,0,143,31,143,63,123
	dc.w	0,143,0,163,0,163,31,143
	dc.l	-1,-1,-1,-1

	dc.w	0,41,0,59,30,59,1,41
	dc.w	0,59,34,76,58,76,30,59
	dc.w	34,76,34,123,58,123,58,76
	dc.w	34,123,0,139,31,139,58,123
	dc.w	0,139,0,158,0,158,31,139
	dc.l	-1,-1,-1,-1

	dc.w	0,45,0,62,29,62,1,45
	dc.w	0,62,29,76,53,76,29,62
	dc.w	29,76,29,123,53,123,53,76
	dc.w	29,123,0,136,30,136,53,123
	dc.w	0,136,0,153,0,153,30,136
	dc.l	-1,-1,-1,-1

	dc.w	0,50,0,65,28,65,1,50
	dc.w	0,65,24,76,48,76,28,65
	dc.w	24,76,24,123,48,123,48,76
	dc.w	24,123,0,134,28,134,48,123
	dc.w	0,134,0,149,0,149,28,134
	dc.l	-1,-1,-1,-1

	dc.w	0,53,0,68,28,68,1,53
	dc.w	0,68,19,76,43,76,28,68
	dc.w	19,76,19,123,43,123,43,76
	dc.w	19,123,0,131,28,131,43,123
	dc.w	0,131,0,145,0,145,28,131
	dc.l	-1,-1,-1,-1

	dc.w	0,57,0,70,26,70,1,57
	dc.w	0,70,14,76,38,76,26,70
	dc.w	14,76,14,123,38,123,38,76
	dc.w	14,123,0,129,26,129,38,123
	dc.w	0,129,0,142,0,142,26,129
	dc.l	-1,-1,-1,-1

	dc.w	0,60,0,72,25,72,1,60
	dc.w	0,72,9,76,33,76,25,72
	dc.w	9,76,9,123,33,123,33,76
	dc.w	9,123,0,127,25,127,33,123
	dc.w	0,127,0,139,0,139,25,127
	dc.l	-1,-1,-1,-1

	dc.w	0,63,0,74,24,74,1,63
	dc.w	0,74,4,76,28,76,24,74
	dc.w	4,76,4,123,28,123,28,76
	dc.w	4,123,0,125,24,125,28,123
	dc.w	0,125,0,136,0,136,24,125
	dc.l	-1,-1,-1,-1

	dc.w	0,66,0,76,23,76,1,66
	dc.w	0,76,0,123,23,123,23,76
	dc.w	0,123,0,133,0,133,23,123
	dc.l	-1,-1,-1,-1

	dc.w	0,68,0,76,18,76,1,68
	dc.w	0,76,0,123,18,123,18,76
	dc.w	0,123,0,131,0,131,18,123
	dc.l	-1,-1,-1,-1

	dc.w	0,71,0,76,13,76,1,71
	dc.w	0,76,0,123,13,123,13,76
	dc.w	0,123,0,128,0,128,13,123
	dc.l	-1,-1,-1,-1

	dc.w	0,73,0,76,8,76,1,73
	dc.w	0,76,0,123,8,123,8,76
	dc.w	0,123,0,126,0,126,8,123
	dc.l	-1,-1,-1,-1

	dc.w	0,75,0,76,3,76,1,75
	dc.w	0,76,0,123,3,123,3,76
	dc.w	0,123,0,124,0,124,3,123
	dc.l	-1,-1,-1,-1

