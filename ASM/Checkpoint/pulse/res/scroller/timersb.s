	dc.w	4
	dc.w	2
	dc.w	1
	dc.w	3
	dc.w	2
	dc.w	2
	dc.w	1
	dc.w	1
	dc.w	1
	dc.w	1
	dc.w	1
	dc.w	2
	dc.w	1
	dc.w	1
	dc.w	1
	dc.w	1
	dc.w	1
	dc.w	2
	dc.w	1
	dc.w	1
	dc.w	2
	dc.w	1
	dc.w	2
	dc.w	1
	dc.w	1
	dc.w	1
	dc.w	1
	dc.w	2
	dc.w	1
	dc.w	3
	dc.w	1
	dc.w	2
	dc.w	1
	dc.w	1
	dc.w	3
	dc.w	1
	dc.w	3
	dc.w	1
	dc.w	2
	dc.w	1
	dc.w	1
	dc.w	4
	dc.w	1
	dc.w	1
	dc.w	3
	dc.w	2
	dc.w	1
	dc.w	1
	dc.w	1
	dc.w	1
	dc.w	2
	dc.w	1
	dc.w	1
	dc.w	5
;	dc.w	0
	dc.w	1
	dc.w	1
	dc.w	2
	dc.w	1
	dc.w	1
	dc.w	1
	dc.w	1
	dc.w	2
	dc.w	3
	dc.w	1
	dc.w	1
	dc.w	2
	dc.w	1
	dc.w	3
	dc.w	1
	dc.w	24
	dc.w	1
	dc.w	3
	dc.w	1
	dc.w	2
	dc.w	1
	dc.w	1
	dc.w	1
	dc.w	1
	dc.w	1
	dc.w	2
	dc.w	1
	dc.w	2
	dc.w	1
	dc.w	2
	dc.w	1
	dc.w	1
	dc.w	2
	dc.w	2
	dc.w	2
	dc.w	2