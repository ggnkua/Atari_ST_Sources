	dc.w	318,76,318,123,319,123,319,76
	dc.l	-1,-1,-1,-1
	dc.w	318,74,313,76,319,76,319,74
	dc.w	313,76,313,123,319,123,319,76
	dc.w	313,123,319,125,319,125,319,123
	dc.l	-1,-1,-1,-1
	dc.w	318,71,308,76,319,76,319,71
	dc.w	308,76,308,123,319,123,319,76
	dc.w	308,123,319,127,319,127,319,123
	dc.l	-1,-1,-1,-1
	dc.w	318,69,303,76,319,76,319,69
	dc.w	303,76,303,123,319,123,319,76
	dc.w	303,123,319,130,319,130,319,123
	dc.l	-1,-1,-1,-1
	dc.w	318,67,298,76,319,76,319,67
	dc.w	298,76,298,123,319,123,319,76
	dc.w	298,123,319,132,319,132,319,123
	dc.l	-1,-1,-1,-1
	dc.w	318,64,295,75,319,75,319,64
	dc.w	295,75,293,76,317,76,319,75
	dc.w	293,76,293,123,317,123,317,76
	dc.w	293,123,295,124,319,124,317,123
	dc.w	295,124,319,135,319,135,319,124
	dc.l	-1,-1,-1,-1
	dc.w	318,61,294,73,319,73,319,61
	dc.w	294,73,288,76,312,76,319,73
	dc.w	288,76,288,123,312,123,312,76
	dc.w	288,123,294,126,319,126,312,123
	dc.w	294,126,319,138,319,138,319,126
	dc.l	-1,-1,-1,-1
	dc.w	318,58,293,71,319,71,319,58
	dc.w	293,71,283,76,307,76,319,71
	dc.w	283,76,283,123,307,123,307,76
	dc.w	283,123,293,128,319,128,307,123
	dc.w	293,128,319,141,319,141,319,128
	dc.l	-1,-1,-1,-1
	dc.w	318,55,292,69,319,69,319,55
	dc.w	292,69,278,76,302,76,319,69
	dc.w	278,76,278,123,302,123,302,76
	dc.w	278,123,292,130,319,130,302,123
	dc.w	292,130,319,144,319,144,319,130
	dc.l	-1,-1,-1,-1
	dc.w	318,51,291,66,319,66,319,51
	dc.w	291,66,273,76,297,76,319,66
	dc.w	273,76,273,123,297,123,297,76
	dc.w	273,123,292,133,319,133,297,123
	dc.w	292,133,319,147,319,147,319,133
	dc.l	-1,-1,-1,-1
	dc.w	318,47,289,64,319,64,319,47
	dc.w	289,64,268,76,292,76,319,64
	dc.w	268,76,268,123,292,123,292,76
	dc.w	268,123,290,135,319,135,292,123
	dc.w	290,135,319,151,319,151,319,135
	dc.l	-1,-1,-1,-1
	dc.w	318,43,288,61,319,61,319,43
	dc.w	288,61,263,76,287,76,319,61
	dc.w	263,76,263,123,287,123,287,76
	dc.w	263,123,289,138,319,138,287,123
	dc.w	289,138,319,156,319,156,319,138
	dc.l	-1,-1,-1,-1
	dc.w	318,38,287,58,319,58,319,38
	dc.w	287,58,258,76,282,76,319,58
	dc.w	258,76,258,123,282,123,282,76
	dc.w	258,123,287,141,319,141,282,123
	dc.w	287,141,319,160,319,160,319,141
	dc.l	-1,-1,-1,-1
	dc.w	318,32,286,54,319,54,319,32
	dc.w	286,54,253,76,277,76,319,54
	dc.w	253,76,253,123,277,123,277,76
	dc.w	253,123,287,145,319,145,277,123
	dc.w	287,145,319,166,319,166,319,145
	dc.l	-1,-1,-1,-1
	dc.w	312,0,319,5,319,5,319,0
;	dc.w	319,5,318,26,319,26,319,5
	dc.w	318,26,285,50,319,50,319,26
	dc.w	285,50,248,76,272,76,319,50
	dc.w	248,76,248,123,272,123,272,76
	dc.w	248,123,284,148,319,148,272,123
	dc.w	284,148,319,172,319,172,319,148
;	dc.w	319,172,318,194,319,194,319,172
	dc.w	318,194,312,199,319,199,319,194
	dc.l	-1,-1,-1,-1
	dc.w	303,0,319,12,319,12,319,0
;	dc.w	319,12,318,20,319,20,319,12
	dc.w	318,20,283,47,319,47,319,20
	dc.w	283,47,243,76,267,76,319,47
	dc.w	243,76,243,123,267,123,267,76
	dc.w	243,123,283,152,319,152,267,123
	dc.w	283,152,319,178,319,178,319,152
;	dc.w	319,178,318,187,319,187,319,178
	dc.w	318,187,303,199,319,199,319,187
	dc.l	-1,-1,-1,-1
	dc.w	294,0,315,16,319,16,319,0
	dc.w	315,16,282,42,319,42,319,16
	dc.w	282,42,238,76,262,76,319,42
	dc.w	238,76,238,123,262,123,262,76
	dc.w	238,123,281,156,319,156,262,123
	dc.w	281,156,315,182,319,182,319,156
	dc.w	315,182,294,199,319,199,319,182
	dc.l	-1,-1,-1,-1
	dc.w	286,0,305,16,319,16,319,0
	dc.w	305,16,280,37,319,37,319,16
	dc.w	280,37,233,76,257,76,319,37
	dc.w	233,76,233,123,257,123,257,76
	dc.w	233,123,279,161,319,161,257,123
	dc.w	279,161,305,182,319,182,319,161
	dc.w	305,182,286,199,319,199,319,182
	dc.l	-1,-1,-1,-1
	dc.w	277,0,295,16,319,16,319,0
	dc.w	295,16,277,32,319,32,319,16
	dc.w	277,32,228,76,252,76,319,32
	dc.w	228,76,228,123,252,123,252,76
	dc.w	228,123,277,166,319,166,252,123
	dc.w	277,166,295,182,319,182,319,166
	dc.w	295,182,277,199,319,199,319,182
	dc.l	-1,-1,-1,-1
	dc.w	268,0,273,5,319,5,312,0
	dc.w	273,5,285,16,319,16,319,5
	dc.w	285,16,275,26,319,26,319,16
	dc.w	275,26,223,76,247,76,319,26
	dc.w	223,76,223,123,247,123,247,76
	dc.w	223,123,274,172,319,172,247,123
	dc.w	274,172,285,182,319,182,319,172
	dc.w	285,182,274,193,319,193,319,182
	dc.w	274,193,268,199,312,199,319,193
	dc.l	-1,-1,-1,-1
	dc.w	260,0,272,13,319,13,304,0
	dc.w	272,13,275,16,319,16,319,13
	dc.w	275,16,272,19,319,19,319,16
	dc.w	272,19,218,76,242,76,319,19
	dc.w	218,76,218,123,242,123,242,76
	dc.w	218,123,272,179,319,179,242,123
	dc.w	272,179,275,182,319,182,319,179
	dc.w	275,182,271,186,319,186,319,182
	dc.w	271,186,260,199,304,199,319,186
	dc.l	-1,-1,-1,-1
	dc.w	251,0,265,16,313,16,295,0
	dc.w	265,16,213,76,237,76,313,16
	dc.w	213,76,213,123,237,123,237,76
	dc.w	213,123,265,182,313,182,237,123
	dc.w	265,182,251,199,295,199,313,182
	dc.l	-1,-1,-1,-1
	dc.w	242,0,255,16,303,16,286,0
	dc.w	255,16,208,76,232,76,303,16
	dc.w	208,76,208,123,232,123,232,76
	dc.w	208,123,255,182,303,182,232,123
	dc.w	255,182,242,199,286,199,303,182
	dc.l	-1,-1,-1,-1
	dc.w	234,0,245,16,293,16,278,0
	dc.w	245,16,203,76,227,76,293,16
	dc.w	203,76,203,123,227,123,227,76
	dc.w	203,123,245,182,293,182,227,123
	dc.w	245,182,234,199,278,199,293,182
	dc.l	-1,-1,-1,-1
	dc.w	225,0,235,16,283,16,269,0
	dc.w	235,16,198,76,222,76,283,16
	dc.w	198,76,198,123,222,123,222,76
	dc.w	198,123,235,182,283,182,222,123
	dc.w	235,182,225,199,269,199,283,182
	dc.l	-1,-1,-1,-1
	dc.w	216,0,225,16,273,16,260,0
	dc.w	225,16,193,76,217,76,273,16
	dc.w	193,76,193,123,217,123,217,76
	dc.w	193,123,225,182,273,182,217,123
	dc.w	225,182,216,199,260,199,273,182
	dc.l	-1,-1,-1,-1
	dc.w	208,0,215,16,263,16,252,0
	dc.w	215,16,188,76,212,76,263,16
	dc.w	188,76,188,123,212,123,212,76
	dc.w	188,123,215,182,263,182,212,123
	dc.w	215,182,208,199,252,199,263,182
	dc.l	-1,-1,-1,-1
	dc.w	199,0,205,16,253,16,243,0
	dc.w	205,16,183,76,207,76,253,16
	dc.w	183,76,183,123,207,123,207,76
	dc.w	183,123,205,182,253,182,207,123
	dc.w	205,182,199,199,243,199,253,182
	dc.l	-1,-1,-1,-1
	dc.w	190,0,196,16,244,16,234,0
	dc.w	196,16,178,76,202,76,244,16
	dc.w	178,76,178,123,202,123,202,76
	dc.w	178,123,196,182,244,182,202,123
	dc.w	196,182,190,199,234,199,244,182
	dc.l	-1,-1,-1,-1
	dc.w	181,0,186,16,234,16,225,0
	dc.w	186,16,173,76,197,76,234,16
	dc.w	173,76,173,123,197,123,197,76
	dc.w	173,123,186,182,234,182,197,123
	dc.w	186,182,181,199,225,199,234,182
	dc.l	-1,-1,-1,-1
	dc.w	173,0,176,16,224,16,217,0
	dc.w	176,16,168,76,192,76,224,16
	dc.w	168,76,168,123,192,123,192,76
	dc.w	168,123,176,182,224,182,192,123
	dc.w	176,182,173,199,217,199,224,182
	dc.l	-1,-1,-1,-1
	dc.w	164,0,166,16,214,16,208,0
	dc.w	166,16,163,76,187,76,214,16
	dc.w	163,76,163,123,187,123,187,76
	dc.w	163,123,166,182,214,182,187,123
	dc.w	166,182,164,199,208,199,214,182
	dc.l	-1,-1,-1,-1
	dc.w	155,0,156,16,204,16,199,0
	dc.w	156,16,158,76,182,76,204,16
	dc.w	158,76,158,123,182,123,182,76
	dc.w	158,123,156,182,204,182,182,123
	dc.w	156,182,155,199,199,199,204,182
	dc.l	-1,-1,-1,-1
	dc.w	147,0,146,16,194,16,191,0
	dc.w	146,16,153,76,177,76,194,16
	dc.w	153,76,153,123,177,123,177,76
	dc.w	153,123,146,182,194,182,177,123
	dc.w	146,182,147,199,191,199,194,182
	dc.l	-1,-1,-1,-1
