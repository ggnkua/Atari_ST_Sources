	dc.w	9600,1548	;387,60,0
	dc.w	13120,1860	;465,82,1
	dc.w	5600,1852	;463,35,2
	dc.w	29920,1792	;448,187,3
	dc.w	17440,1352	;338,109,4
	dc.w	26400,1720	;430,165,5
	dc.w	22720,1756	;439,142,6
	dc.w	12480,1844	;461,78,7
	dc.w	8480,2316	;579,53,8
	dc.w	24480,1812	;453,153,9
	dc.w	2560,1904	;476,16,10
	dc.w	320,2412	;603,2,11
	dc.w	13120,1748	;437,82,12
	dc.w	18880,2020	;505,118,13
	dc.w	20160,2016	;504,126,14
	dc.w	23040,2352	;588,144,15
	dc.w	26080,1496	;374,163,16
	dc.w	13440,1344	;336,84,17
	dc.w	19520,1736	;434,122,18
	dc.w	13440,1520	;380,84,19
	dc.w	12000,1616	;404,75,20
	dc.w	16480,1440	;360,103,21
	dc.w	20320,2324	;581,127,22
	dc.w	17760,2316	;579,111,23
	dc.w	26080,1700	;425,163,24
	dc.w	11040,2312	;578,69,25
	dc.w	27200,1728	;432,170,26
	dc.w	28640,1628	;407,179,27
	dc.w	23520,1880	;470,147,28
	dc.w	28640,1744	;436,179,29
	dc.w	4000,2016	;504,25,30
	dc.w	9920,2364	;591,62,31
	dc.w	30400,1756	;439,190,32
	dc.w	3360,1748	;437,21,33
	dc.w	17600,1864	;466,110,34
	dc.w	2240,1960	;490,14,35
	dc.w	8640,2400	;600,54,36
	dc.w	4320,1540	;385,27,37
	dc.w	25760,1848	;462,161,38
	dc.w	16960,2112	;528,106,39
	dc.w	10400,2300	;575,65,40
	dc.w	19680,1980	;495,123,41
	dc.w	3680,1876	;469,23,42
	dc.w	160,1608	;402,1,43
	dc.w	3840,1688	;422,24,44
	dc.w	6400,2304	;576,40,45
	dc.w	1920,1512	;378,12,46
	dc.w	8960,1524	;381,56,47
	dc.w	16960,2240	;560,106,48
	dc.w	20800,1524	;381,130,49
	dc.w	28960,1592	;398,181,50
	dc.w	14080,2308	;577,88,51
	dc.w	11680,2020	;505,73,52
	dc.w	22560,2244	;561,141,53
	dc.w	5120,1804	;451,32,54
	dc.w	5280,1408	;352,33,55
	dc.w	1440,2164	;541,9,56
	dc.w	22080,1524	;381,138,57
	dc.w	8320,2096	;524,52,58
	dc.w	13280,1760	;440,83,59
	dc.w	800,2008	;502,5,60
	dc.w	2720,2176	;544,17,61
	dc.w	18080,1620	;405,113,62
	dc.w	12960,2320	;580,81,63
	dc.w	15360,1688	;422,96,64
	dc.w	4640,2340	;585,29,65
	dc.w	7040,1896	;474,44,66
	dc.w	17920,2348	;587,112,67
	dc.w	11360,2124	;531,71,68
	dc.w	16800,2188	;547,105,69
	dc.w	9280,1860	;465,58,70
	dc.w	18560,1944	;486,116,71
	dc.w	5920,1348	;337,37,72
	dc.w	30080,1572	;393,188,73
	dc.w	19840,1596	;399,124,74
	dc.w	12640,2204	;551,79,75
	dc.w	6720,1852	;463,42,76
	dc.w	6240,1920	;480,39,77
	dc.w	4160,2160	;540,26,78
	dc.w	22240,1876	;469,139,79
	dc.w	2080,1372	;343,13,80
	dc.w	6720,1692	;423,42,81
	dc.w	28160,2292	;573,176,82
	dc.w	2400,2236	;559,15,83
	dc.w	3040,2092	;523,19,84
	dc.w	12800,1452	;363,80,85
	dc.w	27840,2380	;595,174,86
	dc.w	25920,1440	;360,162,87
	dc.w	480,2020	;505,3,88
	dc.w	2080,1504	;376,13,89
	dc.w	6560,2248	;562,41,90
	dc.w	2880,2100	;525,18,91
	dc.w	23360,1856	;464,146,92
	dc.w	20480,1408	;352,128,93
	dc.w	25120,2180	;545,157,94
	dc.w	15680,2256	;564,98,95
	dc.w	23200,1912	;478,145,96
	dc.w	31040,1808	;452,194,97
	dc.w	14400,1388	;347,90,98
	dc.w	26880,1608	;402,168,99
	dc.w	13600,2352	;588,85,100
	dc.w	3200,2084	;521,20,101
	dc.w	23680,2148	;537,148,102
	dc.w	11200,1840	;460,70,103
	dc.w	8160,1860	;465,51,104
	dc.w	18400,2148	;537,115,105
	dc.w	10720,1496	;374,67,106
	dc.w	21600,2160	;540,135,107
	dc.w	28320,2044	;511,177,108
	dc.w	10880,2092	;523,68,109
	dc.w	24800,1548	;387,155,110
	dc.w	28800,1592	;398,180,111
	dc.w	31040,1716	;429,194,112
	dc.w	13760,1816	;454,86,113
	dc.w	27040,2092	;523,169,114
	dc.w	13600,1828	;457,85,115
	dc.w	27680,1960	;490,173,116
	dc.w	25440,2352	;588,159,117
	dc.w	8000,1948	;487,50,118
	dc.w	24160,1532	;383,151,119
	dc.w	19360,1928	;482,121,120
	dc.w	24000,1876	;469,150,121
	dc.w	14560,2056	;514,91,122
	dc.w	1760,2144	;536,11,123
	dc.w	5760,1508	;377,36,124
	dc.w	1120,2256	;564,7,125
	dc.w	31360,1844	;461,196,126
	dc.w	9760,2264	;566,61,127
	dc.w	9440,2064	;516,59,128
	dc.w	31200,1532	;383,195,129
	dc.w	21440,2244	;561,134,130
	dc.w	28480,1508	;377,178,131
	dc.w	9440,1704	;426,59,132
	dc.w	23840,1748	;437,149,133
	dc.w	19040,2296	;574,119,134
	dc.w	17120,1768	;442,107,135
	dc.w	6080,1568	;392,38,136
	dc.w	960,1776	;444,6,137
	dc.w	20640,2248	;562,129,138
	dc.w	7200,2020	;505,45,139
	dc.w	640,1992	;498,4,140
	dc.w	11840,2092	;523,74,141
	dc.w	14240,2176	;544,89,142
	dc.w	29600,1584	;396,185,143
	dc.w	20640,2008	;502,129,144
	dc.w	1600,2128	;532,10,145
	dc.w	12160,1980	;495,76,146
	dc.w	25600,1520	;380,160,147
	dc.w	31200,1832	;458,195,148
	dc.w	960,2220	;555,6,149
	dc.w	7520,2240	;560,47,150
	dc.w	13920,1940	;485,87,151
	dc.w	20960,1436	;359,131,152
	dc.w	25280,1968	;492,158,153
	dc.w	7360,1912	;478,46,154
	dc.w	30720,2232	;558,192,155
	dc.w	21120,1928	;482,132,156
	dc.w	26720,2136	;534,167,157
	dc.w	26240,2284	;571,164,158
	dc.w	13920,1396	;349,87,159
	dc.w	16160,2092	;523,101,160
	dc.w	15520,1416	;354,97,161
	dc.w	7840,1508	;377,49,162
	dc.w	21760,1484	;371,136,163
	dc.w	30240,1536	;384,189,164
	dc.w	30240,2308	;577,189,165
	dc.w	16160,2276	;569,101,166
	dc.w	16160,1700	;425,101,167
	dc.w	30240,2172	;543,189,168
	dc.w	14720,1852	;463,92,169
	dc.w	21280,1520	;380,133,170
	dc.w	16320,2076	;519,102,171
	dc.w	20000,2256	;564,125,172
	dc.w	13920,2016	;504,87,173
	dc.w	7520,1396	;349,47,174
	dc.w	29760,1772	;443,186,175
	dc.w	29280,1808	;452,183,176
	dc.w	18720,1988	;497,117,177
	dc.w	16160,1380	;345,101,178
	dc.w	16320,1476	;369,102,179
	dc.w	4960,1380	;345,31,180
	dc.w	11520,1852	;463,72,181
	dc.w	16640,2344	;586,104,182
	dc.w	5440,1848	;462,34,183
	dc.w	8800,1924	;481,55,184
	dc.w	24320,1948	;487,152,185
	dc.w	29120,1712	;428,182,186
	dc.w	24960,1464	;366,156,187
	dc.w	24320,1712	;428,152,188
	dc.w	31520,2052	;513,197,189
	dc.w	16640,1556	;389,104,190
	dc.w	24640,1884	;471,154,191
	dc.w	30560,1404	;351,191,192
	dc.w	5440,2228	;557,34,193
	dc.w	4960,2328	;582,31,194
	dc.w	4800,1968	;492,30,195
	dc.w	0,2176	;544,0,196
	dc.w	10560,2368	;592,66,197
	dc.w	15200,1804	;451,95,198
	dc.w	22880,1548	;387,143,199
	dc.w	5440,1532	;383,34,200
	dc.w	0,1584	;396,0,201
	dc.w	29120,2124	;531,182,202
	dc.w	17280,2112	;528,108,203
	dc.w	24320,2212	;553,152,204
	dc.w	21920,2212	;553,137,205
	dc.w	17280,1408	;352,108,206
	dc.w	19200,2068	;517,120,207
	dc.w	31520,1476	;369,197,208
	dc.w	22400,1524	;381,140,209
