	dc.w 0,18560
	dc.w 4,18560
	dc.w 8,18560
	dc.w 12,18560
	dc.w 16,18560
	dc.w 20,18560
	dc.w 24,18560
	dc.w 28,18560
	dc.w 32,18560
	dc.w 36,18560
	dc.w 40,18560
	dc.w 44,18560
	dc.w 48,18560
	dc.w 52,18560
	dc.w 56,18560
	dc.w 60,18560
	dc.w 64,18560
	dc.w 68,18560
	dc.w 72,18560
	dc.w 76,18560
	dc.w 80,18560
	dc.w 84,18560
	dc.w 88,18560
	dc.w 92,18560
	dc.w 96,18560
	dc.w 100,18560
	dc.w 104,18400
	dc.w 104,18240
	dc.w 104,18080
	dc.w 104,17920
	dc.w 108,17760
	dc.w 108,17600
	dc.w 108,17440
	dc.w 112,17280
	dc.w 112,17120
	dc.w 112,16960
	dc.w 116,16800
	dc.w 116,16640
	dc.w 120,16480
	dc.w 120,16320
	dc.w 124,16160
	dc.w 128,16000
	dc.w 132,16000
	dc.w 136,16160
	dc.w 140,16320
	dc.w 140,16480
	dc.w 144,16640
	dc.w 144,16800
	dc.w 144,16960
	dc.w 148,17120
	dc.w 148,17280
	dc.w 148,17440
	dc.w 152,17600
	dc.w 152,17760
	dc.w 152,17920
	dc.w 156,18080
	dc.w 156,18240
	dc.w 160,18400
	dc.w 164,18560
	dc.w 168,18400
	dc.w 172,18240
	dc.w 172,18080
	dc.w 176,17920
	dc.w 176,17760
	dc.w 176,17600
	dc.w 180,17440
	dc.w 180,17280
	dc.w 180,17120
	dc.w 180,16960
	dc.w 180,16800
	dc.w 184,16640
	dc.w 184,16480
	dc.w 184,16320
	dc.w 184,16160
	dc.w 184,16000
	dc.w 184,15840
	dc.w 188,15680
	dc.w 188,15520
	dc.w 188,15360
	dc.w 188,15200
	dc.w 188,15040
	dc.w 188,14880
	dc.w 188,14720
	dc.w 192,14560
	dc.w 192,14400
	dc.w 192,14240
	dc.w 192,14080
	dc.w 192,13920
	dc.w 192,13760
	dc.w 192,13600
	dc.w 192,13440
	dc.w 192,13280
	dc.w 196,13120
	dc.w 196,12960
	dc.w 196,12800
	dc.w 196,12640
	dc.w 196,12480
	dc.w 196,12320
	dc.w 196,12160
	dc.w 196,12000
	dc.w 196,11840
	dc.w 196,11680
	dc.w 196,11520
	dc.w 200,11360
	dc.w 200,11200
	dc.w 200,11040
	dc.w 200,10880
	dc.w 200,10720
	dc.w 200,10560
	dc.w 200,10400
	dc.w 200,10240
	dc.w 200,10080
	dc.w 200,9920
	dc.w 200,9760
	dc.w 200,9600
	dc.w 200,9440
	dc.w 204,9280
	dc.w 204,9120
	dc.w 204,8960
	dc.w 204,8800
	dc.w 204,8640
	dc.w 204,8480
	dc.w 204,8320
	dc.w 204,8160
	dc.w 204,8000
	dc.w 204,7840
	dc.w 204,7680
	dc.w 204,7520
	dc.w 204,7360
	dc.w 204,7200
	dc.w 208,7040
	dc.w 208,6880
	dc.w 208,6720
	dc.w 208,6560
	dc.w 208,6400
	dc.w 208,6240
	dc.w 208,6080
	dc.w 208,5920
	dc.w 208,5760
	dc.w 208,5600
	dc.w 208,5440
	dc.w 208,5280
	dc.w 208,5120
	dc.w 208,4960
	dc.w 208,4800
	dc.w 212,4640
	dc.w 212,4480
	dc.w 212,4320
	dc.w 212,4160
	dc.w 212,4000
	dc.w 212,3840
	dc.w 212,3680
	dc.w 212,3520
	dc.w 212,3360
	dc.w 212,3200
	dc.w 212,3040
	dc.w 212,2880
	dc.w 212,2720
	dc.w 212,2560
	dc.w 216,2400
	dc.w 216,2240
	dc.w 216,2080
	dc.w 216,1920
	dc.w 216,1760
	dc.w 216,1600
	dc.w 216,1440
	dc.w 216,1280
	dc.w 216,1120
	dc.w 216,960
	dc.w 216,800
	dc.w 220,640
	dc.w 220,480
	dc.w 220,320
	dc.w 220,160
	dc.w 224,0
	dc.w 228,160
	dc.w 228,320
	dc.w 228,480
	dc.w 228,640
	dc.w 232,800
	dc.w 232,960
	dc.w 232,1120
	dc.w 232,1280
	dc.w 232,1440
	dc.w 232,1600
	dc.w 232,1760
	dc.w 232,1920
	dc.w 232,2080
	dc.w 232,2240
	dc.w 232,2400
	dc.w 232,2560
	dc.w 232,2720
	dc.w 232,2880
	dc.w 236,3040
	dc.w 236,3200
	dc.w 236,3360
	dc.w 236,3520
	dc.w 236,3680
	dc.w 236,3840
	dc.w 236,4000
	dc.w 236,4160
	dc.w 236,4320
	dc.w 236,4480
	dc.w 236,4640
	dc.w 236,4800
	dc.w 236,4960
	dc.w 236,5120
	dc.w 236,5280
	dc.w 236,5440
	dc.w 236,5600
	dc.w 236,5760
	dc.w 236,5920
	dc.w 236,6080
	dc.w 240,6240
	dc.w 240,6400
	dc.w 240,6560
	dc.w 240,6720
	dc.w 240,6880
	dc.w 240,7040
	dc.w 240,7200
	dc.w 240,7360
	dc.w 240,7520
	dc.w 240,7680
	dc.w 240,7840
	dc.w 240,8000
	dc.w 240,8160
	dc.w 240,8320
	dc.w 240,8480
	dc.w 240,8640
	dc.w 240,8800
	dc.w 240,8960
	dc.w 240,9120
	dc.w 240,9280
	dc.w 240,9440
	dc.w 240,9600
	dc.w 240,9760
	dc.w 240,9920
	dc.w 240,10080
	dc.w 240,10240
	dc.w 244,10400
	dc.w 244,10560
	dc.w 244,10720
	dc.w 244,10880
	dc.w 244,11040
	dc.w 244,11200
	dc.w 244,11360
	dc.w 244,11520
	dc.w 244,11680
	dc.w 244,11840
	dc.w 244,12000
	dc.w 244,12160
	dc.w 244,12320
	dc.w 244,12480
	dc.w 244,12640
	dc.w 244,12800
	dc.w 244,12960
	dc.w 244,13120
	dc.w 244,13280
	dc.w 244,13440
	dc.w 244,13600
	dc.w 244,13760
	dc.w 244,13920
	dc.w 244,14080
	dc.w 244,14240
	dc.w 244,14400
	dc.w 244,14560
	dc.w 244,14720
	dc.w 244,14880
	dc.w 244,15040
	dc.w 248,15200
	dc.w 248,15360
	dc.w 248,15520
	dc.w 248,15680
	dc.w 248,15840
	dc.w 248,16000
	dc.w 248,16160
	dc.w 248,16320
	dc.w 248,16480
	dc.w 248,16640
	dc.w 248,16800
	dc.w 248,16960
	dc.w 248,17120
	dc.w 248,17280
	dc.w 248,17440
	dc.w 248,17600
	dc.w 248,17760
	dc.w 248,17920
	dc.w 248,18080
	dc.w 248,18240
	dc.w 248,18400
	dc.w 248,18560
	dc.w 248,18720
	dc.w 248,18880
	dc.w 248,19040
	dc.w 248,19200
	dc.w 248,19360
	dc.w 248,19520
	dc.w 252,19680
	dc.w 252,19840
	dc.w 252,20000
	dc.w 252,20160
	dc.w 252,20320
	dc.w 252,20480
	dc.w 252,20640
	dc.w 252,20800
	dc.w 252,20960
	dc.w 252,21120
	dc.w 252,21280
	dc.w 252,21440
	dc.w 252,21600
	dc.w 252,21760
	dc.w 252,21920
	dc.w 252,22080
	dc.w 252,22240
	dc.w 256,22400
	dc.w 256,22560
	dc.w 256,22720
	dc.w 256,22880
	dc.w 256,23040
	dc.w 256,23200
	dc.w 256,23360
	dc.w 256,23520
	dc.w 256,23680
	dc.w 256,23840
	dc.w 256,24000
	dc.w 256,24160
	dc.w 256,24320
	dc.w 260,24480
	dc.w 260,24640
	dc.w 260,24800
	dc.w 260,24960
	dc.w 260,25120
	dc.w 260,25280
	dc.w 260,25440
	dc.w 260,25600
	dc.w 264,25760
	dc.w 264,25920
	dc.w 264,26080
	dc.w 264,26240
	dc.w 264,26400
	dc.w 264,26560
	dc.w 264,26720
	dc.w 264,26880
	dc.w 268,27040
	dc.w 272,27040
	dc.w 276,26880
	dc.w 276,26720
	dc.w 276,26560
	dc.w 276,26400
	dc.w 276,26240
	dc.w 276,26080
	dc.w 276,25920
	dc.w 276,25760
	dc.w 276,25600
	dc.w 276,25440
	dc.w 280,25280
	dc.w 280,25120
	dc.w 280,24960
	dc.w 280,24800
	dc.w 280,24640
	dc.w 280,24480
	dc.w 280,24320
	dc.w 284,24160
	dc.w 284,24000
	dc.w 284,23840
	dc.w 284,23680
	dc.w 284,23520
	dc.w 284,23360
	dc.w 284,23200
	dc.w 284,23040
	dc.w 284,22880
	dc.w 288,22720
	dc.w 288,22560
	dc.w 288,22400
	dc.w 288,22240
	dc.w 288,22080
	dc.w 288,21920
	dc.w 288,21760
	dc.w 288,21600
	dc.w 288,21440
	dc.w 288,21280
	dc.w 288,21120
	dc.w 292,20960
	dc.w 292,20800
	dc.w 292,20640
	dc.w 292,20480
	dc.w 292,20320
	dc.w 292,20160
	dc.w 292,20000
	dc.w 292,19840
	dc.w 292,19680
	dc.w 292,19520
	dc.w 292,19360
	dc.w 292,19200
	dc.w 296,19040
	dc.w 296,18880
	dc.w 296,18720
	dc.w 296,18560
	dc.w 296,18400
	dc.w 296,18240
	dc.w 296,18080
	dc.w 296,17920
	dc.w 300,17760
	dc.w 300,17600
	dc.w 300,17440
	dc.w 300,17280
	dc.w 304,17120
	dc.w 308,16960
	dc.w 312,16960
	dc.w 316,17120
	dc.w 320,17280
	dc.w 320,17440
	dc.w 320,17600
	dc.w 320,17760
	dc.w 320,17920
	dc.w 320,18080
	dc.w 324,18240
	dc.w 324,18400
	dc.w 328,18560
	dc.w 332,18400
	dc.w 332,18240
	dc.w 332,18080
	dc.w 332,17920
	dc.w 332,17760
	dc.w 332,17600
	dc.w 332,17440
	dc.w 332,17280
	dc.w 332,17120
	dc.w 332,16960
	dc.w 332,16800
	dc.w 332,16640
	dc.w 332,16480
	dc.w 332,16320
	dc.w 332,16160
	dc.w 332,16000
	dc.w 332,15840
	dc.w 332,15680
	dc.w 336,15520
	dc.w 336,15360
	dc.w 336,15200
	dc.w 336,15040
	dc.w 336,14880
	dc.w 336,14720
	dc.w 336,14560
	dc.w 340,14400
	dc.w 340,14240
	dc.w 340,14080
	dc.w 340,13920
	dc.w 340,13760
	dc.w 340,13600
	dc.w 344,13440
	dc.w 344,13280
	dc.w 344,13120
	dc.w 344,12960
	dc.w 344,12800
	dc.w 348,12640
	dc.w 348,12480
	dc.w 348,12320
	dc.w 348,12160
	dc.w 352,12000
	dc.w 352,11840
	dc.w 352,11680
	dc.w 356,11520
	dc.w 360,11360
	dc.w 364,11360
	dc.w 368,11520
	dc.w 372,11680
	dc.w 372,11840
	dc.w 372,12000
	dc.w 376,12160
	dc.w 376,12320
	dc.w 376,12480
	dc.w 380,12640
	dc.w 380,12800
	dc.w 380,12960
	dc.w 384,13120
	dc.w 384,13280
	dc.w 384,13440
	dc.w 384,13600
	dc.w 388,13760
	dc.w 388,13920
	dc.w 388,14080
	dc.w 388,14240
	dc.w 388,14400
	dc.w 392,14560
	dc.w 392,14720
	dc.w 392,14880
	dc.w 392,15040
	dc.w 392,15200
	dc.w 396,15360
	dc.w 396,15520
	dc.w 396,15680
	dc.w 396,15840
	dc.w 400,16000
	dc.w 400,16160
	dc.w 400,16320
	dc.w 400,16480
	dc.w 400,16640
	dc.w 404,16800
	dc.w 404,16960
	dc.w 404,17120
	dc.w 404,17280
	dc.w 404,17440
	dc.w 404,17600
	dc.w 408,17760
	dc.w 408,17920
	dc.w 408,18080
	dc.w 408,18240
	dc.w 408,18400
	dc.w 412,18560
	dc.w 416,18400
	dc.w 416,18240
	dc.w 420,18080
	dc.w 424,17920
	dc.w 424,17760
	dc.w 424,17600
	dc.w 428,17440
	dc.w 432,17280
	dc.w 436,17280
	dc.w 440,17280
	dc.w 444,17280
	dc.w 448,17440
	dc.w 448,17600
	dc.w 452,17760
	dc.w 456,17920
	dc.w 460,18080
	dc.w 464,18240
	dc.w 464,18400
	dc.w 468,18560
	dc.w 472,18560
	dc.w 476,18560
	dc.w 480,18560
	dc.w 484,18560
	dc.w 488,18560
	dc.w 492,18560
	dc.w 496,18560
	dc.w 500,18560
	dc.w 504,18560
	dc.w 508,18560
	dc.w 512,18560
	dc.w 516,18560
	dc.w 520,18560
	dc.w 524,18560
	dc.w 528,18560
	dc.w 532,18560
	dc.w 536,18560
	dc.w 540,18560
	dc.w 544,18560
	dc.w 548,18560
	dc.w 552,18560
	dc.w 556,18560
	dc.w 560,18560
	dc.w 564,18560
	dc.w 568,18560
	dc.w 572,18560
	dc.w 576,18560
	dc.w 580,18560
	dc.w 584,18560
	dc.w 588,18560
	dc.w 592,18560
	dc.w 596,18560
	dc.w 600,18560
	dc.w 604,18560
	dc.w 608,18560
	dc.w 612,18560
	dc.w 616,18560
	dc.w 620,18560
	dc.w 624,18560
	dc.w 628,18560
	dc.w 632,18560
	dc.w 636,18560
	dc.w 640,18560
	dc.w 644,18560
	dc.w 648,18560
	dc.w 652,18560
	dc.w 656,18560
	dc.w 660,18560
	dc.w 664,18560
	dc.w 668,18560
	dc.w 672,18560
	dc.w 676,18560
	dc.w 680,18560
	dc.w 684,18560
	dc.w 688,18560
	dc.w 692,18560
	dc.w 696,18560
	dc.w 700,18400
	dc.w 700,18240
	dc.w 700,18080
	dc.w 700,17920
	dc.w 704,17760
	dc.w 704,17600
	dc.w 704,17440
	dc.w 708,17280
	dc.w 708,17120
	dc.w 708,16960
	dc.w 712,16800
	dc.w 712,16640
	dc.w 716,16480
	dc.w 716,16320
	dc.w 720,16160
	dc.w 724,16000
	dc.w 728,16000
	dc.w 732,16160
	dc.w 736,16320
	dc.w 736,16480
	dc.w 740,16640
	dc.w 740,16800
	dc.w 740,16960
	dc.w 744,17120
	dc.w 744,17280
	dc.w 744,17440
	dc.w 748,17600
	dc.w 748,17760
	dc.w 748,17920
	dc.w 752,18080
	dc.w 752,18240
	dc.w 756,18400
	dc.w 760,18560
	dc.w 764,18400
	dc.w 768,18240
	dc.w 768,18080
	dc.w 772,17920
	dc.w 772,17760
	dc.w 772,17600
	dc.w 776,17440
	dc.w 776,17280
	dc.w 776,17120
	dc.w 776,16960
	dc.w 776,16800
	dc.w 780,16640
	dc.w 780,16480
	dc.w 780,16320
	dc.w 780,16160
	dc.w 780,16000
	dc.w 780,15840
	dc.w 784,15680
	dc.w 784,15520
	dc.w 784,15360
	dc.w 784,15200
	dc.w 784,15040
	dc.w 784,14880
	dc.w 784,14720
	dc.w 788,14560
	dc.w 788,14400
	dc.w 788,14240
	dc.w 788,14080
	dc.w 788,13920
	dc.w 788,13760
	dc.w 788,13600
	dc.w 788,13440
	dc.w 788,13280
	dc.w 792,13120
	dc.w 792,12960
	dc.w 792,12800
	dc.w 792,12640
	dc.w 792,12480
	dc.w 792,12320
	dc.w 792,12160
	dc.w 792,12000
	dc.w 792,11840
	dc.w 792,11680
	dc.w 792,11520
	dc.w 796,11360
	dc.w 796,11200
	dc.w 796,11040
	dc.w 796,10880
	dc.w 796,10720
	dc.w 796,10560
	dc.w 796,10400
	dc.w 796,10240
	dc.w 796,10080
	dc.w 796,9920
	dc.w 796,9760
	dc.w 796,9600
	dc.w 796,9440
	dc.w 800,9280
	dc.w 800,9120
	dc.w 800,8960
	dc.w 800,8800
	dc.w 800,8640
	dc.w 800,8480
	dc.w 800,8320
	dc.w 800,8160
	dc.w 800,8000
	dc.w 800,7840
	dc.w 800,7680
	dc.w 800,7520
	dc.w 800,7360
	dc.w 800,7200
	dc.w 804,7040
	dc.w 804,6880
	dc.w 804,6720
	dc.w 804,6560
	dc.w 804,6400
	dc.w 804,6240
	dc.w 804,6080
	dc.w 804,5920
	dc.w 804,5760
	dc.w 804,5600
	dc.w 804,5440
	dc.w 804,5280
	dc.w 804,5120
	dc.w 804,4960
	dc.w 804,4800
	dc.w 808,4640
	dc.w 808,4480
	dc.w 808,4320
	dc.w 808,4160
	dc.w 808,4000
	dc.w 808,3840
	dc.w 808,3680
	dc.w 808,3520
	dc.w 808,3360
	dc.w 808,3200
	dc.w 808,3040
	dc.w 808,2880
	dc.w 808,2720
	dc.w 808,2560
	dc.w 812,2400
	dc.w 812,2240
	dc.w 812,2080
	dc.w 812,1920
	dc.w 812,1760
	dc.w 812,1600
	dc.w 812,1440
	dc.w 812,1280
	dc.w 812,1120
	dc.w 812,960
	dc.w 812,800
	dc.w 816,640
	dc.w 816,480
	dc.w 816,320
	dc.w 816,160
	dc.w 820,0
	dc.w 824,160
	dc.w 824,320
	dc.w 824,480
	dc.w 824,640
	dc.w 828,800
	dc.w 828,960
	dc.w 828,1120
	dc.w 828,1280
	dc.w 828,1440
	dc.w 828,1600
	dc.w 828,1760
	dc.w 828,1920
	dc.w 828,2080
	dc.w 828,2240
	dc.w 828,2400
	dc.w 828,2560
	dc.w 828,2720
	dc.w 828,2880
	dc.w 832,3040
	dc.w 832,3200
	dc.w 832,3360
	dc.w 832,3520
	dc.w 832,3680
	dc.w 832,3840
	dc.w 832,4000
	dc.w 832,4160
	dc.w 832,4320
	dc.w 832,4480
	dc.w 832,4640
	dc.w 832,4800
	dc.w 832,4960
	dc.w 832,5120
	dc.w 832,5280
	dc.w 832,5440
	dc.w 832,5600
	dc.w 832,5760
	dc.w 832,5920
	dc.w 832,6080
	dc.w 836,6240
	dc.w 836,6400
	dc.w 836,6560
	dc.w 836,6720
	dc.w 836,6880
	dc.w 836,7040
	dc.w 836,7200
	dc.w 836,7360
	dc.w 836,7520
	dc.w 836,7680
	dc.w 836,7840
	dc.w 836,8000
	dc.w 836,8160
	dc.w 836,8320
	dc.w 836,8480
	dc.w 836,8640
	dc.w 836,8800
	dc.w 836,8960
	dc.w 836,9120
	dc.w 836,9280
	dc.w 836,9440
	dc.w 836,9600
	dc.w 836,9760
	dc.w 836,9920
	dc.w 836,10080
	dc.w 836,10240
	dc.w 840,10400
	dc.w 840,10560
	dc.w 840,10720
	dc.w 840,10880
	dc.w 840,11040
	dc.w 840,11200
	dc.w 840,11360
	dc.w 840,11520
	dc.w 840,11680
	dc.w 840,11840
	dc.w 840,12000
	dc.w 840,12160
	dc.w 840,12320
	dc.w 840,12480
	dc.w 840,12640
	dc.w 840,12800
	dc.w 840,12960
	dc.w 840,13120
	dc.w 840,13280
	dc.w 840,13440
	dc.w 840,13600
	dc.w 840,13760
	dc.w 840,13920
	dc.w 840,14080
	dc.w 840,14240
	dc.w 840,14400
	dc.w 840,14560
	dc.w 840,14720
	dc.w 840,14880
	dc.w 840,15040
	dc.w 844,15200
	dc.w 844,15360
	dc.w 844,15520
	dc.w 844,15680
	dc.w 844,15840
	dc.w 844,16000
	dc.w 844,16160
	dc.w 844,16320
	dc.w 844,16480
	dc.w 844,16640
	dc.w 844,16800
	dc.w 844,16960
	dc.w 844,17120
	dc.w 844,17280
	dc.w 844,17440
	dc.w 844,17600
	dc.w 844,17760
	dc.w 844,17920
	dc.w 844,18080
	dc.w 844,18240
	dc.w 844,18400
	dc.w 844,18560
	dc.w 844,18720
	dc.w 844,18880
	dc.w 844,19040
	dc.w 844,19200
	dc.w 844,19360
	dc.w 844,19520
	dc.w 848,19680
	dc.w 848,19840
	dc.w 848,20000
	dc.w 848,20160
	dc.w 848,20320
	dc.w 848,20480
	dc.w 848,20640
	dc.w 848,20800
	dc.w 848,20960
	dc.w 848,21120
	dc.w 848,21280
	dc.w 848,21440
	dc.w 848,21600
	dc.w 848,21760
	dc.w 848,21920
	dc.w 848,22080
	dc.w 848,22240
	dc.w 852,22400
	dc.w 852,22560
	dc.w 852,22720
	dc.w 852,22880
	dc.w 852,23040
	dc.w 852,23200
	dc.w 852,23360
	dc.w 852,23520
	dc.w 852,23680
	dc.w 852,23840
	dc.w 852,24000
	dc.w 852,24160
	dc.w 852,24320
	dc.w 856,24480
	dc.w 856,24640
	dc.w 856,24800
	dc.w 856,24960
	dc.w 856,25120
	dc.w 856,25280
	dc.w 856,25440
	dc.w 856,25600
	dc.w 860,25760
	dc.w 860,25920
	dc.w 860,26080
	dc.w 860,26240
	dc.w 860,26400
	dc.w 860,26560
	dc.w 860,26720
	dc.w 860,26880
	dc.w 864,27040
	dc.w 868,27040
	dc.w 872,26880
	dc.w 872,26720
	dc.w 872,26560
	dc.w 872,26400
	dc.w 872,26240
	dc.w 872,26080
	dc.w 872,25920
	dc.w 872,25760
	dc.w 872,25600
	dc.w 872,25440
	dc.w 876,25280
	dc.w 876,25120
	dc.w 876,24960
	dc.w 876,24800
	dc.w 876,24640
	dc.w 876,24480
	dc.w 876,24320
	dc.w 880,24160
	dc.w 880,24000
	dc.w 880,23840
	dc.w 880,23680
	dc.w 880,23520
	dc.w 880,23360
	dc.w 880,23200
	dc.w 880,23040
	dc.w 880,22880
	dc.w 884,22720
	dc.w 884,22560
	dc.w 884,22400
	dc.w 884,22240
	dc.w 884,22080
	dc.w 884,21920
	dc.w 884,21760
	dc.w 884,21600
	dc.w 884,21440
	dc.w 884,21280
	dc.w 884,21120
	dc.w 888,20960
	dc.w 888,20800
	dc.w 888,20640
	dc.w 888,20480
	dc.w 888,20320
	dc.w 888,20160
	dc.w 888,20000
	dc.w 888,19840
	dc.w 888,19680
	dc.w 888,19520
	dc.w 888,19360
	dc.w 888,19200
	dc.w 892,19040
	dc.w 892,18880
	dc.w 892,18720
	dc.w 892,18560
	dc.w 892,18400
	dc.w 892,18240
	dc.w 892,18080
	dc.w 892,17920
	dc.w 896,17760
	dc.w 896,17600
	dc.w 896,17440
	dc.w 896,17280
	dc.w 900,17120
	dc.w 904,16960
	dc.w 908,16960
	dc.w 912,17120
	dc.w 916,17280
	dc.w 916,17440
	dc.w 916,17600
	dc.w 916,17760
	dc.w 916,17920
	dc.w 916,18080
	dc.w 920,18240
	dc.w 920,18400
	dc.w 924,18560
	dc.w 928,18400
	dc.w 928,18240
	dc.w 928,18080
	dc.w 928,17920
	dc.w 928,17760
	dc.w 928,17600
	dc.w 928,17440
	dc.w 928,17280
	dc.w 928,17120
	dc.w 928,16960
	dc.w 928,16800
	dc.w 928,16640
	dc.w 928,16480
	dc.w 928,16320
	dc.w 928,16160
	dc.w 928,16000
	dc.w 928,15840
	dc.w 928,15680
	dc.w 932,15520
	dc.w 932,15360
	dc.w 932,15200
	dc.w 932,15040
	dc.w 932,14880
	dc.w 932,14720
	dc.w 932,14560
	dc.w 936,14400
	dc.w 936,14240
	dc.w 936,14080
	dc.w 936,13920
	dc.w 936,13760
	dc.w 936,13600
	dc.w 940,13440
	dc.w 940,13280
	dc.w 940,13120
	dc.w 940,12960
	dc.w 940,12800
	dc.w 944,12640
	dc.w 944,12480
	dc.w 944,12320
	dc.w 944,12160
	dc.w 948,12000
	dc.w 948,11840
	dc.w 948,11680
	dc.w 952,11520
	dc.w 956,11360
	dc.w 960,11360
	dc.w 964,11520
	dc.w 968,11680
	dc.w 968,11840
	dc.w 968,12000
	dc.w 972,12160
	dc.w 972,12320
	dc.w 972,12480
	dc.w 976,12640
	dc.w 976,12800
	dc.w 976,12960
	dc.w 980,13120
	dc.w 980,13280
	dc.w 980,13440
	dc.w 980,13600
	dc.w 984,13760
	dc.w 984,13920
	dc.w 984,14080
	dc.w 984,14240
	dc.w 984,14400
	dc.w 988,14560
	dc.w 988,14720
	dc.w 988,14880
	dc.w 988,15040
	dc.w 988,15200
	dc.w 992,15360
	dc.w 992,15520
	dc.w 992,15680
	dc.w 992,15840
	dc.w 996,16000
	dc.w 996,16160
	dc.w 996,16320
	dc.w 996,16480
	dc.w 996,16640
	dc.w 1000,16800
	dc.w 1000,16960
	dc.w 1000,17120
	dc.w 1000,17280
	dc.w 1000,17440
	dc.w 1000,17600
	dc.w 1004,17760
	dc.w 1004,17920
	dc.w 1004,18080
	dc.w 1004,18240
	dc.w 1004,18400
	dc.w 1008,18560
	dc.w 1012,18400
	dc.w 1012,18240
	dc.w 1016,18080
	dc.w 1020,17920
	dc.w 1020,17760
	dc.w 1020,17600
	dc.w 1024,17440
	dc.w 1028,17280
	dc.w 1032,17280
	dc.w 1036,17280
	dc.w 1040,17280
	dc.w 1044,17440
	dc.w 1044,17600
	dc.w 1048,17760
	dc.w 1052,17920
	dc.w 1056,18080
	dc.w 1060,18240
	dc.w 1060,18400
	dc.w 1064,18560
	dc.w 1068,18560
	dc.w 1072,18560
	dc.w 1076,18560
	dc.w 1080,18560
	dc.w 1084,18560
	dc.w 1088,18560
	dc.w 1092,18560
	dc.w 1096,18560
	dc.w 1100,18560
	dc.w 1104,18560
	dc.w 1108,18560
	dc.w 1112,18560
	dc.w 1116,18560
	dc.w 1120,18560
	dc.w 1124,18560
	dc.w 1128,18560
	dc.w 1132,18560
	dc.w 1136,18560
	dc.w 1140,18560
	dc.w 1144,18560
	dc.w 1148,18560
	dc.w 1152,18560
	dc.w 1156,18560
	dc.w 1160,18560
	dc.w 1164,18560
	dc.w 1168,18560
	dc.w 1172,18560
	dc.w 1176,18560
	dc.w 1180,18560
	dc.w 1184,18560
	dc.w 1188,18560
	dc.w 1192,18560
	dc.w 1196,18560
	dc.w 1200,18560
	dc.w 1204,18560
	dc.w 1208,18560
	dc.w 1212,18560
	dc.w 1216,18560
	dc.w 1220,18560
	dc.w 1224,18560
	dc.w 1228,18560
	dc.w 1232,18560
	dc.w 1236,18560
	dc.w 1240,18560
	dc.w 1244,18560
	dc.w 1248,18560
	dc.w 1252,18560
	dc.w 1256,18560
	dc.w 1260,18560
	dc.w 1264,18560
	dc.w 1268,18560
	dc.w 1272,18560
	dc.w -1,-1
;1141
pulse_y_vals
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 4
	dc.w 6
	dc.w 8
	dc.w 10
	dc.w 12
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 10
	dc.w 8
	dc.w 6
	dc.w 4
	dc.w 2
	dc.w 2
	dc.w 2
	dc.w 4
	dc.w 6
	dc.w 10
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 6
	dc.w 6
	dc.w 6
	dc.w 8
	dc.w 8
	dc.w 10
	dc.w 10
	dc.w 6
	dc.w 4
	dc.w 2
	dc.w 8
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 10
	dc.w 6
	dc.w 4
	dc.w 4
	dc.w 4
	dc.w 6
	dc.w 6
	dc.w 8
	dc.w 8
	dc.w 8
	dc.w 8
	dc.w 6
	dc.w 6
	dc.w 4
	dc.w 2
	dc.w 2
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 4
	dc.w 6
	dc.w 8
	dc.w 10
	dc.w 12
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 10
	dc.w 8
	dc.w 6
	dc.w 4
	dc.w 2
	dc.w 2
	dc.w 2
	dc.w 4
	dc.w 6
	dc.w 10
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 6
	dc.w 6
	dc.w 6
	dc.w 8
	dc.w 8
	dc.w 10
	dc.w 10
	dc.w 6
	dc.w 4
	dc.w 2
	dc.w 8
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 10
	dc.w 6
	dc.w 4
	dc.w 4
	dc.w 4
	dc.w 6
	dc.w 6
	dc.w 8
	dc.w 8
	dc.w 8
	dc.w 8
	dc.w 6
	dc.w 6
	dc.w 4
	dc.w 2
	dc.w 2
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
