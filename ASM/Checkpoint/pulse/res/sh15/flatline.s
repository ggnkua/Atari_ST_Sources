	dc.w 0,18560
	dc.w 4,18560
	dc.w 8,18560
	dc.w 12,18560
	dc.w 16,18560
	dc.w 20,18560
	dc.w 24,18560
	dc.w 28,18560
	dc.w 32,18560
	dc.w 36,18560
	dc.w 40,18560
	dc.w 44,18560
	dc.w 48,18560
	dc.w 52,18560
	dc.w 56,18560
	dc.w 60,18560
	dc.w 64,18560
	dc.w 68,18560
	dc.w 72,18560
	dc.w 76,18560
	dc.w 80,18560
	dc.w 84,18560
	dc.w 88,18560
	dc.w 92,18560
	dc.w 96,18560
	dc.w 100,18560
	dc.w 104,18560
	dc.w 108,18560
	dc.w 112,18560
	dc.w 116,18560
	dc.w 120,18560
	dc.w 124,18560
	dc.w 128,18560
	dc.w 132,18560
	dc.w 136,18560
	dc.w 140,18560
	dc.w 144,18560
	dc.w 148,18560
	dc.w 152,18560
	dc.w 156,18560
	dc.w 160,18560
	dc.w 164,18560
	dc.w 168,18560
	dc.w 172,18560
	dc.w 176,18560
	dc.w 180,18560
	dc.w 184,18560
	dc.w 188,18560
	dc.w 192,18560
	dc.w 196,18560
	dc.w 200,18560
	dc.w 204,18560
	dc.w 208,18560
	dc.w 212,18560
	dc.w 216,18560
	dc.w 220,18560
	dc.w 224,18560
	dc.w 228,18560
	dc.w 232,18560
	dc.w 236,18560
	dc.w 240,18560
	dc.w 244,18560
	dc.w 248,18560
	dc.w 252,18560
	dc.w 256,18560
	dc.w 260,18560
	dc.w 264,18560
	dc.w 268,18560
	dc.w 272,18560
	dc.w 276,18560
	dc.w 280,18560
	dc.w 284,18560
	dc.w 288,18560
	dc.w 292,18560
	dc.w 296,18560
	dc.w 300,18560
	dc.w 304,18560
	dc.w 308,18560
	dc.w 312,18560
	dc.w 316,18560
	dc.w 320,18560
	dc.w 324,18560
	dc.w 328,18560
	dc.w 332,18560
	dc.w 336,18560
	dc.w 340,18560
	dc.w 344,18560
	dc.w 348,18560
	dc.w 352,18560
	dc.w 356,18560
	dc.w 360,18560
	dc.w 364,18560
	dc.w 368,18560
	dc.w 372,18560
	dc.w 376,18560
	dc.w 380,18560
	dc.w 384,18560
	dc.w 388,18560
	dc.w 392,18560
	dc.w 396,18560
	dc.w 400,18560
	dc.w 404,18560
	dc.w 408,18560
	dc.w 412,18560
	dc.w 416,18560
	dc.w 420,18560
	dc.w 424,18560
	dc.w 428,18560
	dc.w 432,18560
	dc.w 436,18560
	dc.w 440,18560
	dc.w 444,18560
	dc.w 448,18560
	dc.w 452,18560
	dc.w 456,18560
	dc.w 460,18560
	dc.w 464,18560
	dc.w 468,18560
	dc.w 472,18560
	dc.w 476,18560
	dc.w 480,18560
	dc.w 484,18560
	dc.w 488,18560
	dc.w 492,18560
	dc.w 496,18560
	dc.w 500,18560
	dc.w 504,18560
	dc.w 508,18560
	dc.w 512,18560
	dc.w 516,18560
	dc.w 520,18560
	dc.w 524,18560
	dc.w 528,18560
	dc.w 532,18560
	dc.w 536,18560
	dc.w 540,18560
	dc.w 544,18560
	dc.w 548,18560
	dc.w 552,18560
	dc.w 556,18560
	dc.w 560,18560
	dc.w 564,18560
	dc.w 568,18560
	dc.w 572,18560
	dc.w 576,18560
	dc.w 580,18560
	dc.w 584,18560
	dc.w 588,18560
	dc.w 592,18560
	dc.w 596,18560
	dc.w 600,18560
	dc.w 604,18560
	dc.w 608,18560
	dc.w 612,18560
	dc.w 616,18560
	dc.w 620,18560
	dc.w 624,18560
	dc.w 628,18560
	dc.w 632,18560
	dc.w 636,18560
	dc.w 640,18560
	dc.w 644,18560
	dc.w 648,18560
	dc.w 652,18560
	dc.w 656,18560
	dc.w 660,18560
	dc.w 664,18560
	dc.w 668,18560
	dc.w 672,18560
	dc.w 676,18560
	dc.w 680,18560
	dc.w 684,18560
	dc.w 688,18560
	dc.w 692,18560
	dc.w 696,18560
	dc.w 700,18560
	dc.w 704,18560
	dc.w 708,18560
	dc.w 712,18560
	dc.w 716,18560
	dc.w 720,18560
	dc.w 724,18560
	dc.w 728,18560
	dc.w 732,18560
	dc.w 736,18560
	dc.w 740,18560
	dc.w 744,18560
	dc.w 748,18560
	dc.w 752,18560
	dc.w 756,18560
	dc.w 760,18560
	dc.w 764,18560
	dc.w 768,18560
	dc.w 772,18560
	dc.w 776,18560
	dc.w 780,18560
	dc.w 784,18560
	dc.w 788,18560
	dc.w 792,18560
	dc.w 796,18560
	dc.w 800,18560
	dc.w 804,18560
	dc.w 808,18560
	dc.w 812,18560
	dc.w 816,18560
	dc.w 820,18560
	dc.w 824,18560
	dc.w 828,18560
	dc.w 832,18560
	dc.w 836,18560
	dc.w 840,18560
	dc.w 844,18560
	dc.w 848,18560
	dc.w 852,18560
	dc.w 856,18560
	dc.w 860,18560
	dc.w 864,18560
	dc.w 868,18560
	dc.w 872,18560
	dc.w 876,18560
	dc.w 880,18560
	dc.w 884,18560
	dc.w 888,18560
	dc.w 892,18560
	dc.w 896,18560
	dc.w 900,18560
	dc.w 904,18560
	dc.w 908,18560
	dc.w 912,18560
	dc.w 916,18560
	dc.w 920,18560
	dc.w 924,18560
	dc.w 928,18560
	dc.w 932,18560
	dc.w 936,18560
	dc.w 940,18560
	dc.w 944,18560
	dc.w 948,18560
	dc.w 952,18560
	dc.w 956,18560
	dc.w 960,18560
	dc.w 964,18560
	dc.w 968,18560
	dc.w 972,18560
	dc.w 976,18560
	dc.w 980,18560
	dc.w 984,18560
	dc.w 988,18560
	dc.w 992,18560
	dc.w 996,18560
	dc.w 1000,18560
	dc.w 1004,18560
	dc.w 1008,18560
	dc.w 1012,18560
	dc.w 1016,18560
	dc.w 1020,18560
	dc.w 1024,18560
	dc.w 1028,18560
	dc.w 1032,18560
	dc.w 1036,18560
	dc.w 1040,18560
	dc.w 1044,18560
	dc.w 1048,18560
	dc.w 1052,18560
	dc.w 1056,18560
	dc.w 1060,18560
	dc.w 1064,18560
	dc.w 1068,18560
	dc.w 1072,18560
	dc.w 1076,18560
	dc.w 1080,18560
	dc.w 1084,18560
	dc.w 1088,18560
	dc.w 1092,18560
	dc.w 1096,18560
	dc.w 1100,18560
	dc.w 1104,18560
	dc.w 1108,18560
	dc.w 1112,18560
	dc.w 1116,18560
	dc.w 1120,18560
	dc.w 1124,18560
	dc.w 1128,18560
	dc.w 1132,18560
	dc.w 1136,18560
	dc.w 1140,18560
	dc.w 1144,18560
	dc.w 1148,18560
	dc.w 1152,18560
	dc.w 1156,18560
	dc.w 1160,18560
	dc.w 1164,18560
	dc.w 1168,18560
	dc.w 1172,18560
	dc.w 1176,18560
	dc.w 1180,18560
	dc.w 1184,18560
	dc.w 1188,18560
	dc.w 1192,18560
	dc.w 1196,18560
	dc.w 1200,18560
	dc.w 1204,18560
	dc.w 1208,18560
	dc.w 1212,18560
	dc.w 1216,18560
	dc.w 1220,18560
	dc.w 1224,18560
	dc.w 1228,18560
	dc.w 1232,18560
	dc.w 1236,18560
	dc.w 1240,18560
	dc.w 1244,18560
	dc.w 1248,18560
	dc.w 1252,18560
	dc.w 1256,18560
	dc.w 1260,18560
	dc.w 1264,18560
	dc.w 1268,18560
	dc.w 1272,18560
	dc.w -1,-1
;319
