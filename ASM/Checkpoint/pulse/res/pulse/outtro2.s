	dc.w 0,18560
	dc.w 4,18560
	dc.w 8,18560
	dc.w 12,18560
	dc.w 16,18560
	dc.w 20,18560
	dc.w 24,18560
	dc.w 28,18560
	dc.w 32,18560
	dc.w 36,18560
	dc.w 40,18560
	dc.w 44,18560
	dc.w 48,18560
	dc.w 52,18400
	dc.w 52,18240
	dc.w 52,18080
	dc.w 52,17920
	dc.w 56,17760
	dc.w 56,17600
	dc.w 56,17440
	dc.w 60,17280
	dc.w 60,17120
	dc.w 60,16960
	dc.w 64,16800
	dc.w 64,16640
	dc.w 68,16480
	dc.w 68,16320
	dc.w 72,16160
	dc.w 76,16000
	dc.w 80,16000
	dc.w 84,16160
	dc.w 88,16320
	dc.w 88,16480
	dc.w 92,16640
	dc.w 92,16800
	dc.w 92,16960
	dc.w 96,17120
	dc.w 96,17280
	dc.w 96,17440
	dc.w 100,17600
	dc.w 100,17760
	dc.w 100,17920
	dc.w 104,18080
	dc.w 104,18240
	dc.w 108,18400
	dc.w 112,18560
	dc.w 116,18400
	dc.w 120,18240
	dc.w 120,18080
	dc.w 124,17920
	dc.w 124,17760
	dc.w 124,17600
	dc.w 128,17440
	dc.w 128,17280
	dc.w 128,17120
	dc.w 128,16960
	dc.w 128,16800
	dc.w 132,16640
	dc.w 132,16480
	dc.w 132,16320
	dc.w 132,16160
	dc.w 132,16000
	dc.w 132,15840
	dc.w 136,15680
	dc.w 136,15520
	dc.w 136,15360
	dc.w 136,15200
	dc.w 136,15040
	dc.w 136,14880
	dc.w 136,14720
	dc.w 140,14560
	dc.w 140,14400
	dc.w 140,14240
	dc.w 140,14080
	dc.w 140,13920
	dc.w 140,13760
	dc.w 140,13600
	dc.w 140,13440
	dc.w 140,13280
	dc.w 144,13120
	dc.w 144,12960
	dc.w 144,12800
	dc.w 144,12640
	dc.w 144,12480
	dc.w 144,12320
	dc.w 144,12160
	dc.w 144,12000
	dc.w 144,11840
	dc.w 144,11680
	dc.w 144,11520
	dc.w 148,11360
	dc.w 148,11200
	dc.w 148,11040
	dc.w 148,10880
	dc.w 148,10720
	dc.w 148,10560
	dc.w 148,10400
	dc.w 148,10240
	dc.w 148,10080
	dc.w 148,9920
	dc.w 148,9760
	dc.w 148,9600
	dc.w 148,9440
	dc.w 152,9280
	dc.w 152,9120
	dc.w 152,8960
	dc.w 152,8800
	dc.w 152,8640
	dc.w 152,8480
	dc.w 152,8320
	dc.w 152,8160
	dc.w 152,8000
	dc.w 152,7840
	dc.w 152,7680
	dc.w 152,7520
	dc.w 152,7360
	dc.w 152,7200
	dc.w 156,7040
	dc.w 156,6880
	dc.w 156,6720
	dc.w 156,6560
	dc.w 156,6400
	dc.w 156,6240
	dc.w 156,6080
	dc.w 156,5920
	dc.w 156,5760
	dc.w 156,5600
	dc.w 156,5440
	dc.w 156,5280
	dc.w 156,5120
	dc.w 156,4960
	dc.w 156,4800
	dc.w 160,4640
	dc.w 160,4480
	dc.w 160,4320
	dc.w 160,4160
	dc.w 160,4000
	dc.w 160,3840
	dc.w 160,3680
	dc.w 160,3520
	dc.w 160,3360
	dc.w 160,3200
	dc.w 160,3040
	dc.w 160,2880
	dc.w 160,2720
	dc.w 160,2560
	dc.w 164,2400
	dc.w 164,2240
	dc.w 164,2080
	dc.w 164,1920
	dc.w 164,1760
	dc.w 164,1600
	dc.w 164,1440
	dc.w 164,1280
	dc.w 164,1120
	dc.w 164,960
	dc.w 164,800
	dc.w 168,640
	dc.w 168,480
	dc.w 168,320
	dc.w 168,160
	dc.w 172,0
	dc.w 176,160
	dc.w 176,320
	dc.w 176,480
	dc.w 176,640
	dc.w 180,800
	dc.w 180,960
	dc.w 180,1120
	dc.w 180,1280
	dc.w 180,1440
	dc.w 180,1600
	dc.w 180,1760
	dc.w 180,1920
	dc.w 180,2080
	dc.w 180,2240
	dc.w 180,2400
	dc.w 180,2560
	dc.w 180,2720
	dc.w 180,2880
	dc.w 184,3040
	dc.w 184,3200
	dc.w 184,3360
	dc.w 184,3520
	dc.w 184,3680
	dc.w 184,3840
	dc.w 184,4000
	dc.w 184,4160
	dc.w 184,4320
	dc.w 184,4480
	dc.w 184,4640
	dc.w 184,4800
	dc.w 184,4960
	dc.w 184,5120
	dc.w 184,5280
	dc.w 184,5440
	dc.w 184,5600
	dc.w 184,5760
	dc.w 184,5920
	dc.w 184,6080
	dc.w 188,6240
	dc.w 188,6400
	dc.w 188,6560
	dc.w 188,6720
	dc.w 188,6880
	dc.w 188,7040
	dc.w 188,7200
	dc.w 188,7360
	dc.w 188,7520
	dc.w 188,7680
	dc.w 188,7840
	dc.w 188,8000
	dc.w 188,8160
	dc.w 188,8320
	dc.w 188,8480
	dc.w 188,8640
	dc.w 188,8800
	dc.w 188,8960
	dc.w 188,9120
	dc.w 188,9280
	dc.w 188,9440
	dc.w 188,9600
	dc.w 188,9760
	dc.w 188,9920
	dc.w 188,10080
	dc.w 188,10240
	dc.w 192,10400
	dc.w 192,10560
	dc.w 192,10720
	dc.w 192,10880
	dc.w 192,11040
	dc.w 192,11200
	dc.w 192,11360
	dc.w 192,11520
	dc.w 192,11680
	dc.w 192,11840
	dc.w 192,12000
	dc.w 192,12160
	dc.w 192,12320
	dc.w 192,12480
	dc.w 192,12640
	dc.w 192,12800
	dc.w 192,12960
	dc.w 192,13120
	dc.w 192,13280
	dc.w 192,13440
	dc.w 192,13600
	dc.w 192,13760
	dc.w 192,13920
	dc.w 192,14080
	dc.w 192,14240
	dc.w 192,14400
	dc.w 192,14560
	dc.w 192,14720
	dc.w 192,14880
	dc.w 192,15040
	dc.w 196,15200
	dc.w 196,15360
	dc.w 196,15520
	dc.w 196,15680
	dc.w 196,15840
	dc.w 196,16000
	dc.w 196,16160
	dc.w 196,16320
	dc.w 196,16480
	dc.w 196,16640
	dc.w 196,16800
	dc.w 196,16960
	dc.w 196,17120
	dc.w 196,17280
	dc.w 196,17440
	dc.w 196,17600
	dc.w 196,17760
	dc.w 196,17920
	dc.w 196,18080
	dc.w 196,18240
	dc.w 196,18400
	dc.w 196,18560
	dc.w 196,18720
	dc.w 196,18880
	dc.w 196,19040
	dc.w 196,19200
	dc.w 196,19360
	dc.w 196,19520
	dc.w 200,19680
	dc.w 200,19840
	dc.w 200,20000
	dc.w 200,20160
	dc.w 200,20320
	dc.w 200,20480
	dc.w 200,20640
	dc.w 200,20800
	dc.w 200,20960
	dc.w 200,21120
	dc.w 200,21280
	dc.w 200,21440
	dc.w 200,21600
	dc.w 200,21760
	dc.w 200,21920
	dc.w 200,22080
	dc.w 200,22240
	dc.w 204,22400
	dc.w 204,22560
	dc.w 204,22720
	dc.w 204,22880
	dc.w 204,23040
	dc.w 204,23200
	dc.w 204,23360
	dc.w 204,23520
	dc.w 204,23680
	dc.w 204,23840
	dc.w 204,24000
	dc.w 204,24160
	dc.w 204,24320
	dc.w 208,24480
	dc.w 208,24640
	dc.w 208,24800
	dc.w 208,24960
	dc.w 208,25120
	dc.w 208,25280
	dc.w 208,25440
	dc.w 208,25600
	dc.w 212,25760
	dc.w 212,25920
	dc.w 212,26080
	dc.w 212,26240
	dc.w 212,26400
	dc.w 212,26560
	dc.w 212,26720
	dc.w 212,26880
	dc.w 216,27040
	dc.w 220,27040
	dc.w 224,26880
	dc.w 224,26720
	dc.w 224,26560
	dc.w 224,26400
	dc.w 224,26240
	dc.w 224,26080
	dc.w 224,25920
	dc.w 224,25760
	dc.w 224,25600
	dc.w 224,25440
	dc.w 228,25280
	dc.w 228,25120
	dc.w 228,24960
	dc.w 228,24800
	dc.w 228,24640
	dc.w 228,24480
	dc.w 228,24320
	dc.w 232,24160
	dc.w 232,24000
	dc.w 232,23840
	dc.w 232,23680
	dc.w 232,23520
	dc.w 232,23360
	dc.w 232,23200
	dc.w 232,23040
	dc.w 232,22880
	dc.w 236,22720
	dc.w 236,22560
	dc.w 236,22400
	dc.w 236,22240
	dc.w 236,22080
	dc.w 236,21920
	dc.w 236,21760
	dc.w 236,21600
	dc.w 236,21440
	dc.w 236,21280
	dc.w 236,21120
	dc.w 240,20960
	dc.w 240,20800
	dc.w 240,20640
	dc.w 240,20480
	dc.w 240,20320
	dc.w 240,20160
	dc.w 240,20000
	dc.w 240,19840
	dc.w 240,19680
	dc.w 240,19520
	dc.w 240,19360
	dc.w 240,19200
	dc.w 244,19040
	dc.w 244,18880
	dc.w 244,18720
	dc.w 244,18560
	dc.w 244,18400
	dc.w 244,18240
	dc.w 244,18080
	dc.w 244,17920
	dc.w 248,17760
	dc.w 248,17600
	dc.w 248,17440
	dc.w 248,17280
	dc.w 252,17120
	dc.w 256,16960
	dc.w 260,16960
	dc.w 264,17120
	dc.w 268,17280
	dc.w 268,17440
	dc.w 268,17600
	dc.w 268,17760
	dc.w 268,17920
	dc.w 268,18080
	dc.w 272,18240
	dc.w 272,18400
	dc.w 276,18560
	dc.w 280,18400
	dc.w 280,18240
	dc.w 280,18080
	dc.w 280,17920
	dc.w 280,17760
	dc.w 280,17600
	dc.w 280,17440
	dc.w 280,17280
	dc.w 280,17120
	dc.w 280,16960
	dc.w 280,16800
	dc.w 280,16640
	dc.w 280,16480
	dc.w 280,16320
	dc.w 280,16160
	dc.w 280,16000
	dc.w 280,15840
	dc.w 280,15680
	dc.w 284,15520
	dc.w 284,15360
	dc.w 284,15200
	dc.w 284,15040
	dc.w 284,14880
	dc.w 284,14720
	dc.w 284,14560
	dc.w 288,14400
	dc.w 288,14240
	dc.w 288,14080
	dc.w 288,13920
	dc.w 288,13760
	dc.w 288,13600
	dc.w 292,13440
	dc.w 292,13280
	dc.w 292,13120
	dc.w 292,12960
	dc.w 292,12800
	dc.w 296,12640
	dc.w 296,12480
	dc.w 296,12320
	dc.w 296,12160
	dc.w 300,12000
	dc.w 300,11840
	dc.w 300,11680
	dc.w 304,11520
	dc.w 308,11360
	dc.w 312,11360
	dc.w 316,11520
	dc.w 320,11680
	dc.w 320,11840
	dc.w 320,12000
	dc.w 324,12160
	dc.w 324,12320
	dc.w 324,12480
	dc.w 328,12640
	dc.w 328,12800
	dc.w 328,12960
	dc.w 332,13120
	dc.w 332,13280
	dc.w 332,13440
	dc.w 332,13600
	dc.w 336,13760
	dc.w 336,13920
	dc.w 336,14080
	dc.w 336,14240
	dc.w 336,14400
	dc.w 340,14560
	dc.w 340,14720
	dc.w 340,14880
	dc.w 340,15040
	dc.w 340,15200
	dc.w 344,15360
	dc.w 344,15520
	dc.w 344,15680
	dc.w 344,15840
	dc.w 348,16000
	dc.w 348,16160
	dc.w 348,16320
	dc.w 348,16480
	dc.w 348,16640
	dc.w 352,16800
	dc.w 352,16960
	dc.w 352,17120
	dc.w 352,17280
	dc.w 352,17440
	dc.w 352,17600
	dc.w 356,17760
	dc.w 356,17920
	dc.w 356,18080
	dc.w 356,18240
	dc.w 356,18400
	dc.w 360,18560
	dc.w 364,18400
	dc.w 364,18240
	dc.w 368,18080
	dc.w 372,17920
	dc.w 372,17760
	dc.w 372,17600
	dc.w 376,17440
	dc.w 380,17280
	dc.w 384,17280
	dc.w 388,17280
	dc.w 392,17280
	dc.w 396,17440
	dc.w 396,17600
	dc.w 400,17760
	dc.w 404,17920
	dc.w 408,18080
	dc.w 412,18240
	dc.w 412,18400
	dc.w 416,18560
	dc.w 420,18560
	dc.w 424,18560
	dc.w 428,18560
	dc.w 432,18560
	dc.w 436,18560
	dc.w 440,18560
	dc.w 444,18560
	dc.w 448,18560
	dc.w 452,18560
	dc.w 456,18560
	dc.w 460,18560
	dc.w 464,18560
	dc.w 468,18560
	dc.w 472,18560
	dc.w 476,18560
	dc.w 480,18560
	dc.w 484,18560
	dc.w 488,18560
	dc.w 492,18560
	dc.w 496,18560
	dc.w 500,18560
	dc.w 504,18560
	dc.w 508,18560
	dc.w 512,18560
	dc.w 516,18560
	dc.w 520,18560
	dc.w 524,18560
	dc.w 528,18560
	dc.w 532,18560
	dc.w 536,18560
	dc.w 540,18560
	dc.w 544,18560
	dc.w 548,18560
	dc.w 552,18560
	dc.w 556,18560
	dc.w 560,18560
	dc.w 564,18560
	dc.w 568,18560
	dc.w 572,18560
	dc.w 576,18560
	dc.w 580,18560
	dc.w 584,18560
	dc.w 588,18560
	dc.w 592,18560
	dc.w 596,18560
	dc.w 600,18560
	dc.w 604,18560
	dc.w 608,18560
	dc.w 612,18560
	dc.w 616,18560
	dc.w 620,18560
	dc.w 624,18560
	dc.w 628,18560
	dc.w 632,18560
	dc.w 636,18560
	dc.w 640,18560
	dc.w 644,18560
	dc.w 648,18560
	dc.w 652,18560
	dc.w 656,18560
	dc.w 660,18560
	dc.w 664,18560
	dc.w 668,18560
	dc.w 672,18560
	dc.w 676,18560
	dc.w 680,18560
	dc.w 684,18560
	dc.w 688,18560
	dc.w 692,18560
	dc.w 696,18560
	dc.w 700,18560
	dc.w 704,18560
	dc.w 708,18560
	dc.w 712,18560
	dc.w 716,18560
	dc.w 720,18560
	dc.w 724,18560
	dc.w 728,18560
	dc.w 732,18560
	dc.w 736,18560
	dc.w 740,18560
	dc.w 744,18560
	dc.w 748,18560
	dc.w 752,18560
	dc.w 756,18560
	dc.w 760,18560
	dc.w 764,18560
	dc.w 768,18560
	dc.w 772,18560
	dc.w 776,18560
	dc.w 780,18560
	dc.w 784,18560
	dc.w 788,18560
	dc.w 792,18560
	dc.w 796,18560
	dc.w 800,18560
	dc.w 804,18560
	dc.w 808,18560
	dc.w 812,18560
	dc.w 816,18560
	dc.w 820,18560
	dc.w 824,18560
	dc.w 828,18560
	dc.w 832,18400
	dc.w 832,18240
	dc.w 832,18080
	dc.w 832,17920
	dc.w 836,17760
	dc.w 836,17600
	dc.w 836,17440
	dc.w 840,17280
	dc.w 840,17120
	dc.w 840,16960
	dc.w 844,16800
	dc.w 844,16640
	dc.w 848,16480
	dc.w 848,16320
	dc.w 852,16160
	dc.w 856,16000
	dc.w 860,16000
	dc.w 864,16160
	dc.w 868,16320
	dc.w 868,16480
	dc.w 872,16640
	dc.w 872,16800
	dc.w 872,16960
	dc.w 876,17120
	dc.w 876,17280
	dc.w 876,17440
	dc.w 880,17600
	dc.w 880,17760
	dc.w 880,17920
	dc.w 884,18080
	dc.w 884,18240
	dc.w 888,18400
	dc.w 892,18560
	dc.w 896,18400
	dc.w 900,18240
	dc.w 900,18080
	dc.w 904,17920
	dc.w 904,17760
	dc.w 904,17600
	dc.w 908,17440
	dc.w 908,17280
	dc.w 908,17120
	dc.w 908,16960
	dc.w 908,16800
	dc.w 912,16640
	dc.w 912,16480
	dc.w 912,16320
	dc.w 912,16160
	dc.w 912,16000
	dc.w 912,15840
	dc.w 916,15680
	dc.w 916,15520
	dc.w 916,15360
	dc.w 916,15200
	dc.w 916,15040
	dc.w 916,14880
	dc.w 916,14720
	dc.w 920,14560
	dc.w 920,14400
	dc.w 920,14240
	dc.w 920,14080
	dc.w 920,13920
	dc.w 920,13760
	dc.w 920,13600
	dc.w 920,13440
	dc.w 920,13280
	dc.w 924,13120
	dc.w 924,12960
	dc.w 924,12800
	dc.w 924,12640
	dc.w 924,12480
	dc.w 924,12320
	dc.w 924,12160
	dc.w 924,12000
	dc.w 924,11840
	dc.w 924,11680
	dc.w 924,11520
	dc.w 928,11360
	dc.w 928,11200
	dc.w 928,11040
	dc.w 928,10880
	dc.w 928,10720
	dc.w 928,10560
	dc.w 928,10400
	dc.w 928,10240
	dc.w 928,10080
	dc.w 928,9920
	dc.w 928,9760
	dc.w 928,9600
	dc.w 928,9440
	dc.w 932,9280
	dc.w 932,9120
	dc.w 932,8960
	dc.w 932,8800
	dc.w 932,8640
	dc.w 932,8480
	dc.w 932,8320
	dc.w 932,8160
	dc.w 932,8000
	dc.w 932,7840
	dc.w 932,7680
	dc.w 932,7520
	dc.w 932,7360
	dc.w 932,7200
	dc.w 936,7040
	dc.w 936,6880
	dc.w 936,6720
	dc.w 936,6560
	dc.w 936,6400
	dc.w 936,6240
	dc.w 936,6080
	dc.w 936,5920
	dc.w 936,5760
	dc.w 936,5600
	dc.w 936,5440
	dc.w 936,5280
	dc.w 936,5120
	dc.w 936,4960
	dc.w 936,4800
	dc.w 940,4640
	dc.w 940,4480
	dc.w 940,4320
	dc.w 940,4160
	dc.w 940,4000
	dc.w 940,3840
	dc.w 940,3680
	dc.w 940,3520
	dc.w 940,3360
	dc.w 940,3200
	dc.w 940,3040
	dc.w 940,2880
	dc.w 940,2720
	dc.w 940,2560
	dc.w 944,2400
	dc.w 944,2240
	dc.w 944,2080
	dc.w 944,1920
	dc.w 944,1760
	dc.w 944,1600
	dc.w 944,1440
	dc.w 944,1280
	dc.w 944,1120
	dc.w 944,960
	dc.w 944,800
	dc.w 948,640
	dc.w 948,480
	dc.w 948,320
	dc.w 948,160
	dc.w 952,0
	dc.w 956,160
	dc.w 956,320
	dc.w 956,480
	dc.w 956,640
	dc.w 960,800
	dc.w 960,960
	dc.w 960,1120
	dc.w 960,1280
	dc.w 960,1440
	dc.w 960,1600
	dc.w 960,1760
	dc.w 960,1920
	dc.w 960,2080
	dc.w 960,2240
	dc.w 960,2400
	dc.w 960,2560
	dc.w 960,2720
	dc.w 960,2880
	dc.w 964,3040
	dc.w 964,3200
	dc.w 964,3360
	dc.w 964,3520
	dc.w 964,3680
	dc.w 964,3840
	dc.w 964,4000
	dc.w 964,4160
	dc.w 964,4320
	dc.w 964,4480
	dc.w 964,4640
	dc.w 964,4800
	dc.w 964,4960
	dc.w 964,5120
	dc.w 964,5280
	dc.w 964,5440
	dc.w 964,5600
	dc.w 964,5760
	dc.w 964,5920
	dc.w 964,6080
	dc.w 968,6240
	dc.w 968,6400
	dc.w 968,6560
	dc.w 968,6720
	dc.w 968,6880
	dc.w 968,7040
	dc.w 968,7200
	dc.w 968,7360
	dc.w 968,7520
	dc.w 968,7680
	dc.w 968,7840
	dc.w 968,8000
	dc.w 968,8160
	dc.w 968,8320
	dc.w 968,8480
	dc.w 968,8640
	dc.w 968,8800
	dc.w 968,8960
	dc.w 968,9120
	dc.w 968,9280
	dc.w 968,9440
	dc.w 968,9600
	dc.w 968,9760
	dc.w 968,9920
	dc.w 968,10080
	dc.w 968,10240
	dc.w 972,10400
	dc.w 972,10560
	dc.w 972,10720
	dc.w 972,10880
	dc.w 972,11040
	dc.w 972,11200
	dc.w 972,11360
	dc.w 972,11520
	dc.w 972,11680
	dc.w 972,11840
	dc.w 972,12000
	dc.w 972,12160
	dc.w 972,12320
	dc.w 972,12480
	dc.w 972,12640
	dc.w 972,12800
	dc.w 972,12960
	dc.w 972,13120
	dc.w 972,13280
	dc.w 972,13440
	dc.w 972,13600
	dc.w 972,13760
	dc.w 972,13920
	dc.w 972,14080
	dc.w 972,14240
	dc.w 972,14400
	dc.w 972,14560
	dc.w 972,14720
	dc.w 972,14880
	dc.w 972,15040
	dc.w 976,15200
	dc.w 976,15360
	dc.w 976,15520
	dc.w 976,15680
	dc.w 976,15840
	dc.w 976,16000
	dc.w 976,16160
	dc.w 976,16320
	dc.w 976,16480
	dc.w 976,16640
	dc.w 976,16800
	dc.w 976,16960
	dc.w 976,17120
	dc.w 976,17280
	dc.w 976,17440
	dc.w 976,17600
	dc.w 976,17760
	dc.w 976,17920
	dc.w 976,18080
	dc.w 976,18240
	dc.w 976,18400
	dc.w 976,18560
	dc.w 976,18720
	dc.w 976,18880
	dc.w 976,19040
	dc.w 976,19200
	dc.w 976,19360
	dc.w 976,19520
	dc.w 980,19680
	dc.w 980,19840
	dc.w 980,20000
	dc.w 980,20160
	dc.w 980,20320
	dc.w 980,20480
	dc.w 980,20640
	dc.w 980,20800
	dc.w 980,20960
	dc.w 980,21120
	dc.w 980,21280
	dc.w 980,21440
	dc.w 980,21600
	dc.w 980,21760
	dc.w 980,21920
	dc.w 980,22080
	dc.w 980,22240
	dc.w 984,22400
	dc.w 984,22560
	dc.w 984,22720
	dc.w 984,22880
	dc.w 984,23040
	dc.w 984,23200
	dc.w 984,23360
	dc.w 984,23520
	dc.w 984,23680
	dc.w 984,23840
	dc.w 984,24000
	dc.w 984,24160
	dc.w 984,24320
	dc.w 988,24480
	dc.w 988,24640
	dc.w 988,24800
	dc.w 988,24960
	dc.w 988,25120
	dc.w 988,25280
	dc.w 988,25440
	dc.w 988,25600
	dc.w 992,25760
	dc.w 992,25920
	dc.w 992,26080
	dc.w 992,26240
	dc.w 992,26400
	dc.w 992,26560
	dc.w 992,26720
	dc.w 992,26880
	dc.w 996,27040
	dc.w 1000,27040
	dc.w 1004,26880
	dc.w 1004,26720
	dc.w 1004,26560
	dc.w 1004,26400
	dc.w 1004,26240
	dc.w 1004,26080
	dc.w 1004,25920
	dc.w 1004,25760
	dc.w 1004,25600
	dc.w 1004,25440
	dc.w 1008,25280
	dc.w 1008,25120
	dc.w 1008,24960
	dc.w 1008,24800
	dc.w 1008,24640
	dc.w 1008,24480
	dc.w 1008,24320
	dc.w 1012,24160
	dc.w 1012,24000
	dc.w 1012,23840
	dc.w 1012,23680
	dc.w 1012,23520
	dc.w 1012,23360
	dc.w 1012,23200
	dc.w 1012,23040
	dc.w 1012,22880
	dc.w 1016,22720
	dc.w 1016,22560
	dc.w 1016,22400
	dc.w 1016,22240
	dc.w 1016,22080
	dc.w 1016,21920
	dc.w 1016,21760
	dc.w 1016,21600
	dc.w 1016,21440
	dc.w 1016,21280
	dc.w 1016,21120
	dc.w 1020,20960
	dc.w 1020,20800
	dc.w 1020,20640
	dc.w 1020,20480
	dc.w 1020,20320
	dc.w 1020,20160
	dc.w 1020,20000
	dc.w 1020,19840
	dc.w 1020,19680
	dc.w 1020,19520
	dc.w 1020,19360
	dc.w 1020,19200
	dc.w 1024,19040
	dc.w 1024,18880
	dc.w 1024,18720
	dc.w 1024,18560
	dc.w 1024,18400
	dc.w 1024,18240
	dc.w 1024,18080
	dc.w 1024,17920
	dc.w 1028,17760
	dc.w 1028,17600
	dc.w 1028,17440
	dc.w 1028,17280
	dc.w 1032,17120
	dc.w 1036,16960
	dc.w 1040,16960
	dc.w 1044,17120
	dc.w 1048,17280
	dc.w 1048,17440
	dc.w 1048,17600
	dc.w 1048,17760
	dc.w 1048,17920
	dc.w 1048,18080
	dc.w 1052,18240
	dc.w 1052,18400
	dc.w 1056,18560
	dc.w 1060,18400
	dc.w 1060,18240
	dc.w 1060,18080
	dc.w 1060,17920
	dc.w 1060,17760
	dc.w 1060,17600
	dc.w 1060,17440
	dc.w 1060,17280
	dc.w 1060,17120
	dc.w 1060,16960
	dc.w 1060,16800
	dc.w 1060,16640
	dc.w 1060,16480
	dc.w 1060,16320
	dc.w 1060,16160
	dc.w 1060,16000
	dc.w 1060,15840
	dc.w 1060,15680
	dc.w 1064,15520
	dc.w 1064,15360
	dc.w 1064,15200
	dc.w 1064,15040
	dc.w 1064,14880
	dc.w 1064,14720
	dc.w 1064,14560
	dc.w 1068,14400
	dc.w 1068,14240
	dc.w 1068,14080
	dc.w 1068,13920
	dc.w 1068,13760
	dc.w 1068,13600
	dc.w 1072,13440
	dc.w 1072,13280
	dc.w 1072,13120
	dc.w 1072,12960
	dc.w 1072,12800
	dc.w 1076,12640
	dc.w 1076,12480
	dc.w 1076,12320
	dc.w 1076,12160
	dc.w 1080,12000
	dc.w 1080,11840
	dc.w 1080,11680
	dc.w 1084,11520
	dc.w 1088,11360
	dc.w 1092,11360
	dc.w 1096,11520
	dc.w 1100,11680
	dc.w 1100,11840
	dc.w 1100,12000
	dc.w 1104,12160
	dc.w 1104,12320
	dc.w 1104,12480
	dc.w 1108,12640
	dc.w 1108,12800
	dc.w 1108,12960
	dc.w 1112,13120
	dc.w 1112,13280
	dc.w 1112,13440
	dc.w 1112,13600
	dc.w 1116,13760
	dc.w 1116,13920
	dc.w 1116,14080
	dc.w 1116,14240
	dc.w 1116,14400
	dc.w 1120,14560
	dc.w 1120,14720
	dc.w 1120,14880
	dc.w 1120,15040
	dc.w 1120,15200
	dc.w 1124,15360
	dc.w 1124,15520
	dc.w 1124,15680
	dc.w 1124,15840
	dc.w 1128,16000
	dc.w 1128,16160
	dc.w 1128,16320
	dc.w 1128,16480
	dc.w 1128,16640
	dc.w 1132,16800
	dc.w 1132,16960
	dc.w 1132,17120
	dc.w 1132,17280
	dc.w 1132,17440
	dc.w 1132,17600
	dc.w 1136,17760
	dc.w 1136,17920
	dc.w 1136,18080
	dc.w 1136,18240
	dc.w 1136,18400
	dc.w 1140,18560
	dc.w 1144,18400
	dc.w 1144,18240
	dc.w 1148,18080
	dc.w 1152,17920
	dc.w 1152,17760
	dc.w 1152,17600
	dc.w 1156,17440
	dc.w 1160,17280
	dc.w 1164,17280
	dc.w 1168,17280
	dc.w 1172,17280
	dc.w 1176,17440
	dc.w 1176,17600
	dc.w 1180,17760
	dc.w 1184,17920
	dc.w 1188,18080
	dc.w 1192,18240
	dc.w 1192,18400
	dc.w 1196,18560
	dc.w 1200,18560
	dc.w 1204,18560
	dc.w 1208,18560
	dc.w 1212,18560
	dc.w 1216,18560
	dc.w 1220,18560
	dc.w 1224,18560
	dc.w 1228,18560
	dc.w 1232,18560
	dc.w 1236,18560
	dc.w 1240,18560
	dc.w 1244,18560
	dc.w 1248,18560
	dc.w 1252,18560
	dc.w 1256,18560
	dc.w 1260,18560
	dc.w 1264,18560
	dc.w 1268,18560
	dc.w 1272,18560
	dc.w 1276,18560
	dc.w -1,-1
;1142
pulse_y_vals2
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 4
	dc.w 6
	dc.w 8
	dc.w 10
	dc.w 12
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 10
	dc.w 8
	dc.w 6
	dc.w 4
	dc.w 2
	dc.w 2
	dc.w 2
	dc.w 4
	dc.w 6
	dc.w 10
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 6
	dc.w 6
	dc.w 6
	dc.w 8
	dc.w 8
	dc.w 10
	dc.w 10
	dc.w 6
	dc.w 4
	dc.w 2
	dc.w 8
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 10
	dc.w 6
	dc.w 4
	dc.w 4
	dc.w 4
	dc.w 6
	dc.w 6
	dc.w 8
	dc.w 8
	dc.w 8
	dc.w 8
	dc.w 6
	dc.w 6
	dc.w 4
	dc.w 2
	dc.w 2
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 4
	dc.w 6
	dc.w 8
	dc.w 10
	dc.w 12
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 10
	dc.w 8
	dc.w 6
	dc.w 4
	dc.w 2
	dc.w 2
	dc.w 2
	dc.w 4
	dc.w 6
	dc.w 10
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 6
	dc.w 6
	dc.w 6
	dc.w 8
	dc.w 8
	dc.w 10
	dc.w 10
	dc.w 6
	dc.w 4
	dc.w 2
	dc.w 8
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 14
	dc.w 10
	dc.w 6
	dc.w 4
	dc.w 4
	dc.w 4
	dc.w 6
	dc.w 6
	dc.w 8
	dc.w 8
	dc.w 8
	dc.w 8
	dc.w 6
	dc.w 6
	dc.w 4
	dc.w 2
	dc.w 2
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
	dc.w 0
