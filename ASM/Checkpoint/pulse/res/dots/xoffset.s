	dc.w	50
	dc.w	52
	dc.w	54
	dc.w	56
	dc.w	57
	dc.w	59
	dc.w	61
	dc.w	63
	dc.w	64
	dc.w	66
	dc.w	68
	dc.w	69
	dc.w	71
	dc.w	72
	dc.w	73
	dc.w	74
	dc.w	75
	dc.w	76
	dc.w	77
	dc.w	78
	dc.w	79
	dc.w	79
	dc.w	79
	dc.w	80
	dc.w	80
	dc.w	80
	dc.w	80
	dc.w	80
	dc.w	79
	dc.w	79
	dc.w	79
	dc.w	78
	dc.w	77
	dc.w	76
	dc.w	75
	dc.w	74
	dc.w	73
	dc.w	72
	dc.w	71
	dc.w	69
	dc.w	68
	dc.w	66
	dc.w	64
	dc.w	63
	dc.w	61
	dc.w	59
	dc.w	57
	dc.w	56
	dc.w	54
	dc.w	52
	dc.w	50
	dc.w	48
	dc.w	46
	dc.w	44
	dc.w	43
	dc.w	41
	dc.w	39
	dc.w	37
	dc.w	36
	dc.w	34
	dc.w	32
	dc.w	31
	dc.w	29
	dc.w	28
	dc.w	27
	dc.w	26
	dc.w	25
	dc.w	24
	dc.w	23
	dc.w	22
	dc.w	21
	dc.w	21
	dc.w	21
	dc.w	20
	dc.w	20
	dc.w	20
	dc.w	20
	dc.w	20
	dc.w	21
	dc.w	21
	dc.w	21
	dc.w	22
	dc.w	23
	dc.w	24
	dc.w	25
	dc.w	26
	dc.w	27
	dc.w	28
	dc.w	29
	dc.w	31
	dc.w	32
	dc.w	34
	dc.w	36
	dc.w	37
	dc.w	39
	dc.w	41
	dc.w	43
	dc.w	44
	dc.w	46
	dc.w	48
