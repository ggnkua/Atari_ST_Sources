	dc.w	1984
	dc.w	2048
	dc.w	2176
	dc.w	2304
	dc.w	2432
	dc.w	2560
	dc.w	2688
	dc.w	2752
	dc.w	2880
	dc.w	3008
	dc.w	3072
	dc.w	3200
	dc.w	3264
	dc.w	3328
	dc.w	3456
	dc.w	3520
	dc.w	3584
	dc.w	3648
	dc.w	3712
	dc.w	3712
	dc.w	3776
	dc.w	3840
	dc.w	3840
	dc.w	3840
	dc.w	3840
	dc.w	3904
	dc.w	3840
	dc.w	3840
	dc.w	3840
	dc.w	3840
	dc.w	3776
	dc.w	3712
	dc.w	3712
	dc.w	3648
	dc.w	3584
	dc.w	3520
	dc.w	3456
	dc.w	3328
	dc.w	3264
	dc.w	3200
	dc.w	3072
	dc.w	3008
	dc.w	2880
	dc.w	2752
	dc.w	2688
	dc.w	2560
	dc.w	2432
	dc.w	2304
	dc.w	2176
	dc.w	2048
	dc.w	1984
	dc.w	1856
	dc.w	1728
	dc.w	1600
	dc.w	1472
	dc.w	1344
	dc.w	1216
	dc.w	1152
	dc.w	1024
	dc.w	896
	dc.w	832
	dc.w	704
	dc.w	640
	dc.w	576
	dc.w	448
	dc.w	384
	dc.w	320
	dc.w	256
	dc.w	192
	dc.w	192
	dc.w	128
	dc.w	64
	dc.w	64
	dc.w	64
	dc.w	64
	dc.w	64
	dc.w	64
	dc.w	64
	dc.w	64
	dc.w	64
	dc.w	128
	dc.w	192
	dc.w	192
	dc.w	256
	dc.w	320
	dc.w	384
	dc.w	448
	dc.w	576
	dc.w	640
	dc.w	704
	dc.w	832
	dc.w	896
	dc.w	1024
	dc.w	1152
	dc.w	1216
	dc.w	1344
	dc.w	1472
	dc.w	1600
	dc.w	1728
	dc.w	1856
