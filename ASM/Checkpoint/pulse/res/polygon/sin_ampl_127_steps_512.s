	 dc.w 0	;	0
	 dc.w 2	;	1
	 dc.w 3	;	2
	 dc.w 5	;	3
	 dc.w 6	;	4
	 dc.w 8	;	5
	 dc.w 9	;	6
	 dc.w 11	;	7
	 dc.w 12	;	8
	 dc.w 14	;	9
	 dc.w 16	;	10
	 dc.w 17	;	11
	 dc.w 19	;	12
	 dc.w 20	;	13
	 dc.w 22	;	14
	 dc.w 23	;	15
	 dc.w 25	;	16
	 dc.w 26	;	17
	 dc.w 28	;	18
	 dc.w 29	;	19
	 dc.w 31	;	20
	 dc.w 32	;	21
	 dc.w 34	;	22
	 dc.w 35	;	23
	 dc.w 37	;	24
	 dc.w 38	;	25
	 dc.w 40	;	26
	 dc.w 41	;	27
	 dc.w 43	;	28
	 dc.w 44	;	29
	 dc.w 46	;	30
	 dc.w 47	;	31
	 dc.w 49	;	32
	 dc.w 50	;	33
	 dc.w 51	;	34
	 dc.w 53	;	35
	 dc.w 54	;	36
	 dc.w 56	;	37
	 dc.w 57	;	38
	 dc.w 58	;	39
	 dc.w 60	;	40
	 dc.w 61	;	41
	 dc.w 63	;	42
	 dc.w 64	;	43
	 dc.w 65	;	44
	 dc.w 67	;	45
	 dc.w 68	;	46
	 dc.w 69	;	47
	 dc.w 71	;	48
	 dc.w 72	;	49
	 dc.w 73	;	50
	 dc.w 74	;	51
	 dc.w 76	;	52
	 dc.w 77	;	53
	 dc.w 78	;	54
	 dc.w 79	;	55
	 dc.w 81	;	56
	 dc.w 82	;	57
	 dc.w 83	;	58
	 dc.w 84	;	59
	 dc.w 85	;	60
	 dc.w 86	;	61
	 dc.w 88	;	62
	 dc.w 89	;	63
	 dc.w 90	;	64
	 dc.w 91	;	65
	 dc.w 92	;	66
	 dc.w 93	;	67
	 dc.w 94	;	68
	 dc.w 95	;	69
	 dc.w 96	;	70
	 dc.w 97	;	71
	 dc.w 98	;	72
	 dc.w 99	;	73
	 dc.w 100	;	74
	 dc.w 101	;	75
	 dc.w 102	;	76
	 dc.w 103	;	77
	 dc.w 104	;	78
	 dc.w 105	;	79
	 dc.w 106	;	80
	 dc.w 106	;	81
	 dc.w 107	;	82
	 dc.w 108	;	83
	 dc.w 109	;	84
	 dc.w 110	;	85
	 dc.w 111	;	86
	 dc.w 111	;	87
	 dc.w 112	;	88
	 dc.w 113	;	89
	 dc.w 113	;	90
	 dc.w 114	;	91
	 dc.w 115	;	92
	 dc.w 115	;	93
	 dc.w 116	;	94
	 dc.w 117	;	95
	 dc.w 117	;	96
	 dc.w 118	;	97
	 dc.w 118	;	98
	 dc.w 119	;	99
	 dc.w 120	;	100
	 dc.w 120	;	101
	 dc.w 121	;	102
	 dc.w 121	;	103
	 dc.w 122	;	104
	 dc.w 122	;	105
	 dc.w 122	;	106
	 dc.w 123	;	107
	 dc.w 123	;	108
	 dc.w 124	;	109
	 dc.w 124	;	110
	 dc.w 124	;	111
	 dc.w 125	;	112
	 dc.w 125	;	113
	 dc.w 125	;	114
	 dc.w 125	;	115
	 dc.w 126	;	116
	 dc.w 126	;	117
	 dc.w 126	;	118
	 dc.w 126	;	119
	 dc.w 126	;	120
	 dc.w 127	;	121
	 dc.w 127	;	122
	 dc.w 127	;	123
	 dc.w 127	;	124
	 dc.w 127	;	125
	 dc.w 127	;	126
	 dc.w 127	;	127
	 dc.w 127	;	128
	 dc.w 127	;	129
	 dc.w 127	;	130
	 dc.w 127	;	131
	 dc.w 127	;	132
	 dc.w 127	;	133
	 dc.w 127	;	134
	 dc.w 127	;	135
	 dc.w 126	;	136
	 dc.w 126	;	137
	 dc.w 126	;	138
	 dc.w 126	;	139
	 dc.w 126	;	140
	 dc.w 125	;	141
	 dc.w 125	;	142
	 dc.w 125	;	143
	 dc.w 125	;	144
	 dc.w 124	;	145
	 dc.w 124	;	146
	 dc.w 124	;	147
	 dc.w 123	;	148
	 dc.w 123	;	149
	 dc.w 122	;	150
	 dc.w 122	;	151
	 dc.w 122	;	152
	 dc.w 121	;	153
	 dc.w 121	;	154
	 dc.w 120	;	155
	 dc.w 120	;	156
	 dc.w 119	;	157
	 dc.w 118	;	158
	 dc.w 118	;	159
	 dc.w 117	;	160
	 dc.w 117	;	161
	 dc.w 116	;	162
	 dc.w 115	;	163
	 dc.w 115	;	164
	 dc.w 114	;	165
	 dc.w 113	;	166
	 dc.w 113	;	167
	 dc.w 112	;	168
	 dc.w 111	;	169
	 dc.w 111	;	170
	 dc.w 110	;	171
	 dc.w 109	;	172
	 dc.w 108	;	173
	 dc.w 107	;	174
	 dc.w 106	;	175
	 dc.w 106	;	176
	 dc.w 105	;	177
	 dc.w 104	;	178
	 dc.w 103	;	179
	 dc.w 102	;	180
	 dc.w 101	;	181
	 dc.w 100	;	182
	 dc.w 99	;	183
	 dc.w 98	;	184
	 dc.w 97	;	185
	 dc.w 96	;	186
	 dc.w 95	;	187
	 dc.w 94	;	188
	 dc.w 93	;	189
	 dc.w 92	;	190
	 dc.w 91	;	191
	 dc.w 90	;	192
	 dc.w 89	;	193
	 dc.w 88	;	194
	 dc.w 86	;	195
	 dc.w 85	;	196
	 dc.w 84	;	197
	 dc.w 83	;	198
	 dc.w 82	;	199
	 dc.w 81	;	200
	 dc.w 79	;	201
	 dc.w 78	;	202
	 dc.w 77	;	203
	 dc.w 76	;	204
	 dc.w 74	;	205
	 dc.w 73	;	206
	 dc.w 72	;	207
	 dc.w 71	;	208
	 dc.w 69	;	209
	 dc.w 68	;	210
	 dc.w 67	;	211
	 dc.w 65	;	212
	 dc.w 64	;	213
	 dc.w 63	;	214
	 dc.w 61	;	215
	 dc.w 60	;	216
	 dc.w 58	;	217
	 dc.w 57	;	218
	 dc.w 56	;	219
	 dc.w 54	;	220
	 dc.w 53	;	221
	 dc.w 51	;	222
	 dc.w 50	;	223
	 dc.w 49	;	224
	 dc.w 47	;	225
	 dc.w 46	;	226
	 dc.w 44	;	227
	 dc.w 43	;	228
	 dc.w 41	;	229
	 dc.w 40	;	230
	 dc.w 38	;	231
	 dc.w 37	;	232
	 dc.w 35	;	233
	 dc.w 34	;	234
	 dc.w 32	;	235
	 dc.w 31	;	236
	 dc.w 29	;	237
	 dc.w 28	;	238
	 dc.w 26	;	239
	 dc.w 25	;	240
	 dc.w 23	;	241
	 dc.w 22	;	242
	 dc.w 20	;	243
	 dc.w 19	;	244
	 dc.w 17	;	245
	 dc.w 16	;	246
	 dc.w 14	;	247
	 dc.w 12	;	248
	 dc.w 11	;	249
	 dc.w 9	;	250
	 dc.w 8	;	251
	 dc.w 6	;	252
	 dc.w 5	;	253
	 dc.w 3	;	254
	 dc.w 2	;	255
	 dc.w 0	;	256
	 dc.w -2	;	257
	 dc.w -3	;	258
	 dc.w -5	;	259
	 dc.w -6	;	260
	 dc.w -8	;	261
	 dc.w -9	;	262
	 dc.w -11	;	263
	 dc.w -12	;	264
	 dc.w -14	;	265
	 dc.w -16	;	266
	 dc.w -17	;	267
	 dc.w -19	;	268
	 dc.w -20	;	269
	 dc.w -22	;	270
	 dc.w -23	;	271
	 dc.w -25	;	272
	 dc.w -26	;	273
	 dc.w -28	;	274
	 dc.w -29	;	275
	 dc.w -31	;	276
	 dc.w -32	;	277
	 dc.w -34	;	278
	 dc.w -35	;	279
	 dc.w -37	;	280
	 dc.w -38	;	281
	 dc.w -40	;	282
	 dc.w -41	;	283
	 dc.w -43	;	284
	 dc.w -44	;	285
	 dc.w -46	;	286
	 dc.w -47	;	287
	 dc.w -49	;	288
	 dc.w -50	;	289
	 dc.w -51	;	290
	 dc.w -53	;	291
	 dc.w -54	;	292
	 dc.w -56	;	293
	 dc.w -57	;	294
	 dc.w -58	;	295
	 dc.w -60	;	296
	 dc.w -61	;	297
	 dc.w -63	;	298
	 dc.w -64	;	299
	 dc.w -65	;	300
	 dc.w -67	;	301
	 dc.w -68	;	302
	 dc.w -69	;	303
	 dc.w -71	;	304
	 dc.w -72	;	305
	 dc.w -73	;	306
	 dc.w -74	;	307
	 dc.w -76	;	308
	 dc.w -77	;	309
	 dc.w -78	;	310
	 dc.w -79	;	311
	 dc.w -81	;	312
	 dc.w -82	;	313
	 dc.w -83	;	314
	 dc.w -84	;	315
	 dc.w -85	;	316
	 dc.w -86	;	317
	 dc.w -88	;	318
	 dc.w -89	;	319
	 dc.w -90	;	320
	 dc.w -91	;	321
	 dc.w -92	;	322
	 dc.w -93	;	323
	 dc.w -94	;	324
	 dc.w -95	;	325
	 dc.w -96	;	326
	 dc.w -97	;	327
	 dc.w -98	;	328
	 dc.w -99	;	329
	 dc.w -100	;	330
	 dc.w -101	;	331
	 dc.w -102	;	332
	 dc.w -103	;	333
	 dc.w -104	;	334
	 dc.w -105	;	335
	 dc.w -106	;	336
	 dc.w -106	;	337
	 dc.w -107	;	338
	 dc.w -108	;	339
	 dc.w -109	;	340
	 dc.w -110	;	341
	 dc.w -111	;	342
	 dc.w -111	;	343
	 dc.w -112	;	344
	 dc.w -113	;	345
	 dc.w -113	;	346
	 dc.w -114	;	347
	 dc.w -115	;	348
	 dc.w -115	;	349
	 dc.w -116	;	350
	 dc.w -117	;	351
	 dc.w -117	;	352
	 dc.w -118	;	353
	 dc.w -118	;	354
	 dc.w -119	;	355
	 dc.w -120	;	356
	 dc.w -120	;	357
	 dc.w -121	;	358
	 dc.w -121	;	359
	 dc.w -122	;	360
	 dc.w -122	;	361
	 dc.w -122	;	362
	 dc.w -123	;	363
	 dc.w -123	;	364
	 dc.w -124	;	365
	 dc.w -124	;	366
	 dc.w -124	;	367
	 dc.w -125	;	368
	 dc.w -125	;	369
	 dc.w -125	;	370
	 dc.w -125	;	371
	 dc.w -126	;	372
	 dc.w -126	;	373
	 dc.w -126	;	374
	 dc.w -126	;	375
	 dc.w -126	;	376
	 dc.w -127	;	377
	 dc.w -127	;	378
	 dc.w -127	;	379
	 dc.w -127	;	380
	 dc.w -127	;	381
	 dc.w -127	;	382
	 dc.w -127	;	383
	 dc.w -127	;	384
	 dc.w -127	;	385
	 dc.w -127	;	386
	 dc.w -127	;	387
	 dc.w -127	;	388
	 dc.w -127	;	389
	 dc.w -127	;	390
	 dc.w -127	;	391
	 dc.w -126	;	392
	 dc.w -126	;	393
	 dc.w -126	;	394
	 dc.w -126	;	395
	 dc.w -126	;	396
	 dc.w -125	;	397
	 dc.w -125	;	398
	 dc.w -125	;	399
	 dc.w -125	;	400
	 dc.w -124	;	401
	 dc.w -124	;	402
	 dc.w -124	;	403
	 dc.w -123	;	404
	 dc.w -123	;	405
	 dc.w -122	;	406
	 dc.w -122	;	407
	 dc.w -122	;	408
	 dc.w -121	;	409
	 dc.w -121	;	410
	 dc.w -120	;	411
	 dc.w -120	;	412
	 dc.w -119	;	413
	 dc.w -118	;	414
	 dc.w -118	;	415
	 dc.w -117	;	416
	 dc.w -117	;	417
	 dc.w -116	;	418
	 dc.w -115	;	419
	 dc.w -115	;	420
	 dc.w -114	;	421
	 dc.w -113	;	422
	 dc.w -113	;	423
	 dc.w -112	;	424
	 dc.w -111	;	425
	 dc.w -111	;	426
	 dc.w -110	;	427
	 dc.w -109	;	428
	 dc.w -108	;	429
	 dc.w -107	;	430
	 dc.w -106	;	431
	 dc.w -106	;	432
	 dc.w -105	;	433
	 dc.w -104	;	434
	 dc.w -103	;	435
	 dc.w -102	;	436
	 dc.w -101	;	437
	 dc.w -100	;	438
	 dc.w -99	;	439
	 dc.w -98	;	440
	 dc.w -97	;	441
	 dc.w -96	;	442
	 dc.w -95	;	443
	 dc.w -94	;	444
	 dc.w -93	;	445
	 dc.w -92	;	446
	 dc.w -91	;	447
	 dc.w -90	;	448
	 dc.w -89	;	449
	 dc.w -88	;	450
	 dc.w -86	;	451
	 dc.w -85	;	452
	 dc.w -84	;	453
	 dc.w -83	;	454
	 dc.w -82	;	455
	 dc.w -81	;	456
	 dc.w -79	;	457
	 dc.w -78	;	458
	 dc.w -77	;	459
	 dc.w -76	;	460
	 dc.w -74	;	461
	 dc.w -73	;	462
	 dc.w -72	;	463
	 dc.w -71	;	464
	 dc.w -69	;	465
	 dc.w -68	;	466
	 dc.w -67	;	467
	 dc.w -65	;	468
	 dc.w -64	;	469
	 dc.w -63	;	470
	 dc.w -61	;	471
	 dc.w -60	;	472
	 dc.w -58	;	473
	 dc.w -57	;	474
	 dc.w -56	;	475
	 dc.w -54	;	476
	 dc.w -53	;	477
	 dc.w -51	;	478
	 dc.w -50	;	479
	 dc.w -49	;	480
	 dc.w -47	;	481
	 dc.w -46	;	482
	 dc.w -44	;	483
	 dc.w -43	;	484
	 dc.w -41	;	485
	 dc.w -40	;	486
	 dc.w -38	;	487
	 dc.w -37	;	488
	 dc.w -35	;	489
	 dc.w -34	;	490
	 dc.w -32	;	491
	 dc.w -31	;	492
	 dc.w -29	;	493
	 dc.w -28	;	494
	 dc.w -26	;	495
	 dc.w -25	;	496
	 dc.w -23	;	497
	 dc.w -22	;	498
	 dc.w -20	;	499
	 dc.w -19	;	500
	 dc.w -17	;	501
	 dc.w -16	;	502
	 dc.w -14	;	503
	 dc.w -12	;	504
	 dc.w -11	;	505
	 dc.w -9	;	506
	 dc.w -8	;	507
	 dc.w -6	;	508
	 dc.w -5	;	509
	 dc.w -3	;	510
	 dc.w -2	;	511
	 dc.w -0	;	512
	 dc.w 2	;	513
	 dc.w 3	;	514
	 dc.w 5	;	515
	 dc.w 6	;	516
	 dc.w 8	;	517
	 dc.w 9	;	518
	 dc.w 11	;	519
	 dc.w 12	;	520
	 dc.w 14	;	521
	 dc.w 16	;	522
	 dc.w 17	;	523
	 dc.w 19	;	524
	 dc.w 20	;	525
	 dc.w 22	;	526
	 dc.w 23	;	527
	 dc.w 25	;	528
	 dc.w 26	;	529
	 dc.w 28	;	530
	 dc.w 29	;	531
	 dc.w 31	;	532
	 dc.w 32	;	533
	 dc.w 34	;	534
	 dc.w 35	;	535
	 dc.w 37	;	536
	 dc.w 38	;	537
	 dc.w 40	;	538
	 dc.w 41	;	539
	 dc.w 43	;	540
	 dc.w 44	;	541
	 dc.w 46	;	542
	 dc.w 47	;	543
	 dc.w 49	;	544
	 dc.w 50	;	545
	 dc.w 51	;	546
	 dc.w 53	;	547
	 dc.w 54	;	548
	 dc.w 56	;	549
	 dc.w 57	;	550
	 dc.w 58	;	551
	 dc.w 60	;	552
	 dc.w 61	;	553
	 dc.w 63	;	554
	 dc.w 64	;	555
	 dc.w 65	;	556
	 dc.w 67	;	557
	 dc.w 68	;	558
	 dc.w 69	;	559
	 dc.w 71	;	560
	 dc.w 72	;	561
	 dc.w 73	;	562
	 dc.w 74	;	563
	 dc.w 76	;	564
	 dc.w 77	;	565
	 dc.w 78	;	566
	 dc.w 79	;	567
	 dc.w 81	;	568
	 dc.w 82	;	569
	 dc.w 83	;	570
	 dc.w 84	;	571
	 dc.w 85	;	572
	 dc.w 86	;	573
	 dc.w 88	;	574
	 dc.w 89	;	575
	 dc.w 90	;	576
	 dc.w 91	;	577
	 dc.w 92	;	578
	 dc.w 93	;	579
	 dc.w 94	;	580
	 dc.w 95	;	581
	 dc.w 96	;	582
	 dc.w 97	;	583
	 dc.w 98	;	584
	 dc.w 99	;	585
	 dc.w 100	;	586
	 dc.w 101	;	587
	 dc.w 102	;	588
	 dc.w 103	;	589
	 dc.w 104	;	590
	 dc.w 105	;	591
	 dc.w 106	;	592
	 dc.w 106	;	593
	 dc.w 107	;	594
	 dc.w 108	;	595
	 dc.w 109	;	596
	 dc.w 110	;	597
	 dc.w 111	;	598
	 dc.w 111	;	599
	 dc.w 112	;	600
	 dc.w 113	;	601
	 dc.w 113	;	602
	 dc.w 114	;	603
	 dc.w 115	;	604
	 dc.w 115	;	605
	 dc.w 116	;	606
	 dc.w 117	;	607
	 dc.w 117	;	608
	 dc.w 118	;	609
	 dc.w 118	;	610
	 dc.w 119	;	611
	 dc.w 120	;	612
	 dc.w 120	;	613
	 dc.w 121	;	614
	 dc.w 121	;	615
	 dc.w 122	;	616
	 dc.w 122	;	617
	 dc.w 122	;	618
	 dc.w 123	;	619
	 dc.w 123	;	620
	 dc.w 124	;	621
	 dc.w 124	;	622
	 dc.w 124	;	623
	 dc.w 125	;	624
	 dc.w 125	;	625
	 dc.w 125	;	626
	 dc.w 125	;	627
	 dc.w 126	;	628
	 dc.w 126	;	629
	 dc.w 126	;	630
	 dc.w 126	;	631
	 dc.w 126	;	632
	 dc.w 127	;	633
	 dc.w 127	;	634
	 dc.w 127	;	635
	 dc.w 127	;	636
	 dc.w 127	;	637
	 dc.w 127	;	638
	 dc.w 127	;	639
