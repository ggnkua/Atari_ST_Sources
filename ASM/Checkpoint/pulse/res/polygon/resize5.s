	 dc.w 0	;	0
	 dc.w 8	;	1
	 dc.w 16	;	2
	 dc.w 24	;	3
	 dc.w 32	;	4
	 dc.w 40	;	5
	 dc.w 48	;	6
	 dc.w 56	;	7
	 dc.w 64	;	8
	 dc.w 72	;	9
	 dc.w 80	;	10
	 dc.w 84	;	11
	 dc.w 92	;	12
	 dc.w 100	;	13
	 dc.w 108	;	14
	 dc.w 116	;	15
	 dc.w 124	;	16
	 dc.w 128	;	17
	 dc.w 136	;	18
	 dc.w 144	;	19
	 dc.w 148	;	20
	 dc.w 156	;	21
	 dc.w 160	;	22
	 dc.w 168	;	23
	 dc.w 172	;	24
	 dc.w 180	;	25
	 dc.w 184	;	26
	 dc.w 188	;	27
	 dc.w 192	;	28
	 dc.w 200	;	29
	 dc.w 204	;	30
	 dc.w 208	;	31
	 dc.w 212	;	32
	 dc.w 216	;	33
	 dc.w 220	;	34
	 dc.w 224	;	35
	 dc.w 224	;	36
	 dc.w 228	;	37
	 dc.w 232	;	38
	 dc.w 232	;	39
	 dc.w 236	;	40
	 dc.w 236	;	41
	 dc.w 240	;	42
	 dc.w 240	;	43
	 dc.w 240	;	44
	 dc.w 244	;	45
	 dc.w 244	;	46
	 dc.w 244	;	47
	 dc.w 244	;	48
	 dc.w 244	;	49
	 dc.w 244	;	50
	 dc.w 244	;	51
	 dc.w 240	;	52
	 dc.w 240	;	53
	 dc.w 240	;	54
	 dc.w 236	;	55
	 dc.w 236	;	56
	 dc.w 232	;	57
	 dc.w 232	;	58
	 dc.w 228	;	59
	 dc.w 224	;	60
	 dc.w 224	;	61
	 dc.w 220	;	62
	 dc.w 216	;	63
	 dc.w 212	;	64
	 dc.w 208	;	65
	 dc.w 204	;	66
	 dc.w 200	;	67
	 dc.w 192	;	68
	 dc.w 188	;	69
	 dc.w 184	;	70
	 dc.w 180	;	71
	 dc.w 172	;	72
	 dc.w 168	;	73
	 dc.w 160	;	74
	 dc.w 156	;	75
	 dc.w 148	;	76
	 dc.w 144	;	77
	 dc.w 136	;	78
	 dc.w 128	;	79
	 dc.w 124	;	80
	 dc.w 116	;	81
	 dc.w 108	;	82
	 dc.w 100	;	83
	 dc.w 92	;	84
	 dc.w 84	;	85
	 dc.w 80	;	86
	 dc.w 72	;	87
	 dc.w 64	;	88
	 dc.w 56	;	89
	 dc.w 48	;	90
	 dc.w 40	;	91
	 dc.w 32	;	92
	 dc.w 24	;	93
	 dc.w 16	;	94
	 dc.w 8	;	95
	 dc.w 0	;	96
	 dc.w 8	;	97
	 dc.w 16	;	98
	 dc.w 24	;	99
	 dc.w 32	;	100
	 dc.w 40	;	101
	 dc.w 48	;	102
	 dc.w 56	;	103
	 dc.w 64	;	104
	 dc.w 72	;	105
	 dc.w 80	;	106
	 dc.w 84	;	107
	 dc.w 92	;	108
	 dc.w 100	;	109
	 dc.w 108	;	110
	 dc.w 116	;	111
	 dc.w 124	;	112
	 dc.w 128	;	113
	 dc.w 136	;	114
	 dc.w 144	;	115
	 dc.w 148	;	116
	 dc.w 156	;	117
	 dc.w 160	;	118
	 dc.w 168	;	119
	 dc.w 172	;	120
	 dc.w 180	;	121
	 dc.w 184	;	122
	 dc.w 188	;	123
	 dc.w 192	;	124
	 dc.w 200	;	125
	 dc.w 204	;	126
	 dc.w 208	;	127
	 dc.w 212	;	128
	 dc.w 216	;	129
	 dc.w 220	;	130
	 dc.w 224	;	131
	 dc.w 224	;	132
	 dc.w 228	;	133
	 dc.w 232	;	134
	 dc.w 232	;	135
	 dc.w 236	;	136
	 dc.w 236	;	137
	 dc.w 240	;	138
	 dc.w 240	;	139
	 dc.w 240	;	140
	 dc.w 244	;	141
	 dc.w 244	;	142
	 dc.w 244	;	143
	 dc.w 244	;	144
	 dc.w 244	;	145
	 dc.w 244	;	146
	 dc.w 244	;	147
	 dc.w 240	;	148
	 dc.w 240	;	149
	 dc.w 240	;	150
	 dc.w 236	;	151
	 dc.w 236	;	152
	 dc.w 232	;	153
	 dc.w 232	;	154
	 dc.w 228	;	155
	 dc.w 224	;	156
	 dc.w 224	;	157
	 dc.w 220	;	158
	 dc.w 216	;	159
	 dc.w 212	;	160
	 dc.w 208	;	161
	 dc.w 204	;	162
	 dc.w 200	;	163
	 dc.w 192	;	164
	 dc.w 188	;	165
	 dc.w 184	;	166
	 dc.w 180	;	167
	 dc.w 172	;	168
	 dc.w 168	;	169
	 dc.w 160	;	170
	 dc.w 156	;	171
	 dc.w 148	;	172
	 dc.w 144	;	173
	 dc.w 136	;	174
	 dc.w 128	;	175
	 dc.w 124	;	176
	 dc.w 116	;	177
	 dc.w 108	;	178
	 dc.w 100	;	179
	 dc.w 92	;	180
	 dc.w 84	;	181
	 dc.w 80	;	182
	 dc.w 72	;	183
	 dc.w 64	;	184
	 dc.w 56	;	185
	 dc.w 48	;	186
	 dc.w 40	;	187
	 dc.w 32	;	188
	 dc.w 24	;	189
	 dc.w 16	;	190
	 dc.w 8	;	191
