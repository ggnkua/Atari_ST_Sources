	 dc.w 0	;	0
	 dc.w 3	;	1
	 dc.w 6	;	2
	 dc.w 9	;	3
	 dc.w 12	;	4
	 dc.w 16	;	5
	 dc.w 19	;	6
	 dc.w 22	;	7
	 dc.w 25	;	8
	 dc.w 28	;	9
	 dc.w 31	;	10
	 dc.w 34	;	11
	 dc.w 37	;	12
	 dc.w 40	;	13
	 dc.w 43	;	14
	 dc.w 46	;	15
	 dc.w 49	;	16
	 dc.w 51	;	17
	 dc.w 54	;	18
	 dc.w 57	;	19
	 dc.w 60	;	20
	 dc.w 63	;	21
	 dc.w 65	;	22
	 dc.w 68	;	23
	 dc.w 71	;	24
	 dc.w 73	;	25
	 dc.w 76	;	26
	 dc.w 78	;	27
	 dc.w 81	;	28
	 dc.w 83	;	29
	 dc.w 85	;	30
	 dc.w 88	;	31
	 dc.w 90	;	32
	 dc.w 92	;	33
	 dc.w 94	;	34
	 dc.w 96	;	35
	 dc.w 98	;	36
	 dc.w 100	;	37
	 dc.w 102	;	38
	 dc.w 104	;	39
	 dc.w 106	;	40
	 dc.w 107	;	41
	 dc.w 109	;	42
	 dc.w 111	;	43
	 dc.w 112	;	44
	 dc.w 113	;	45
	 dc.w 115	;	46
	 dc.w 116	;	47
	 dc.w 117	;	48
	 dc.w 118	;	49
	 dc.w 120	;	50
	 dc.w 121	;	51
	 dc.w 122	;	52
	 dc.w 122	;	53
	 dc.w 123	;	54
	 dc.w 124	;	55
	 dc.w 125	;	56
	 dc.w 125	;	57
	 dc.w 126	;	58
	 dc.w 126	;	59
	 dc.w 126	;	60
	 dc.w 127	;	61
	 dc.w 127	;	62
	 dc.w 127	;	63
	 dc.w 127	;	64
	 dc.w 127	;	65
	 dc.w 127	;	66
	 dc.w 127	;	67
	 dc.w 126	;	68
	 dc.w 126	;	69
	 dc.w 126	;	70
	 dc.w 125	;	71
	 dc.w 125	;	72
	 dc.w 124	;	73
	 dc.w 123	;	74
	 dc.w 122	;	75
	 dc.w 122	;	76
	 dc.w 121	;	77
	 dc.w 120	;	78
	 dc.w 118	;	79
	 dc.w 117	;	80
	 dc.w 116	;	81
	 dc.w 115	;	82
	 dc.w 113	;	83
	 dc.w 112	;	84
	 dc.w 111	;	85
	 dc.w 109	;	86
	 dc.w 107	;	87
	 dc.w 106	;	88
	 dc.w 104	;	89
	 dc.w 102	;	90
	 dc.w 100	;	91
	 dc.w 98	;	92
	 dc.w 96	;	93
	 dc.w 94	;	94
	 dc.w 92	;	95
	 dc.w 90	;	96
	 dc.w 88	;	97
	 dc.w 85	;	98
	 dc.w 83	;	99
	 dc.w 81	;	100
	 dc.w 78	;	101
	 dc.w 76	;	102
	 dc.w 73	;	103
	 dc.w 71	;	104
	 dc.w 68	;	105
	 dc.w 65	;	106
	 dc.w 63	;	107
	 dc.w 60	;	108
	 dc.w 57	;	109
	 dc.w 54	;	110
	 dc.w 51	;	111
	 dc.w 49	;	112
	 dc.w 46	;	113
	 dc.w 43	;	114
	 dc.w 40	;	115
	 dc.w 37	;	116
	 dc.w 34	;	117
	 dc.w 31	;	118
	 dc.w 28	;	119
	 dc.w 25	;	120
	 dc.w 22	;	121
	 dc.w 19	;	122
	 dc.w 16	;	123
	 dc.w 12	;	124
	 dc.w 9	;	125
	 dc.w 6	;	126
	 dc.w 3	;	127
	 dc.w 0	;	128
	 dc.w -3	;	129
	 dc.w -6	;	130
	 dc.w -9	;	131
	 dc.w -12	;	132
	 dc.w -16	;	133
	 dc.w -19	;	134
	 dc.w -22	;	135
	 dc.w -25	;	136
	 dc.w -28	;	137
	 dc.w -31	;	138
	 dc.w -34	;	139
	 dc.w -37	;	140
	 dc.w -40	;	141
	 dc.w -43	;	142
	 dc.w -46	;	143
	 dc.w -49	;	144
	 dc.w -51	;	145
	 dc.w -54	;	146
	 dc.w -57	;	147
	 dc.w -60	;	148
	 dc.w -63	;	149
	 dc.w -65	;	150
	 dc.w -68	;	151
	 dc.w -71	;	152
	 dc.w -73	;	153
	 dc.w -76	;	154
	 dc.w -78	;	155
	 dc.w -81	;	156
	 dc.w -83	;	157
	 dc.w -85	;	158
	 dc.w -88	;	159
	 dc.w -90	;	160
	 dc.w -92	;	161
	 dc.w -94	;	162
	 dc.w -96	;	163
	 dc.w -98	;	164
	 dc.w -100	;	165
	 dc.w -102	;	166
	 dc.w -104	;	167
	 dc.w -106	;	168
	 dc.w -107	;	169
	 dc.w -109	;	170
	 dc.w -111	;	171
	 dc.w -112	;	172
	 dc.w -113	;	173
	 dc.w -115	;	174
	 dc.w -116	;	175
	 dc.w -117	;	176
	 dc.w -118	;	177
	 dc.w -120	;	178
	 dc.w -121	;	179
	 dc.w -122	;	180
	 dc.w -122	;	181
	 dc.w -123	;	182
	 dc.w -124	;	183
	 dc.w -125	;	184
	 dc.w -125	;	185
	 dc.w -126	;	186
	 dc.w -126	;	187
	 dc.w -126	;	188
	 dc.w -127	;	189
	 dc.w -127	;	190
	 dc.w -127	;	191
	 dc.w -127	;	192
	 dc.w -127	;	193
	 dc.w -127	;	194
	 dc.w -127	;	195
	 dc.w -126	;	196
	 dc.w -126	;	197
	 dc.w -126	;	198
	 dc.w -125	;	199
	 dc.w -125	;	200
	 dc.w -124	;	201
	 dc.w -123	;	202
	 dc.w -122	;	203
	 dc.w -122	;	204
	 dc.w -121	;	205
	 dc.w -120	;	206
	 dc.w -118	;	207
	 dc.w -117	;	208
	 dc.w -116	;	209
	 dc.w -115	;	210
	 dc.w -113	;	211
	 dc.w -112	;	212
	 dc.w -111	;	213
	 dc.w -109	;	214
	 dc.w -107	;	215
	 dc.w -106	;	216
	 dc.w -104	;	217
	 dc.w -102	;	218
	 dc.w -100	;	219
	 dc.w -98	;	220
	 dc.w -96	;	221
	 dc.w -94	;	222
	 dc.w -92	;	223
	 dc.w -90	;	224
	 dc.w -88	;	225
	 dc.w -85	;	226
	 dc.w -83	;	227
	 dc.w -81	;	228
	 dc.w -78	;	229
	 dc.w -76	;	230
	 dc.w -73	;	231
	 dc.w -71	;	232
	 dc.w -68	;	233
	 dc.w -65	;	234
	 dc.w -63	;	235
	 dc.w -60	;	236
	 dc.w -57	;	237
	 dc.w -54	;	238
	 dc.w -51	;	239
	 dc.w -49	;	240
	 dc.w -46	;	241
	 dc.w -43	;	242
	 dc.w -40	;	243
	 dc.w -37	;	244
	 dc.w -34	;	245
	 dc.w -31	;	246
	 dc.w -28	;	247
	 dc.w -25	;	248
	 dc.w -22	;	249
	 dc.w -19	;	250
	 dc.w -16	;	251
	 dc.w -12	;	252
	 dc.w -9	;	253
	 dc.w -6	;	254
	 dc.w -3	;	255
	 dc.w -0	;	256
	 dc.w 3	;	257
	 dc.w 6	;	258
	 dc.w 9	;	259
	 dc.w 12	;	260
	 dc.w 16	;	261
	 dc.w 19	;	262
	 dc.w 22	;	263
	 dc.w 25	;	264
	 dc.w 28	;	265
	 dc.w 31	;	266
	 dc.w 34	;	267
	 dc.w 37	;	268
	 dc.w 40	;	269
	 dc.w 43	;	270
	 dc.w 46	;	271
	 dc.w 49	;	272
	 dc.w 51	;	273
	 dc.w 54	;	274
	 dc.w 57	;	275
	 dc.w 60	;	276
	 dc.w 63	;	277
	 dc.w 65	;	278
	 dc.w 68	;	279
	 dc.w 71	;	280
	 dc.w 73	;	281
	 dc.w 76	;	282
	 dc.w 78	;	283
	 dc.w 81	;	284
	 dc.w 83	;	285
	 dc.w 85	;	286
	 dc.w 88	;	287
	 dc.w 90	;	288
	 dc.w 92	;	289
	 dc.w 94	;	290
	 dc.w 96	;	291
	 dc.w 98	;	292
	 dc.w 100	;	293
	 dc.w 102	;	294
	 dc.w 104	;	295
	 dc.w 106	;	296
	 dc.w 107	;	297
	 dc.w 109	;	298
	 dc.w 111	;	299
	 dc.w 112	;	300
	 dc.w 113	;	301
	 dc.w 115	;	302
	 dc.w 116	;	303
	 dc.w 117	;	304
	 dc.w 118	;	305
	 dc.w 120	;	306
	 dc.w 121	;	307
	 dc.w 122	;	308
	 dc.w 122	;	309
	 dc.w 123	;	310
	 dc.w 124	;	311
	 dc.w 125	;	312
	 dc.w 125	;	313
	 dc.w 126	;	314
	 dc.w 126	;	315
	 dc.w 126	;	316
	 dc.w 127	;	317
	 dc.w 127	;	318
	 dc.w 127	;	319
