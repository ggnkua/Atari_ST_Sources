	dc.b	15,14,14,14,14,14,14,14,14,14,14,14,14,14,14,15,15,15,15,15,15,15,15,15,15,15,15,15,15,15,15,15
	dc.b	15,14,14,14,14,14,14,14,14,14,14,14,14,14,14,15,15,15,15,15,15,15,15,15,15,15,15,15,15,15,15,15
	dc.b	14,14,13,12,12,12,13,14,14,13,13,12,12,13,14,15,15,15,15,15,15,15,15,15,15,15,15,15,15,15,15,15
	dc.b	15,14,13,12,12,12,13,14,14,13,13,12,12,13,14,15,15,15,15,15,15,15,15,15,15,15,15,15,15,15,15,15
	dc.b	14,13,11,10,10,11,12,13,13,12,11,11,11,12,13,14,15,15,15,15,15,14,14,14,14,14,14,15,15,15,15,14
	dc.b	14,13,11,10,10,11,12,13,13,12,11,11,11,12,13,14,15,15,15,15,15,14,14,14,14,14,14,15,15,15,15,14
	dc.b	12,11,9,8,7,8,10,11,12,11,10,10,10,11,12,14,14,15,15,15,14,13,13,13,13,13,14,14,14,14,14,13
	dc.b	13,11,9,8,7,8,10,11,12,11,10,10,10,11,12,14,14,15,15,15,14,13,13,13,13,13,14,14,14,14,14,14
	dc.b	11,10,7,6,5,6,8,10,11,11,10,9,9,10,12,13,14,14,15,14,14,12,11,11,11,12,13,13,13,13,13,12
	dc.b	11,9,7,6,5,6,8,10,11,11,10,9,9,10,12,13,14,14,15,14,14,12,11,11,11,12,13,13,13,13,13,13
	dc.b	10,9,6,4,3,4,6,8,9,10,10,10,10,10,11,12,13,13,14,14,13,11,10,9,10,11,12,12,11,11,11,11
	dc.b	10,9,6,4,3,4,6,8,9,10,10,10,10,10,11,12,13,13,14,14,13,11,10,9,10,11,12,12,11,11,11,11
	dc.b	10,9,7,5,4,4,5,7,9,10,11,11,10,10,10,10,11,12,13,14,12,10,8,7,8,10,11,11,10,9,9,9
	dc.b	9,8,7,5,4,4,5,7,9,10,11,11,10,10,10,10,11,12,13,14,12,10,8,7,8,10,11,11,10,9,10,10
	dc.b	11,10,8,7,5,5,5,6,8,10,11,12,11,10,9,9,10,11,13,13,12,9,7,7,8,9,10,10,9,8,8,8
	dc.b	9,9,8,7,5,5,5,6,8,10,11,12,11,10,9,9,10,11,13,13,12,9,7,7,8,9,10,10,9,8,8,10
	dc.b	12,12,11,9,8,6,6,6,7,9,11,12,12,9,8,7,8,10,12,12,11,8,7,6,8,10,11,10,8,6,6,8
	dc.b	9,10,10,9,8,6,6,6,7,9,11,12,12,9,8,7,8,10,12,12,11,8,7,6,8,10,11,10,8,6,7,9
	dc.b	14,13,12,12,10,8,7,6,7,8,11,12,11,9,7,6,7,10,12,12,10,8,6,7,8,10,11,10,7,6,6,7
	dc.b	9,11,12,12,10,8,7,6,7,8,11,12,11,9,7,6,7,10,12,12,10,8,6,7,8,10,11,10,7,6,6,9
	dc.b	14,14,14,13,12,10,8,6,6,8,10,11,10,8,6,6,7,10,12,12,10,7,6,7,9,11,11,10,7,5,5,7
	dc.b	9,12,13,13,12,10,8,6,6,8,10,11,10,8,6,6,7,10,12,12,10,7,6,7,9,11,11,10,7,5,5,9
	dc.b	15,15,15,14,13,11,8,7,6,7,9,10,10,8,6,6,8,10,12,11,9,7,6,7,9,11,11,10,7,5,5,7
	dc.b	9,12,14,14,13,11,8,7,6,7,9,10,10,8,6,6,8,10,12,11,9,7,6,7,9,11,11,10,7,5,5,9
	dc.b	15,15,15,15,14,11,8,7,6,7,8,9,8,7,5,6,8,10,12,11,8,6,6,7,9,11,11,9,6,4,4,6
	dc.b	9,12,14,15,14,11,8,7,6,7,8,9,8,7,5,6,8,10,12,11,8,6,6,7,9,11,11,9,6,4,4,8
	dc.b	15,15,15,15,14,11,8,6,6,7,8,9,8,6,5,6,9,11,12,10,8,6,6,7,9,10,9,7,5,3,4,6
	dc.b	9,12,14,15,14,11,8,6,6,7,8,9,8,6,5,6,9,11,12,10,8,6,6,7,9,10,9,7,5,3,4,8
	dc.b	15,15,15,15,13,11,8,6,6,7,8,8,7,6,5,7,9,12,12,10,8,6,6,7,9,9,8,6,3,3,4,6
	dc.b	9,12,14,15,13,11,8,6,6,7,8,8,7,6,5,7,9,12,12,10,8,6,6,7,9,9,8,6,3,3,4,8
	dc.b	15,15,15,14,13,10,7,6,6,7,7,7,6,5,6,8,10,12,12,9,7,5,6,7,8,8,7,4,2,2,4,7
	dc.b	10,13,14,14,13,10,7,6,6,7,7,7,6,5,6,8,10,12,12,9,7,5,6,7,8,8,7,4,2,2,4,9
	dc.b	15,15,15,14,12,9,7,5,5,6,7,6,5,5,6,8,10,12,11,9,6,5,6,7,8,7,6,3,2,3,5,8
	dc.b	11,13,14,14,12,9,7,5,5,6,7,6,5,5,6,8,10,12,11,9,6,5,6,7,8,7,6,3,2,3,5,9
	dc.b	15,15,14,13,11,8,6,5,5,6,6,5,4,4,5,8,11,11,10,8,6,5,6,8,8,7,5,3,2,4,6,9
	dc.b	12,13,14,13,11,8,6,5,5,6,6,5,4,4,5,8,11,11,10,8,6,5,6,8,8,7,5,3,2,4,6,10
	dc.b	15,15,14,12,10,7,4,4,4,5,5,5,4,4,5,8,10,11,10,7,6,6,7,9,9,8,6,4,4,6,8,11
	dc.b	13,14,14,12,10,7,4,4,4,5,5,5,4,4,5,8,10,11,10,7,6,6,7,9,9,8,6,4,4,6,8,11
	dc.b	15,14,13,11,8,5,3,3,4,5,5,5,4,4,5,8,10,10,9,7,5,6,8,10,10,9,7,6,6,8,10,12
	dc.b	14,14,13,11,8,5,3,3,4,5,5,5,4,4,5,8,10,10,9,7,5,6,8,10,10,9,7,6,6,8,10,13
	dc.b	15,14,12,10,7,4,2,3,4,5,6,6,5,5,6,8,10,9,8,6,6,7,9,11,12,11,10,9,9,10,12,13
	dc.b	14,14,12,10,7,4,2,3,4,5,6,6,5,5,6,8,10,9,8,6,6,7,9,11,12,11,10,9,9,10,12,13
	dc.b	15,13,11,8,5,3,2,3,4,6,7,7,7,7,8,9,9,8,7,6,6,8,10,12,13,13,12,11,11,12,13,14
	dc.b	14,13,11,8,5,3,2,3,4,6,7,7,7,7,8,9,9,8,7,6,6,8,10,12,13,13,12,11,11,12,13,14
	dc.b	14,13,10,7,4,2,1,3,5,7,9,9,9,9,9,9,8,8,7,7,8,9,11,12,13,13,13,13,13,14,14,15
	dc.b	14,13,10,7,4,2,1,3,5,7,9,9,9,9,9,9,8,8,7,7,8,9,11,12,13,13,13,13,13,14,14,15
	dc.b	14,12,10,7,4,1,1,3,5,8,10,11,11,10,9,8,7,7,7,8,9,10,11,12,12,12,13,13,14,15,15,15
	dc.b	14,12,10,7,4,1,1,3,5,8,10,11,11,10,9,8,7,7,7,8,9,10,11,12,12,12,13,13,14,15,15,15
	dc.b	14,12,9,6,3,1,1,3,6,9,11,12,12,10,9,7,6,7,8,9,11,11,11,11,11,11,11,13,14,15,15,15
	dc.b	14,12,9,6,3,1,1,3,6,9,11,12,12,10,9,7,6,7,8,9,11,11,11,11,11,11,11,13,14,15,15,15
	dc.b	14,12,9,6,3,1,1,3,6,9,11,12,12,9,7,6,5,7,9,11,12,12,11,10,9,8,9,11,13,14,15,15
	dc.b	14,12,9,6,3,1,1,3,6,9,11,12,12,9,7,6,5,7,9,11,12,12,11,10,9,8,9,11,13,14,15,15
	dc.b	14,12,9,6,3,1,1,3,6,9,11,11,10,7,5,4,5,7,10,12,13,13,12,9,8,7,8,10,12,13,14,15
	dc.b	14,12,9,6,3,1,1,3,6,9,11,11,10,7,5,4,5,7,10,12,13,13,12,9,8,7,8,10,12,13,14,15
	dc.b	14,12,9,6,3,1,1,3,6,8,10,10,8,5,4,4,6,8,11,13,14,13,12,10,8,6,7,8,10,12,14,15
	dc.b	14,12,9,6,3,1,1,3,6,8,10,10,8,5,4,4,6,8,11,13,14,13,12,10,8,6,7,8,10,12,14,15
	dc.b	14,12,9,6,3,1,1,3,5,7,8,8,6,4,3,4,6,9,11,12,13,13,12,11,9,7,6,7,9,11,13,14
	dc.b	14,12,9,6,3,1,1,3,5,7,8,8,6,4,3,4,6,9,11,12,13,13,12,11,9,7,6,7,9,11,13,14
	dc.b	14,12,9,6,3,1,1,3,5,6,7,6,4,3,3,5,7,9,10,11,11,12,12,12,10,8,6,6,7,10,12,14
	dc.b	14,12,9,6,3,1,1,3,5,6,7,6,4,3,3,5,7,9,10,11,11,12,12,12,10,8,6,6,7,10,12,14
	dc.b	14,12,9,6,3,1,1,3,4,5,5,4,3,2,3,5,7,8,9,9,9,10,12,12,11,9,7,6,6,9,11,13
	dc.b	13,12,9,6,3,1,1,3,4,5,5,4,3,2,3,5,7,8,9,9,9,10,12,12,11,9,7,6,6,9,11,13
	dc.b	14,12,9,6,3,1,1,2,4,4,4,3,2,1,3,5,7,8,8,7,7,8,10,12,12,10,8,6,6,7,10,12
	dc.b	13,12,9,6,3,1,1,2,4,4,4,3,2,1,3,5,7,8,8,7,7,8,10,12,12,10,8,6,6,7,10,12
	dc.b	14,12,10,7,4,1,1,2,4,4,4,3,2,1,3,5,7,7,7,5,5,6,8,11,12,11,9,6,6,6,9,11
	dc.b	13,12,10,7,4,1,1,2,4,4,4,3,2,1,3,5,7,7,7,5,5,6,8,11,12,11,9,6,6,6,9,12
	dc.b	14,13,10,7,4,2,2,3,4,4,4,3,2,1,3,5,7,7,6,5,4,5,7,10,12,12,10,7,6,6,8,10
	dc.b	12,12,10,7,4,2,2,3,4,4,4,3,2,1,3,5,7,7,6,5,4,5,7,10,12,12,10,7,6,6,8,11
	dc.b	15,13,11,8,5,3,2,3,5,5,5,4,2,1,3,5,7,7,7,5,4,4,7,10,12,12,11,8,6,6,7,10
	dc.b	12,13,11,8,5,3,2,3,5,5,5,4,2,1,3,5,7,7,7,5,4,4,7,10,12,12,11,8,6,6,7,10
	dc.b	15,14,12,10,7,4,3,4,5,6,6,4,2,1,2,5,7,8,7,6,4,5,7,9,12,13,11,8,6,6,7,9
	dc.b	12,13,12,10,7,4,3,4,5,6,6,4,2,1,2,5,7,8,7,6,4,5,7,9,12,13,11,8,6,6,7,10
	dc.b	15,14,13,11,8,5,4,5,6,7,7,5,3,2,2,5,7,8,8,7,5,5,6,9,12,13,12,9,7,6,7,9
	dc.b	12,13,13,11,8,5,4,5,6,7,7,5,3,2,2,5,7,8,8,7,5,5,6,9,12,13,12,9,7,6,7,10
	dc.b	15,15,14,12,9,6,5,6,7,8,8,6,4,2,3,5,7,9,9,8,6,5,6,8,11,12,12,9,7,6,7,9
	dc.b	12,14,14,12,9,6,5,6,7,8,8,6,4,2,3,5,7,9,9,8,6,5,6,8,11,12,12,9,7,6,7,10
	dc.b	15,15,14,12,9,7,6,6,8,9,9,8,5,3,3,5,7,9,10,9,7,6,6,7,10,11,11,9,7,6,7,9
	dc.b	12,14,14,12,9,7,6,6,8,9,9,8,5,3,3,5,7,9,10,9,7,6,6,7,10,11,11,9,7,6,7,10
	dc.b	15,15,14,13,10,8,6,7,8,9,10,9,7,5,4,5,7,9,10,10,8,6,6,7,9,10,10,8,7,6,6,8
	dc.b	11,14,14,13,10,8,6,7,8,9,10,9,7,5,4,5,7,9,10,10,8,6,6,7,9,10,10,8,7,6,6,10
	dc.b	15,15,15,13,11,8,6,6,7,9,11,10,9,6,5,5,6,9,10,10,9,7,6,6,8,9,10,8,6,5,6,8
	dc.b	11,13,14,13,11,8,6,6,7,9,11,10,9,6,5,5,6,9,10,10,9,7,6,6,8,9,10,8,6,5,6,9
	dc.b	15,15,15,14,12,9,7,6,7,9,10,11,10,8,6,5,6,7,9,10,10,8,7,6,7,8,9,8,6,5,5,7
	dc.b	10,13,14,14,12,9,7,6,7,9,10,11,10,8,6,5,6,7,9,10,10,8,7,6,7,8,9,8,6,5,5,9
	dc.b	15,15,15,14,12,9,7,6,6,8,10,11,10,8,6,5,5,6,8,10,10,9,8,7,7,8,8,7,6,4,5,7
	dc.b	10,12,14,14,12,9,7,6,6,8,10,11,10,8,6,5,5,6,8,10,10,9,8,7,7,8,8,7,6,4,5,8
	dc.b	15,15,15,14,13,10,7,6,6,7,9,11,11,9,7,6,5,6,8,9,10,10,9,8,8,8,8,7,5,4,4,6
	dc.b	9,12,14,14,13,10,7,6,6,7,9,11,11,9,7,6,5,6,8,9,10,10,9,8,8,8,8,7,5,4,4,8
	dc.b	14,14,14,14,12,10,8,6,6,7,9,10,11,10,9,7,7,6,7,8,10,10,10,10,9,8,8,6,5,4,4,6
	dc.b	9,11,13,14,12,10,8,6,6,7,9,10,11,10,9,7,7,6,7,8,10,10,10,10,9,8,8,6,5,4,4,8
	dc.b	14,13,13,12,12,10,8,7,6,7,8,10,11,11,10,9,8,7,7,7,9,10,11,11,10,10,8,7,5,4,4,6
	dc.b	8,10,12,12,12,10,8,7,6,7,8,10,11,11,10,9,8,7,7,7,9,10,11,11,10,10,8,7,5,4,4,8
	dc.b	13,12,11,11,11,10,9,7,6,6,8,9,11,12,12,11,10,9,7,7,8,9,10,11,12,11,9,7,5,4,4,6
	dc.b	8,9,10,11,11,10,9,7,6,6,8,9,11,12,12,11,10,9,7,7,8,9,10,11,12,11,9,7,5,4,4,8
	dc.b	13,11,10,9,9,9,9,8,7,6,7,9,12,13,13,13,12,10,8,7,7,8,10,11,12,12,10,8,5,4,4,5
	dc.b	7,8,9,9,9,9,9,8,7,6,7,9,12,13,13,13,12,10,8,7,7,8,10,11,12,12,10,8,5,4,4,7
	dc.b	12,10,8,7,8,9,9,8,7,6,7,9,11,13,13,13,12,11,9,7,7,7,8,10,12,12,11,8,6,4,4,6
	dc.b	7,7,7,7,8,9,9,8,7,6,7,9,11,13,13,13,12,11,9,7,7,7,8,10,12,12,11,8,6,4,4,7
	dc.b	11,9,7,6,7,9,10,9,8,7,7,8,10,12,12,12,11,10,9,8,7,7,7,9,11,12,11,9,6,4,5,6
	dc.b	7,7,7,6,7,9,10,9,8,7,7,8,10,12,12,12,11,10,9,8,7,7,7,9,11,12,11,9,6,4,5,8
	dc.b	11,9,7,6,7,9,10,10,8,7,6,8,9,11,11,10,10,10,9,9,8,7,7,8,10,11,11,9,6,5,5,6
	dc.b	7,7,6,6,7,9,10,10,8,7,6,8,9,11,11,10,10,10,9,9,8,7,7,8,10,11,11,9,6,5,5,8
	dc.b	11,9,7,6,7,9,11,10,9,7,6,7,8,9,9,9,8,9,9,10,9,7,6,7,9,10,10,9,7,5,6,7
	dc.b	8,7,7,6,7,9,11,10,9,7,6,7,8,9,9,9,8,9,9,10,9,7,6,7,9,10,10,9,7,5,6,8
	dc.b	11,9,7,6,7,9,11,11,9,7,6,7,8,9,8,7,7,8,9,10,9,7,6,6,8,9,10,8,7,6,6,7
	dc.b	8,8,7,6,7,9,11,11,9,7,6,7,8,9,8,7,7,8,9,10,9,7,6,6,8,9,10,8,7,6,6,9
	dc.b	11,9,7,6,7,9,11,11,9,7,6,7,7,8,7,6,6,7,9,10,10,8,6,6,7,9,10,8,7,6,7,7
	dc.b	8,7,7,6,7,9,11,11,9,7,6,7,7,8,7,6,6,7,9,10,10,8,6,6,7,9,10,8,7,6,7,9
	dc.b	10,8,6,6,7,9,11,10,8,6,6,7,7,8,7,6,6,7,9,11,10,8,6,6,7,9,10,8,7,6,7,8
	dc.b	8,7,6,6,7,9,11,10,8,6,6,7,7,8,7,6,6,7,9,11,10,8,6,6,7,9,10,8,7,6,7,9
	dc.b	10,8,6,6,7,9,10,10,8,6,6,7,8,8,7,6,6,8,10,11,10,8,6,6,8,9,10,8,7,6,7,7
	dc.b	8,7,6,6,7,9,10,10,8,6,6,7,8,8,7,6,6,8,10,11,10,8,6,6,8,9,10,8,7,6,7,9
	dc.b	9,8,6,6,8,10,11,10,8,6,6,7,8,8,7,6,6,8,10,11,10,8,6,7,8,10,10,8,7,6,6,7
	dc.b	7,7,6,6,8,10,11,10,8,6,6,7,8,8,7,6,6,8,10,11,10,8,6,7,8,10,10,8,7,6,7,8
	dc.b	9,7,6,6,8,10,10,9,7,6,6,7,8,8,7,6,6,8,10,11,9,7,6,7,9,10,10,8,6,6,6,7
	dc.b	7,6,6,6,8,10,10,9,7,6,6,7,8,8,7,6,6,8,10,11,9,7,6,7,9,10,10,8,6,6,7,8
	dc.b	8,7,5,6,8,10,10,9,7,6,7,8,9,8,6,6,7,8,10,10,9,7,6,7,9,10,10,8,6,6,6,7
	dc.b	7,6,5,6,8,10,10,9,7,6,7,8,9,8,6,6,7,8,10,10,9,7,6,7,9,10,10,8,6,6,7,8
	dc.b	6,6,5,7,9,10,10,8,6,6,7,9,9,8,6,6,7,9,10,10,8,7,6,8,9,10,9,7,6,6,6,7
	dc.b	6,6,5,7,9,10,10,8,6,6,7,9,9,8,6,6,7,9,10,10,8,7,6,8,9,10,9,7,6,6,7,8
	dc.b	5,5,5,7,9,10,9,8,6,6,8,9,10,8,7,7,8,9,10,10,8,6,7,8,9,10,9,7,5,6,6,7
	dc.b	6,6,6,7,9,10,9,8,6,6,8,9,10,8,7,7,8,9,10,10,8,6,7,8,9,10,9,7,5,6,7,7
	dc.b	4,4,5,7,9,10,8,7,6,7,9,10,11,10,9,8,9,10,11,9,7,6,7,8,9,9,8,6,5,6,6,7
	dc.b	6,6,6,7,9,10,8,7,6,7,9,10,11,10,9,8,9,10,11,9,7,6,7,8,9,9,8,6,5,6,7,6
	dc.b	2,3,5,8,9,9,8,6,6,7,9,11,12,11,10,10,11,11,11,9,7,6,7,8,9,9,7,5,5,6,7,7
	dc.b	6,6,6,8,9,9,8,6,6,7,9,11,12,11,10,10,11,11,11,9,7,6,7,8,9,9,7,5,5,6,7,5
	dc.b	1,3,5,8,9,9,7,6,6,8,10,12,13,12,12,12,12,12,10,8,7,6,7,8,9,8,6,4,5,6,7,7
	dc.b	6,6,6,8,9,9,7,6,6,8,10,12,13,12,12,12,12,12,10,8,7,6,7,8,9,8,6,4,5,6,7,5
	dc.b	1,3,6,8,9,9,7,6,6,8,11,13,14,14,13,13,12,11,10,8,7,7,8,9,9,8,6,5,5,6,7,7
	dc.b	6,6,7,8,9,9,7,6,6,8,11,13,14,14,13,13,12,11,10,8,7,7,8,9,9,8,6,5,5,6,7,5
	dc.b	1,3,6,8,9,8,7,6,6,8,11,13,14,14,13,13,11,10,8,7,7,8,10,10,10,8,7,6,6,8,8,7
	dc.b	7,6,7,8,9,8,7,6,6,8,11,13,14,14,13,13,11,10,8,7,7,8,10,10,10,8,7,6,6,8,8,5
	dc.b	1,3,6,8,9,8,7,6,7,9,12,14,14,14,13,11,9,8,7,7,8,9,11,12,11,10,8,8,9,9,9,8
	dc.b	7,6,7,8,9,8,7,6,7,9,12,14,14,14,13,11,9,8,7,7,8,9,11,12,11,10,8,8,9,9,9,6
	dc.b	1,3,6,8,9,8,7,6,7,9,12,13,14,12,11,9,7,6,6,7,9,11,12,13,13,11,11,10,11,11,10,8
	dc.b	7,6,7,8,9,8,7,6,7,9,12,13,14,12,11,9,7,6,6,7,9,11,12,13,13,11,11,10,11,11,10,6
	dc.b	1,3,6,8,9,8,7,6,7,9,11,12,12,10,9,7,6,5,6,8,10,12,14,14,14,13,12,12,13,12,11,9
	dc.b	7,6,7,8,9,8,7,6,7,9,11,12,12,10,9,7,6,5,6,8,10,12,14,14,14,13,12,12,13,12,11,7
	dc.b	1,3,5,7,8,7,6,6,7,8,10,11,10,8,6,5,5,6,8,10,12,13,14,14,14,14,14,14,14,13,12,9
	dc.b	7,6,6,7,8,7,6,6,7,8,10,11,10,8,6,5,5,6,8,10,12,13,14,14,14,14,14,14,14,13,12,7
	dc.b	1,3,5,6,7,6,6,5,6,8,9,9,7,5,4,4,5,7,10,12,13,14,14,14,13,13,13,14,14,14,12,9
	dc.b	7,6,6,6,7,6,6,5,6,8,9,9,7,5,4,4,5,7,10,12,13,14,14,14,13,13,13,14,14,14,12,7
	dc.b	2,3,5,6,6,6,5,5,6,7,8,7,5,3,3,4,7,9,12,13,14,14,13,12,11,11,12,13,14,14,12,10
	dc.b	7,6,5,6,6,6,5,5,6,7,8,7,5,3,3,4,7,9,12,13,14,14,13,12,11,11,12,13,14,14,12,8
	dc.b	4,4,5,5,5,5,5,5,6,7,6,5,3,2,3,5,7,10,13,14,14,13,12,10,9,9,10,11,13,14,13,10
	dc.b	8,6,5,5,5,5,5,5,6,7,6,5,3,2,3,5,7,10,13,14,14,13,12,10,9,9,10,11,13,14,13,9
	dc.b	5,5,4,4,4,4,5,6,6,6,6,4,2,1,3,5,8,11,14,15,14,12,10,8,6,6,7,10,12,13,13,11
	dc.b	8,6,5,4,4,4,5,6,6,6,6,4,2,1,3,5,8,11,14,15,14,12,10,8,6,6,7,10,12,13,13,11
	dc.b	6,6,5,4,3,4,5,6,6,6,5,3,1,1,3,6,9,12,14,14,13,11,8,6,4,4,5,8,11,13,13,11
	dc.b	8,6,5,4,3,4,5,6,6,6,5,3,1,1,3,6,9,12,14,14,13,11,8,6,4,4,5,8,11,13,14,12
	dc.b	7,6,5,4,3,4,5,6,6,6,5,3,1,1,3,6,9,12,14,14,13,10,7,4,2,2,4,7,10,12,13,12
	dc.b	9,7,5,4,3,4,5,6,6,6,5,3,1,1,3,6,9,12,14,14,13,10,7,4,2,2,4,7,10,12,14,13
	dc.b	8,7,5,3,2,3,5,6,6,7,6,4,2,2,3,5,8,11,14,14,13,10,7,4,2,2,4,7,10,12,13,12
	dc.b	9,7,5,3,2,3,5,6,6,7,6,4,2,2,3,5,8,11,14,14,13,10,7,4,2,2,4,7,10,12,14,13
	dc.b	9,7,5,3,2,3,4,6,6,7,7,6,4,3,3,5,8,11,13,14,12,10,7,5,3,3,5,7,10,13,13,12
	dc.b	10,7,5,3,2,3,4,6,6,7,7,6,4,3,3,5,8,11,13,14,12,10,7,5,3,3,5,7,10,13,14,13
	dc.b	9,8,5,4,2,3,4,5,6,7,8,7,6,4,5,6,8,10,12,13,11,9,7,5,4,5,6,9,11,13,14,13
	dc.b	10,8,5,4,2,3,4,5,6,7,8,7,6,4,5,6,8,10,12,13,11,9,7,5,4,5,6,9,11,13,14,13
	dc.b	10,9,6,4,3,3,3,4,6,7,8,8,8,7,6,7,8,10,11,11,10,8,6,6,6,7,8,10,12,14,14,13
	dc.b	11,9,6,4,3,3,3,4,6,7,8,8,8,7,6,7,8,10,11,11,10,8,6,6,6,7,8,10,12,14,15,14
	dc.b	12,10,7,5,3,3,3,4,5,6,8,9,9,9,8,9,9,10,10,9,8,6,5,6,7,9,10,12,13,14,15,14
	dc.b	12,10,7,5,3,3,3,4,5,6,8,9,9,9,8,9,9,10,10,9,8,6,5,6,7,9,10,12,13,14,15,14
	dc.b	13,11,8,6,4,3,3,4,5,6,7,9,10,11,11,10,10,9,9,7,5,4,4,5,7,10,12,13,14,15,15,14
	dc.b	13,11,8,6,4,3,3,4,5,6,7,9,10,11,11,10,10,9,9,7,5,4,4,5,7,10,12,13,14,15,15,15
	dc.b	14,12,9,6,5,4,4,4,4,5,6,8,10,12,12,12,11,9,8,5,3,2,2,4,7,10,12,14,15,15,15,15
	dc.b	14,12,9,6,5,4,4,4,4,5,6,8,10,12,12,12,11,9,8,5,3,2,2,4,7,10,12,14,15,15,15,15
	dc.b	14,13,10,7,5,5,4,4,4,5,6,7,9,12,13,13,12,9,7,4,2,1,1,3,6,9,12,14,15,15,15,15
	dc.b	14,13,10,7,5,5,4,4,4,5,6,7,9,12,13,13,12,9,7,4,2,1,1,3,6,9,12,14,15,15,15,15
	dc.b	15,13,11,9,6,5,5,5,5,5,5,6,8,11,12,13,12,10,7,4,2,0,1,2,5,8,11,13,15,15,15,15
	dc.b	15,13,11,9,6,5,5,5,5,5,5,6,8,11,12,13,12,10,7,4,2,0,1,2,5,8,11,13,15,15,15,15
	dc.b	15,14,12,10,7,6,5,5,5,6,5,6,7,9,11,13,12,10,7,4,2,1,1,2,4,7,10,13,14,15,15,15
	dc.b	15,14,12,10,7,6,5,5,5,6,5,6,7,9,11,13,12,10,7,4,2,1,1,2,4,7,10,13,14,15,15,15
	dc.b	15,14,13,11,8,6,5,5,6,7,6,6,6,8,10,12,12,11,8,5,3,1,1,2,4,7,10,12,13,14,14,14
	dc.b	14,14,13,11,8,6,5,5,6,7,6,6,6,8,10,12,12,11,8,5,3,1,1,2,4,7,10,12,13,14,14,14
	dc.b	15,15,14,12,9,6,5,6,7,8,7,6,6,7,9,11,12,12,10,7,4,2,1,2,4,7,9,11,12,13,13,13
	dc.b	13,14,13,12,9,6,5,6,7,8,7,6,6,7,9,11,12,12,10,7,4,2,1,2,4,7,9,11,12,13,13,13
	dc.b	15,15,14,12,9,7,5,6,7,8,8,7,6,6,8,10,12,13,11,9,6,3,2,2,4,7,9,11,11,11,11,11
	dc.b	12,13,14,12,9,7,5,6,7,8,8,7,6,6,8,10,12,13,11,9,6,3,2,2,4,7,9,11,11,11,11,12
	dc.b	15,15,14,13,10,8,6,6,7,9,9,8,7,6,7,9,12,13,12,10,7,4,3,3,5,7,9,10,10,9,9,10
	dc.b	11,13,14,13,10,8,6,6,7,9,9,8,7,6,7,9,12,13,12,10,7,4,3,3,5,7,9,10,10,9,9,11
	dc.b	15,15,15,13,11,9,6,6,7,9,10,9,8,7,7,8,11,13,13,11,8,6,4,4,5,8,10,10,8,7,7,8
	dc.b	10,13,14,13,11,9,6,6,7,9,10,9,8,7,7,8,11,13,13,11,8,6,4,4,5,8,10,10,8,7,7,10
	dc.b	15,15,15,14,12,10,7,6,7,8,9,10,8,7,7,8,10,12,13,12,9,7,5,5,6,8,10,9,8,6,6,8
	dc.b	10,13,14,14,12,10,7,6,7,8,9,10,8,7,7,8,10,12,13,12,9,7,5,5,6,8,10,9,8,6,6,9
	dc.b	15,15,15,14,13,11,8,6,6,8,9,10,9,8,7,7,9,11,13,12,10,7,6,5,7,9,9,8,7,5,6,8
	dc.b	11,13,14,14,13,11,8,6,6,8,9,10,9,8,7,7,9,11,13,12,10,7,6,5,7,9,9,8,7,5,6,9
	dc.b	15,15,15,15,14,11,9,7,6,7,9,11,10,8,7,7,8,10,12,12,11,8,6,6,7,8,9,8,6,5,6,9
	dc.b	12,14,15,15,14,11,9,7,6,7,9,11,10,8,7,7,8,10,12,12,11,8,6,6,7,8,9,8,6,5,6,10
	dc.b	15,15,15,15,14,12,9,7,6,7,9,11,11,9,7,6,7,9,12,12,11,8,6,6,7,7,8,7,6,5,7,9
	dc.b	12,14,15,15,14,12,9,7,6,7,9,11,11,9,7,6,7,9,12,12,11,8,6,6,7,7,8,7,6,5,7,10
	dc.b	14,14,14,14,13,12,9,7,6,7,8,11,11,10,8,7,7,8,11,12,11,9,7,6,6,7,7,7,6,6,7,10
	dc.b	12,14,14,14,13,12,9,7,6,7,8,11,11,10,8,7,7,8,11,12,11,9,7,6,6,7,7,7,6,6,8,11
	dc.b	13,12,12,12,12,11,10,8,6,7,8,10,11,10,8,7,6,8,10,12,11,9,7,6,6,6,7,6,6,6,8,10
	dc.b	12,12,12,12,12,11,10,8,6,7,8,10,11,10,8,7,6,8,10,12,11,9,7,6,6,6,7,6,6,6,8,10
	dc.b	11,10,10,10,10,11,9,8,7,6,8,10,12,11,9,7,6,7,10,11,11,9,7,6,6,6,6,6,6,6,8,10
	dc.b	10,10,10,10,10,11,9,8,7,6,8,10,12,11,9,7,6,7,10,11,11,9,7,6,6,6,6,6,6,6,8,10
	dc.b	8,7,7,7,9,10,10,8,7,6,7,10,11,11,9,7,6,7,9,11,10,8,7,6,6,6,6,6,6,6,7,9
	dc.b	9,8,7,7,9,10,10,8,7,6,7,10,11,11,9,7,6,7,9,11,10,8,7,6,6,6,6,6,6,6,8,8
	dc.b	5,4,4,5,7,9,9,8,7,6,7,9,11,11,9,7,6,7,9,10,10,9,7,7,7,7,7,6,6,6,7,8
	dc.b	7,6,5,5,7,9,9,8,7,6,7,9,11,11,9,7,6,7,9,10,10,9,7,7,7,7,7,6,6,6,7,7
	dc.b	2,2,2,4,6,8,9,8,7,6,7,9,11,11,9,7,6,7,9,10,11,10,9,8,8,8,7,6,6,6,7,7
	dc.b	6,4,3,4,6,8,9,8,7,6,7,9,11,11,9,7,6,7,9,10,11,10,9,8,8,8,7,6,6,6,7,5
	dc.b	1,1,1,3,6,8,9,8,7,6,7,9,11,11,10,7,6,7,8,10,11,11,10,10,9,9,7,6,6,6,6,7
	dc.b	6,4,2,3,6,8,9,8,7,6,7,9,11,11,10,7,6,7,8,10,11,11,10,10,9,9,7,6,6,6,6,5
	dc.b	2,1,2,3,6,8,9,8,7,6,7,9,11,12,10,8,6,7,8,10,12,12,12,12,11,10,8,6,6,6,7,7
	dc.b	6,4,2,3,6,8,9,8,7,6,7,9,11,12,10,8,6,7,8,10,12,12,12,12,11,10,8,6,6,6,7,5
	dc.b	3,3,2,4,6,8,9,8,7,6,7,9,11,12,11,8,6,6,7,10,12,13,13,13,12,10,8,6,6,6,7,8
	dc.b	7,4,3,4,6,8,9,8,7,6,7,9,11,12,11,8,6,6,7,10,12,13,13,13,12,10,8,6,6,6,8,7
	dc.b	5,4,3,4,6,8,9,9,7,6,7,9,11,12,11,9,7,6,7,9,12,14,14,14,13,10,7,6,6,7,8,9
	dc.b	8,5,4,4,6,8,9,9,7,6,7,9,11,12,11,9,7,6,7,9,12,14,14,14,13,10,7,6,6,7,8,8
	dc.b	8,6,5,5,7,9,10,9,8,6,7,8,11,12,12,9,7,6,6,8,11,13,15,14,13,10,7,6,6,7,9,10
	dc.b	9,7,5,5,7,9,10,9,8,6,7,8,11,12,12,9,7,6,6,8,11,13,15,14,13,10,7,6,6,7,9,10
	dc.b	10,8,7,6,8,10,11,10,8,7,6,8,10,12,12,10,8,6,6,7,10,13,14,14,13,10,8,6,6,7,9,11
	dc.b	10,9,7,6,8,10,11,10,8,7,6,8,10,12,12,10,8,6,6,7,10,13,14,14,13,10,8,6,6,7,10,11
	dc.b	12,10,9,9,9,11,12,11,9,7,6,7,10,12,12,11,8,6,5,7,9,12,14,14,13,11,8,6,6,7,9,11
	dc.b	11,10,9,9,9,11,12,11,9,7,6,7,10,12,12,11,8,6,5,7,9,12,14,14,13,11,8,6,6,7,10,12
	dc.b	13,12,11,11,11,12,12,11,9,7,6,7,9,12,13,12,9,7,5,6,8,11,13,14,14,11,8,6,6,7,9,12
	dc.b	12,12,11,11,11,12,12,11,9,7,6,7,9,12,13,12,9,7,5,6,8,11,13,14,14,11,8,6,6,7,9,12
	dc.b	14,13,13,13,13,13,13,12,9,7,6,7,9,12,13,13,10,7,6,6,8,10,13,14,14,12,9,7,6,7,9,11
	dc.b	13,13,13,13,13,13,13,12,9,7,6,7,9,12,13,13,10,7,6,6,8,10,13,14,14,12,9,7,6,7,9,12
	dc.b	14,14,14,14,14,14,14,12,9,7,6,7,9,12,14,13,11,8,6,5,7,9,12,14,14,12,9,7,6,6,8,11
	dc.b	13,14,14,14,14,14,14,12,9,7,6,7,9,12,14,13,11,8,6,5,7,9,12,14,14,12,9,7,6,6,8,11
	dc.b	15,15,15,15,15,15,14,12,9,7,6,7,9,12,14,14,12,9,6,5,6,8,11,13,14,12,10,7,6,6,8,11
	dc.b	13,14,15,15,15,15,14,12,9,7,6,7,9,12,14,14,12,9,6,5,6,8,11,13,14,12,10,7,6,6,8,11
	dc.b	15,15,15,15,15,15,14,12,9,7,6,7,9,12,14,14,12,10,7,6,6,7,10,12,14,13,10,8,6,6,7,10
	dc.b	13,14,15,15,15,15,14,12,9,7,6,7,9,12,14,14,12,10,7,6,6,7,10,12,14,13,10,8,6,6,7,11
	dc.b	15,15,15,15,15,15,14,12,9,7,6,7,9,12,14,14,13,11,8,6,6,7,9,11,13,13,11,8,6,5,7,9
	dc.b	12,14,15,15,15,15,14,12,9,7,6,7,9,12,14,14,13,11,8,6,6,7,9,11,13,13,11,8,6,5,7,10
	dc.b	15,15,15,15,15,15,14,12,9,7,6,7,9,12,14,14,13,12,9,7,6,6,8,10,12,13,12,9,7,5,6,8
	dc.b	11,13,15,15,15,15,14,12,9,7,6,7,9,12,14,14,13,12,9,7,6,6,8,10,12,13,12,9,7,5,6,9
	dc.b	15,15,15,15,15,15,14,11,9,7,6,7,10,12,14,14,13,12,10,8,6,6,6,9,11,13,12,10,8,6,6,8
	dc.b	10,13,14,15,15,15,14,11,9,7,6,7,10,12,14,14,13,12,10,8,6,6,6,9,11,13,12,10,8,6,6,9
	dc.b	15,15,15,15,15,14,13,11,8,6,6,8,10,12,13,12,12,12,11,9,7,6,6,7,10,12,12,11,9,7,7,8
	dc.b	10,13,14,15,15,14,13,11,8,6,6,8,10,12,13,12,12,12,11,9,7,6,6,7,10,12,12,11,9,7,7,10
	dc.b	15,15,15,15,15,14,12,10,7,6,7,8,10,11,11,11,10,11,10,10,8,6,6,6,9,11,12,12,10,9,9,10
	dc.b	11,13,14,15,15,14,12,10,7,6,7,8,10,11,11,11,10,11,10,10,8,6,6,6,9,11,12,12,10,9,9,11
	dc.b	15,15,15,15,15,13,11,9,6,6,7,9,10,10,9,8,8,9,10,10,9,8,6,6,8,10,12,13,12,11,11,11
	dc.b	12,14,15,15,15,13,11,9,6,6,7,9,10,10,9,8,8,9,10,10,9,8,6,6,8,10,12,13,12,11,11,12
	dc.b	15,15,15,15,14,13,10,7,6,6,7,9,10,9,7,6,6,8,9,11,11,9,8,7,8,10,12,13,13,13,13,13
	dc.b	13,14,15,15,14,13,10,7,6,6,7,9,10,9,7,6,6,8,9,11,11,9,8,7,8,10,12,13,13,13,13,13
	dc.b	15,15,15,15,14,12,9,7,5,6,8,10,10,8,6,4,4,7,9,11,12,11,10,9,9,11,12,13,14,14,14,14
	dc.b	14,15,15,15,14,12,9,7,5,6,8,10,10,8,6,4,4,7,9,11,12,11,10,9,9,11,12,13,14,14,14,14
	dc.b	15,15,15,15,13,11,9,7,6,7,9,10,10,8,5,4,4,7,9,12,13,13,11,11,11,12,13,14,14,15,15,15
	dc.b	15,15,15,15,13,11,9,7,6,7,9,10,10,8,5,4,4,7,9,12,13,13,11,11,11,12,13,14,14,15,15,15
	dc.b	15,15,15,15,13,11,9,7,7,8,10,11,11,9,6,5,5,7,10,12,14,14,13,13,13,13,13,14,15,15,15,15
	dc.b	15,15,15,15,13,11,9,7,7,8,10,11,11,9,6,5,5,7,10,12,14,14,13,13,13,13,13,14,15,15,15,15
	dc.b	15,15,15,15,13,12,10,9,9,10,12,12,12,10,8,7,8,9,11,13,14,15,14,14,14,14,14,15,15,15,15,15
	dc.b	15,15,15,15,13,12,10,9,9,10,12,12,12,10,8,7,8,9,11,13,14,15,14,14,14,14,14,15,15,15,15,15
	dc.b	15,15,15,15,14,12,11,11,11,12,13,13,13,12,10,10,10,11,12,14,15,15,15,15,15,15,15,15,15,15,15,15
	dc.b	15,15,15,15,14,12,11,11,11,12,13,13,13,12,10,10,10,11,12,14,15,15,15,15,15,15,15,15,15,15,15,15
	dc.b	15,15,15,15,14,13,13,12,12,13,14,14,14,13,13,12,12,13,13,14,15,15,15,15,15,15,15,15,15,15,15,15
	dc.b	15,15,15,15,14,13,13,12,12,13,14,14,14,13,13,12,12,13,13,14,15,15,15,15,15,15,15,15,15,15,15,15
	dc.b	15,15,15,15,15,14,14,14,14,14,15,15,15,14,14,14,14,14,14,15,15,15,15,15,15,15,15,15,15,15,15,15
	dc.b	15,15,15,15,15,14,14,14,14,14,15,15,15,14,14,14,14,14,14,15,15,15,15,15,15,15,15,15,15,15,15,15
	dc.b	15,15,15,15,15,14,14,15,15,15,15,15,15,15,15,15,15,15,15,15,15,15,15,15,15,15,15,15,15,15,15,15
	dc.b	15,15,15,15,15,14,14,15,15,15,15,15,15,15,15,15,15,15,15,15,15,15,15,15,15,15,15,15,15,15,15,15
