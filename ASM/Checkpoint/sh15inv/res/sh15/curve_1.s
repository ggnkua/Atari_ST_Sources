	dc.w	96
	dc.w	96
	dc.w	96
	dc.w	96
	dc.w	96
	dc.w	96
	dc.w	95
	dc.w	95
	dc.w	95
	dc.w	95
	dc.w	95
	dc.w	94
	dc.w	94
	dc.w	94
	dc.w	93
	dc.w	93
	dc.w	92
	dc.w	92
	dc.w	91
	dc.w	91
	dc.w	90
	dc.w	90
	dc.w	89
	dc.w	89
	dc.w	88
	dc.w	87
	dc.w	87
	dc.w	86
	dc.w	85
	dc.w	84
	dc.w	84
	dc.w	83
	dc.w	82
	dc.w	81
	dc.w	80
	dc.w	79
	dc.w	78
	dc.w	78
	dc.w	77
	dc.w	76
	dc.w	75
	dc.w	74
	dc.w	73
	dc.w	72
	dc.w	71
	dc.w	70
	dc.w	69
	dc.w	67
	dc.w	66
	dc.w	65
	dc.w	64
	dc.w	63
	dc.w	62
	dc.w	61
	dc.w	60
	dc.w	59
	dc.w	57
	dc.w	56
	dc.w	55
	dc.w	54
	dc.w	53
	dc.w	52
	dc.w	50
	dc.w	49
	dc.w	48
	dc.w	47
	dc.w	46
	dc.w	44
	dc.w	43
	dc.w	42
	dc.w	41
	dc.w	40
	dc.w	39
	dc.w	37
	dc.w	36
	dc.w	35
	dc.w	34
	dc.w	33
	dc.w	32
	dc.w	31
	dc.w	30
	dc.w	29
	dc.w	27
	dc.w	26
	dc.w	25
	dc.w	24
	dc.w	23
	dc.w	22
	dc.w	21
	dc.w	20
	dc.w	19
	dc.w	18
	dc.w	18
	dc.w	17
	dc.w	16
	dc.w	15
	dc.w	14
	dc.w	13
	dc.w	12
	dc.w	12
	dc.w	11
	dc.w	10
	dc.w	9
	dc.w	9
	dc.w	8
	dc.w	7
	dc.w	7
	dc.w	6
	dc.w	6
	dc.w	5
	dc.w	5
	dc.w	4
	dc.w	4
	dc.w	3
	dc.w	3
	dc.w	2
	dc.w	2
	dc.w	2
	dc.w	1
	dc.w	1
	dc.w	1
	dc.w	1
	dc.w	1
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	0
	dc.w	1
	dc.w	1
	dc.w	1
	dc.w	1
	dc.w	1
	dc.w	2
	dc.w	2
	dc.w	2
	dc.w	3
	dc.w	3
	dc.w	4
	dc.w	4
	dc.w	5
	dc.w	5
	dc.w	6
	dc.w	6
	dc.w	7
	dc.w	7
	dc.w	8
	dc.w	9
	dc.w	9
	dc.w	10
	dc.w	11
	dc.w	12
	dc.w	12
	dc.w	13
	dc.w	14
	dc.w	15
	dc.w	16
	dc.w	17
	dc.w	18
	dc.w	18
	dc.w	19
	dc.w	20
	dc.w	21
	dc.w	22
	dc.w	23
	dc.w	24
	dc.w	25
	dc.w	26
	dc.w	27
	dc.w	29
	dc.w	30
	dc.w	31
	dc.w	32
	dc.w	33
	dc.w	34
	dc.w	35
	dc.w	36
	dc.w	37
	dc.w	39
	dc.w	40
	dc.w	41
	dc.w	42
	dc.w	43
	dc.w	44
	dc.w	46
	dc.w	47
	dc.w	48
	dc.w	49
	dc.w	50
	dc.w	52
	dc.w	53
	dc.w	54
	dc.w	55
	dc.w	56
	dc.w	57
	dc.w	59
	dc.w	60
	dc.w	61
	dc.w	62
	dc.w	63
	dc.w	64
	dc.w	65
	dc.w	66
	dc.w	67
	dc.w	69
	dc.w	70
	dc.w	71
	dc.w	72
	dc.w	73
	dc.w	74
	dc.w	75
	dc.w	76
	dc.w	77
	dc.w	78
	dc.w	78
	dc.w	79
	dc.w	80
	dc.w	81
	dc.w	82
	dc.w	83
	dc.w	84
	dc.w	84
	dc.w	85
	dc.w	86
	dc.w	87
	dc.w	87
	dc.w	88
	dc.w	89
	dc.w	89
	dc.w	90
	dc.w	90
	dc.w	91
	dc.w	91
	dc.w	92
	dc.w	92
	dc.w	93
	dc.w	93
	dc.w	94
	dc.w	94
	dc.w	94
	dc.w	95
	dc.w	95
	dc.w	95
	dc.w	95
	dc.w	95
	dc.w	96
	dc.w	96
	dc.w	96
	dc.w	96
	dc.w	96
