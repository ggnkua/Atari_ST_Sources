path1:
	dc.l 250,98
	dc.l 249,100
	dc.l 249,103
	dc.l 248,106
	dc.l 248,109
	dc.l 246,112
	dc.l 245,115
	dc.l 244,118
	dc.l 242,120
	dc.l 240,123
	dc.l 238,126
	dc.l 235,129
	dc.l 232,131
	dc.l 229,134
	dc.l 226,137
	dc.l 223,139
	dc.l 220,142
	dc.l 216,144
	dc.l 212,147
	dc.l 208,149
	dc.l 204,152
	dc.l 200,154
	dc.l 195,156
	dc.l 191,158
	dc.l 186,160
	dc.l 182,163
	dc.l 177,165
	dc.l 172,167
	dc.l 167,168
	dc.l 162,170
	dc.l 157,172
	dc.l 152,174
	dc.l 146,175
	dc.l 141,177
	dc.l 136,178
	dc.l 131,179
	dc.l 126,181
	dc.l 121,182
	dc.l 116,183
	dc.l 110,184
	dc.l 106,185
	dc.l 101,186
	dc.l 96,187
	dc.l 91,187
	dc.l 87,188
	dc.l 82,188
	dc.l 78,189
	dc.l 73,189
	dc.l 69,189
	dc.l 65,189
	dc.l 62,190
	dc.l 58,189
	dc.l 55,189
	dc.l 52,189
	dc.l 49,189
	dc.l 46,188
	dc.l 43,188
	dc.l 41,187
	dc.l 39,187
	dc.l 37,186
	dc.l 35,185
	dc.l 33,184
	dc.l 32,183
	dc.l 31,182
	dc.l 30,181
	dc.l 30,179
	dc.l 30,178
	dc.l 30,177
	dc.l 30,175
	dc.l 30,174
	dc.l 31,172
	dc.l 32,170
	dc.l 33,168
	dc.l 34,167
	dc.l 36,165
	dc.l 38,163
	dc.l 40,160
	dc.l 42,158
	dc.l 45,156
	dc.l 48,154
	dc.l 51,152
	dc.l 54,149
	dc.l 57,147
	dc.l 61,144
	dc.l 64,142
	dc.l 68,139
	dc.l 72,137
	dc.l 76,134
	dc.l 81,131
	dc.l 85,129
	dc.l 90,126
	dc.l 94,123
	dc.l 99,120
	dc.l 104,118
	dc.l 109,115
	dc.l 114,112
	dc.l 119,109
	dc.l 124,106
	dc.l 129,103
	dc.l 134,100
	dc.l 139,98
	dc.l 145,95
	dc.l 150,92
	dc.l 155,89
	dc.l 160,86
	dc.l 165,83
	dc.l 170,80
	dc.l 175,77
	dc.l 180,75
	dc.l 185,72
	dc.l 189,69
	dc.l 194,66
	dc.l 198,64
	dc.l 203,61
	dc.l 207,58
	dc.l 211,56
	dc.l 215,53
	dc.l 218,51
	dc.l 222,48
	dc.l 225,46
	dc.l 228,43
	dc.l 231,41
	dc.l 234,39
	dc.l 237,37
	dc.l 239,35
	dc.l 241,32
	dc.l 243,30
	dc.l 245,28
	dc.l 246,27
	dc.l 247,25
	dc.l 248,23
	dc.l 249,21
	dc.l 249,20
	dc.l 249,18
	dc.l 249,17
	dc.l 249,16
	dc.l 249,14
	dc.l 248,13
	dc.l 247,12
	dc.l 246,11
	dc.l 244,10
	dc.l 242,9
	dc.l 240,8
	dc.l 238,8
	dc.l 236,7
	dc.l 233,7
	dc.l 230,6
	dc.l 227,6
	dc.l 224,6
	dc.l 221,6
	dc.l 217,6
	dc.l 214,6
	dc.l 210,6
	dc.l 206,6
	dc.l 201,6
	dc.l 197,7
	dc.l 192,7
	dc.l 188,8
	dc.l 183,8
	dc.l 178,9
	dc.l 173,10
	dc.l 169,11
	dc.l 163,12
	dc.l 158,13
	dc.l 153,14
	dc.l 148,16
	dc.l 143,17
	dc.l 138,18
	dc.l 133,20
	dc.l 127,21
	dc.l 122,23
	dc.l 117,25
	dc.l 112,27
	dc.l 107,28
	dc.l 102,30
	dc.l 97,32
	dc.l 93,35
	dc.l 88,37
	dc.l 84,39
	dc.l 79,41
	dc.l 75,43
	dc.l 71,46
	dc.l 67,48
	dc.l 63,51
	dc.l 59,53
	dc.l 56,56
	dc.l 53,58
	dc.l 50,61
	dc.l 47,64
	dc.l 44,66
	dc.l 41,69
	dc.l 39,72
	dc.l 37,75
	dc.l 35,77
	dc.l 34,80
	dc.l 33,83
	dc.l 31,86
	dc.l 31,89
	dc.l 30,92
	dc.l 30,95
	dc.l 30,97
	dc.l 30,100
	dc.l 30,103
	dc.l 31,106
	dc.l 31,109
	dc.l 33,112
	dc.l 34,115
	dc.l 35,118
	dc.l 37,120
	dc.l 39,123
	dc.l 41,126
	dc.l 44,129
	dc.l 47,131
	dc.l 50,134
	dc.l 53,137
	dc.l 56,139
	dc.l 59,142
	dc.l 63,144
	dc.l 67,147
	dc.l 71,149
	dc.l 75,152
	dc.l 79,154
	dc.l 84,156
	dc.l 88,158
	dc.l 93,160
	dc.l 97,163
	dc.l 102,165
	dc.l 107,167
	dc.l 112,168
	dc.l 117,170
	dc.l 122,172
	dc.l 127,174
	dc.l 133,175
	dc.l 138,177
	dc.l 143,178
	dc.l 148,179
	dc.l 153,181
	dc.l 158,182
	dc.l 163,183
	dc.l 169,184
	dc.l 173,185
	dc.l 178,186
	dc.l 183,187
	dc.l 188,187
	dc.l 192,188
	dc.l 197,188
	dc.l 201,189
	dc.l 206,189
	dc.l 210,189
	dc.l 214,189
	dc.l 217,190
	dc.l 221,189
	dc.l 224,189
	dc.l 227,189
	dc.l 230,189
	dc.l 233,188
	dc.l 236,188
	dc.l 238,187
	dc.l 240,187
	dc.l 242,186
	dc.l 244,185
	dc.l 246,184
	dc.l 247,183
	dc.l 248,182
	dc.l 249,181
	dc.l 249,179
	dc.l 249,178
	dc.l 249,177
	dc.l 249,175
	dc.l 249,174
	dc.l 248,172
	dc.l 247,170
	dc.l 246,168
	dc.l 245,167
	dc.l 243,165
	dc.l 241,163
	dc.l 239,160
	dc.l 237,158
	dc.l 234,156
	dc.l 231,154
	dc.l 228,152
	dc.l 225,149
	dc.l 222,147
	dc.l 218,144
	dc.l 215,142
	dc.l 211,139
	dc.l 207,137
	dc.l 203,134
	dc.l 198,131
	dc.l 194,129
	dc.l 189,126
	dc.l 185,123
	dc.l 180,120
	dc.l 175,118
	dc.l 170,115
	dc.l 165,112
	dc.l 160,109
	dc.l 155,106
	dc.l 150,103
	dc.l 145,100
	dc.l 140,98
	dc.l 134,95
	dc.l 129,92
	dc.l 124,89
	dc.l 119,86
	dc.l 114,83
	dc.l 109,80
	dc.l 104,77
	dc.l 99,75
	dc.l 94,72
	dc.l 90,69
	dc.l 85,66
	dc.l 81,64
	dc.l 76,61
	dc.l 72,58
	dc.l 68,56
	dc.l 64,53
	dc.l 61,51
	dc.l 57,48
	dc.l 54,46
	dc.l 51,43
	dc.l 48,41
	dc.l 45,39
	dc.l 42,37
	dc.l 40,35
	dc.l 38,32
	dc.l 36,30
	dc.l 34,28
	dc.l 33,27
	dc.l 32,25
	dc.l 31,23
	dc.l 30,21
	dc.l 30,20
	dc.l 30,18
	dc.l 30,17
	dc.l 30,16
	dc.l 30,14
	dc.l 31,13
	dc.l 32,12
	dc.l 33,11
	dc.l 35,10
	dc.l 37,9
	dc.l 39,8
	dc.l 41,8
	dc.l 43,7
	dc.l 46,7
	dc.l 49,6
	dc.l 52,6
	dc.l 55,6
	dc.l 58,6
	dc.l 62,6
	dc.l 65,6
	dc.l 69,6
	dc.l 73,6
	dc.l 78,6
	dc.l 82,7
	dc.l 87,7
	dc.l 91,8
	dc.l 96,8
	dc.l 101,9
	dc.l 106,10
	dc.l 110,11
	dc.l 116,12
	dc.l 121,13
	dc.l 126,14
	dc.l 131,16
	dc.l 136,17
	dc.l 141,18
	dc.l 146,20
	dc.l 152,21
	dc.l 157,23
	dc.l 162,25
	dc.l 167,27
	dc.l 172,28
	dc.l 177,30
	dc.l 182,32
	dc.l 186,35
	dc.l 191,37
	dc.l 195,39
	dc.l 200,41
	dc.l 204,43
	dc.l 208,46
	dc.l 212,48
	dc.l 216,51
	dc.l 220,53
	dc.l 223,56
	dc.l 226,58
	dc.l 229,61
	dc.l 232,64
	dc.l 235,66
	dc.l 238,69
	dc.l 240,72
	dc.l 242,75
	dc.l 244,77
	dc.l 245,80
	dc.l 246,83
	dc.l 248,86
	dc.l 248,89
	dc.l 249,92
	dc.l 249,95


path2:
	dc.l 318,100
	dc.l 317,104
	dc.l 317,108
	dc.l 317,112
	dc.l 317,116
	dc.l 317,121
	dc.l 317,125
	dc.l 317,129
	dc.l 316,133
	dc.l 316,137
	dc.l 316,140
	dc.l 315,144
	dc.l 315,148
	dc.l 314,151
	dc.l 314,155
	dc.l 313,158
	dc.l 313,161
	dc.l 312,164
	dc.l 312,167
	dc.l 311,170
	dc.l 310,172
	dc.l 310,175
	dc.l 309,177
	dc.l 308,179
	dc.l 307,181
	dc.l 306,183
	dc.l 305,184
	dc.l 304,186
	dc.l 303,187
	dc.l 302,188
	dc.l 301,188
	dc.l 300,189
	dc.l 299,189
	dc.l 298,189
	dc.l 297,189
	dc.l 296,189
	dc.l 294,189
	dc.l 293,188
	dc.l 292,187
	dc.l 291,186
	dc.l 289,185
	dc.l 288,184
	dc.l 286,182
	dc.l 285,180
	dc.l 284,178
	dc.l 282,176
	dc.l 281,174
	dc.l 279,171
	dc.l 277,169
	dc.l 276,166
	dc.l 274,163
	dc.l 272,160
	dc.l 271,157
	dc.l 269,154
	dc.l 267,150
	dc.l 266,147
	dc.l 264,143
	dc.l 262,139
	dc.l 260,135
	dc.l 258,131
	dc.l 256,127
	dc.l 255,123
	dc.l 253,119
	dc.l 251,115
	dc.l 249,111
	dc.l 247,107
	dc.l 245,102
	dc.l 243,98
	dc.l 241,94
	dc.l 239,90
	dc.l 237,85
	dc.l 235,81
	dc.l 233,77
	dc.l 230,73
	dc.l 228,69
	dc.l 226,65
	dc.l 224,61
	dc.l 222,57
	dc.l 220,54
	dc.l 217,50
	dc.l 215,47
	dc.l 213,43
	dc.l 211,40
	dc.l 209,37
	dc.l 206,34
	dc.l 204,31
	dc.l 202,28
	dc.l 200,26
	dc.l 197,24
	dc.l 195,21
	dc.l 193,19
	dc.l 190,17
	dc.l 188,16
	dc.l 186,14
	dc.l 183,13
	dc.l 181,12
	dc.l 179,11
	dc.l 176,10
	dc.l 174,10
	dc.l 172,10
	dc.l 170,10
	dc.l 167,10
	dc.l 165,10
	dc.l 163,10
	dc.l 160,11
	dc.l 158,12
	dc.l 156,13
	dc.l 153,14
	dc.l 151,16
	dc.l 149,17
	dc.l 146,19
	dc.l 144,21
	dc.l 142,24
	dc.l 139,26
	dc.l 137,28
	dc.l 135,31
	dc.l 133,34
	dc.l 130,37
	dc.l 128,40
	dc.l 126,43
	dc.l 124,47
	dc.l 122,50
	dc.l 119,54
	dc.l 117,57
	dc.l 115,61
	dc.l 113,65
	dc.l 111,69
	dc.l 109,73
	dc.l 106,77
	dc.l 104,81
	dc.l 102,85
	dc.l 100,90
	dc.l 98,94
	dc.l 96,98
	dc.l 94,102
	dc.l 92,107
	dc.l 90,111
	dc.l 88,115
	dc.l 86,119
	dc.l 84,123
	dc.l 83,127
	dc.l 81,131
	dc.l 79,135
	dc.l 77,139
	dc.l 75,143
	dc.l 73,147
	dc.l 72,150
	dc.l 70,154
	dc.l 68,157
	dc.l 67,160
	dc.l 65,163
	dc.l 63,166
	dc.l 62,169
	dc.l 60,171
	dc.l 58,174
	dc.l 57,176
	dc.l 55,178
	dc.l 54,180
	dc.l 53,182
	dc.l 51,184
	dc.l 50,185
	dc.l 48,186
	dc.l 47,187
	dc.l 46,188
	dc.l 45,189
	dc.l 43,189
	dc.l 42,189
	dc.l 41,189
	dc.l 40,189
	dc.l 39,189
	dc.l 38,188
	dc.l 37,188
	dc.l 36,187
	dc.l 35,186
	dc.l 34,184
	dc.l 33,183
	dc.l 32,181
	dc.l 31,179
	dc.l 30,177
	dc.l 29,175
	dc.l 29,172
	dc.l 28,170
	dc.l 27,167
	dc.l 27,164
	dc.l 26,161
	dc.l 26,158
	dc.l 25,155
	dc.l 25,151
	dc.l 24,148
	dc.l 24,144
	dc.l 23,140
	dc.l 23,137
	dc.l 23,133
	dc.l 22,129
	dc.l 22,125
	dc.l 22,121
	dc.l 22,116
	dc.l 22,112
	dc.l 22,108
	dc.l 22,104
	dc.l 22,100
	dc.l 22,95
	dc.l 22,91
	dc.l 22,87
	dc.l 22,83
	dc.l 22,78
	dc.l 22,74
	dc.l 22,70
	dc.l 23,66
	dc.l 23,62
	dc.l 23,59
	dc.l 24,55
	dc.l 24,51
	dc.l 25,48
	dc.l 25,44
	dc.l 26,41
	dc.l 26,38
	dc.l 27,35
	dc.l 27,32
	dc.l 28,29
	dc.l 29,27
	dc.l 29,24
	dc.l 30,22
	dc.l 31,20
	dc.l 32,18
	dc.l 33,16
	dc.l 34,15
	dc.l 35,13
	dc.l 36,12
	dc.l 37,11
	dc.l 38,11
	dc.l 39,10
	dc.l 40,10
	dc.l 41,10
	dc.l 42,10
	dc.l 43,10
	dc.l 45,10
	dc.l 46,11
	dc.l 47,12
	dc.l 48,13
	dc.l 50,14
	dc.l 51,15
	dc.l 53,17
	dc.l 54,19
	dc.l 55,21
	dc.l 57,23
	dc.l 58,25
	dc.l 60,28
	dc.l 62,30
	dc.l 63,33
	dc.l 65,36
	dc.l 67,39
	dc.l 68,42
	dc.l 70,45
	dc.l 72,49
	dc.l 73,52
	dc.l 75,56
	dc.l 77,60
	dc.l 79,64
	dc.l 81,68
	dc.l 83,72
	dc.l 84,76
	dc.l 86,80
	dc.l 88,84
	dc.l 90,88
	dc.l 92,92
	dc.l 94,97
	dc.l 96,101
	dc.l 98,105
	dc.l 100,109
	dc.l 102,114
	dc.l 104,118
	dc.l 106,122
	dc.l 109,126
	dc.l 111,130
	dc.l 113,134
	dc.l 115,138
	dc.l 117,142
	dc.l 119,145
	dc.l 122,149
	dc.l 124,152
	dc.l 126,156
	dc.l 128,159
	dc.l 130,162
	dc.l 133,165
	dc.l 135,168
	dc.l 137,171
	dc.l 139,173
	dc.l 142,175
	dc.l 144,178
	dc.l 146,180
	dc.l 149,182
	dc.l 151,183
	dc.l 153,185
	dc.l 156,186
	dc.l 158,187
	dc.l 160,188
	dc.l 163,189
	dc.l 165,189
	dc.l 167,189
	dc.l 169,190
	dc.l 172,189
	dc.l 174,189
	dc.l 176,189
	dc.l 179,188
	dc.l 181,187
	dc.l 183,186
	dc.l 186,185
	dc.l 188,183
	dc.l 190,182
	dc.l 193,180
	dc.l 195,178
	dc.l 197,175
	dc.l 200,173
	dc.l 202,171
	dc.l 204,168
	dc.l 206,165
	dc.l 209,162
	dc.l 211,159
	dc.l 213,156
	dc.l 215,152
	dc.l 217,149
	dc.l 220,145
	dc.l 222,142
	dc.l 224,138
	dc.l 226,134
	dc.l 228,130
	dc.l 230,126
	dc.l 233,122
	dc.l 235,118
	dc.l 237,114
	dc.l 239,109
	dc.l 241,105
	dc.l 243,101
	dc.l 245,97
	dc.l 247,92
	dc.l 249,88
	dc.l 251,84
	dc.l 253,80
	dc.l 255,76
	dc.l 256,72
	dc.l 258,68
	dc.l 260,64
	dc.l 262,60
	dc.l 264,56
	dc.l 266,52
	dc.l 267,49
	dc.l 269,45
	dc.l 271,42
	dc.l 272,39
	dc.l 274,36
	dc.l 276,33
	dc.l 277,30
	dc.l 279,28
	dc.l 281,25
	dc.l 282,23
	dc.l 284,21
	dc.l 285,19
	dc.l 286,17
	dc.l 288,15
	dc.l 289,14
	dc.l 291,13
	dc.l 292,12
	dc.l 293,11
	dc.l 294,10
	dc.l 296,10
	dc.l 297,10
	dc.l 298,10
	dc.l 299,10
	dc.l 300,10
	dc.l 301,11
	dc.l 302,11
	dc.l 303,12
	dc.l 304,13
	dc.l 305,15
	dc.l 306,16
	dc.l 307,18
	dc.l 308,20
	dc.l 309,22
	dc.l 310,24
	dc.l 310,27
	dc.l 311,29
	dc.l 312,32
	dc.l 312,35
	dc.l 313,38
	dc.l 313,41
	dc.l 314,44
	dc.l 314,48
	dc.l 315,51
	dc.l 315,55
	dc.l 316,59
	dc.l 316,62
	dc.l 316,66
	dc.l 317,70
	dc.l 317,74
	dc.l 317,78
	dc.l 317,83
	dc.l 317,87
	dc.l 317,91
	dc.l 317,95
