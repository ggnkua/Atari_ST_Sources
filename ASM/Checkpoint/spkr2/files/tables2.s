sintable:
	dc.w 0
	dc.w 6
	dc.w 12
	dc.w 18
	dc.w 25
	dc.w 31
	dc.w 37
	dc.w 43
	dc.w 49
	dc.w 56
	dc.w 62
	dc.w 68
	dc.w 74
	dc.w 80
	dc.w 86
	dc.w 92
	dc.w 97
	dc.w 103
	dc.w 109
	dc.w 115
	dc.w 120
	dc.w 126
	dc.w 131
	dc.w 136
	dc.w 142
	dc.w 147
	dc.w 152
	dc.w 157
	dc.w 162
	dc.w 167
	dc.w 171
	dc.w 176
	dc.w 181
	dc.w 185
	dc.w 189
	dc.w 193
	dc.w 197
	dc.w 201
	dc.w 205
	dc.w 209
	dc.w 212
	dc.w 216
	dc.w 219
	dc.w 222
	dc.w 225
	dc.w 228
	dc.w 231
	dc.w 234
	dc.w 236
	dc.w 238
	dc.w 241
	dc.w 243
	dc.w 244
	dc.w 246
	dc.w 248
	dc.w 249
	dc.w 251
	dc.w 252
	dc.w 253
	dc.w 254
	dc.w 254
	dc.w 255
	dc.w 255
	dc.w 255
	dc.w 256
	dc.w 255
	dc.w 255
	dc.w 255
	dc.w 254
	dc.w 254
	dc.w 253
	dc.w 252
	dc.w 251
	dc.w 249
	dc.w 248
	dc.w 246
	dc.w 244
	dc.w 243
	dc.w 241
	dc.w 238
	dc.w 236
	dc.w 234
	dc.w 231
	dc.w 228
	dc.w 225
	dc.w 222
	dc.w 219
	dc.w 216
	dc.w 212
	dc.w 209
	dc.w 205
	dc.w 201
	dc.w 197
	dc.w 193
	dc.w 189
	dc.w 185
	dc.w 181
	dc.w 176
	dc.w 171
	dc.w 167
	dc.w 162
	dc.w 157
	dc.w 152
	dc.w 147
	dc.w 142
	dc.w 136
	dc.w 131
	dc.w 126
	dc.w 120
	dc.w 115
	dc.w 109
	dc.w 103
	dc.w 97
	dc.w 92
	dc.w 86
	dc.w 80
	dc.w 74
	dc.w 68
	dc.w 62
	dc.w 56
	dc.w 49
	dc.w 43
	dc.w 37
	dc.w 31
	dc.w 25
	dc.w 18
	dc.w 12
	dc.w 6
	dc.w 0
	dc.w -6
	dc.w -12
	dc.w -18
	dc.w -25
	dc.w -31
	dc.w -37
	dc.w -43
	dc.w -49
	dc.w -56
	dc.w -62
	dc.w -68
	dc.w -74
	dc.w -80
	dc.w -86
	dc.w -92
	dc.w -97
	dc.w -103
	dc.w -109
	dc.w -115
	dc.w -120
	dc.w -126
	dc.w -131
	dc.w -136
	dc.w -142
	dc.w -147
	dc.w -152
	dc.w -157
	dc.w -162
	dc.w -167
	dc.w -171
	dc.w -176
	dc.w -181
	dc.w -185
	dc.w -189
	dc.w -193
	dc.w -197
	dc.w -201
	dc.w -205
	dc.w -209
	dc.w -212
	dc.w -216
	dc.w -219
	dc.w -222
	dc.w -225
	dc.w -228
	dc.w -231
	dc.w -234
	dc.w -236
	dc.w -238
	dc.w -241
	dc.w -243
	dc.w -244
	dc.w -246
	dc.w -248
	dc.w -249
	dc.w -251
	dc.w -252
	dc.w -253
	dc.w -254
	dc.w -254
	dc.w -255
	dc.w -255
	dc.w -255
	dc.w -256
	dc.w -255
	dc.w -255
	dc.w -255
	dc.w -254
	dc.w -254
	dc.w -253
	dc.w -252
	dc.w -251
	dc.w -249
	dc.w -248
	dc.w -246
	dc.w -244
	dc.w -243
	dc.w -241
	dc.w -238
	dc.w -236
	dc.w -234
	dc.w -231
	dc.w -228
	dc.w -225
	dc.w -222
	dc.w -219
	dc.w -216
	dc.w -212
	dc.w -209
	dc.w -205
	dc.w -201
	dc.w -197
	dc.w -193
	dc.w -189
	dc.w -185
	dc.w -181
	dc.w -176
	dc.w -171
	dc.w -167
	dc.w -162
	dc.w -157
	dc.w -152
	dc.w -147
	dc.w -142
	dc.w -136
	dc.w -131
	dc.w -126
	dc.w -120
	dc.w -115
	dc.w -109
	dc.w -103
	dc.w -97
	dc.w -92
	dc.w -86
	dc.w -80
	dc.w -74
	dc.w -68
	dc.w -62
	dc.w -56
	dc.w -49
	dc.w -43
	dc.w -37
	dc.w -31
	dc.w -25
	dc.w -18
	dc.w -12
	dc.w -6			;1
	dc.w 0
	dc.w 6
	dc.w 12
	dc.w 18
	dc.w 25
	dc.w 31
	dc.w 37
	dc.w 43
	dc.w 49
	dc.w 56
	dc.w 62
	dc.w 68
	dc.w 74
	dc.w 80
	dc.w 86
	dc.w 92
	dc.w 97
	dc.w 103
	dc.w 109
	dc.w 115
	dc.w 120
	dc.w 126
	dc.w 131
	dc.w 136
	dc.w 142
	dc.w 147
	dc.w 152
	dc.w 157
	dc.w 162
	dc.w 167
	dc.w 171
	dc.w 176
	dc.w 181
	dc.w 185
	dc.w 189
	dc.w 193
	dc.w 197
	dc.w 201
	dc.w 205
	dc.w 209
	dc.w 212
	dc.w 216
	dc.w 219
	dc.w 222
	dc.w 225
	dc.w 228
	dc.w 231
	dc.w 234
	dc.w 236
	dc.w 238
	dc.w 241
	dc.w 243
	dc.w 244
	dc.w 246
	dc.w 248
	dc.w 249
	dc.w 251
	dc.w 252
	dc.w 253
	dc.w 254
	dc.w 254
	dc.w 255
	dc.w 255
	dc.w 255
	dc.w 256
	dc.w 255
	dc.w 255
	dc.w 255
	dc.w 254
	dc.w 254
	dc.w 253
	dc.w 252
	dc.w 251
	dc.w 249
	dc.w 248
	dc.w 246
	dc.w 244
	dc.w 243
	dc.w 241
	dc.w 238
	dc.w 236
	dc.w 234
	dc.w 231
	dc.w 228
	dc.w 225
	dc.w 222
	dc.w 219
	dc.w 216
	dc.w 212
	dc.w 209
	dc.w 205
	dc.w 201
	dc.w 197
	dc.w 193
	dc.w 189
	dc.w 185
	dc.w 181
	dc.w 176
	dc.w 171
	dc.w 167
	dc.w 162
	dc.w 157
	dc.w 152
	dc.w 147
	dc.w 142
	dc.w 136
	dc.w 131
	dc.w 126
	dc.w 120
	dc.w 115
	dc.w 109
	dc.w 103
	dc.w 97
	dc.w 92
	dc.w 86
	dc.w 80
	dc.w 74
	dc.w 68
	dc.w 62
	dc.w 56
	dc.w 49
	dc.w 43
	dc.w 37
	dc.w 31
	dc.w 25
	dc.w 18
	dc.w 12
	dc.w 6
	dc.w 0
	dc.w -6
	dc.w -12
	dc.w -18
	dc.w -25
	dc.w -31
	dc.w -37
	dc.w -43
	dc.w -49
	dc.w -56
	dc.w -62
	dc.w -68
	dc.w -74
	dc.w -80
	dc.w -86
	dc.w -92
	dc.w -97
	dc.w -103
	dc.w -109
	dc.w -115
	dc.w -120
	dc.w -126
	dc.w -131
	dc.w -136
	dc.w -142
	dc.w -147
	dc.w -152
	dc.w -157
	dc.w -162
	dc.w -167
	dc.w -171
	dc.w -176
	dc.w -181
	dc.w -185
	dc.w -189
	dc.w -193
	dc.w -197
	dc.w -201
	dc.w -205
	dc.w -209
	dc.w -212
	dc.w -216
	dc.w -219
	dc.w -222
	dc.w -225
	dc.w -228
	dc.w -231
	dc.w -234
	dc.w -236
	dc.w -238
	dc.w -241
	dc.w -243
	dc.w -244
	dc.w -246
	dc.w -248
	dc.w -249
	dc.w -251
	dc.w -252
	dc.w -253
	dc.w -254
	dc.w -254
	dc.w -255
	dc.w -255
	dc.w -255
	dc.w -256
	dc.w -255
	dc.w -255
	dc.w -255
	dc.w -254
	dc.w -254
	dc.w -253
	dc.w -252
	dc.w -251
	dc.w -249
	dc.w -248
	dc.w -246
	dc.w -244
	dc.w -243
	dc.w -241
	dc.w -238
	dc.w -236
	dc.w -234
	dc.w -231
	dc.w -228
	dc.w -225
	dc.w -222
	dc.w -219
	dc.w -216
	dc.w -212
	dc.w -209
	dc.w -205
	dc.w -201
	dc.w -197
	dc.w -193
	dc.w -189
	dc.w -185
	dc.w -181
	dc.w -176
	dc.w -171
	dc.w -167
	dc.w -162
	dc.w -157
	dc.w -152
	dc.w -147
	dc.w -142
	dc.w -136
	dc.w -131
	dc.w -126
	dc.w -120
	dc.w -115
	dc.w -109
	dc.w -103
	dc.w -97
	dc.w -92
	dc.w -86
	dc.w -80
	dc.w -74
	dc.w -68
	dc.w -62
	dc.w -56
	dc.w -49
	dc.w -43
	dc.w -37
	dc.w -31
	dc.w -25
	dc.w -18
	dc.w -12
	dc.w -6			;2
	dc.w 0
	dc.w 6
	dc.w 12
	dc.w 18
	dc.w 25
	dc.w 31
	dc.w 37
	dc.w 43
	dc.w 49
	dc.w 56
	dc.w 62
	dc.w 68
	dc.w 74
	dc.w 80
	dc.w 86
	dc.w 92
	dc.w 97
	dc.w 103
	dc.w 109
	dc.w 115
	dc.w 120
	dc.w 126
	dc.w 131
	dc.w 136
	dc.w 142
	dc.w 147
	dc.w 152
	dc.w 157
	dc.w 162
	dc.w 167
	dc.w 171
	dc.w 176
	dc.w 181
	dc.w 185
	dc.w 189
	dc.w 193
	dc.w 197
	dc.w 201
	dc.w 205
	dc.w 209
	dc.w 212
	dc.w 216
	dc.w 219
	dc.w 222
	dc.w 225
	dc.w 228
	dc.w 231
	dc.w 234
	dc.w 236
	dc.w 238
	dc.w 241
	dc.w 243
	dc.w 244
	dc.w 246
	dc.w 248
	dc.w 249
	dc.w 251
	dc.w 252
	dc.w 253
	dc.w 254
	dc.w 254
	dc.w 255
	dc.w 255
	dc.w 255
	dc.w 256
	dc.w 255
	dc.w 255
	dc.w 255
	dc.w 254
	dc.w 254
	dc.w 253
	dc.w 252
	dc.w 251
	dc.w 249
	dc.w 248
	dc.w 246
	dc.w 244
	dc.w 243
	dc.w 241
	dc.w 238
	dc.w 236
	dc.w 234
	dc.w 231
	dc.w 228
	dc.w 225
	dc.w 222
	dc.w 219
	dc.w 216
	dc.w 212
	dc.w 209
	dc.w 205
	dc.w 201
	dc.w 197
	dc.w 193
	dc.w 189
	dc.w 185
	dc.w 181
	dc.w 176
	dc.w 171
	dc.w 167
	dc.w 162
	dc.w 157
	dc.w 152
	dc.w 147
	dc.w 142
	dc.w 136
	dc.w 131
	dc.w 126
	dc.w 120
	dc.w 115
	dc.w 109
	dc.w 103
	dc.w 97
	dc.w 92
	dc.w 86
	dc.w 80
	dc.w 74
	dc.w 68
	dc.w 62
	dc.w 56
	dc.w 49
	dc.w 43
	dc.w 37
	dc.w 31
	dc.w 25
	dc.w 18
	dc.w 12
	dc.w 6
	dc.w 0
	dc.w -6
	dc.w -12
	dc.w -18
	dc.w -25
	dc.w -31
	dc.w -37
	dc.w -43
	dc.w -49
	dc.w -56
	dc.w -62
	dc.w -68
	dc.w -74
	dc.w -80
	dc.w -86
	dc.w -92
	dc.w -97
	dc.w -103
	dc.w -109
	dc.w -115
	dc.w -120
	dc.w -126
	dc.w -131
	dc.w -136
	dc.w -142
	dc.w -147
	dc.w -152
	dc.w -157
	dc.w -162
	dc.w -167
	dc.w -171
	dc.w -176
	dc.w -181
	dc.w -185
	dc.w -189
	dc.w -193
	dc.w -197
	dc.w -201
	dc.w -205
	dc.w -209
	dc.w -212
	dc.w -216
	dc.w -219
	dc.w -222
	dc.w -225
	dc.w -228
	dc.w -231
	dc.w -234
	dc.w -236
	dc.w -238
	dc.w -241
	dc.w -243
	dc.w -244
	dc.w -246
	dc.w -248
	dc.w -249
	dc.w -251
	dc.w -252
	dc.w -253
	dc.w -254
	dc.w -254
	dc.w -255
	dc.w -255
	dc.w -255
	dc.w -256
	dc.w -255
	dc.w -255
	dc.w -255
	dc.w -254
	dc.w -254
	dc.w -253
	dc.w -252
	dc.w -251
	dc.w -249
	dc.w -248
	dc.w -246
	dc.w -244
	dc.w -243
	dc.w -241
	dc.w -238
	dc.w -236
	dc.w -234
	dc.w -231
	dc.w -228
	dc.w -225
	dc.w -222
	dc.w -219
	dc.w -216
	dc.w -212
	dc.w -209
	dc.w -205
	dc.w -201
	dc.w -197
	dc.w -193
	dc.w -189
	dc.w -185
	dc.w -181
	dc.w -176
	dc.w -171
	dc.w -167
	dc.w -162
	dc.w -157
	dc.w -152
	dc.w -147
	dc.w -142
	dc.w -136
	dc.w -131
	dc.w -126
	dc.w -120
	dc.w -115
	dc.w -109
	dc.w -103
	dc.w -97
	dc.w -92
	dc.w -86
	dc.w -80
	dc.w -74
	dc.w -68
	dc.w -62
	dc.w -56
	dc.w -49
	dc.w -43
	dc.w -37
	dc.w -31
	dc.w -25
	dc.w -18
	dc.w -12
	dc.w -6			;3
	
costable:
	dc.w 256
	dc.w 255
	dc.w 255
	dc.w 255
	dc.w 254
	dc.w 254
	dc.w 253
	dc.w 252
	dc.w 251
	dc.w 249
	dc.w 248
	dc.w 246
	dc.w 244
	dc.w 243
	dc.w 241
	dc.w 238
	dc.w 236
	dc.w 234
	dc.w 231
	dc.w 228
	dc.w 225
	dc.w 222
	dc.w 219
	dc.w 216
	dc.w 212
	dc.w 209
	dc.w 205
	dc.w 201
	dc.w 197
	dc.w 193
	dc.w 189
	dc.w 185
	dc.w 181
	dc.w 176
	dc.w 171
	dc.w 167
	dc.w 162
	dc.w 157
	dc.w 152
	dc.w 147
	dc.w 142
	dc.w 136
	dc.w 131
	dc.w 126
	dc.w 120
	dc.w 115
	dc.w 109
	dc.w 103
	dc.w 97
	dc.w 92
	dc.w 86
	dc.w 80
	dc.w 74
	dc.w 68
	dc.w 62
	dc.w 56
	dc.w 49
	dc.w 43
	dc.w 37
	dc.w 31
	dc.w 25
	dc.w 18
	dc.w 12
	dc.w 6
	dc.w 0
	dc.w -6
	dc.w -12
	dc.w -18
	dc.w -25
	dc.w -31
	dc.w -37
	dc.w -43
	dc.w -49
	dc.w -56
	dc.w -62
	dc.w -68
	dc.w -74
	dc.w -80
	dc.w -86
	dc.w -92
	dc.w -97
	dc.w -103
	dc.w -109
	dc.w -115
	dc.w -120
	dc.w -126
	dc.w -131
	dc.w -136
	dc.w -142
	dc.w -147
	dc.w -152
	dc.w -157
	dc.w -162
	dc.w -167
	dc.w -171
	dc.w -176
	dc.w -181
	dc.w -185
	dc.w -189
	dc.w -193
	dc.w -197
	dc.w -201
	dc.w -205
	dc.w -209
	dc.w -212
	dc.w -216
	dc.w -219
	dc.w -222
	dc.w -225
	dc.w -228
	dc.w -231
	dc.w -234
	dc.w -236
	dc.w -238
	dc.w -241
	dc.w -243
	dc.w -244
	dc.w -246
	dc.w -248
	dc.w -249
	dc.w -251
	dc.w -252
	dc.w -253
	dc.w -254
	dc.w -254
	dc.w -255
	dc.w -255
	dc.w -255
	dc.w -256
	dc.w -255
	dc.w -255
	dc.w -255
	dc.w -254
	dc.w -254
	dc.w -253
	dc.w -252
	dc.w -251
	dc.w -249
	dc.w -248
	dc.w -246
	dc.w -244
	dc.w -243
	dc.w -241
	dc.w -238
	dc.w -236
	dc.w -234
	dc.w -231
	dc.w -228
	dc.w -225
	dc.w -222
	dc.w -219
	dc.w -216
	dc.w -212
	dc.w -209
	dc.w -205
	dc.w -201
	dc.w -197
	dc.w -193
	dc.w -189
	dc.w -185
	dc.w -181
	dc.w -176
	dc.w -171
	dc.w -167
	dc.w -162
	dc.w -157
	dc.w -152
	dc.w -147
	dc.w -142
	dc.w -136
	dc.w -131
	dc.w -126
	dc.w -120
	dc.w -115
	dc.w -109
	dc.w -103
	dc.w -97
	dc.w -92
	dc.w -86
	dc.w -80
	dc.w -74
	dc.w -68
	dc.w -62
	dc.w -56
	dc.w -49
	dc.w -43
	dc.w -37
	dc.w -31
	dc.w -25
	dc.w -18
	dc.w -12
	dc.w -6
	dc.w 0
	dc.w 6
	dc.w 12
	dc.w 18
	dc.w 25
	dc.w 31
	dc.w 37
	dc.w 43
	dc.w 49
	dc.w 56
	dc.w 62
	dc.w 68
	dc.w 74
	dc.w 80
	dc.w 86
	dc.w 92
	dc.w 97
	dc.w 103
	dc.w 109
	dc.w 115
	dc.w 120
	dc.w 126
	dc.w 131
	dc.w 136
	dc.w 142
	dc.w 147
	dc.w 152
	dc.w 157
	dc.w 162
	dc.w 167
	dc.w 171
	dc.w 176
	dc.w 181
	dc.w 185
	dc.w 189
	dc.w 193
	dc.w 197
	dc.w 201
	dc.w 205
	dc.w 209
	dc.w 212
	dc.w 216
	dc.w 219
	dc.w 222
	dc.w 225
	dc.w 228
	dc.w 231
	dc.w 234
	dc.w 236
	dc.w 238
	dc.w 241
	dc.w 243
	dc.w 244
	dc.w 246
	dc.w 248
	dc.w 249
	dc.w 251
	dc.w 252
	dc.w 253
	dc.w 254
	dc.w 254
	dc.w 255
	dc.w 255
	dc.w 255 ;1
	dc.w 256
	dc.w 255
	dc.w 255
	dc.w 255
	dc.w 254
	dc.w 254
	dc.w 253
	dc.w 252
	dc.w 251
	dc.w 249
	dc.w 248
	dc.w 246
	dc.w 244
	dc.w 243
	dc.w 241
	dc.w 238
	dc.w 236
	dc.w 234
	dc.w 231
	dc.w 228
	dc.w 225
	dc.w 222
	dc.w 219
	dc.w 216
	dc.w 212
	dc.w 209
	dc.w 205
	dc.w 201
	dc.w 197
	dc.w 193
	dc.w 189
	dc.w 185
	dc.w 181
	dc.w 176
	dc.w 171
	dc.w 167
	dc.w 162
	dc.w 157
	dc.w 152
	dc.w 147
	dc.w 142
	dc.w 136
	dc.w 131
	dc.w 126
	dc.w 120
	dc.w 115
	dc.w 109
	dc.w 103
	dc.w 97
	dc.w 92
	dc.w 86
	dc.w 80
	dc.w 74
	dc.w 68
	dc.w 62
	dc.w 56
	dc.w 49
	dc.w 43
	dc.w 37
	dc.w 31
	dc.w 25
	dc.w 18
	dc.w 12
	dc.w 6
	dc.w 0
	dc.w -6
	dc.w -12
	dc.w -18
	dc.w -25
	dc.w -31
	dc.w -37
	dc.w -43
	dc.w -49
	dc.w -56
	dc.w -62
	dc.w -68
	dc.w -74
	dc.w -80
	dc.w -86
	dc.w -92
	dc.w -97
	dc.w -103
	dc.w -109
	dc.w -115
	dc.w -120
	dc.w -126
	dc.w -131
	dc.w -136
	dc.w -142
	dc.w -147
	dc.w -152
	dc.w -157
	dc.w -162
	dc.w -167
	dc.w -171
	dc.w -176
	dc.w -181
	dc.w -185
	dc.w -189
	dc.w -193
	dc.w -197
	dc.w -201
	dc.w -205
	dc.w -209
	dc.w -212
	dc.w -216
	dc.w -219
	dc.w -222
	dc.w -225
	dc.w -228
	dc.w -231
	dc.w -234
	dc.w -236
	dc.w -238
	dc.w -241
	dc.w -243
	dc.w -244
	dc.w -246
	dc.w -248
	dc.w -249
	dc.w -251
	dc.w -252
	dc.w -253
	dc.w -254
	dc.w -254
	dc.w -255
	dc.w -255
	dc.w -255
	dc.w -256
	dc.w -255
	dc.w -255
	dc.w -255
	dc.w -254
	dc.w -254
	dc.w -253
	dc.w -252
	dc.w -251
	dc.w -249
	dc.w -248
	dc.w -246
	dc.w -244
	dc.w -243
	dc.w -241
	dc.w -238
	dc.w -236
	dc.w -234
	dc.w -231
	dc.w -228
	dc.w -225
	dc.w -222
	dc.w -219
	dc.w -216
	dc.w -212
	dc.w -209
	dc.w -205
	dc.w -201
	dc.w -197
	dc.w -193
	dc.w -189
	dc.w -185
	dc.w -181
	dc.w -176
	dc.w -171
	dc.w -167
	dc.w -162
	dc.w -157
	dc.w -152
	dc.w -147
	dc.w -142
	dc.w -136
	dc.w -131
	dc.w -126
	dc.w -120
	dc.w -115
	dc.w -109
	dc.w -103
	dc.w -97
	dc.w -92
	dc.w -86
	dc.w -80
	dc.w -74
	dc.w -68
	dc.w -62
	dc.w -56
	dc.w -49
	dc.w -43
	dc.w -37
	dc.w -31
	dc.w -25
	dc.w -18
	dc.w -12
	dc.w -6
	dc.w 0
	dc.w 6
	dc.w 12
	dc.w 18
	dc.w 25
	dc.w 31
	dc.w 37
	dc.w 43
	dc.w 49
	dc.w 56
	dc.w 62
	dc.w 68
	dc.w 74
	dc.w 80
	dc.w 86
	dc.w 92
	dc.w 97
	dc.w 103
	dc.w 109
	dc.w 115
	dc.w 120
	dc.w 126
	dc.w 131
	dc.w 136
	dc.w 142
	dc.w 147
	dc.w 152
	dc.w 157
	dc.w 162
	dc.w 167
	dc.w 171
	dc.w 176
	dc.w 181
	dc.w 185
	dc.w 189
	dc.w 193
	dc.w 197
	dc.w 201
	dc.w 205
	dc.w 209
	dc.w 212
	dc.w 216
	dc.w 219
	dc.w 222
	dc.w 225
	dc.w 228
	dc.w 231
	dc.w 234
	dc.w 236
	dc.w 238
	dc.w 241
	dc.w 243
	dc.w 244
	dc.w 246
	dc.w 248
	dc.w 249
	dc.w 251
	dc.w 252
	dc.w 253
	dc.w 254
	dc.w 254
	dc.w 255
	dc.w 255
	dc.w 255 ;2
	dc.w 256
	dc.w 255
	dc.w 255
	dc.w 255
	dc.w 254
	dc.w 254
	dc.w 253
	dc.w 252
	dc.w 251
	dc.w 249
	dc.w 248
	dc.w 246
	dc.w 244
	dc.w 243
	dc.w 241
	dc.w 238
	dc.w 236
	dc.w 234
	dc.w 231
	dc.w 228
	dc.w 225
	dc.w 222
	dc.w 219
	dc.w 216
	dc.w 212
	dc.w 209
	dc.w 205
	dc.w 201
	dc.w 197
	dc.w 193
	dc.w 189
	dc.w 185
	dc.w 181
	dc.w 176
	dc.w 171
	dc.w 167
	dc.w 162
	dc.w 157
	dc.w 152
	dc.w 147
	dc.w 142
	dc.w 136
	dc.w 131
	dc.w 126
	dc.w 120
	dc.w 115
	dc.w 109
	dc.w 103
	dc.w 97
	dc.w 92
	dc.w 86
	dc.w 80
	dc.w 74
	dc.w 68
	dc.w 62
	dc.w 56
	dc.w 49
	dc.w 43
	dc.w 37
	dc.w 31
	dc.w 25
	dc.w 18
	dc.w 12
	dc.w 6
	dc.w 0
	dc.w -6
	dc.w -12
	dc.w -18
	dc.w -25
	dc.w -31
	dc.w -37
	dc.w -43
	dc.w -49
	dc.w -56
	dc.w -62
	dc.w -68
	dc.w -74
	dc.w -80
	dc.w -86
	dc.w -92
	dc.w -97
	dc.w -103
	dc.w -109
	dc.w -115
	dc.w -120
	dc.w -126
	dc.w -131
	dc.w -136
	dc.w -142
	dc.w -147
	dc.w -152
	dc.w -157
	dc.w -162
	dc.w -167
	dc.w -171
	dc.w -176
	dc.w -181
	dc.w -185
	dc.w -189
	dc.w -193
	dc.w -197
	dc.w -201
	dc.w -205
	dc.w -209
	dc.w -212
	dc.w -216
	dc.w -219
	dc.w -222
	dc.w -225
	dc.w -228
	dc.w -231
	dc.w -234
	dc.w -236
	dc.w -238
	dc.w -241
	dc.w -243
	dc.w -244
	dc.w -246
	dc.w -248
	dc.w -249
	dc.w -251
	dc.w -252
	dc.w -253
	dc.w -254
	dc.w -254
	dc.w -255
	dc.w -255
	dc.w -255
	dc.w -256
	dc.w -255
	dc.w -255
	dc.w -255
	dc.w -254
	dc.w -254
	dc.w -253
	dc.w -252
	dc.w -251
	dc.w -249
	dc.w -248
	dc.w -246
	dc.w -244
	dc.w -243
	dc.w -241
	dc.w -238
	dc.w -236
	dc.w -234
	dc.w -231
	dc.w -228
	dc.w -225
	dc.w -222
	dc.w -219
	dc.w -216
	dc.w -212
	dc.w -209
	dc.w -205
	dc.w -201
	dc.w -197
	dc.w -193
	dc.w -189
	dc.w -185
	dc.w -181
	dc.w -176
	dc.w -171
	dc.w -167
	dc.w -162
	dc.w -157
	dc.w -152
	dc.w -147
	dc.w -142
	dc.w -136
	dc.w -131
	dc.w -126
	dc.w -120
	dc.w -115
	dc.w -109
	dc.w -103
	dc.w -97
	dc.w -92
	dc.w -86
	dc.w -80
	dc.w -74
	dc.w -68
	dc.w -62
	dc.w -56
	dc.w -49
	dc.w -43
	dc.w -37
	dc.w -31
	dc.w -25
	dc.w -18
	dc.w -12
	dc.w -6
	dc.w 0
	dc.w 6
	dc.w 12
	dc.w 18
	dc.w 25
	dc.w 31
	dc.w 37
	dc.w 43
	dc.w 49
	dc.w 56
	dc.w 62
	dc.w 68
	dc.w 74
	dc.w 80
	dc.w 86
	dc.w 92
	dc.w 97
	dc.w 103
	dc.w 109
	dc.w 115
	dc.w 120
	dc.w 126
	dc.w 131
	dc.w 136
	dc.w 142
	dc.w 147
	dc.w 152
	dc.w 157
	dc.w 162
	dc.w 167
	dc.w 171
	dc.w 176
	dc.w 181
	dc.w 185
	dc.w 189
	dc.w 193
	dc.w 197
	dc.w 201
	dc.w 205
	dc.w 209
	dc.w 212
	dc.w 216
	dc.w 219
	dc.w 222
	dc.w 225
	dc.w 228
	dc.w 231
	dc.w 234
	dc.w 236
	dc.w 238
	dc.w 241
	dc.w 243
	dc.w 244
	dc.w 246
	dc.w 248
	dc.w 249
	dc.w 251
	dc.w 252
	dc.w 253
	dc.w 254
	dc.w 254
	dc.w 255
	dc.w 255
	dc.w 255 ;3


	

