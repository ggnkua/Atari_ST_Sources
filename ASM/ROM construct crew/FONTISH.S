	dc.l	$00000000,$00000000,$00000000,$00000000,$00000000 

	dc.l	$00000000,$00000000,$00000000,$07C00FE0,$0FE00FE0 

	dc.l	$0FE00FE0,$0FE007C0,$000007C0,$0FE00FE0,$0FE00FE0 

	dc.l	$07C00000,$7C7CFEFE,$FEFEFEFE,$FEFE7C7C,$7C7CF8F8 

	dc.l	$00000000,$00000000,$00000000,$00000000,$00000000 

	dc.l	$00000000,$00000000,$00000000,$00000000,$00000000 

	dc.l	$00000000,$00000000,$00000000,$00000000,$00000000 

	dc.l	$00000000,$00000000,$00000000,$00000000,$00000000 

	dc.l	$00000000,$00000000,$00000000,$00000000,$00000000 

	dc.l	$00000000,$00000000,$00000000,$00000000,$00000000 

	dc.l	$00000000,$00000000,$00000000,$00000000,$00000000 

	dc.l	$00000000,$07C00FE0,$0FE00FE0,$0FE007C0,$07C00F80 

	dc.l	$00000000,$00000000,$00000000,$00000000,$1FF83FF0 

	dc.l	$3FE03FE0,$3FC03FC0,$3FC03FC0,$3FC03FC0,$3FC03FE0 

	dc.l	$3FE03FF0,$1FF80000,$3FF01FF8,$0FF80FF8,$07F807F8 

	dc.l	$07F807F8,$07F807F8,$07F80FF8,$0FF81FF8,$3FF00000 

	dc.l	$238877DC,$FFFE7FFC,$3FF87FFC,$FFFEFFFE,$FFFE7FFC 

	dc.l	$3FF87FFC,$FFFE77DC,$23880000,$07C00FE0,$0FE00FE0 

	dc.l	$7FFCFFFE,$FFFEFFFE,$FFFEFFFE,$7FFC0FE0,$0FE00FE0 

	dc.l	$07C00000,$00000000,$00000000,$00000000,$00001F00 

	dc.l	$3F803F80,$3F803F80,$1F001F00,$3E000000,$00000000 

	dc.l	$00000000,$7FFCFFFE,$FFFEFFFE,$FFFEFFFE,$7FFC0000 

	dc.l	$00000000,$00000000,$00000000,$00000000,$00000000 

	dc.l	$00000000,$00000F80,$1FC01FC0,$1FC01FC0,$0F800000 

	dc.l	$0038007C,$00FC01FC,$03FC07F8,$0FF01FE0,$3FC07F80 

	dc.l	$FF00FE00,$FC00F800,$70000000,$3FF87FFC,$FFFEFFFE 

	dc.l	$FEFEFEFE,$FEFEFEFE,$FEFEFEFE,$FEFEFFFE,$FFFE7FFC 

	dc.l	$3FF80000,$1FC03FE0,$7FE07FE0,$7FE03FE0,$0FE00FE0 

	dc.l	$0FE00FE0,$3FF87FFC,$7FFC7FFC,$3FF80000,$7FF8FFFC 

	dc.l	$FFFEFFFE,$FFFE7FFE,$00FE7FFC,$FE00FFFC,$FFFEFFFE 

	dc.l	$FFFEFFFE,$FFFC0000,$7FFCFFFE,$FFFEFFFE,$7FFE00FC 

	dc.l	$3FF83FF8,$00FC7FFE,$FFFEFFFE,$FFFEFFFE,$7FFC0000 

	dc.l	$7C7CFEFE,$FEFEFEFE,$FEFEFEFE,$FFFEFFFE,$FFFE7FFE 

	dc.l	$00FE00FE,$00FE00FE,$007C0000,$FFFCFFFE,$FFFEFFFE 

	dc.l	$FFFEFFFC,$FE007FFC,$00FE7FFE,$FFFEFFFE,$FFFEFFFC 

	dc.l	$7FF80000,$3FFC7FFE,$FFFEFFFE,$FFFEFFFC,$FE00FFFC 

	dc.l	$FEFEFFFE,$FFFEFFFE,$FFFE7FFC,$3FF80000,$7FFCFFFE 

	dc.l	$FFFEFFFE,$FFFE7FFE,$03FE07FC,$0FF80FF0,$0FF00FF0 

	dc.l	$0FF00FF0,$07E00000,$3FF87FFC,$7FFC7FFC,$7FFC7FFC 

	dc.l	$3EF87FFC,$FEFEFFFE,$FFFEFFFE,$FFFE7FFC,$3FF80000 

	dc.l	$3FF87FFC,$FFFEFFFE,$FFFEFFFE,$FEFE7FFE,$00FE7FFE 

	dc.l	$FFFEFFFE,$FFFEFFFC,$7FF80000,$00000000,$07C00FE0 

	dc.l	$0FE00FE0,$0FE007C0,$000007C0,$0FE00FE0,$0FE00FE0 

	dc.l	$07C00000,$07C00FE0,$0FE00FE0,$0FE007C0,$000007C0 

	dc.l	$0FE00FE0,$0FE00FE0,$07C007C0,$0F800000,$00000000 

	dc.l	$00000000,$00000000,$00000000,$00000000,$00000000 

	dc.l	$00000000,$00000000,$7FFCFFFE,$FFFEFFFE,$FFFEFFFE 

	dc.l	$7FFC0000,$7FFCFFFE,$FFFEFFFE,$FFFEFFFE,$7FFC0000 

	dc.l	$00000000,$00000000,$00000000,$00000000,$00000000 

	dc.l	$00000000,$00000000,$00000000,$7FFCFFFE,$FFFEFFFE 

	dc.l	$78FE00FE,$01FC03F8,$000007E0,$0FF00FF0,$0FF00FF0 

	dc.l	$07E00000 

	dc.l	$00000000,$00000000,$00000000,$00000000,$00000000 

	dc.l	$00000000,$00000000,$00000000,$0FE03FF8,$7FFC7FFC 

	dc.l	$FFFEFEFE,$FEFEFFFE,$FFFEFFFE,$FFFEFFFE,$FEFEFEFE 

	dc.l	$7C7C0000,$FFC0FFF0,$FFF8FFF8,$FCF8FCF8,$FFF0FFF8 

	dc.l	$FC7CFC3E,$FC7EFFFE,$FFFEFFFE,$FFFC0000,$0FF03FFC 

	dc.l	$7FFE7FFE,$FF7EFE3C,$FE00FE00,$FE00FE3C,$FF7E7FFE 

	dc.l	$7FFE3FFC,$0FF00000,$FFE0FFF8,$FFFCFFFC,$FEFEFE7E 

	dc.l	$FE7EFE3E,$FE3EFE3E,$FE7EFFFE,$FFFEFFFE,$FFFC0000 

	dc.l	$7FFCFFFE,$FFFEFFFE,$FFFCFE00,$FFF8FFF8,$FE00FFFC 

	dc.l	$FFFEFFFE,$FFFEFFFE,$7FFC0000,$7FFCFFFE,$FFFEFFFE 

	dc.l	$FFFCFF00,$FFF8FFF8,$FF00FF00,$FF00FF00,$FF00FF00 

	dc.l	$7E000000,$0FF03FFC,$7FFE7FFE,$FE3CFC00,$FCFCFDFE 

	dc.l	$FDFEFCFE,$FE7E7FFE,$7FFE3FFC,$0FF00000,$7C7CFEFE 

	dc.l	$FEFEFEFE,$FEFEFEFE,$FFFEFFFE,$FEFEFEFE,$FEFEFEFE 

	dc.l	$FEFEFEFE,$7C7C0000,$3FF87FFC,$7FFC7FFC,$3FF80FE0 

	dc.l	$0FE00FE0,$0FE00FE0,$3FF87FFC,$7FFC7FFC,$3FF80000 

	dc.l	$03FE07FE,$07FE07FE,$03FE00FE,$00FE00FE,$01FE7FFE 

	dc.l	$FFFEFFFC,$FFFCFFF8,$7FE00000,$7E3CFF7E,$FFFEFFFE 

	dc.l	$FFFEFFFC,$FFF8FFF0,$FFF8FFFC,$FFFEFFFE,$FFFEFF7E 

	dc.l	$7E3C0000,$7E00FF00,$FF00FF00,$FF00FF00,$FF00FFFC 

	dc.l	$FFFEFFFE,$FFFEFFFE,$FFFEFFFE,$7FFC0000,$783CFC7E 

	dc.l	$FEFEFFFE,$FFFEFFFE,$FFFEFBBE,$F93EFC7E,$FC7EFEFE 

	dc.l	$FEFEFEFE,$7C7C0000,$783CFC7E,$FE7EFF7E,$FFFEFFFE 

	dc.l	$FFFEFBFE,$F9FEFCFE,$FCFEFEFE,$FEFEFEFE,$7C7C0000 

	dc.l	$7FFCFFFE,$FFFEFFFE,$FEFEFEFE,$FEFEFEFE,$FEFEFEFE 

	dc.l	$FEFEFFFE,$FFFEFFFE,$7FFC0000,$7FF8FFFC,$FFFEFFFE 

	dc.l	$FF7EFFFE,$FFFEFFFC,$FFF8FF00,$FF00FF00,$FF00FF00 

	dc.l	$7E000000,$7FFCFFFE,$FFFEFFFE,$FCFEFCFE,$FCFEFC7E 

	dc.l	$FCBEFCDE,$FCEEFBF6,$FDFAFEFC,$7F7E0000,$7FF8FFFC 

	dc.l	$FFFEFFFE,$FF7EFFFE,$FFFEFFFC,$FFF8FF7C,$FF7EFF7E 

	dc.l	$FF7EFF7E,$7E3C0000,$3FFC7FFE,$FFFEFFFE,$FFFEFFFC 

	dc.l	$FE007FFC,$00FE7FFE,$FFFEFFFE,$FFFEFFFC,$7FF80000 

	dc.l	$7FFCFFFE,$FFFEFFFE,$FFFEFFFE,$FFFE7FFC,$0FE00FE0 

	dc.l	$0FE00FE0,$0FE00FE0,$07C00000,$7C7CFEFE,$FEFEFEFE 

	dc.l	$FEFEFEFE,$FEFEFEFE,$FEFEFEFE,$FFFEFFFE,$FFFE7FFC 

	dc.l	$3FF80000,$7C7CFEFE,$FEFEFEFE,$FEFEFEFE,$FEFEFEFE 

	dc.l	$FEFEFEFE,$7FFC3FF8,$1FF00FE0,$07C00000,$7C7CFEFE 

	dc.l	$FEFEFEFE,$FC7EFC7E,$F93EFBBE,$FFFEFFFE,$FFFEFFFE 

	dc.l	$FEFEFC7E,$783C0000,$783CFC7E,$FEFEFFFE,$FFFE7FFC 

	dc.l	$3FF81FF0,$3FF87FFC,$FFFEFFFE,$FEFEFC7E,$783C0000 

	dc.l	$783CFC7E,$FEFEFFFE,$FFFE7FFC,$3FF81FF0,$0FE00FE0 

	dc.l	$0FE00FE0,$0FE00FE0,$07C00000,$7FFCFFFE,$FFFEFFFE 

	dc.l	$FFFE7FFC,$0FF81FF0,$3FE07FFC,$FFFEFFFE,$FFFEFFFE 

	dc.l	$7FFC0000,$00000000,$00000000,$00000000,$00000000 

	dc.l	$00000000,$00000000,$00000000,$00000000,$00000000 

	dc.l	$00000000,$00000000,$00000000,$00000000,$00000000 

	dc.l	$00000000,$00000000,$00FCFFFE 

