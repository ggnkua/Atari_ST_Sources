
SPC	equ	180-" "

A	equ	180-"A"
B	equ	180-"B"
C	equ	180-"C"
D	equ	180-"D"
E	equ	180-"E"
F	equ	180-"F"
G	equ	180-"G"
H	equ	180-"H"
i	equ	180-"I"
J	equ	180-"J"
K	equ	180-"K"
L	equ	180-"L"
M	equ	180-"M"
N	equ	180-"N"
O	equ	180-"O"
P	equ	180-"P"
Q	equ	180-"Q"
R	equ	180-"R"
S	equ	180-"S"
T	equ	180-"T"
U	equ	180-"U"
V	equ	180-"V"
W	equ	180-"W"
X	equ	180-"X"
Y	equ	180-"Y"
Z	equ	180-"Z"
N0	equ	180-"0"
N1	equ	180-"1"
N2	equ	180-"2"
N3	equ	180-"3"
N4	equ	180-"4"
N5	equ	180-"5"
N6	equ	180-"6"
N7	equ	180-"7"
N8	equ	180-"8"
N9	equ	180-"9"
