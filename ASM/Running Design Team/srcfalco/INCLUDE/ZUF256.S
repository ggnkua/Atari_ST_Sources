	dc.b	 180
	dc.b	 136
	dc.b	 148
	dc.b	 74
	dc.b	 77
	dc.b	 198
	dc.b	 3
	dc.b	 194
	dc.b	 208
	dc.b	 181
	dc.b	 11
	dc.b	 105
	dc.b	 220
	dc.b	 202
	dc.b	 95
	dc.b	 246
	dc.b	 223
	dc.b	 14
	dc.b	 243
	dc.b	 93
	dc.b	 134
	dc.b	 196
	dc.b	 13
	dc.b	 151
	dc.b	 119
	dc.b	 76
	dc.b	 159
	dc.b	 165
	dc.b	 67
	dc.b	 71
	dc.b	 212
	dc.b	 211
	dc.b	 150
	dc.b	 252
	dc.b	 233
	dc.b	 58
	dc.b	 177
	dc.b	 250
	dc.b	 62
	dc.b	 136
	dc.b	 27
	dc.b	 255
	dc.b	 173
	dc.b	 4
	dc.b	 147
	dc.b	 25
	dc.b	 26
	dc.b	 204
	dc.b	 72
	dc.b	 11
	dc.b	 75
	dc.b	 97
	dc.b	 77
	dc.b	 242
	dc.b	 250
	dc.b	 102
	dc.b	 71
	dc.b	 41
	dc.b	 41
	dc.b	 165
	dc.b	 104
	dc.b	 105
	dc.b	 182
	dc.b	 83
	dc.b	 162
	dc.b	 53
	dc.b	 47
	dc.b	 149
	dc.b	 20
	dc.b	 117
	dc.b	 231
	dc.b	 66
	dc.b	 201
	dc.b	 96
	dc.b	 74
	dc.b	 235
	dc.b	 161
	dc.b	 160
	dc.b	 109
	dc.b	 25
	dc.b	 143
	dc.b	 177
	dc.b	 233
	dc.b	 213
	dc.b	 5
	dc.b	 139
	dc.b	 234
	dc.b	 110
	dc.b	 173
	dc.b	 128
	dc.b	 131
	dc.b	 118
	dc.b	 90
	dc.b	 103
	dc.b	 69
	dc.b	 14
	dc.b	 62
	dc.b	 250
	dc.b	 15
	dc.b	 99
	dc.b	 93
	dc.b	 125
	dc.b	 39
	dc.b	 121
	dc.b	 65
	dc.b	 160
	dc.b	 138
	dc.b	 40
	dc.b	 240
	dc.b	 167
	dc.b	 129
	dc.b	 99
	dc.b	 27
	dc.b	 200
	dc.b	 117
	dc.b	 192
	dc.b	 152
	dc.b	 213
	dc.b	 4
	dc.b	 53
	dc.b	 18
	dc.b	 26
	dc.b	 84
	dc.b	 32
	dc.b	 0
	dc.b	 137
	dc.b	 168
	dc.b	 139
	dc.b	 211
	dc.b	 20
	dc.b	 49
	dc.b	 173
	dc.b	 116
	dc.b	 91
	dc.b	 38
	dc.b	 180
	dc.b	 237
	dc.b	 135
	dc.b	 22
	dc.b	 193
	dc.b	 102
	dc.b	 118
	dc.b	 125
	dc.b	 53
	dc.b	 84
	dc.b	 24
	dc.b	 150
	dc.b	 43
	dc.b	 237
	dc.b	 25
	dc.b	 113
	dc.b	 69
	dc.b	 223
	dc.b	 192
	dc.b	 69
	dc.b	 172
	dc.b	 65
	dc.b	 23
	dc.b	 7
	dc.b	 82
	dc.b	 202
	dc.b	 76
	dc.b	 60
	dc.b	 123
	dc.b	 65
	dc.b	 87
	dc.b	 11
	dc.b	 123
	dc.b	 52
	dc.b	 221
	dc.b	 150
	dc.b	 193
	dc.b	 237
	dc.b	 84
	dc.b	 138
	dc.b	 20
	dc.b	 162
	dc.b	 104
	dc.b	 245
	dc.b	 29
	dc.b	 236
	dc.b	 158
	dc.b	 89
	dc.b	 38
	dc.b	 122
	dc.b	 56
	dc.b	 254
	dc.b	 33
	dc.b	 7
	dc.b	 88
	dc.b	 140
	dc.b	 236
	dc.b	 137
	dc.b	 104
	dc.b	 216
	dc.b	 211
	dc.b	 172
	dc.b	 184
	dc.b	 255
	dc.b	 86
	dc.b	 126
	dc.b	 105
	dc.b	 177
	dc.b	 45
	dc.b	 108
	dc.b	 139
	dc.b	 208
	dc.b	 138
	dc.b	 109
	dc.b	 130
	dc.b	 58
	dc.b	 158
	dc.b	 125
	dc.b	 174
	dc.b	 226
	dc.b	 94
	dc.b	 77
	dc.b	 74
	dc.b	 38
	dc.b	 135
	dc.b	 57
	dc.b	 149
	dc.b	 93
	dc.b	 224
	dc.b	 122
	dc.b	 48
	dc.b	 175
	dc.b	 191
	dc.b	 157
	dc.b	 200
	dc.b	 41
	dc.b	 206
	dc.b	 51
	dc.b	 244
	dc.b	 16
	dc.b	 15
	dc.b	 203
	dc.b	 97
	dc.b	 118
	dc.b	 30
	dc.b	 29
	dc.b	 44
	dc.b	 12
	dc.b	 182
	dc.b	 136
	dc.b	 143
	dc.b	 55
	dc.b	 119
	dc.b	 191
	dc.b	 192
	dc.b	 102
	dc.b	 231
	dc.b	 190
	dc.b	 22
	dc.b	 162
	dc.b	 182
