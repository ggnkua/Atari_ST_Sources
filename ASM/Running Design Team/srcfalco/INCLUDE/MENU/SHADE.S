********* MKSHADE Palette **********
	dc.w	0,0,2113,4226,6339,8452,10565,12678,14791,16904,19017,21130,23243,25356,27469,29582
	dc.w	31695,-31728,-29615,-27502,-25389,-23276,-21163,-19050,-16937,-14824,-12711,-10598,-8485,-6372,-4259,-2146

	dc.w	-2146,-4259,-6372,-8485,-10598,-12711,-14824,-16937,-19050,-21163,-23276,-25389,-27502,-29615,-31728,31695
	dc.w	31695,29582,27469,25356,23243,21130,19017,16904,14791,12678,10565,8452,6339,4226,2113,0
