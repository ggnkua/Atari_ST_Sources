
; running tabellen
; (c) 1994-1996

sinus_256_tab:
                DC.W 0,402,804,1205,1606,2006,2404,2801
                DC.W 3196,3590,3981,4370,4756,5139,5520,5897
                DC.W 6270,6639,7005,7366,7723,8076,8423,8765
                DC.W 9102,9434,9760,10080,10394,10702,11003,11297
                DC.W 11585,11866,12140,12406,12665,12916,13160,13395
                DC.W 13623,13842,14053,14256,14449,14635,14811,14978
                DC.W 15137,15286,15426,15557,15679,15791,15893,15986
                DC.W 16069,16143,16207,16261,16305,16340,16364,16379
                DC.W 16384,16379,16364,16340,16305,16261,16207,16143
                DC.W 16069,15986,15893,15791,15679,15557,15426,15286
                DC.W 15137,14978,14811,14635,14449,14256,14053,13842
                DC.W 13623,13395,13160,12916,12665,12406,12140,11866
                DC.W 11585,11297,11003,10702,10394,10080,9760,9434
                DC.W 9102,8765,8423,8076,7723,7366,7005,6639
                DC.W 6270,5897,5520,5139,4756,4370,3981,3590
                DC.W 3196,2801,2404,2006,1606,1205,804,402
                DC.W 0,-402,-804,-1205,-1606,-2006,-2404,-2801
                DC.W -3196,-3590,-3981,-4370,-4756,-5139,-5520,-5897
                DC.W -6270,-6639,-7005,-7366,-7723,-8076,-8423,-8765
                DC.W -9102,-9434,-9760,-10080,-10394,-10702,-11003,-11297
                DC.W -11585,-11866,-12140,-12406,-12665,-12916,-13160,-13395
                DC.W -13623,-13842,-14053,-14256,-14449,-14635,-14811,-14978
                DC.W -15137,-15286,-15426,-15557,-15679,-15791,-15893,-15986
                DC.W -16069,-16143,-16207,-16261,-16305,-16340,-16364,-16379
                DC.W -16384,-16379,-16364,-16340,-16305,-16261,-16207,-16143
                DC.W -16069,-15986,-15893,-15791,-15679,-15557,-15426,-15286
                DC.W -15137,-14978,-14811,-14635,-14449,-14256,-14053,-13842
                DC.W -13623,-13395,-13160,-12916,-12665,-12406,-12140,-11866
                DC.W -11585,-11297,-11003,-10702,-10394,-10080,-9760,-9434
                DC.W -9102,-8765,-8423,-8076,-7723,-7366,-7005,-6639
                DC.W -6270,-5897,-5520,-5139,-4756,-4370,-3981,-3590
                DC.W -3196,-2801,-2404,-2006,-1606,-1205,-804,-402

;**************************************

winkel_320_tab:
                DC.W -32,-32,-32,-32,-31,-31,-31,-31
                DC.W -31,-31,-31,-31,-30,-30,-30,-30
                DC.W -30,-30,-30,-29,-29,-29,-29,-29
                DC.W -29,-29,-28,-28,-28,-28,-28,-28
                DC.W -27,-27,-27,-27,-27,-27,-27,-26
                DC.W -26,-26,-26,-26,-26,-25,-25,-25
                DC.W -25,-25,-25,-24,-24,-24,-24,-24
                DC.W -23,-23,-23,-23,-23,-23,-22,-22
                DC.W -22,-22,-22,-21,-21,-21,-21,-21
                DC.W -20,-20,-20,-20,-20,-19,-19,-19
                DC.W -19,-19,-18,-18,-18,-18,-18,-17
                DC.W -17,-17,-17,-17,-16,-16,-16,-16
                DC.W -15,-15,-15,-15,-15,-14,-14,-14
                DC.W -14,-13,-13,-13,-13,-12,-12,-12
                DC.W -12,-12,-11,-11,-11,-11,-10,-10
                DC.W -10,-10,-9,-9,-9,-9,-8,-8
                DC.W -8,-8,-7,-7,-7,-7,-6,-6
                DC.W -6,-6,-5,-5,-5,-5,-4,-4
                DC.W -4,-4,-3,-3,-3,-3,-2,-2
                DC.W -2,-2,-1,-1,-1,-1,0,0
                DC.W 0,0,1,1,1,1,2,2
                DC.W 2,2,3,3,3,3,4,4
                DC.W 4,4,5,5,5,5,6,6
                DC.W 6,6,7,7,7,7,8,8
                DC.W 8,8,9,9,9,9,10,10
                DC.W 10,10,11,11,11,11,12,12
                DC.W 12,12,12,13,13,13,13,14
                DC.W 14,14,14,15,15,15,15,15
                DC.W 16,16,16,16,17,17,17,17
                DC.W 17,18,18,18,18,18,19,19
                DC.W 19,19,19,20,20,20,20,20
                DC.W 21,21,21,21,21,22,22,22
                DC.W 22,22,23,23,23,23,23,23
                DC.W 24,24,24,24,24,25,25,25
                DC.W 25,25,25,26,26,26,26,26
                DC.W 26,27,27,27,27,27,27,27
                DC.W 28,28,28,28,28,28,29,29
                DC.W 29,29,29,29,29,30,30,30
                DC.W 30,30,30,30,31,31,31,31
                DC.W 31,31,31,31,32,32,32,32
              
;**************************************

tangens_tab:  
                DC.L -8388608,-8336015,-8283422,-8230829
                DC.L -8178235,-8125642,-8073049,-8020456
                DC.L -7967863,-7915270,-7862676,-7810083
                DC.L -7757490,-7704897,-7652304,-7599711
                DC.L -7547118,-7494524,-7441931,-7389338
                DC.L -7336745,-7284152,-7231559,-7178965
                DC.L -7126372,-7073779,-7021186,-6968593
                DC.L -6916000,-6863407,-6810813,-6758220
                DC.L -6705627,-6653034,-6600441,-6547848
                DC.L -6495254,-6442661,-6390068,-6337475
                DC.L -6284882,-6232289,-6179696,-6127102
                DC.L -6074509,-6021916,-5969323,-5916730
                DC.L -5864137,-5811543,-5758950,-5706357
                DC.L -5653764,-5601171,-5548578,-5495985
                DC.L -5443391,-5390798,-5338205,-5285612
                DC.L -5233019,-5180426,-5127832,-5075239
                DC.L -5022646,-4970053,-4917460,-4864867
                DC.L -4812274,-4759680,-4707087,-4654494
                DC.L -4601901,-4549308,-4496715,-4444121
                DC.L -4391528,-4338935,-4286342,-4233749
                DC.L -4181156,-4128563,-4075969,-4023376
                DC.L -3970783,-3918190,-3865597,-3813004
                DC.L -3760410,-3707817,-3655224,-3602631
                DC.L -3550038,-3497445,-3444852,-3392258
                DC.L -3339665,-3287072,-3234479,-3181886
                DC.L -3129293,-3076699,-3024106,-2971513
                DC.L -2918920,-2866327,-2813734,-2761141
                DC.L -2708547,-2655954,-2603361,-2550768
                DC.L -2498175,-2445582,-2392988,-2340395
                DC.L -2287802,-2235209,-2182616,-2130023
                DC.L -2077430,-2024836,-1972243,-1919650
                DC.L -1867057,-1814464,-1761871,-1709277
                DC.L -1656684,-1604091,-1551498,-1498905
                DC.L -1446312,-1393719,-1341125,-1288532
                DC.L -1235939,-1183346,-1130753,-1078160
                DC.L -1025566,-972973,-920380,-867787
                DC.L -815194,-762601,-710008,-657414
                DC.L -604821,-552228,-499635,-447042
                DC.L -394449,-341855,-289262,-236669
                DC.L -184076,-131483,-78890,-26297
                DC.L 26297,78890,131483,184076
                DC.L 236669,289262,341855,394449
                DC.L 447042,499635,552228,604821
                DC.L 657414,710008,762601,815194
                DC.L 867787,920380,972973,1025566
                DC.L 1078160,1130753,1183346,1235939
                DC.L 1288532,1341125,1393719,1446312
                DC.L 1498905,1551498,1604091,1656684
                DC.L 1709277,1761871,1814464,1867057
                DC.L 1919650,1972243,2024836,2077430
                DC.L 2130023,2182616,2235209,2287802
                DC.L 2340395,2392988,2445582,2498175
                DC.L 2550768,2603361,2655954,2708547
                DC.L 2761141,2813734,2866327,2918920
                DC.L 2971513,3024106,3076699,3129293
                DC.L 3181886,3234479,3287072,3339665
                DC.L 3392258,3444852,3497445,3550038
                DC.L 3602631,3655224,3707817,3760410
                DC.L 3813004,3865597,3918190,3970783
                DC.L 4023376,4075969,4128563,4181156
                DC.L 4233749,4286342,4338935,4391528
                DC.L 4444121,4496715,4549308,4601901
                DC.L 4654494,4707087,4759680,4812274
                DC.L 4864867,4917460,4970053,5022646
                DC.L 5075239,5127832,5180426,5233019
                DC.L 5285612,5338205,5390798,5443391
                DC.L 5495985,5548578,5601171,5653764
                DC.L 5706357,5758950,5811543,5864137
                DC.L 5916730,5969323,6021916,6074509
                DC.L 6127102,6179696,6232289,6284882
                DC.L 6337475,6390068,6442661,6495254
                DC.L 6547848,6600441,6653034,6705627
                DC.L 6758220,6810813,6863407,6916000
                DC.L 6968593,7021186,7073779,7126372
                DC.L 7178965,7231559,7284152,7336745
                DC.L 7389338,7441931,7494524,7547118
                DC.L 7599711,7652304,7704897,7757490
                DC.L 7810083,7862676,7915270,7967863
                DC.L 8020456,8073049,8125642,8178235
                DC.L 8230829,8283422,8336015,8388607

;---------------

arctangens_tab

		dc.l 0*2
		dc.l 6 
		dc.l 1*2 
		dc.l 18 
		dc.l 2*2 
		dc.l 31 
		dc.l 3*2 
		dc.l 44 
		dc.l 4*2 
		dc.l 57 
		dc.l 5*2 
		dc.l 70 
		dc.l 6*2 
		dc.l 84 
		dc.l 7*2 
		dc.l 98 
		dc.l 8*2 
		dc.l 113 
		dc.l 9*2 
		dc.l 128 
		dc.l 10*2 
		dc.l 145 
		dc.l 11*2 
		dc.l 162 
		dc.l 12*2 
		dc.l 180 
		dc.l 13*2 
		dc.l 199 
		dc.l 14*2 
		dc.l 220 
		dc.l 15*2 
arctangens_mitte
		dc.l 243 
		dc.l 16*2 
		dc.l 268 
		dc.l 17*2 
		dc.l 296 
		dc.l 18*2 
		dc.l 328 
		dc.l 19*2 
		dc.l 363 
		dc.l 20*2 
		dc.l 404 
		dc.l 21*2 
		dc.l 451 
		dc.l 22*2 
		dc.l 508 
		dc.l 23*2 
		dc.l 577 
		dc.l 24*2 
		dc.l 663 
		dc.l 25*2 
		dc.l 774 
		dc.l 26*2 
		dc.l 925 
		dc.l 27*2 
		dc.l 1140 
		dc.l 28*2 
		dc.l 1475 
		dc.l 29*2 
		dc.l 2075 
		dc.l 30*2 
		dc.l 3470 
		dc.l 31*2 
		dc.l 10428 
		dc.l 32*2 
