; tabellenwerte fuer den ueberblendeffekt i

ueber_1_tab
		dc.w	 3868
		dc.w	 2626
		dc.w	 3216
		dc.w	 1328
		dc.w	 1340
		dc.w	 3924
		dc.w	 10
		dc.w	 3912
		dc.w	 4508
		dc.w	 3870
		dc.w	 36
		dc.w	 1980
		dc.w	 4546
		dc.w	 4488
		dc.w	 1946
		dc.w	 5174
		dc.w	 4552
		dc.w	 44
		dc.w	 5164
		dc.w	 1938
		dc.w	 2616
		dc.w	 3908
		dc.w	 42
		dc.w	 3224
		dc.w	 2572
		dc.w	 1332
		dc.w	 3248
		dc.w	 3266
		dc.w	 1304
		dc.w	 1316
		dc.w	 4520
		dc.w	 4514
		dc.w	 3218
		dc.w	 5194
		dc.w	 5134
		dc.w	 720
		dc.w	 3852
		dc.w	 5188
		dc.w	 1286
		dc.w	 2618
		dc.w	 80
		dc.w	 5202
		dc.w	 3282
		dc.w	 12
		dc.w	 3202
		dc.w	 78
		dc.w	 84
		dc.w	 4490
		dc.w	 1324
		dc.w	 34
		dc.w	 1338
		dc.w	 1956
		dc.w	 1344
		dc.w	 5158
		dc.w	 5184
		dc.w	 1970
		dc.w	 1314
		dc.w	 676
		dc.w	 680
		dc.w	 3264
		dc.w	 1982
		dc.w	 1986
		dc.w	 3872
		dc.w	 1362
		dc.w	 3254
		dc.w	 708
		dc.w	 694
		dc.w	 3220
		dc.w	 62
		dc.w	 2574
		dc.w	 5128
		dc.w	 1306
		dc.w	 4482
		dc.w	 1958
		dc.w	 1334
		dc.w	 5138
		dc.w	 3256
		dc.w	 3250
		dc.w	 1996
		dc.w	 74
		dc.w	 2644
		dc.w	 3860
		dc.w	 5132
		dc.w	 4522
		dc.w	 16
		dc.w	 2630
		dc.w	 5136
		dc.w	 1994
		dc.w	 3846
		dc.w	 2598
		dc.w	 2606
		dc.w	 2568
		dc.w	 1928
		dc.w	 1968
		dc.w	 1300
		dc.w	 46
		dc.w	 1284
		dc.w	 5182
		dc.w	 50
		dc.w	 1964
		dc.w	 1942
		dc.w	 2596
		dc.w	 670
		dc.w	 2588
		dc.w	 1296
		dc.w	 3268
		dc.w	 2640
		dc.w	 668
		dc.w	 5152
		dc.w	 3840
		dc.w	 2610
		dc.w	 1962
		dc.w	 640
		dc.w	 4492
		dc.w	 2578
		dc.w	 3910
		dc.w	 3236
		dc.w	 4528
		dc.w	 14
		dc.w	 710
		dc.w	 58
		dc.w	 642
		dc.w	 1920
		dc.w	 656
		dc.w	 0
		dc.w	 3200
		dc.w	 3848
		dc.w	 3204
		dc.w	 4526
		dc.w	 68
		dc.w	 704
		dc.w	 3866
		dc.w	 2576
		dc.w	 1940
		dc.w	 674
		dc.w	 3886
		dc.w	 5150
		dc.w	 2636
		dc.w	 72
		dc.w	 3920
		dc.w	 1978
		dc.w	 2584
		dc.w	 2608
		dc.w	 716
		dc.w	 1364
		dc.w	 76
		dc.w	 3244
		dc.w	 690
		dc.w	 5148
		dc.w	 644
		dc.w	 2566
		dc.w	 1326
		dc.w	 4558
		dc.w	 3916
		dc.w	 1322
		dc.w	 3864
		dc.w	 1310
		dc.w	 66
		dc.w	 24
		dc.w	 1926
		dc.w	 4504
		dc.w	 1352
		dc.w	 1292
		dc.w	 2614
		dc.w	 1312
		dc.w	 1948
		dc.w	 30
		dc.w	 2622
		dc.w	 718
		dc.w	 4556
		dc.w	 3260
		dc.w	 4484
		dc.w	 5156
		dc.w	 1934
		dc.w	 3226
		dc.w	 64
		dc.w	 3844
		dc.w	 2002
		dc.w	 5176
		dc.w	 654
		dc.w	 5146
		dc.w	 3278
		dc.w	 1950
		dc.w	 682
		dc.w	 2612
		dc.w	 1282
		dc.w	 5198
		dc.w	 662
		dc.w	 20
		dc.w	 1960
		dc.w	 3232
		dc.w	 5142
		dc.w	 3222
		dc.w	 2004
		dc.w	 4540
		dc.w	 4530
		dc.w	 3878
		dc.w	 3900
		dc.w	 5200
		dc.w	 1932
		dc.w	 2628
		dc.w	 2000
		dc.w	 3888
		dc.w	 696
		dc.w	 2562
		dc.w	 3228
		dc.w	 4518
		dc.w	 3212
		dc.w	 2564
		dc.w	 2638
		dc.w	 1280
		dc.w	 3284
		dc.w	 2620
		dc.w	 3884
		dc.w	 5120
		dc.w	 1952
		dc.w	 1346
		dc.w	 1336
		dc.w	 666
		dc.w	 3214
		dc.w	 722
		dc.w	 3270
		dc.w	 1954
		dc.w	 4562
		dc.w	 2602
		dc.w	 692
		dc.w	 3894
		dc.w	 4486
		dc.w	 3842
		dc.w	 4506
		dc.w	 672
		dc.w	 4532
		dc.w	 702
		dc.w	 5172
		dc.w	 40
		dc.w	 38
		dc.w	 4510
		dc.w	 1974
		dc.w	 2592
		dc.w	 648
		dc.w	 646
		dc.w	 698
		dc.w	 26
		dc.w	 3906
		dc.w	 3234
		dc.w	 3252
		dc.w	 1290
		dc.w	 2604
		dc.w	 4494
		dc.w	 4498
		dc.w	 1990
		dc.w	 5140
		dc.w	 3922
		dc.w	 56
		dc.w	 3856
		dc.w	 3902
		dc.w	 6
		dc.w	 2570
		dc.w	 1988
		dc.w	 1330
		dc.w	 5192
		dc.w	 4536
		dc.w	 3892
		dc.w	 1998
		dc.w	 3918
		dc.w	 1320
		dc.w	 1930
		dc.w	 2582
		dc.w	 5168
		dc.w	 652
		dc.w	 3858
		dc.w	 1924
		dc.w	 70
		dc.w	 700
		dc.w	 52
		dc.w	 2594
		dc.w	 5178
		dc.w	 3242
		dc.w	 3206
		dc.w	 5186
		dc.w	 1288
		dc.w	 1972
		dc.w	 1992
		dc.w	 1342
		dc.w	 3230
		dc.w	 664
		dc.w	 3240
		dc.w	 5170
		dc.w	 3272
		dc.w	 5130
		dc.w	 3882
		dc.w	 2586
		dc.w	 3904
		dc.w	 28
		dc.w	 4512
		dc.w	 3898
		dc.w	 2634
		dc.w	 678
		dc.w	 724
		dc.w	 1358
		dc.w	 4538
		dc.w	 22
		dc.w	 3238
		dc.w	 4516
		dc.w	 4544
		dc.w	 1356
		dc.w	 5180
		dc.w	 4542
		dc.w	 3876
		dc.w	 5126
		dc.w	 4564
		dc.w	 1976
		dc.w	 650
		dc.w	 5162
		dc.w	 4502
		dc.w	 3874
		dc.w	 1944
		dc.w	 4
		dc.w	 686
		dc.w	 688
		dc.w	 2642
		dc.w	 1984
		dc.w	 60
		dc.w	 1318
		dc.w	 3854
		dc.w	 4554
		dc.w	 2632
		dc.w	 712
		dc.w	 5144
		dc.w	 1936
		dc.w	 1354
		dc.w	 4500
		dc.w	 714
		dc.w	 2600
		dc.w	 1298
		dc.w	 5122
		dc.w	 3280
		dc.w	 1966
		dc.w	 2560
		dc.w	 4560
		dc.w	 3274
		dc.w	 5160
		dc.w	 3210
		dc.w	 1348
		dc.w	 4550
		dc.w	 706
		dc.w	 1294
		dc.w	 82
		dc.w	 1922
		dc.w	 2
		dc.w	 4480
		dc.w	 4548
		dc.w	 1308
		dc.w	 3896
		dc.w	 2590
		dc.w	 4534
		dc.w	 3914
		dc.w	 2624
		dc.w	 32
		dc.w	 3208
		dc.w	 1350
		dc.w	 3890
		dc.w	 1302
		dc.w	 5124
		dc.w	 54
		dc.w	 3850
		dc.w	 5196
		dc.w	 660
		dc.w	 5166
		dc.w	 18
		dc.w	 5190
		dc.w	 3276
		dc.w	 3262
		dc.w	 4524
		dc.w	 3246
		dc.w	 658
		dc.w	 4496
		dc.w	 8
		dc.w	 2580
		dc.w	 3880
		dc.w	 684
		dc.w	 1360
		dc.w	 3258
		dc.w	 3862
		dc.w	 48
		dc.w	 5154
		dc.w	 5204
