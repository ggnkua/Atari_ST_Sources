
TSTATIC		equ	0
TREDKEY		equ	1
TGREENKEY	equ	2
TBLUEKEY	equ	3
TYELLOWKEY	equ	4
TAMMO1		equ	5
TAMMO2		equ	6
TAMMO3		equ	7
TAMMO4		equ	8
TSCANNER	equ	9
TNIGHT		equ	10
TMASK		equ	11
TSMEDKITI	equ	12
TBMEDKITI	equ	13
TSMEDKIT	equ	14
TBMEDKIT	equ	15
TSARMOR		equ	16
TBARMOR		equ	17
TINVUL		equ	18
TINVIS		equ	19
TPISTOL1	equ	20
TPISTOL2	equ	21
TPISTOL3	equ	22
TPISTOL4	equ	23
TRADSUIT	equ	24
TGEIGERCOUNTER	equ	25
TJETPACK	equ	26
TBACKPACK	equ	27
TMONDETECTOR	equ	28
TPLAN		equ	29
TAMMO1DEF	equ	30
TAMMO2DEF	equ	31
TAMMO3DEF	equ	32
TAMMO4DEF	equ	33
TOPENDOOR	equ	34
TOPENLIFT	equ	35
TCLOSEDOOR	equ	36
TCLOSELIFT	equ	37
TTELEPORTER	equ	38
TCAMERAVIEW	equ	39
TTERMINAL	equ	40
TWELDER		equ	41
TTIMEDEACT	equ	42
TGIFT		equ	43
TLEVELEND	equ	44
TSAMPLE		equ	45
TSMALLPLAN	equ	46
TNEVERGET	equ	47
TSFTOZERO	equ	48
TCHANGEVIS	equ	49
TLASERDEACT	equ	50
TMESSAGE	equ	51
TSPRENGSTOFF	equ	52
TZUENDER	equ	53
TPRIMARY	equ	54
TSECONDARY	equ	55
TGENINVUL	equ	56
TGENINVIS	equ	57
TCOLOR0		equ	58
TCOLOR1		equ	59
TCOLOR2		equ	60
TCOLOR3		equ	61
TCOLOR4		equ	62
TCOLOR5		equ	63
TCOLOR6		equ	64
TCOLOR7		equ	65
TCOLOR		equ	66
TBIERKRUG	equ	67
TTRNDETECTOR	equ	68
TDCOLOR0	equ	69
TDCOLOR1	equ	70
TDCOLOR2	equ	71
TDCOLOR3	equ	72
TDCOLOR4	equ	73
TDCOLOR5	equ	74
TDCOLOR6	equ	75
TDCOLOR7	equ	76
TDCOLOR		equ	77
TSECCHANGEVIS	equ	78
TBURGER		equ	79
TCONDOM		equ	80
TIDCARD		equ	81
TWHICHEND	equ	82
TAMMO0		equ	83
TAMMO5		equ	84
TAMMO6		equ	85
TAMMO7		equ	86
TAMMO8		equ	87
TAMMO9		equ	88
TAMMO0DEF	equ	89
TAMMO5DEF	equ	90
TAMMO6DEF	equ	91
TAMMO7DEF	equ	92
TAMMO8DEF	equ	93
TAMMO9DEF	equ	94
TPISTOL0	equ	95
TPISTOL5	equ	96
TPISTOL6	equ	97
TPISTOL7	equ	98
TPISTOL8	equ	99
TPISTOL9	equ	100
TREVOLVINGPLAN	equ	101

THINGSMAX	equ	102

; maximal aufnehmbare munition
MUNX0START	equ	75
MUNX1START	equ	50
MUNX2START	equ	30
MUNX3START	equ	20
MUNX4START	equ	20
MUNX5START	equ	20
MUNX6START	equ	20
MUNX7START	equ	20
MUNX8START	equ	10
MUNX9START	equ	5

; maximal aufnehmbare munition mit backpack
MUNX0BACKPACK	equ	100
MUNX1BACKPACK	equ	80
MUNX2BACKPACK	equ	60
MUNX3BACKPACK	equ	40
MUNX4BACKPACK	equ	40
MUNX5BACKPACK	equ	40
MUNX6BACKPACK	equ	40
MUNX7BACKPACK	equ	40

MUNX9BACKPACK	equ	10

; statische munitionswerte fuer thingsType
MUN0STATIC	equ	10
MUN1STATIC	equ	10
MUN2STATIC	equ	10
MUN3STATIC	equ	10
MUN4STATIC	equ	10
MUN5STATIC	equ	10
MUN6STATIC	equ	10
MUN7STATIC	equ	10
MUN8STATIC	equ	5
MUN9STATIC	equ	5

; zugriff auf gegenstaende
		rsreset
THGROUT		rs.l	1
THGACTIONROUT	rs.l	1
THGACTIONTXT	rs.l	1
THGDEACTIONROUT	rs.l	1
THGDEACTIONTXT	rs.l	1
THGTXT		rs.l	1
THGNEEDTXT	rs.l	1
THGGFXINDEX	rs.w	1
THGSAMPLE	rs.w	1
THGTIMELIMIT	rs.w	1
THGTIMEDURATION	rs.w	1
THGMULTIPLE	rs.w	1
THGBYTES	rs.w	1

; zugriff auf aufgenommene gegenstaende (fuer array playerthings in ldsvarea.s)
		rsreset
PTHGFLAG	rs.w	1		; gegenstand vorhanden?
PTHGMULTIPLE	rs.w	1		; gegenstand mehrfach aufnehmbar?
PTHGNB		rs.w	1		; anzahl aufgenommener gegenstaende (des aktuellen typs)
PTHGTIMELIMIT	rs.l	1		; original zeitlimit
PTHGTIMECOUNTER	rs.l	1		; zeitlimit-zaehler
PTHGACTFLAG	rs.w	1		; gegenstand aktiviert?
PTHGBYTES	rs.w	1

