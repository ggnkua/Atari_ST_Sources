



		text


lineaSolidrect

