
LAPTOPCODENUMBER	equ	199

SPC			equ	LAPTOPCODENUMBER-" "

xA			equ	LAPTOPCODENUMBER-"a"
xB			equ	LAPTOPCODENUMBER-"b"
xC			equ	LAPTOPCODENUMBER-"c"
xD			equ	LAPTOPCODENUMBER-"d"
xE			equ	LAPTOPCODENUMBER-"e"
xF			equ	LAPTOPCODENUMBER-"f"
xG			equ	LAPTOPCODENUMBER-"g"
xH			equ	LAPTOPCODENUMBER-"h"
xI			equ	LAPTOPCODENUMBER-"i"
xJ			equ	LAPTOPCODENUMBER-"j"
xK			equ	LAPTOPCODENUMBER-"k"
xL			equ	LAPTOPCODENUMBER-"l"
xM			equ	LAPTOPCODENUMBER-"m"
xN			equ	LAPTOPCODENUMBER-"n"
xO			equ	LAPTOPCODENUMBER-"o"
xP			equ	LAPTOPCODENUMBER-"p"
xQ			equ	LAPTOPCODENUMBER-"q"
xR			equ	LAPTOPCODENUMBER-"r"
xS			equ	LAPTOPCODENUMBER-"s"
xT			equ	LAPTOPCODENUMBER-"t"
xU			equ	LAPTOPCODENUMBER-"u"
xV			equ	LAPTOPCODENUMBER-"v"
xW			equ	LAPTOPCODENUMBER-"w"
xX			equ	LAPTOPCODENUMBER-"x"
xY			equ	LAPTOPCODENUMBER-"y"
xZ			equ	LAPTOPCODENUMBER-"z"
x0			equ	LAPTOPCODENUMBER-"0"
x1			equ	LAPTOPCODENUMBER-"1"
x2			equ	LAPTOPCODENUMBER-"2"
x3			equ	LAPTOPCODENUMBER-"3"
x4			equ	LAPTOPCODENUMBER-"4"
x5			equ	LAPTOPCODENUMBER-"5"
x6			equ	LAPTOPCODENUMBER-"6"
x7			equ	LAPTOPCODENUMBER-"7"
x8			equ	LAPTOPCODENUMBER-"8"
x9			equ	LAPTOPCODENUMBER-"9"
