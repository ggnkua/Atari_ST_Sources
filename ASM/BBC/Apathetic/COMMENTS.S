Hi,

Cyrano Jones/The Law here (Aug 14th 2004)

This archive contains the (almost) final source code for the BBC
Apathetic Games demo disk.

As we now live in an Open Source Atari World, I thought I'd share it
with you all.

If you have any questions or comments please address them to me via
the Atari Forum (http://www.atari-forum.com)



------------------------=====================--------------------------

Folder List:

BEEBRIS.S	-	Demo release code

CYCLES.S	-	Demo release code

LOADER.S	-	Demo release code

PARASPRT.S	-	Source for the screen from The Nostalgic Demo
			Its the same screen, but I couldn't find the
			Apathetic version unfortunatly, so the return
			to loader code isn't there

RESET.S		-	Demo release code


CJ/D-Bug