
		dc.l $60720000,$00000000,$00000000,$00000000,$00000000,$00000000,$00000000,$00000000
		dc.l $00000000,$00000000,$00000000,$00000000,$00000000,$00000000,$00000000,$00000000
		dc.l $00000000,$00000000,$00000000,$00000000,$00000000,$00000000,$00000000,$00000000
		dc.l $00000000,$FFFFFFFF,$00000000,$00000000,$00000000,$2F0E4DFA,$FF8A48D6,$FFFF4DEE
		dc.l $00402D5F,$FFF82039,$00000010,$487A000A,$23DF0000,$00104AFC,$23C00000,$00104CF9
		dc.l $00FF0000,$000848D6,$00FF41FA,$008423C8,$00000010,$41FAFFB6,$20884AFC,$D503DF79
		dc.l $40862ADA,$B525BF1B,$20E44AF0,$D50FDF31,$40CE2AF6,$B509BF2B,$20D44AD8,$D527DF6D
		dc.l $40922AF2,$B50DBF7B,$20844AE4,$D51BDFD3,$402C2AFA,$B505403D,$DFC24AC8,$D537DFFF
		dc.l $4000D51A,$4AE54025,$DFDAB50C,$2AF3DF9F,$4060D50A,$4AF54031,$DFCE4ABC,$D543DFD7
		dc.l $4028D506,$4AF94039,$DFC64AC4,$D53BDFD7,$48E780C0,$41FA0034,$23C80000,$002441FA
		dc.l $057C23C8,$00000020,$06AF0000,$0002000E,$002F0007,$000C086F,$0007000C,$43FAFF0E
		dc.l $671A2051,$20A90004,$6026027C,$F8FF48E7,$80C043FA,$FEF82051,$20A90004,$206F000E
		dc.l $22882350,$00042028,$FFFC4680,$4840B190,$4CDF0301,$4E739275,$FCFE0004,$0000007C
		dc.l $BE79FFE1,$22624186,$0008B60D,$40B1CF49,$42B68F51,$A2227F1C,$D12BA22B,$3DD42EC6
		dc.l $06C80688,$00BC0708,$07480648,$06E800F6,$F330F9ED,$0000013D,$98D054D3,$9E3C0000
		dc.l $007CDC7F,$FFFF001F,$0000013C,$BF39FD31,$63CE4150,$CAA94556,$E92B718A,$FE74608B
		dc.l $8E17161A,$C6E5491C,$D7E33942,$A1557CB5,$13CB87D6,$B8D5EC50,$936EDCAD,$13AD8184
		dc.l $0C7E8381,$70EEA1EE,$6220FB15,$0842D3B0,$72740004,$993B6A6C,$979E6E20,$00089941
		dc.l $6A16BC98,$6D70000C,$995FB638,$AE5F0069,$B63D0838,$0278DCC7,$F7DB6924,$225CBDA3
		dc.l $94F523ED,$321CACE3,$DC0269BD,$F1407CBF,$A3411061,$814E30C4,$FCC77E35,$00FF8606
		dc.l $4A39FFFF,$860459F3,$B5CC7904,$860D997A,$7545790D,$860B997C,$7543790B,$86094A0A
		dc.l $866400FF,$86064A05,$FE9000FF,$86064A05,$FF9000FF,$86064A05,$FF1600FF,$86044A07
		dc.l $FF8000FF,$86063A00,$FFFF860B,$0BF4D003,$09C0F40D,$1A80AF83,$33FC0080,$00FF8604
		dc.l $53836732,$01090000,$B44067F4,$06820000,$02005281,$01090000,$B44066F6,$53836716
		dc.l $08390005,$00FFFA01,$66F24AFC,$D4039869,$65D62BEC,$9A660499,$D5515A51,$EBDB27D8
		dc.l $A52800FF,$86064A3B,$FFFF8604,$49C70014,$9EEBB6C2,$222DEDE8,$B417A8A0,$16A5B6CE
		dc.l $78B3E95A,$66A5D72F,$5A84C47B,$29DEDE21,$3B86A269,$2DF6B309,$5D42C9B9,$65C7FCD6
		dc.l $73D6C25C,$49F72289,$ED4C4AF0,$5687E882,$49FBF474,$177DDB7E,$0B0900FF,$860609F9
		dc.l $C5C67906,$8604378E,$8096997B,$277E83B5,$4CF3D881,$043EAB38,$277E043E,$C83DD803
		dc.l $00FF8606,$4DC0FFFF,$86043801,$FCBC33C1,$AD3E036F,$8C90126F,$FCE44FC4,$EC975D1D
		dc.l $EA05F3E8,$382DE958,$77A73886,$A679881C,$4419A51E,$0000043E,$B71EFEF8,$4F7280B7
		dc.l $FD85507A,$4C8DB332,$AF855A7A,$4CCAB135,$A5821081,$13FC000E,$00FF8800,$123900FF
		dc.l $88000201,$00F88200,$13C100FF,$88024AFC,$FB764C6E,$7503BAC0,$890917F6,$4553AA90
		dc.l $E80E76F1,$AAA11981,$890D3887,$C73876F1,$BAF23847,$00FF8606,$4A39FFFF,$860459C7
		dc.l $00060000,$F7C6FFFC,$00FFFA01,$62DACEA5,$57A8C957,$315CBE5C,$0FD6C3D5,$412300FF
		dc.l $86064A05,$FFD000FF,$860449C7,$FF0F61F0,$B6207A23,$9E8F00FF,$860609F9,$C63F7906
		dc.l $86047BBB,$86E6376C,$995B86E7,$376D8968,$826A5D15,$EE107D6A,$FBAA246C,$82950004
		dc.l $DDFB63FE,$FDE32D54,$9C032900,$48F900FF,$00000008,$4CFA7FFF,$FB4A4E73,$680CFC75
		dc.l $087D1803,$77F28A23,$32392D82,$75DC9E8C,$3B28396D,$41281A10,$03A91C23,$BD37DC0F
		dc.l $6A1EB603,$C86AC5EA,$51E6E76F,$411FB6FF,$96618FC5,$0AB78DAF,$1AEF8E67,$02932C5A
		dc.l $BDF0C4B4,$09117160,$60C3110B,$FE923E21,$E1CA55CE,$C37771FD,$2164705B,$371EEC54
		dc.l $00F14214,$39E98D86,$5ED1AB57,$AB3636F3,$1C648B86,$6C66C5FC,$180AC200,$5CDA1CFF
		dc.l $33222F24,$5AF0195D,$4D0EB454,$48099E76,$472D30EE,$058689AA,$FFDF8354,$70C5BB59
		dc.l $56848DE5,$6B2715E3,$2C7C2E00,$D50D75A8,$61264607,$8ED5BD08,$D6E4B558,$75E0CB63
		dc.l $69155B55,$6C8F8119,$FB19185D,$5240BD8B,$6C50CCCF,$06546117,$9C1A570D,$6A2C4B1E
		dc.l $6CD69975,$5D265D00,$BAE67269,$BFA3751D,$67A9C248,$6F0475D5,$537F6971,$4FA73B88
		dc.l $5FC84746,$3EEDA996,$69E43C25,$1C379D5F,$52332870,$C8E3F943,$FA14EB86,$24529BA2
		dc.l $41E965C6,$0FE564DD,$08117692,$68FA3552,$2DECFE48,$11F2EC62,$91DADD4A,$E92E6B6D
		dc.l $143BF3F7,$D00C90D3,$976E20AE,$A5ED3DF4,$F8D544D1,$4A325030,$18CF3FBE,$9E39ABE7
		dc.l $D7BCF1D7,$80642C79,$15FC3A7A,$D211B546,$B3EFFA09,$73A124AF,$8FF511E3,$43755B12
		dc.l $8A6D5E67,$21EB38D0,$84B9C3F7,$EF649D49,$5E381FF1,$8C4168DD,$F64A52B7,$D7E07AEC
		dc.l $2D4F3CA8,$B2A2B4D6,$E3A7BD23,$FCE8F4FB,$F8B1B58A,$95101CBB,$4DCF043B,$5C7B0A76
		dc.l $C0608A98,$338AA08C,$32C42700,$F99BBC5E,$835BBBD2,$8D0F404A,$93852670,$D1470AB1
		dc.l $43A14838,$A4A1FCF3,$7111018C,$E67EF470,$FE3431CB,$763FD488,$CA6AB854
