	DC.L $78000+(116*160)
	DC.L $78000+(117*160)
	DC.L $78000+(117*160)
	DC.L $78000+(118*160)
	DC.L $78000+(119*160)
	DC.L $78000+(120*160)
	DC.L $78000+(122*160)
	DC.L $78000+(124*160)
	DC.L $78000+(126*160)
	DC.L $78000+(128*160)
	DC.L $78000+(130*160)
	DC.L $78000+(132*160)
	DC.L $78000+(134*160)
	DC.L $78000+(136*160)
	DC.L $78000+(138*160)
	DC.L $78000+(140*160)
	DC.L $78000+(142*160)
	DC.L $78000+(144*160)
	DC.L $78000+(146*160)
	DC.L $78000+(148*160)
	DC.L $78000+(150*160)
	DC.L $78000+(152*160)
	DC.L $78000+(154*160)
	DC.L $78000+(156*160)
	DC.L $78000+(158*160)
	DC.L $78000+(160*160)
	DC.L $78000+(162*160)
	DC.L $78000+(164*160)
	DC.L $78000+(166*160)
	DC.L $78000+(167*160)
	DC.L $78000+(168*160)
	DC.L $78000+(169*160)
	DC.L $78000+(169*160)
	DC.L $78000+(170*160)
	DC.L $78000+(169*160)
	DC.L $78000+(169*160)
	DC.L $78000+(168*160)
	DC.L $78000+(167*160)
	DC.L $78000+(166*160)
	DC.L $78000+(164*160)
	DC.L $78000+(162*160)
	DC.L $78000+(160*160)
	DC.L $78000+(158*160)
	DC.L $78000+(156*160)
	DC.L $78000+(154*160)
	DC.L $78000+(152*160)
	DC.L $78000+(150*160)
	DC.L $78000+(148*160)
	DC.L $78000+(146*160)
	DC.L $78000+(144*160)
	DC.L $78000+(142*160)
	DC.L $78000+(140*160)
	DC.L $78000+(138*160)
	DC.L $78000+(136*160)
	DC.L $78000+(134*160)
	DC.L $78000+(132*160)
	DC.L $78000+(130*160)
	DC.L $78000+(128*160)
	DC.L $78000+(126*160)
	DC.L $78000+(124*160)
	DC.L $78000+(122*160)
	DC.L $78000+(120*160)
	DC.L $78000+(119*160)
	DC.L $78000+(118*160)
	DC.L $78000+(117*160)
	DC.L $78000+(117*160)