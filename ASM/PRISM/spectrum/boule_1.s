*
*  NEOchrome V2.24 cut buffer contents (left justified):
*  by Chaos, Inc. of the Delta Force (member of The Union)
*
*    pixels/scanline    = $0020 (bytes/scanline: $0010)
*  # scanlines (height) = $0016
*
*  Hardware color pallet  (color 0 to 15):
*
*      $0000,$0100,$0210,$0321,$0432,$0543,$0654,$0765
*      $0777,$0010,$0120,$0231,$0342,$0453,$0564,$0675
*
*
		dc.w	$000F,$0018,$0007,$001F,$A000,$2000,$C000,$E000
		dc.w	$003C,$0040,$003F,$007F,$F000,$F000,$0C00,$FC00
		dc.w	$00D3,$0122,$00FC,$01FF,$C300,$0300,$0000,$C300
		dc.w	$017E,$02D8,$01E0,$03FE,$0000,$0080,$0000,$0080
		dc.w	$02E8,$05B0,$03C0,$07F8,$0000,$0040,$0000,$0040
		dc.w	$05D0,$0B60,$0780,$0FF0,$0020,$0000,$0000,$0020
		dc.w	$0FA0,$0AC0,$0700,$0FE0,$0020,$0000,$0000,$0020
		dc.w	$0B40,$1580,$0E00,$1FC0,$0000,$0000,$0000,$0000
		dc.w	$1E80,$1300,$0C00,$1F80,$0000,$0000,$0000,$0000
		dc.w	$1A80,$0300,$1C00,$1F80,$0000,$0000,$0000,$0000
		dc.w	$1900,$0200,$1C00,$1F00,$0000,$0000,$0000,$0000
		dc.w	$1500,$0600,$1800,$1F00,$0008,$0000,$0000,$0008
		dc.w	$1200,$0400,$1800,$1E00,$0008,$0000,$0000,$0008
		dc.w	$0200,$0400,$1800,$1E00,$0010,$0008,$0000,$0018
		dc.w	$1200,$1400,$0800,$1E00,$0010,$0008,$0000,$0018
		dc.w	$0200,$1400,$0800,$1E00,$0028,$0010,$0000,$0038
		dc.w	$0D00,$0E00,$0000,$0F00,$0060,$0030,$0000,$0070
		dc.w	$0500,$0E00,$0000,$0F00,$00D0,$0040,$0020,$00F0
		dc.w	$0200,$0300,$0000,$0300,$0180,$00A0,$0040,$01E0
		dc.w	$0100,$0180,$0000,$0180,$0280,$01C0,$0000,$03C0
		dc.w	$0000,$00C0,$0000,$00C0,$0480,$0300,$0000,$0780
		dc.w	$0030,$0000,$0000,$0030,$1A00,$0400,$0000,$1E00
