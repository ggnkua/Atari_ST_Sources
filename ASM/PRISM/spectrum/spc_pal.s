	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $706,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $706,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $706,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $705,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $705,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $705,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $704,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $704,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $704,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $703,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $703,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $703,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $702,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $702,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $702,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $701,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $701,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $701,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $700,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $700,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $700,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $710,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $710,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $710,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $720,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $720,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $720,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $730,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $730,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $730,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $740,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $740,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $740,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $750,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $750,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $750,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $760,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $760,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $760,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $770,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $770,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $770,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $670,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $670,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $670,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $570,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $570,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $570,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $470,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $470,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $470,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $370,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $370,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $370,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $270,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $270,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $270,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $170,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $170,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $170,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $070,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $070,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $070,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $071,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $071,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $071,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $072,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $072,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $072,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $073,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $073,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $073,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $074,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $074,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $074,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $075,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $075,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $075,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $076,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $076,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $076,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $077,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $077,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $077,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $067,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $067,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $067,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $057,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $057,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $057,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $047,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $047,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $047,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $037,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $037,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $037,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $027,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $027,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $027,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $017,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $017,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $017,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $007,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $007,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $007,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $107,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $107,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $107,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $207,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $207,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $207,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $307,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $307,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $307,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $407,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $407,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $407,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $507,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $507,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $507,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $607,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $607,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $607,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $707,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $707,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $707,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $706,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $706,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $706,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $705,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $705,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $705,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $704,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $704,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $704,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $703,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $703,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $703,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $702,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $702,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $702,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $701,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $701,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $701,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $700,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $700,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $700,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $710,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $710,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $710,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $720,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $720,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $720,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $730,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $730,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $730,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $740,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $740,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $740,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $750,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $750,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $750,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $760,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $760,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $760,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $770,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $770,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $770,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $670,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $670,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $670,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $570,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $570,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $570,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $470,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $470,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $470,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $370,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $370,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $370,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $270,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $270,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $270,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $170,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $170,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $170,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $070,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $070,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $070,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $071,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $071,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $071,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $072,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $072,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $072,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $073,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $073,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $654,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $074,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $074,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $074,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $075,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $075,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $075,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $076,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $076,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $076,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $077,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $077,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $077,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $067,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $067,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $067,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $057,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $057,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $057,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $047,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $047,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $047,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $037,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $037,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $037,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $027,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $027,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $027,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $017,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $017,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $017,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $007,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $007,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $007,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $107,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $107,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $107,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $207,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $207,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $207,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $307,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $307,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $307,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $407,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $407,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $407,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $507,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $507,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $507,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $607,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $607,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $607,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $707,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $707,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $707,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $706,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $706,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $706,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $705,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $705,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $705,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $704,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $704,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $704,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $703,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $703,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $703,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $702,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $702,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $702,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $701,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $701,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $701,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $700,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $700,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $700,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $710,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $710,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $710,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $720,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $720,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $720,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $730,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $730,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $730,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $740,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $740,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $740,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $750,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $750,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $750,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $760,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $760,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $760,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $770,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $770,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $770,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $670,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $670,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $670,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $570,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $570,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $570,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $470,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $470,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $470,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $370,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $370,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $370,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $270,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $270,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $270,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $170,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $170,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $170,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $070,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $070,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $070,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $071,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $071,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $071,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $072,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $072,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $072,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $073,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $073,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $073,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $074,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $074,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $074,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $075,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $075,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $075,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $076,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $076,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $076,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $077,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $077,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $077,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $067,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $067,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $067,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $057,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $057,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $057,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $047,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $047,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $047,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $037,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $037,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $037,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $027,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $027,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $027,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $017,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $017,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $017,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $007,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $007,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $007,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $107,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $107,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $107,$010,$021,$132,$243,$354,$465,$576
	
	dc.w $000,$001,$102,$213,$324,$435,$546,$657
	dc.w $207,$001,$012,$123,$234,$345,$456,$567
	dc.w $000,$100,$201,$312,$423,$534,$645,$756
	dc.w $207,$010,$120,$231,$342,$453,$564,$675
	dc.w $000,$100,$210,$321,$432,$543,$654,$765
	dc.w $207,$010,$021,$132,$243,$354,$465,$576
