c0	dc.w $7ffe,$7ffc,$7ffe,$7ffe,$7ffa,$4004
	dc.w $6006,$6006,$4004,$6006,$6006,$4004
	dc.w $6006,$6006,$4004,$6006,$6006,$4004
	dc.w $6006,$6006,$4004,$6006,$6006,$4004
	dc.w $6006,$6006,$4004,$6006,$6006,$4004
	dc.w $6006,$6006,$4004,$6006,$6006,$4004
	dc.w $7ffe,$5ffe,$7ffc,$7ffe,$3ffe,$4000

c1	dc.w $0180,$0000,$0180,$0180,$0180,$0100
	dc.w $0180,$0180,$0100,$0180,$0180,$0100
	dc.w $0180,$0180,$0100,$0180,$0180,$0100
	dc.w $0180,$0180,$0100,$0180,$0180,$0100
	dc.w $0180,$0180,$0100,$0180,$0180,$0100
	dc.w $0180,$0180,$0100,$0180,$0180,$0100
	dc.w $0180,$0180,$0100,$0180,$0000,$0180

c2	dc.w $7ffe,$7ffc,$7ffe,$7ffe,$7ffa,$4004
	dc.w $6006,$6006,$4004,$6006,$0006,$6004
	dc.w $0006,$0006,$0004,$0006,$0006,$0004
	dc.w $7ffe,$7ffe,$7ffc,$7ffe,$7ffe,$4000
	dc.w $6000,$6000,$4000,$6000,$6000,$4000
	dc.w $6000,$6000,$4000,$6000,$6000,$4000
	dc.w $7ffe,$5ffc,$7ffe,$7ffe,$3ffc,$4002

c3	dc.w $7ffe,$3ffc,$7ffe,$7ffe,$3ffa,$4004
	dc.w $0006,$0006,$0004,$0006,$0006,$0004
	dc.w $0006,$0006,$0004,$0006,$0006,$0004
	dc.w $00fe,$007a,$00fc,$00fe,$007a,$0084
	dc.w $0006,$0006,$0004,$0006,$0006,$0004
	dc.w $0006,$0006,$0004,$0006,$0006,$0004
	dc.w $7ffe,$3ffe,$7ffc,$7ffe,$3ffe,$4000

c4	dc.w $6000,$0000,$6000,$6000,$6000,$4000
	dc.w $6030,$6000,$4030,$6030,$6030,$4020
	dc.w $6030,$6030,$4020,$6030,$6030,$4020
	dc.w $6030,$6030,$4020,$6030,$6030,$4020
	dc.w $7ffe,$5fdc,$7fee,$7ffe,$3fdc,$4022
	dc.w $0030,$0030,$0020,$0030,$0030,$0020
	dc.w $0030,$0030,$0020,$0030,$0000,$0030

c5	dc.w $7ffe,$7ffc,$7ffe,$7ffe,$7ffc,$4002
	dc.w $6000,$6000,$4000,$6000,$6000,$4000
	dc.w $6000,$6000,$4000,$6000,$6000,$4000
	dc.w $7ffe,$5ffc,$7ffe,$7ffe,$3ffa,$4004
	dc.w $0006,$0006,$0004,$0006,$0006,$0004
	dc.w $6006,$0006,$6004,$6006,$6006,$4004
	dc.w $7ffe,$5ffe,$7ffc,$7ffe,$3ffe,$4000

c6	dc.w $7ffe,$7ffc,$7ffe,$7ffe,$7ffa,$4004
	dc.w $6006,$6006,$4004,$6006,$6000,$4006
	dc.w $6000,$6000,$4000,$6000,$6000,$4000
	dc.w $7ffe,$5ffc,$7ffe,$7ffe,$5ffa,$6004
	dc.w $6006,$6006,$4004,$6006,$6006,$4004
	dc.w $6006,$6006,$4004,$6006,$6006,$4004
	dc.w $7ffe,$5ffe,$7ffc,$7ffe,$3ffe,$4000

c7	dc.w $7ffe,$3ffc,$7ffe,$7ffe,$3ffa,$4004
	dc.w $0006,$0006,$0004,$0006,$0006,$0004
	dc.w $0006,$0006,$0004,$0006,$0006,$0004
	dc.w $00fe,$007a,$00fc,$00fe,$007a,$0084
	dc.w $0006,$0006,$0004,$0006,$0006,$0004
	dc.w $0006,$0006,$0004,$0006,$0006,$0004
	dc.w $0006,$0006,$0004,$0006,$0000,$0006

c8	dc.w $7ffe,$7ffc,$7ffe,$7ffe,$7ffa,$4004
	dc.w $6006,$6006,$4004,$6006,$6006,$4004
	dc.w $6006,$6006,$4004,$6006,$6006,$4004
	dc.w $7ffe,$5ffa,$7ffc,$7ffe,$5ffa,$6004
	dc.w $6006,$6006,$4004,$6006,$6006,$4004
	dc.w $6006,$6006,$4004,$6006,$6006,$4004
	dc.w $7ffe,$5ffe,$7ffc,$7ffe,$3ffe,$4000

c9	dc.w $7ffe,$7ffc,$7ffe,$7ffe,$7ffa,$4004
	dc.w $6006,$6006,$4004,$6006,$6006,$4004
	dc.w $6006,$6006,$4004,$6006,$6006,$4004
	dc.w $7ffe,$5ffa,$7ffc,$7ffe,$3ffa,$4004
	dc.w $0006,$0006,$0004,$0006,$0006,$0004
	dc.w $6006,$0006,$6004,$6006,$6006,$4004
	dc.w $7ffe,$5ffe,$7ffc,$7ffe,$3ffe,$4000

ca	dc.w $7ffe,$7ffc,$7ffe,$7ffe,$7ffa,$4004
	dc.w $6006,$6006,$4004,$6006,$6006,$4004
	dc.w $6006,$6006,$4004,$6006,$6006,$4004
	dc.w $7ffe,$5ffa,$7ffc,$7ffe,$5ffa,$6004
	dc.w $6006,$6006,$4004,$6006,$6006,$4004
	dc.w $6006,$6006,$4004,$6006,$6006,$4004
	dc.w $6006,$6006,$4004,$6006,$0000,$6006

cb	dc.w $7ff8,$7ff0,$7ff8,$7ff8,$7fe8,$4010
	dc.w $6018,$6018,$4010,$6018,$6018,$4010
	dc.w $6018,$6018,$4010,$6018,$6018,$4010
	dc.w $7ffe,$5fec,$7ff6,$7ffe,$5ff2,$600c
	dc.w $6006,$6006,$4004,$6006,$6006,$4004
	dc.w $6006,$6006,$4004,$6006,$6006,$4004
	dc.w $7ffe,$5ffe,$7ffc,$7ffe,$3ffe,$4000

cc	dc.w $7ffe,$7ffc,$7ffe,$7ffe,$7ffa,$4004
	dc.w $6006,$6006,$4004,$6006,$6000,$4006
	dc.w $6000,$6000,$4000,$6000,$6000,$4000
	dc.w $6000,$6000,$4000,$6000,$6000,$4000
	dc.w $6000,$6000,$4000,$6000,$6000,$4000
	dc.w $6006,$6000,$4006,$6006,$6006,$4004
	dc.w $7ffe,$5ffe,$7ffc,$7ffe,$3ffe,$4000

cd	dc.w $7ff8,$7ff0,$7ff8,$7ff8,$7ff0,$4008
	dc.w $6006,$6000,$4006,$6006,$6006,$4004
	dc.w $6006,$6006,$4004,$6006,$6006,$4004
	dc.w $6006,$6006,$4004,$6006,$6006,$4004
	dc.w $6006,$6006,$4004,$6006,$6006,$4004
	dc.w $6006,$6006,$4004,$6006,$6000,$4006
	dc.w $7ff8,$5ff0,$7ff8,$7ff8,$3ff0,$4008

ce	dc.w $7ffe,$3ffc,$7ffe,$7ffe,$5ffc,$6002
	dc.w $6000,$6000,$4000,$6000,$6000,$4000
	dc.w $6000,$6000,$4000,$6000,$6000,$4000
	dc.w $7fc0,$5f80,$7fc0,$7fc0,$5f80,$6040
	dc.w $6000,$6000,$4000,$6000,$6000,$4000
	dc.w $6000,$6000,$4000,$6000,$6000,$4000
	dc.w $7ffe,$5ffc,$7ffe,$7ffe,$3ffc,$4002

cf	dc.w $7ffe,$7ffc,$7ffe,$7ffe,$7ffc,$4002
	dc.w $6000,$6000,$4000,$6000,$6000,$4000
	dc.w $6000,$6000,$4000,$6000,$6000,$4000
	dc.w $7fc0,$5f80,$7fc0,$7fc0,$5f80,$6040
	dc.w $6000,$6000,$4000,$6000,$6000,$4000
	dc.w $6000,$6000,$4000,$6000,$6000,$4000
	dc.w $6000,$6000,$4000,$6000,$0000,$6000

cn	dc.w $6006,$0000,$6006,$7006,$7006,$4004
	dc.w $7806,$6806,$5004,$7c06,$6406,$5804
	dc.w $6e06,$6a06,$4c04,$6706,$6506,$4604
	dc.w $6386,$6286,$4304,$61c6,$6146,$4184
	dc.w $60e6,$60a6,$40c4,$6076,$6056,$4064
	dc.w $603e,$602e,$4034,$601e,$6012,$401c
	dc.w $600e,$600a,$400c,$6006,$0000,$6006

cs	dc.w $7ffe,$7ffc,$7ffe,$7ffe,$7ffc,$4002
	dc.w $6000,$6000,$4000,$6000,$6000,$4000
	dc.w $6000,$6000,$4000,$6000,$6000,$4000
	dc.w $7ffe,$5ffc,$7ffe,$7ffe,$3ffa,$4004
	dc.w $0006,$0006,$0004,$0006,$0006,$0004
	dc.w $0006,$0006,$0004,$0006,$0006,$0004
	dc.w $7ffe,$3ffe,$7ffc,$7ffe,$3ffe,$4000

ct	dc.w $7ffe,$3ffc,$7ffe,$7ffe,$3e7c,$4182
	dc.w $0180,$0180,$0100,$0180,$0180,$0100
	dc.w $0180,$0180,$0100,$0180,$0180,$0100
	dc.w $0180,$0180,$0100,$0180,$0180,$0100
	dc.w $0180,$0180,$0100,$0180,$0180,$0100
	dc.w $0180,$0180,$0100,$0180,$0180,$0100
	dc.w $0180,$0180,$0100,$0180,$0000,$0180

cx	dc.w $6006,$2004,$4006,$700e,$500a,$600c
	dc.w $381c,$2814,$3018,$1c38,$1428,$1830
	dc.w $0e70,$0a50,$0c60,$07e0,$05a0,$06c0
	dc.w $03c0,$0240,$0380,$03c0,$0240,$0380
	dc.w $07e0,$05a0,$06c0,$0e70,$0a50,$0c60
	dc.w $1c38,$1428,$1830,$381c,$2814,$3018
	dc.w $700e,$500a,$600c,$6006,$2004,$4006

