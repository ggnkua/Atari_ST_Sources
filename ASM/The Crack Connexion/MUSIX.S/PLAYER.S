          clr.l -(sp)           ;In Supervisor gehen
          move.w #$20,-(sp)
          trap #1
          addq.l #6,sp
          move.l d0,ssp

          jsr muzak

          move.w #1,d0          ;Liednummer in D0
          jsr muzak             ;Lied anspringen
          move.l #muzak+8,$4de  ;Musik in VBL-Queue einbinden

l:        cmpi.b #$39,$fffffc02 ;Auf Space warten
          bne l

          clr.l $4de

          move.l ssp,-(sp)      ;Zur�ck in User
          move.w #$20,-(sp)
          trap #1
          addq.l #6,sp

          clr.w -(sp)           ;Prog. verlassen
          trap #1

ssp:      dc.l 0

muzak:    ibytes 'ancool1.snd'  ;Name des Liedes
          rts

          end
