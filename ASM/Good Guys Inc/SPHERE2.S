**************************
* some kind of globe by griff for falcon using the DSP
* reassembled by an cool
* 
* i just sat down for a few seconds and improved this
* .s.... but it can be inproved more by using our new 
* pixel rout....   se ya'
**************************
* EVERYTHING can be improved ... 
* I just looked at the code for some seconds, and  I've
* found that NEITHER Griff NOR An Cool did activate the
* internal chache....
* This code works now on TV AND VGA-Monitors at a frame
* rate of 60Hz !!!!!!
*                          Spiff / Good Guys Inc.
 TEXT 
Begin:

	jsr	make_y_tab

                  MOVE.W    #4,-(A7) 	;GETREZ 
                  TRAP      #$E 
                  ADDQ.L    #2,A7 
                  MOVE.W    D0,OLDRES 
                  MOVE.W    #2,-(A7) 	;PHYSBASE 
                  TRAP      #$E 
                  ADDQ.L    #2,A7 
                  MOVE.L    D0,OLDBASE
                  MOVE.W    #-1,-(A7) 
                  MOVE.W    #$58,-(A7)
                  TRAP      #$E 
                  ADDQ.L    #4,A7 
                  MOVE.W    D0,OLDVIDEO 

*   This is CLEAN VGA/TV Detection! 
*   USE THIS IN YOUR DEMOS!!! I HATE SWITCHING FROM VGA TO TV
*   ALL THE TIME...(and anyway: there are a lot of losers out there
*   who are crying because no demos are working on their VGA-Monitors
*   So have a heart and at least include a message, that the demo does
*   not work on VGA .Don't be too lazy, and believe me: Crashing demos
*   give a very bad first impression....(Some call it lame.. ;-)
*   ...Spiff
  and.w	  #$10,d0	* Save the Vga/TV-Bit   
  or.w	  #$182,d0	* add 16 Colors/ST-compatibility/320*200
  move.w  d0,-(sp)	* 
  move.w  #88,-(sp)     *
  trap	  #14		* VSetMode
  addq.l  #4,sp
*
*  If you activate the following
*  lines it will speed up again
*  40 Scanlines... (50hz /60 hz I think)
*  (But it won't work on VGA anymore...)
*  ...Spiff 

*   CLR.W     -(A7) 
*   PEA       $FFFFFFFF.W 
*   PEA       $FFFFFFFF.W 
*   MOVE.W    #5,-(A7) 	;SETSCREEN
*   TRAP      #$E 
*   LEA       12(A7),A7 
*

                  CLR.L     -(A7) 
                  MOVE.W    #$20,-(A7) 	;SUPER
                  TRAP      #1
                  ADDQ.L    #6,A7 
                  MOVE.L    D0,OLDSP
                  LEA       MY_STACK,A7 
                  MOVEM.L   $FFFF8240.W,D0-D7 
                  MOVEM.L   D0-D7,OLD_PAL 
                  MOVE.W    #1,-(A7)
                  MOVE.L    #$79,-(A7)
                  PEA       DSPPROG(PC) 
                  MOVE.W    #$6E,-(A7)
                  TRAP      #$E 
                  LEA       12(A7),A7 
                  BSR       INIT_2SC
                  BSR       MAKEPERS
                  BSR       MAKEBIT_
                  BSR       INIT_INT
    movec.l   CACR,d0		* Save Cache to Stack
    move.l    d0,-(sp)
L0000:            BSR       WAIT_VBL
                  LEA       LOG_BASE(PC),A0 
                  MOVE.L    (A0)+,D0
                  MOVE.L    (A0)+,D1
                  MOVE.L    D0,-(A0)
                  MOVE.L    D1,-(A0)
                  LSR.W     #8,D0 
                  MOVE.L    D0,$FFFF8200.W
                  MOVEA.L   LOG_BASE(PC),A1 
                  MOVE.W    #199,D1

  move.l    #$3111,d0		* Activate Cache
  movec.l    d0,CACR

                  MOVEQ     #0,D0 
L0001:
                  MOVE.W    D0,8*3(A1) 
                  MOVE.W    D0,8*4(A1) 
                  MOVE.W    D0,8*5(A1) 
                  MOVE.W    D0,8*6(A1) 
                  MOVE.W    D0,8*7(A1) 
                  MOVE.W    D0,8*8(A1) 
                  MOVE.W    D0,8*9(A1) 
                  MOVE.W    D0,8*10(A1) 
                  MOVE.W    D0,8*11(A1) 
                  MOVE.W    D0,8*12(A1) 
                  MOVE.W    D0,8*13(A1) 
                  MOVE.W    D0,8*14(A1) 
                  MOVE.W    D0,8*15(A1) 
                  MOVE.W    D0,8*16(A1) 
                  LEA       160(A1),A1 
                  DBF       D1,L0001
                  LEA       SPHERE96,A5 
                  ADDQ.W    #4,(A5) 
                  ADDQ.W    #6,2(A5)
                  ADDQ.W    #8,4(A5)
                  JSR       SHOW_OBJ
                  CMPI.B    #$39,KEY
                  BNE       L0000 
  move.l    (SP)+,d0			* Restore Cache from Stack
  movec.l    d0,CACR
                  BSR       RESTORE_
                  MOVEM.L   OLD_PAL(PC),D0-D7 
                  MOVEM.L   D0-D7,$FFFF8240.W 
                  MOVE.L    OLDSP(PC),-(A7) 
                  MOVE.W    #$20,-(A7) 	;SUPER
                  TRAP      #1
                  ADDQ.L    #6,A7 
                  MOVE.W    OLDRES(PC),-(A7)
                  MOVE.L    OLDBASE(PC),-(A7) 
                  MOVE.L    OLDBASE(PC),-(A7) 
                  MOVE.W    #5,-(A7) 	;SETSCREEN
                  TRAP      #$E 
                  LEA       12(A7),A7 
                  MOVE.W    OLDVIDEO(PC),-(A7)
                  MOVE.W    #$58,-(A7)
                  TRAP      #$E 
                  ADDQ.L    #4,A7 

                  CLR.W     -(A7) 	;PTERM0
                  TRAP      #1
OLDVIDEO:         DC.B      $00,$00 
OLDRES:           DC.B      $00,$00 
OLDBASE:          DS.W      2 
OLDSP:            DS.W      2 
make_y_tab:
	lea	ytabc(pc),a0
	move.w	#-100*160,d0
	move.w	#399,d1
.loop:
	move.w	d0,(a0)+
	add.w	#160,d0
	dbra	d1,.loop
	rts
ytabc:
	ds.w	200
ytab:
	ds.w	200
MAKEPERS:         LEA       PERSTABL,A0 
                  MOVE.W    #$141,D0
                  MOVE.W    #$7EBE,D1 
L0007:            MOVE.L    #$A00000,D2 
                  DIVS      D0,D2 
                  MOVE.W    D2,(A0)+
                  ADDQ.W    #1,D0 
                  DBF       D1,L0007
                  RTS 
MAKEBIT_:         LEA       BIT_OFFS,A0 
                  MOVEQ     #0,D1 
                  MOVEQ     #$13,D3 
L0009:            MOVE.W    #-$8000,D0
                  MOVEQ     #$F,D2
L000A:            MOVE.W    D0,(A0)+
                  MOVE.W    D1,(A0)+
                  LSR.W     #1,D0 
                  DBF       D2,L000A
                  ADDQ.W    #8,D1 
                  DBF       D3,L0009
                  RTS 
INIT_INT:         MOVEQ     #$13,D0 
                  BSR       WRITEIKB
                  MOVE      #$2700,SR 
                  LEA       OLD_STUF(PC),A0 
                  MOVE      USP,A1
                  MOVE.L    A1,(A0)+
                  MOVE.L    $68.W,(A0)+ 
                  MOVE.L    $70.W,(A0)+ 
                  MOVE.L    $B0.W,(A0)+ 
                  MOVE.L    $110.W,(A0)+
                  MOVE.L    $118.W,(A0)+
                  MOVE.L    $120.W,(A0)+
                  MOVE.L    $134.W,(A0)+
                  MOVE.B    $FFFFFA07.W,(A0)+ 
                  MOVE.B    $FFFFFA09.W,(A0)+ 
                  MOVE.B    $FFFFFA0B.W,(A0)+ 
                  MOVE.B    $FFFFFA0D.W,(A0)+ 
                  MOVE.B    $FFFFFA0F.W,(A0)+ 
                  MOVE.B    $FFFFFA11.W,(A0)+ 
                  MOVE.B    $FFFFFA13.W,(A0)+ 
                  MOVE.B    $FFFFFA15.W,(A0)+ 
                  MOVE.B    $FFFFFA17.W,(A0)+ 
                  MOVE.B    $FFFFFA19.W,(A0)+ 
                  MOVE.B    $FFFFFA1B.W,(A0)+ 
                  MOVE.B    $FFFFFA1D.W,(A0)+ 
                  MOVE.B    $FFFFFA1F.W,(A0)+ 
                  MOVE.B    $FFFFFA21.W,(A0)+ 
                  MOVE.B    $FFFFFA25.W,(A0)+ 
                  MOVE.B    #0,$FFFFFA07.W
                  MOVE.B    #$40,$FFFFFA09.W
                  MOVE.B    #0,$FFFFFA13.W
                  MOVE.B    #$40,$FFFFFA15.W
                  BCLR      #3,$FFFFFA17.W
                  LEA       VBL(PC),A0
                  MOVE.L    A0,$70.W
                  LEA       KEY_ROUT(PC),A0 
                  MOVE.L    A0,$118.W 
                  CLR.W     KEY 
                  MOVE.B    #0,$FFFFFA0F.W
                  MOVE.B    #0,$FFFFFA11.W
                  MOVE.B    #0,$FFFFFA0B.W
                  MOVE.B    #0,$FFFFFA0D.W
                  MOVE      #$2300,SR 
                  MOVEQ     #$11,D0 
                  BSR       WRITEIKB
                  MOVEQ     #$12,D0 
                  BSR       WRITEIKB
                  BSR       FLUSH 
                  RTS 
RESTORE_:         MOVEQ     #$13,D0 
                  BSR       WRITEIKB
                  MOVE      #$2700,SR 
                  LEA       OLD_STUF(PC),A0 
                  MOVEA.L   (A0)+,A1
                  MOVE      A1,USP
                  MOVE.L    (A0)+,$68.W 
                  MOVE.L    (A0)+,$70.W 
                  MOVE.L    (A0)+,$B0.W 
                  MOVE.L    (A0)+,$110.W
                  MOVE.L    (A0)+,$118.W
                  MOVE.L    (A0)+,$120.W
                  MOVE.L    (A0)+,$134.W
                  MOVE.B    (A0)+,$FFFFFA07.W 
                  MOVE.B    (A0)+,$FFFFFA09.W 
                  MOVE.B    (A0)+,$FFFFFA0B.W 
                  MOVE.B    (A0)+,$FFFFFA0D.W 
                  MOVE.B    (A0)+,$FFFFFA0F.W 
                  MOVE.B    (A0)+,$FFFFFA11.W 
                  MOVE.B    (A0)+,$FFFFFA13.W 
                  MOVE.B    (A0)+,$FFFFFA15.W 
                  MOVE.B    (A0)+,$FFFFFA17.W 
                  MOVE.B    (A0)+,$FFFFFA19.W 
                  MOVE.B    (A0)+,$FFFFFA1B.W 
                  MOVE.B    (A0)+,$FFFFFA1D.W 
                  MOVE.B    (A0)+,$FFFFFA1F.W 
                  MOVE.B    (A0)+,$FFFFFA21.W 
                  MOVE.B    (A0)+,$FFFFFA25.W 
                  MOVE      #$2300,SR 
                  MOVEQ     #$11,D0 
                  BSR       WRITEIKB
                  MOVEQ     #8,D0 
                  BSR       WRITEIKB
                  BSR       FLUSH 
                  RTS 
OLD_PAL:          DS.W      16
OLD_STUF:         DS.W      64
INIT_2SC:         LEA       LOG_BASE(PC),A1 
                  MOVE.L    #L0024,D0 
                  CLR.B     D0
                  MOVEA.L   D0,A0 
                  MOVE.L    A0,(A1)+
                  BSR       CLS 
                  ADDA.L    #$7D00,A0 
                  MOVE.L    A0,(A1)+
                  BSR       CLS 
                  MOVE.L    LOG_BASE(PC),D0 
                  LSR.W     #8,D0 
                  MOVE.L    D0,$FFFF8200.W
                  RTS 
CLS:              MOVEA.L   A0,A2 
                  MOVEQ     #0,D0 
                  MOVE.W    #$7CF,D1
L0011:            MOVE.L    D0,(A2)+
                  MOVE.L    D0,(A2)+
                  MOVE.L    D0,(A2)+
                  MOVE.L    D0,(A2)+
                  DBF       D1,L0011
                  RTS 
VBL:              MOVE.L    #$777,$FFFF8240.W 
                  ADDQ.W    #1,VBL_TIME 
                  RTE 
WAIT_VBL:         LEA       VBL_TIME(PC),A0 
                  MOVE.W    (A0),D0 
L0014:            CMP.W     (A0),D0 
                  BEQ.S     L0014 
                  RTS 
FLUSH:            BTST      #0,$FFFFFC00.W
                  BEQ.S     L0016 
                  MOVE.B    $FFFFFC02.W,D0
                  BRA.S     FLUSH 
L0016:            RTS 
WRITEIKB:         BTST      #1,$FFFFFC00.W
                  BEQ.S     WRITEIKB
                  MOVE.B    D0,$FFFFFC02.W
                  RTS 
KEY_ROUT:         MOVE      #$2500,SR 
                  MOVE.W    D0,-(A7)
                  MOVE.B    $FFFFFC00.W,D0
                  BTST      #7,D0 
                  BEQ.S     L0019 
                  BTST      #0,D0 
                  BEQ.S     L0019 
                  MOVE.B    $FFFFFC02.W,KEY 
L0019:            MOVE.W    (A7)+,D0
                  RTE 
KEY:              DC.B      $00,$00 
VBL_TIME:         DC.B      $00,$00 
LOG_BASE:         DS.W      4 
SHOW_OBJ:
	lea	TRIG_TAB,a0
	lea	$200(a0),a2
	movem.w	(a5)+,d5-d7
	andi.w	#$7FE,d5
	andi.w	#$7FE,d6
	andi.w	#$7FE,d7
	move.w	0(a0,d5.w),d0
	move.w	0(a2,d5.w),d1
	move.w	0(a0,d6.w),d2
	move.w	0(a2,d6.w),d3
	move.w	0(a0,d7.w),d4
	move.w	0(a2,d7.w),d5
	lea	what+6(pc),a1
	move.w	d0,d6
	muls.w	d4,d6
	add.l	d6,d6
	swap	d6
	movea.w	d6,a3
	move.w	d1,d6
	muls.w	d4,d6
	add.l	d6,d6
	swap	d6
	movea.w	d6,a4
	move.w	d3,d6
	muls.w	d1,d6
	move.w	a3,d7
	muls.w	d2,d7
	sub.l	d7,d6
	add.l	d6,d6
	swap	d6
	move.w	d6,(a1)+
	move.w	d2,d6
	muls.w	d1,d6
	move.w	a3,d7
	muls.w	d3,d7
	add.l	d7,d6
	add.l	d6,d6
	swap	d6
	move.w	d6,(a1)+
	move.w	d5,d6
	muls.w	d0,d6
	add.l	d6,d6
	swap	d6
	neg.w	d6
	move.w	d6,(a1)+
	move.w	d2,d6
	muls.w	d5,d6
	add.l	d6,d6
	swap	d6
	neg.w	d6
	move.w	d6,(a1)+
	move.w	d3,d6
	muls.w	d5,d6
	add.l	d6,d6
	swap	d6
	move.w	d6,(a1)+
	move.w	d4,(a1)+
	move.w	d3,d6
	muls.w	d0,d6
	move.w	a4,d7
	muls.w	d2,d7
	add.l	d7,d6
	add.l	d6,d6
	swap	d6
	move.w	d6,(a1)+
	muls.w	d0,d2
	move.w	a4,d7
	muls.w	d3,d7
	sub.l	d7,d2
	add.l	d2,d2
	swap	d2
	move.w	d2,(a1)+
	muls.w	d1,d5
	add.l	d5,d5
	swap	d5
	move.w	d5,(a1)+
	lea	$FFFFA200.w,a0
	clr.b	7(a0)
	lea	what+6(pc),a2
	nop
	move.b	(a2)+,5(a0)
	move.b	(a2)+,6(a0)
	clr.b	7(a0)
	move.b	(a2)+,5(a0)
	move.b	(a2)+,6(a0)
	clr.b	7(a0)
	move.b	(a2)+,5(a0)
	move.b	(a2)+,6(a0)
	clr.b	7(a0)
	move.b	(a2)+,5(a0)
	move.b	(a2)+,6(a0)
	clr.b	7(a0)
	move.b	(a2)+,5(a0)
	move.b	(a2)+,6(a0)
	clr.b	7(a0)
	move.b	(a2)+,5(a0)
	move.b	(a2)+,6(a0)
	clr.b	7(a0)
	move.b	(a2)+,5(a0)
	move.b	(a2)+,6(a0)
	clr.b	7(a0)
	move.b	(a2)+,5(a0)
	move.b	(a2)+,6(a0)
	clr.b	7(a0)
	move.b	(a2)+,5(a0)
	move.b	(a2)+,6(a0)
	clr.b	7(a0)
	move.w	(a5)+,d7
	clr.b	5(a0)
	rol.w	#8,d7
	move.b	d7,6(a0)
	rol.w	#8,d7
	move.b	d7,7(a0)
	subq.w	#1,d7
	lea	PERSTABL,a6
	addq.l	#4,a5
	move.w	(a5)+,d2
	add.w	d2,d2
	adda.w	d2,a6
	lea	ytab(pc),a1
	movea.l	LOG_BASE(pc),a3
	lea	BIT_OFFS,a4

  move.l    #$3111,d0		* Activate cache for this loop
  movec.l   d0,CACR		* (Check it out by enabling/disabling
				* these lines!

TRANS_LP:
	dc.w	$31dd,$a205	*this is not faster..
	clr.b	$ffffa207.w
	dc.w	$31dd,$a205
	clr.b	$ffffa207.w
	dc.w	$31dd,$a205
	clr.b	$ffffa207.w
.loop:			      *from what we can see it's
			      *only the first byte that 
			      *has to be zyncronized....
			      * The CAREBEARS!!!!!!
	btst	#0,2(a0)
	beq.s	.loop
	move.l	4(a0),d0
	lsl.l	#8,d0
	swap	d0
	asr.w	#3,d0
	move.l	4(a0),d1
	lsl.l	#8,d1
	swap	d1
	asr.w	#3,d1
	move.l	4(a0),d2	*a DUMMY..
	addi.w	#$A0,d0
	move.w	(a1,d1.w*2),d1	*mulu	#$a0,(d1+100)
	move.l	(a4,d0.w*4),d0
	add.w	d0,d1
	swap	d0
	or.w	d0,0(a3,d1.w)
	dbf	d7,TRANS_LP

	move.w	#$400,$FFFF8240.w
	rts
what:
                  DS.W      15
                  ADDQ.W    #1,VBL_TIME 
                  RTE 

SPHERE96:         DS.W      3 
                  DC.B      $03,$C8,$00,$00,$00,$00,$04,$00 
                  DC.B      $00,$54,$00,$00,$FC,$E4,$00,$53 
                  DC.B      $00,$0C,$FC,$E4,$00,$50,$00,$18 
                  DC.B      $FC,$E4,$00,$4C,$00,$23,$FC,$E4 
                  DC.B      $00,$46,$00,$2D,$FC,$E4,$00,$3F 
                  DC.B      $00,$37,$FC,$E4,$00,$37,$00,$3F 
                  DC.B      $FC,$E4,$00,$2D,$00,$46,$FC,$E4 
                  DC.B      $00,$23,$00,$4C,$FC,$E4,$00,$18 
                  DC.B      $00,$50,$FC,$E4,$00,$0C,$00,$53 
                  DC.B      $FC,$E4,$00,$00,$00,$54,$FC,$E4 
                  DC.B      $FF,$F4,$00,$53,$FC,$E4,$FF,$E8 
                  DC.B      $00,$50,$FC,$E4,$FF,$DD,$00,$4C 
                  DC.B      $FC,$E4,$FF,$D3,$00,$46,$FC,$E4 
                  DC.B      $FF,$C9,$00,$3F,$FC,$E4,$FF,$C1 
                  DC.B      $00,$37,$FC,$E4,$FF,$BA,$00,$2D 
                  DC.B      $FC,$E4,$FF,$B4,$00,$23,$FC,$E4 
                  DC.B      $FF,$B0,$00,$18,$FC,$E4,$FF,$AD 
                  DC.B      $00,$0C,$FC,$E4,$FF,$AC,$00,$00 
                  DC.B      $FC,$E4,$FF,$AD,$FF,$F4,$FC,$E4 
                  DC.B      $FF,$B0,$FF,$E8,$FC,$E4,$FF,$B4 
                  DC.B      $FF,$DD,$FC,$E4,$FF,$BA,$FF,$D3 
                  DC.B      $FC,$E4,$FF,$C1,$FF,$C9,$FC,$E4 
                  DC.B      $FF,$C9,$FF,$C1,$FC,$E4,$FF,$D3 
                  DC.B      $FF,$BA,$FC,$E4,$FF,$DD,$FF,$B4 
                  DC.B      $FC,$E4,$FF,$E8,$FF,$B0,$FC,$E4 
                  DC.B      $FF,$F4,$FF,$AD,$FC,$E4,$00,$00 
                  DC.B      $FF,$AC,$FC,$E4,$00,$0C,$FF,$AD 
                  DC.B      $FC,$E4,$00,$18,$FF,$B0,$FC,$E4 
                  DC.B      $00,$23,$FF,$B4,$FC,$E4,$00,$2D 
                  DC.B      $FF,$BA,$FC,$E4,$00,$37,$FF,$C1 
                  DC.B      $FC,$E4,$00,$3F,$FF,$C9,$FC,$E4 
                  DC.B      $00,$46,$FF,$D3,$FC,$E4,$00,$4C 
                  DC.B      $FF,$DD,$FC,$E4,$00,$50,$FF,$E8 
                  DC.B      $FC,$E4,$00,$53,$FF,$F4,$FC,$E4 
                  DC.B      $00,$BF,$00,$00,$FC,$F7,$00,$BD 
                  DC.B      $00,$1B,$FC,$F7,$00,$B7,$00,$36 
                  DC.B      $FC,$F7,$00,$AE,$00,$4F,$FC,$F7 
                  DC.B      $00,$A1,$00,$67,$FC,$F7,$00,$90 
                  DC.B      $00,$7D,$FC,$F7,$00,$7D,$00,$90 
                  DC.B      $FC,$F7,$00,$67,$00,$A1,$FC,$F7 
                  DC.B      $00,$4F,$00,$AE,$FC,$F7,$00,$36 
                  DC.B      $00,$B7,$FC,$F7,$00,$1B,$00,$BD 
                  DC.B      $FC,$F7,$00,$00,$00,$BF,$FC,$F7 
                  DC.B      $FF,$E5,$00,$BD,$FC,$F7,$FF,$CA 
                  DC.B      $00,$B7,$FC,$F7,$FF,$B1,$00,$AE 
                  DC.B      $FC,$F7,$FF,$99,$00,$A1,$FC,$F7 
                  DC.B      $FF,$83,$00,$90,$FC,$F7,$FF,$70 
                  DC.B      $00,$7D,$FC,$F7,$FF,$5F,$00,$67 
                  DC.B      $FC,$F7,$FF,$52,$00,$4F,$FC,$F7 
                  DC.B      $FF,$49,$00,$36,$FC,$F7,$FF,$43 
                  DC.B      $00,$1B,$FC,$F7,$FF,$41,$00,$00 
                  DC.B      $FC,$F7,$FF,$43,$FF,$E5,$FC,$F7 
                  DC.B      $FF,$49,$FF,$CA,$FC,$F7,$FF,$52 
                  DC.B      $FF,$B1,$FC,$F7,$FF,$5F,$FF,$99 
                  DC.B      $FC,$F7,$FF,$70,$FF,$83,$FC,$F7 
                  DC.B      $FF,$83,$FF,$70,$FC,$F7,$FF,$99 
                  DC.B      $FF,$5F,$FC,$F7,$FF,$B1,$FF,$52 
                  DC.B      $FC,$F7,$FF,$CA,$FF,$49,$FC,$F7 
                  DC.B      $FF,$E5,$FF,$43,$FC,$F7,$00,$00 
                  DC.B      $FF,$41,$FC,$F7,$00,$1B,$FF,$43 
                  DC.B      $FC,$F7,$00,$36,$FF,$49,$FC,$F7 
                  DC.B      $00,$4F,$FF,$52,$FC,$F7,$00,$67 
                  DC.B      $FF,$5F,$FC,$F7,$00,$7D,$FF,$70 
                  DC.B      $FC,$F7,$00,$90,$FF,$83,$FC,$F7 
                  DC.B      $00,$A1,$FF,$99,$FC,$F7,$00,$AE 
                  DC.B      $FF,$B1,$FC,$F7,$00,$B7,$FF,$CA 
                  DC.B      $FC,$F7,$00,$BD,$FF,$E5,$FC,$F7 
                  DC.B      $01,$27,$00,$00,$FD,$18,$01,$24 
                  DC.B      $00,$2A,$FD,$18,$01,$1B,$00,$53 
                  DC.B      $FD,$18,$01,$0C,$00,$7B,$FD,$18 
                  DC.B      $00,$F8,$00,$9F,$FD,$18,$00,$DF 
                  DC.B      $00,$C1,$FD,$18,$00,$C1,$00,$DF 
                  DC.B      $FD,$18,$00,$9F,$00,$F8,$FD,$18 
                  DC.B      $00,$7B,$01,$0C,$FD,$18,$00,$53 
                  DC.B      $01,$1B,$FD,$18,$00,$2A,$01,$24 
                  DC.B      $FD,$18,$00,$00,$01,$27,$FD,$18 
                  DC.B      $FF,$D6,$01,$24,$FD,$18,$FF,$AD 
                  DC.B      $01,$1B,$FD,$18,$FF,$85,$01,$0C 
                  DC.B      $FD,$18,$FF,$61,$00,$F8,$FD,$18 
                  DC.B      $FF,$3F,$00,$DF,$FD,$18,$FF,$21 
                  DC.B      $00,$C1,$FD,$18,$FF,$08,$00,$9F 
                  DC.B      $FD,$18,$FE,$F4,$00,$7B,$FD,$18 
                  DC.B      $FE,$E5,$00,$53,$FD,$18,$FE,$DC 
                  DC.B      $00,$2A,$FD,$18,$FE,$D9,$00,$00 
                  DC.B      $FD,$18,$FE,$DC,$FF,$D6,$FD,$18 
                  DC.B      $FE,$E5,$FF,$AD,$FD,$18,$FE,$F4 
                  DC.B      $FF,$85,$FD,$18,$FF,$08,$FF,$61 
                  DC.B      $FD,$18,$FF,$21,$FF,$3F,$FD,$18 
                  DC.B      $FF,$3F,$FF,$21,$FD,$18,$FF,$61 
                  DC.B      $FF,$08,$FD,$18,$FF,$85,$FE,$F4 
                  DC.B      $FD,$18,$FF,$AD,$FE,$E5,$FD,$18 
                  DC.B      $FF,$D6,$FE,$DC,$FD,$18,$00,$00 
                  DC.B      $FE,$D9,$FD,$18,$00,$2A,$FE,$DC 
                  DC.B      $FD,$18,$00,$53,$FE,$E5,$FD,$18 
                  DC.B      $00,$7B,$FE,$F4,$FD,$18,$00,$9F 
                  DC.B      $FF,$08,$FD,$18,$00,$C1,$FF,$21 
                  DC.B      $FD,$18,$00,$DF,$FF,$3F,$FD,$18 
                  DC.B      $00,$F8,$FF,$61,$FD,$18,$01,$0C 
                  DC.B      $FF,$85,$FD,$18,$01,$1B,$FF,$AD 
                  DC.B      $FD,$18,$01,$24,$FF,$D6,$FD,$18 
                  DC.B      $01,$89,$00,$00,$FD,$47,$01,$85 
                  DC.B      $00,$38,$FD,$47,$01,$79,$00,$6F 
                  DC.B      $FD,$47,$01,$66,$00,$A3,$FD,$47 
                  DC.B      $01,$4B,$00,$D5,$FD,$47,$01,$29 
                  DC.B      $01,$02,$FD,$47,$01,$02,$01,$29 
                  DC.B      $FD,$47,$00,$D5,$01,$4B,$FD,$47 
                  DC.B      $00,$A3,$01,$66,$FD,$47,$00,$6F 
                  DC.B      $01,$79,$FD,$47,$00,$38,$01,$85 
                  DC.B      $FD,$47,$00,$00,$01,$89,$FD,$47 
                  DC.B      $FF,$C8,$01,$85,$FD,$47,$FF,$91 
                  DC.B      $01,$79,$FD,$47,$FF,$5D,$01,$66 
                  DC.B      $FD,$47,$FF,$2B,$01,$4B,$FD,$47 
                  DC.B      $FE,$FE,$01,$29,$FD,$47,$FE,$D7 
                  DC.B      $01,$02,$FD,$47,$FE,$B5,$00,$D5 
                  DC.B      $FD,$47,$FE,$9A,$00,$A3,$FD,$47 
                  DC.B      $FE,$87,$00,$6F,$FD,$47,$FE,$7B 
                  DC.B      $00,$38,$FD,$47,$FE,$77,$00,$00 
                  DC.B      $FD,$47,$FE,$7B,$FF,$C8,$FD,$47 
                  DC.B      $FE,$87,$FF,$91,$FD,$47,$FE,$9A 
                  DC.B      $FF,$5D,$FD,$47,$FE,$B5,$FF,$2B 
                  DC.B      $FD,$47,$FE,$D7,$FE,$FE,$FD,$47 
                  DC.B      $FE,$FE,$FE,$D7,$FD,$47,$FF,$2B 
                  DC.B      $FE,$B5,$FD,$47,$FF,$5D,$FE,$9A 
                  DC.B      $FD,$47,$FF,$91,$FE,$87,$FD,$47 
                  DC.B      $FF,$C8,$FE,$7B,$FD,$47,$00,$00 
                  DC.B      $FE,$77,$FD,$47,$00,$38,$FE,$7B 
                  DC.B      $FD,$47,$00,$6F,$FE,$87,$FD,$47 
                  DC.B      $00,$A3,$FE,$9A,$FD,$47,$00,$D5 
                  DC.B      $FE,$B5,$FD,$47,$01,$02,$FE,$D7 
                  DC.B      $FD,$47,$01,$29,$FE,$FE,$FD,$47 
                  DC.B      $01,$4B,$FF,$2B,$FD,$47,$01,$66 
                  DC.B      $FF,$5D,$FD,$47,$01,$79,$FF,$91 
                  DC.B      $FD,$47,$01,$85,$FF,$C8,$FD,$47 
                  DC.B      $01,$E4,$00,$00,$FD,$83,$01,$DF 
                  DC.B      $00,$45,$FD,$83,$01,$D1,$00,$89 
                  DC.B      $FD,$83,$01,$B8,$00,$C9,$FD,$83 
                  DC.B      $01,$97,$01,$06,$FD,$83,$01,$6E 
                  DC.B      $01,$3D,$FD,$83,$01,$3D,$01,$6E 
                  DC.B      $FD,$83,$01,$06,$01,$97,$FD,$83 
                  DC.B      $00,$C9,$01,$B8,$FD,$83,$00,$89 
                  DC.B      $01,$D1,$FD,$83,$00,$45,$01,$DF 
                  DC.B      $FD,$83,$00,$00,$01,$E4,$FD,$83 
                  DC.B      $FF,$BB,$01,$DF,$FD,$83,$FF,$77 
                  DC.B      $01,$D1,$FD,$83,$FF,$37,$01,$B8 
                  DC.B      $FD,$83,$FE,$FA,$01,$97,$FD,$83 
                  DC.B      $FE,$C3,$01,$6E,$FD,$83,$FE,$92 
                  DC.B      $01,$3D,$FD,$83,$FE,$69,$01,$06 
                  DC.B      $FD,$83,$FE,$48,$00,$C9,$FD,$83 
                  DC.B      $FE,$2F,$00,$89,$FD,$83,$FE,$21 
                  DC.B      $00,$45,$FD,$83,$FE,$1C,$00,$00 
                  DC.B      $FD,$83,$FE,$21,$FF,$BB,$FD,$83 
                  DC.B      $FE,$2F,$FF,$77,$FD,$83,$FE,$48 
                  DC.B      $FF,$37,$FD,$83,$FE,$69,$FE,$FA 
                  DC.B      $FD,$83,$FE,$92,$FE,$C3,$FD,$83 
                  DC.B      $FE,$C3,$FE,$92,$FD,$83,$FE,$FA 
                  DC.B      $FE,$69,$FD,$83,$FF,$37,$FE,$48 
                  DC.B      $FD,$83,$FF,$77,$FE,$2F,$FD,$83 
                  DC.B      $FF,$BB,$FE,$21,$FD,$83,$00,$00 
                  DC.B      $FE,$1C,$FD,$83,$00,$45,$FE,$21 
                  DC.B      $FD,$83,$00,$89,$FE,$2F,$FD,$83 
                  DC.B      $00,$C9,$FE,$48,$FD,$83,$01,$06 
                  DC.B      $FE,$69,$FD,$83,$01,$3D,$FE,$92 
                  DC.B      $FD,$83,$01,$6E,$FE,$C3,$FD,$83 
                  DC.B      $01,$97,$FE,$FA,$FD,$83,$01,$B8 
                  DC.B      $FF,$37,$FD,$83,$01,$D1,$FF,$77 
                  DC.B      $FD,$83,$01,$DF,$FF,$BB,$FD,$83 
                  DC.B      $02,$36,$00,$00,$FD,$CB,$02,$31 
                  DC.B      $00,$51,$FD,$CB,$02,$1F,$00,$A0 
                  DC.B      $FD,$CB,$02,$03,$00,$EB,$FD,$CB 
                  DC.B      $01,$DC,$01,$32,$FD,$CB,$01,$AC 
                  DC.B      $01,$73,$FD,$CB,$01,$73,$01,$AC 
                  DC.B      $FD,$CB,$01,$32,$01,$DC,$FD,$CB 
                  DC.B      $00,$EB,$02,$03,$FD,$CB,$00,$A0 
                  DC.B      $02,$1F,$FD,$CB,$00,$51,$02,$31 
                  DC.B      $FD,$CB,$00,$00,$02,$36,$FD,$CB 
                  DC.B      $FF,$AF,$02,$31,$FD,$CB,$FF,$60 
                  DC.B      $02,$1F,$FD,$CB,$FF,$15,$02,$03 
                  DC.B      $FD,$CB,$FE,$CE,$01,$DC,$FD,$CB 
                  DC.B      $FE,$8D,$01,$AC,$FD,$CB,$FE,$54 
                  DC.B      $01,$73,$FD,$CB,$FE,$24,$01,$32 
                  DC.B      $FD,$CB,$FD,$FD,$00,$EB,$FD,$CB 
                  DC.B      $FD,$E1,$00,$A0,$FD,$CB,$FD,$CF 
                  DC.B      $00,$51,$FD,$CB,$FD,$CA,$00,$00 
                  DC.B      $FD,$CB,$FD,$CF,$FF,$AF,$FD,$CB 
                  DC.B      $FD,$E1,$FF,$60,$FD,$CB,$FD,$FD 
                  DC.B      $FF,$15,$FD,$CB,$FE,$24,$FE,$CE 
                  DC.B      $FD,$CB,$FE,$54,$FE,$8D,$FD,$CB 
                  DC.B      $FE,$8D,$FE,$54,$FD,$CB,$FE,$CE 
                  DC.B      $FE,$24,$FD,$CB,$FF,$15,$FD,$FD 
                  DC.B      $FD,$CB,$FF,$60,$FD,$E1,$FD,$CB 
                  DC.B      $FF,$AF,$FD,$CF,$FD,$CB,$00,$00 
                  DC.B      $FD,$CA,$FD,$CB,$00,$51,$FD,$CF 
                  DC.B      $FD,$CB,$00,$A0,$FD,$E1,$FD,$CB 
                  DC.B      $00,$EB,$FD,$FD,$FD,$CB,$01,$32 
                  DC.B      $FE,$24,$FD,$CB,$01,$73,$FE,$54 
                  DC.B      $FD,$CB,$01,$AC,$FE,$8D,$FD,$CB 
                  DC.B      $01,$DC,$FE,$CE,$FD,$CB,$02,$03 
                  DC.B      $FF,$15,$FD,$CB,$02,$1F,$FF,$60 
                  DC.B      $FD,$CB,$02,$31,$FF,$AF,$FD,$CB 
                  DC.B      $02,$7E,$00,$00,$FE,$1E,$02,$78 
                  DC.B      $00,$5B,$FE,$1E,$02,$64,$00,$B4 
                  DC.B      $FE,$1E,$02,$45,$01,$09,$FE,$1E 
                  DC.B      $02,$19,$01,$59,$FE,$1E,$01,$E2 
                  DC.B      $01,$A2,$FE,$1E,$01,$A2,$01,$E2 
                  DC.B      $FE,$1E,$01,$59,$02,$19,$FE,$1E 
                  DC.B      $01,$09,$02,$45,$FE,$1E,$00,$B4 
                  DC.B      $02,$64,$FE,$1E,$00,$5B,$02,$78 
                  DC.B      $FE,$1E,$00,$00,$02,$7E,$FE,$1E 
                  DC.B      $FF,$A5,$02,$78,$FE,$1E,$FF,$4C 
                  DC.B      $02,$64,$FE,$1E,$FE,$F7,$02,$45 
                  DC.B      $FE,$1E,$FE,$A7,$02,$19,$FE,$1E 
                  DC.B      $FE,$5E,$01,$E2,$FE,$1E,$FE,$1E 
                  DC.B      $01,$A2,$FE,$1E,$FD,$E7,$01,$59 
                  DC.B      $FE,$1E,$FD,$BB,$01,$09,$FE,$1E 
                  DC.B      $FD,$9C,$00,$B4,$FE,$1E,$FD,$88 
                  DC.B      $00,$5B,$FE,$1E,$FD,$82,$00,$00 
                  DC.B      $FE,$1E,$FD,$88,$FF,$A5,$FE,$1E 
                  DC.B      $FD,$9C,$FF,$4C,$FE,$1E,$FD,$BB 
                  DC.B      $FE,$F7,$FE,$1E,$FD,$E7,$FE,$A7 
                  DC.B      $FE,$1E,$FE,$1E,$FE,$5E,$FE,$1E 
                  DC.B      $FE,$5E,$FE,$1E,$FE,$1E,$FE,$A7 
                  DC.B      $FD,$E7,$FE,$1E,$FE,$F7,$FD,$BB 
                  DC.B      $FE,$1E,$FF,$4C,$FD,$9C,$FE,$1E 
                  DC.B      $FF,$A5,$FD,$88,$FE,$1E,$00,$00 
                  DC.B      $FD,$82,$FE,$1E,$00,$5B,$FD,$88 
                  DC.B      $FE,$1E,$00,$B4,$FD,$9C,$FE,$1E 
                  DC.B      $01,$09,$FD,$BB,$FE,$1E,$01,$59 
                  DC.B      $FD,$E7,$FE,$1E,$01,$A2,$FE,$1E 
                  DC.B      $FE,$1E,$01,$E2,$FE,$5E,$FE,$1E 
                  DC.B      $02,$19,$FE,$A7,$FE,$1E,$02,$45 
                  DC.B      $FE,$F7,$FE,$1E,$02,$64,$FF,$4C 
                  DC.B      $FE,$1E,$02,$78,$FF,$A5,$FE,$1E 
                  DC.B      $02,$BA,$00,$00,$FE,$79,$02,$B3 
                  DC.B      $00,$63,$FE,$79,$02,$9E,$00,$C5 
                  DC.B      $FE,$79,$02,$7B,$01,$22,$FE,$79 
                  DC.B      $02,$4B,$01,$7A,$FE,$79,$02,$0F 
                  DC.B      $01,$C9,$FE,$79,$01,$C9,$02,$0F 
                  DC.B      $FE,$79,$01,$7A,$02,$4B,$FE,$79 
                  DC.B      $01,$22,$02,$7B,$FE,$79,$00,$C5 
                  DC.B      $02,$9E,$FE,$79,$00,$63,$02,$B3 
                  DC.B      $FE,$79,$00,$00,$02,$BA,$FE,$79 
                  DC.B      $FF,$9D,$02,$B3,$FE,$79,$FF,$3B 
                  DC.B      $02,$9E,$FE,$79,$FE,$DE,$02,$7B 
                  DC.B      $FE,$79,$FE,$86,$02,$4B,$FE,$79 
                  DC.B      $FE,$37,$02,$0F,$FE,$79,$FD,$F1 
                  DC.B      $01,$C9,$FE,$79,$FD,$B5,$01,$7A 
                  DC.B      $FE,$79,$FD,$85,$01,$22,$FE,$79 
                  DC.B      $FD,$62,$00,$C5,$FE,$79,$FD,$4D 
                  DC.B      $00,$63,$FE,$79,$FD,$46,$00,$00 
                  DC.B      $FE,$79,$FD,$4D,$FF,$9D,$FE,$79 
                  DC.B      $FD,$62,$FF,$3B,$FE,$79,$FD,$85 
                  DC.B      $FE,$DE,$FE,$79,$FD,$B5,$FE,$86 
                  DC.B      $FE,$79,$FD,$F1,$FE,$37,$FE,$79 
                  DC.B      $FE,$37,$FD,$F1,$FE,$79,$FE,$86 
                  DC.B      $FD,$B5,$FE,$79,$FE,$DE,$FD,$85 
                  DC.B      $FE,$79,$FF,$3B,$FD,$62,$FE,$79 
                  DC.B      $FF,$9D,$FD,$4D,$FE,$79,$00,$00 
                  DC.B      $FD,$46,$FE,$79,$00,$63,$FD,$4D 
                  DC.B      $FE,$79,$00,$C5,$FD,$62,$FE,$79 
                  DC.B      $01,$22,$FD,$85,$FE,$79,$01,$7A 
                  DC.B      $FD,$B5,$FE,$79,$01,$C9,$FD,$F1 
                  DC.B      $FE,$79,$02,$0F,$FE,$37,$FE,$79 
                  DC.B      $02,$4B,$FE,$86,$FE,$79,$02,$7B 
                  DC.B      $FE,$DE,$FE,$79,$02,$9E,$FF,$3B 
                  DC.B      $FE,$79,$02,$B3,$FF,$9D,$FE,$79 
                  DC.B      $02,$E9,$00,$00,$FE,$DC,$02,$E1 
                  DC.B      $00,$6A,$FE,$DC,$02,$CA,$00,$D2 
                  DC.B      $FE,$DC,$02,$A5,$01,$36,$FE,$DC 
                  DC.B      $02,$72,$01,$93,$FE,$DC,$02,$33 
                  DC.B      $01,$E8,$FE,$DC,$01,$E8,$02,$33 
                  DC.B      $FE,$DC,$01,$93,$02,$72,$FE,$DC 
                  DC.B      $01,$36,$02,$A5,$FE,$DC,$00,$D2 
                  DC.B      $02,$CA,$FE,$DC,$00,$6A,$02,$E1 
                  DC.B      $FE,$DC,$00,$00,$02,$E9,$FE,$DC 
                  DC.B      $FF,$96,$02,$E1,$FE,$DC,$FF,$2E 
                  DC.B      $02,$CA,$FE,$DC,$FE,$CA,$02,$A5 
                  DC.B      $FE,$DC,$FE,$6D,$02,$72,$FE,$DC 
                  DC.B      $FE,$18,$02,$33,$FE,$DC,$FD,$CD 
                  DC.B      $01,$E8,$FE,$DC,$FD,$8E,$01,$93 
                  DC.B      $FE,$DC,$FD,$5B,$01,$36,$FE,$DC 
                  DC.B      $FD,$36,$00,$D2,$FE,$DC,$FD,$1F 
                  DC.B      $00,$6A,$FE,$DC,$FD,$17,$00,$00 
                  DC.B      $FE,$DC,$FD,$1F,$FF,$96,$FE,$DC 
                  DC.B      $FD,$36,$FF,$2E,$FE,$DC,$FD,$5B 
                  DC.B      $FE,$CA,$FE,$DC,$FD,$8E,$FE,$6D 
                  DC.B      $FE,$DC,$FD,$CD,$FE,$18,$FE,$DC 
                  DC.B      $FE,$18,$FD,$CD,$FE,$DC,$FE,$6D 
                  DC.B      $FD,$8E,$FE,$DC,$FE,$CA,$FD,$5B 
                  DC.B      $FE,$DC,$FF,$2E,$FD,$36,$FE,$DC 
                  DC.B      $FF,$96,$FD,$1F,$FE,$DC,$00,$00 
                  DC.B      $FD,$17,$FE,$DC,$00,$6A,$FD,$1F 
                  DC.B      $FE,$DC,$00,$D2,$FD,$36,$FE,$DC 
                  DC.B      $01,$36,$FD,$5B,$FE,$DC,$01,$93 
                  DC.B      $FD,$8E,$FE,$DC,$01,$E8,$FD,$CD 
                  DC.B      $FE,$DC,$02,$33,$FE,$18,$FE,$DC 
                  DC.B      $02,$72,$FE,$6D,$FE,$DC,$02,$A5 
                  DC.B      $FE,$CA,$FE,$DC,$02,$CA,$FF,$2E 
                  DC.B      $FE,$DC,$02,$E1,$FF,$96,$FE,$DC 
                  DC.B      $03,$09,$00,$00,$FF,$44,$03,$02 
                  DC.B      $00,$6F,$FF,$44,$02,$EA,$00,$DB 
                  DC.B      $FF,$44,$02,$C3,$01,$43,$FF,$44 
                  DC.B      $02,$8E,$01,$A5,$FF,$44,$02,$4B 
                  DC.B      $01,$FD,$FF,$44,$01,$FD,$02,$4B 
                  DC.B      $FF,$44,$01,$A5,$02,$8E,$FF,$44 
                  DC.B      $01,$43,$02,$C3,$FF,$44,$00,$DB 
                  DC.B      $02,$EA,$FF,$44,$00,$6F,$03,$02 
                  DC.B      $FF,$44,$00,$00,$03,$09,$FF,$44 
                  DC.B      $FF,$91,$03,$02,$FF,$44,$FF,$25 
                  DC.B      $02,$EA,$FF,$44,$FE,$BD,$02,$C3 
                  DC.B      $FF,$44,$FE,$5B,$02,$8E,$FF,$44 
                  DC.B      $FE,$03,$02,$4B,$FF,$44,$FD,$B5 
                  DC.B      $01,$FD,$FF,$44,$FD,$72,$01,$A5 
                  DC.B      $FF,$44,$FD,$3D,$01,$43,$FF,$44 
                  DC.B      $FD,$16,$00,$DB,$FF,$44,$FC,$FE 
                  DC.B      $00,$6F,$FF,$44,$FC,$F7,$00,$00 
                  DC.B      $FF,$44,$FC,$FE,$FF,$91,$FF,$44 
                  DC.B      $FD,$16,$FF,$25,$FF,$44,$FD,$3D 
                  DC.B      $FE,$BD,$FF,$44,$FD,$72,$FE,$5B 
                  DC.B      $FF,$44,$FD,$B5,$FE,$03,$FF,$44 
                  DC.B      $FE,$03,$FD,$B5,$FF,$44,$FE,$5B 
                  DC.B      $FD,$72,$FF,$44,$FE,$BD,$FD,$3D 
                  DC.B      $FF,$44,$FF,$25,$FD,$16,$FF,$44 
                  DC.B      $FF,$91,$FC,$FE,$FF,$44,$00,$00 
                  DC.B      $FC,$F7,$FF,$44,$00,$6F,$FC,$FE 
                  DC.B      $FF,$44,$00,$DB,$FD,$16,$FF,$44 
                  DC.B      $01,$43,$FD,$3D,$FF,$44,$01,$A5 
                  DC.B      $FD,$72,$FF,$44,$01,$FD,$FD,$B5 
                  DC.B      $FF,$44,$02,$4B,$FE,$03,$FF,$44 
                  DC.B      $02,$8E,$FE,$5B,$FF,$44,$02,$C3 
                  DC.B      $FE,$BD,$FF,$44,$02,$EA,$FF,$25 
                  DC.B      $FF,$44,$03,$02,$FF,$91,$FF,$44 
                  DC.B      $03,$1C,$00,$00,$FF,$AF,$03,$14 
                  DC.B      $00,$71,$FF,$AF,$02,$FC,$00,$E0 
                  DC.B      $FF,$AF,$02,$D4,$01,$4B,$FF,$AF 
                  DC.B      $02,$9D,$01,$AF,$FF,$AF,$02,$59 
                  DC.B      $02,$09,$FF,$AF,$02,$09,$02,$59 
                  DC.B      $FF,$AF,$01,$AF,$02,$9D,$FF,$AF 
                  DC.B      $01,$4B,$02,$D4,$FF,$AF,$00,$E0 
                  DC.B      $02,$FC,$FF,$AF,$00,$71,$03,$14 
                  DC.B      $FF,$AF,$00,$00,$03,$1C,$FF,$AF 
                  DC.B      $FF,$8F,$03,$14,$FF,$AF,$FF,$20 
                  DC.B      $02,$FC,$FF,$AF,$FE,$B5,$02,$D4 
                  DC.B      $FF,$AF,$FE,$51,$02,$9D,$FF,$AF 
                  DC.B      $FD,$F7,$02,$59,$FF,$AF,$FD,$A7 
                  DC.B      $02,$09,$FF,$AF,$FD,$63,$01,$AF 
                  DC.B      $FF,$AF,$FD,$2C,$01,$4B,$FF,$AF 
                  DC.B      $FD,$04,$00,$E0,$FF,$AF,$FC,$EC 
                  DC.B      $00,$71,$FF,$AF,$FC,$E4,$00,$00 
                  DC.B      $FF,$AF,$FC,$EC,$FF,$8F,$FF,$AF 
                  DC.B      $FD,$04,$FF,$20,$FF,$AF,$FD,$2C 
                  DC.B      $FE,$B5,$FF,$AF,$FD,$63,$FE,$51 
                  DC.B      $FF,$AF,$FD,$A7,$FD,$F7,$FF,$AF 
                  DC.B      $FD,$F7,$FD,$A7,$FF,$AF,$FE,$51 
                  DC.B      $FD,$63,$FF,$AF,$FE,$B5,$FD,$2C 
                  DC.B      $FF,$AF,$FF,$20,$FD,$04,$FF,$AF 
                  DC.B      $FF,$8F,$FC,$EC,$FF,$AF,$00,$00 
                  DC.B      $FC,$E4,$FF,$AF,$00,$71,$FC,$EC 
                  DC.B      $FF,$AF,$00,$E0,$FD,$04,$FF,$AF 
                  DC.B      $01,$4B,$FD,$2C,$FF,$AF,$01,$AF 
                  DC.B      $FD,$63,$FF,$AF,$02,$09,$FD,$A7 
                  DC.B      $FF,$AF,$02,$59,$FD,$F7,$FF,$AF 
                  DC.B      $02,$9D,$FE,$51,$FF,$AF,$02,$D4 
                  DC.B      $FE,$B5,$FF,$AF,$02,$FC,$FF,$20 
                  DC.B      $FF,$AF,$03,$14,$FF,$8F,$FF,$AF 
                  DC.B      $03,$20,$00,$00,$00,$1C,$03,$17 
                  DC.B      $00,$72,$00,$1C,$02,$FF,$00,$E1 
                  DC.B      $00,$1C,$02,$D7,$01,$4C,$00,$1C 
                  DC.B      $02,$A0,$01,$B1,$00,$1C,$02,$5C 
                  DC.B      $02,$0C,$00,$1C,$02,$0C,$02,$5C 
                  DC.B      $00,$1C,$01,$B1,$02,$A0,$00,$1C 
                  DC.B      $01,$4C,$02,$D7,$00,$1C,$00,$E1 
                  DC.B      $02,$FF,$00,$1C,$00,$72,$03,$17 
                  DC.B      $00,$1C,$00,$00,$03,$20,$00,$1C 
                  DC.B      $FF,$8E,$03,$17,$00,$1C,$FF,$1F 
                  DC.B      $02,$FF,$00,$1C,$FE,$B4,$02,$D7 
                  DC.B      $00,$1C,$FE,$4F,$02,$A0,$00,$1C 
                  DC.B      $FD,$F4,$02,$5C,$00,$1C,$FD,$A4 
                  DC.B      $02,$0C,$00,$1C,$FD,$60,$01,$B1 
                  DC.B      $00,$1C,$FD,$29,$01,$4C,$00,$1C 
                  DC.B      $FD,$01,$00,$E1,$00,$1C,$FC,$E9 
                  DC.B      $00,$72,$00,$1C,$FC,$E0,$00,$00 
                  DC.B      $00,$1C,$FC,$E9,$FF,$8E,$00,$1C 
                  DC.B      $FD,$01,$FF,$1F,$00,$1C,$FD,$29 
                  DC.B      $FE,$B4,$00,$1C,$FD,$60,$FE,$4F 
                  DC.B      $00,$1C,$FD,$A4,$FD,$F4,$00,$1C 
                  DC.B      $FD,$F4,$FD,$A4,$00,$1C,$FE,$4F 
                  DC.B      $FD,$60,$00,$1C,$FE,$B4,$FD,$29 
                  DC.B      $00,$1C,$FF,$1F,$FD,$01,$00,$1C 
                  DC.B      $FF,$8E,$FC,$E9,$00,$1C,$00,$00 
                  DC.B      $FC,$E0,$00,$1C,$00,$72,$FC,$E9 
                  DC.B      $00,$1C,$00,$E1,$FD,$01,$00,$1C 
                  DC.B      $01,$4C,$FD,$29,$00,$1C,$01,$B1 
                  DC.B      $FD,$60,$00,$1C,$02,$0C,$FD,$A4 
                  DC.B      $00,$1C,$02,$5C,$FD,$F4,$00,$1C 
                  DC.B      $02,$A0,$FE,$4F,$00,$1C,$02,$D7 
                  DC.B      $FE,$B4,$00,$1C,$02,$FF,$FF,$1F 
                  DC.B      $00,$1C,$03,$17,$FF,$8E,$00,$1C 
                  DC.B      $03,$14,$00,$00,$00,$88,$03,$0C 
                  DC.B      $00,$70,$00,$88,$02,$F4,$00,$DE 
                  DC.B      $00,$88,$02,$CD,$01,$48,$00,$88 
                  DC.B      $02,$97,$01,$AA,$00,$88,$02,$53 
                  DC.B      $02,$05,$00,$88,$02,$05,$02,$53 
                  DC.B      $00,$88,$01,$AA,$02,$97,$00,$88 
                  DC.B      $01,$48,$02,$CD,$00,$88,$00,$DE 
                  DC.B      $02,$F4,$00,$88,$00,$70,$03,$0C 
                  DC.B      $00,$88,$00,$00,$03,$14,$00,$88 
                  DC.B      $FF,$90,$03,$0C,$00,$88,$FF,$22 
                  DC.B      $02,$F4,$00,$88,$FE,$B8,$02,$CD 
                  DC.B      $00,$88,$FE,$56,$02,$97,$00,$88 
                  DC.B      $FD,$FB,$02,$53,$00,$88,$FD,$AD 
                  DC.B      $02,$05,$00,$88,$FD,$69,$01,$AA 
                  DC.B      $00,$88,$FD,$33,$01,$48,$00,$88 
                  DC.B      $FD,$0C,$00,$DE,$00,$88,$FC,$F4 
                  DC.B      $00,$70,$00,$88,$FC,$EC,$00,$00 
                  DC.B      $00,$88,$FC,$F4,$FF,$90,$00,$88 
                  DC.B      $FD,$0C,$FF,$22,$00,$88,$FD,$33 
                  DC.B      $FE,$B8,$00,$88,$FD,$69,$FE,$56 
                  DC.B      $00,$88,$FD,$AD,$FD,$FB,$00,$88 
                  DC.B      $FD,$FB,$FD,$AD,$00,$88,$FE,$56 
                  DC.B      $FD,$69,$00,$88,$FE,$B8,$FD,$33 
                  DC.B      $00,$88,$FF,$22,$FD,$0C,$00,$88 
                  DC.B      $FF,$90,$FC,$F4,$00,$88,$00,$00 
                  DC.B      $FC,$EC,$00,$88,$00,$70,$FC,$F4 
                  DC.B      $00,$88,$00,$DE,$FD,$0C,$00,$88 
                  DC.B      $01,$48,$FD,$33,$00,$88,$01,$AA 
                  DC.B      $FD,$69,$00,$88,$02,$05,$FD,$AD 
                  DC.B      $00,$88,$02,$53,$FD,$FB,$00,$88 
                  DC.B      $02,$97,$FE,$56,$00,$88,$02,$CD 
                  DC.B      $FE,$B8,$00,$88,$02,$F4,$FF,$22 
                  DC.B      $00,$88,$03,$0C,$FF,$90,$00,$88 
                  DC.B      $02,$FA,$00,$00,$00,$F2,$02,$F3 
                  DC.B      $00,$6D,$00,$F2,$02,$DB,$00,$D7 
                  DC.B      $00,$F2,$02,$B5,$01,$3D,$00,$F2 
                  DC.B      $02,$81,$01,$9C,$00,$F2,$02,$40 
                  DC.B      $01,$F4,$00,$F2,$01,$F4,$02,$40 
                  DC.B      $00,$F2,$01,$9C,$02,$81,$00,$F2 
                  DC.B      $01,$3D,$02,$B5,$00,$F2,$00,$D7 
                  DC.B      $02,$DB,$00,$F2,$00,$6D,$02,$F3 
                  DC.B      $00,$F2,$00,$00,$02,$FA,$00,$F2 
                  DC.B      $FF,$93,$02,$F3,$00,$F2,$FF,$29 
                  DC.B      $02,$DB,$00,$F2,$FE,$C3,$02,$B5 
                  DC.B      $00,$F2,$FE,$64,$02,$81,$00,$F2 
                  DC.B      $FE,$0C,$02,$40,$00,$F2,$FD,$C0 
                  DC.B      $01,$F4,$00,$F2,$FD,$7F,$01,$9C 
                  DC.B      $00,$F2,$FD,$4B,$01,$3D,$00,$F2 
                  DC.B      $FD,$25,$00,$D7,$00,$F2,$FD,$0D 
                  DC.B      $00,$6D,$00,$F2,$FD,$06,$00,$00 
                  DC.B      $00,$F2,$FD,$0D,$FF,$93,$00,$F2 
                  DC.B      $FD,$25,$FF,$29,$00,$F2,$FD,$4B 
                  DC.B      $FE,$C3,$00,$F2,$FD,$7F,$FE,$64 
                  DC.B      $00,$F2,$FD,$C0,$FE,$0C,$00,$F2 
                  DC.B      $FE,$0C,$FD,$C0,$00,$F2,$FE,$64 
                  DC.B      $FD,$7F,$00,$F2,$FE,$C3,$FD,$4B 
                  DC.B      $00,$F2,$FF,$29,$FD,$25,$00,$F2 
                  DC.B      $FF,$93,$FD,$0D,$00,$F2,$00,$00 
                  DC.B      $FD,$06,$00,$F2,$00,$6D,$FD,$0D 
                  DC.B      $00,$F2,$00,$D7,$FD,$25,$00,$F2 
                  DC.B      $01,$3D,$FD,$4B,$00,$F2,$01,$9C 
                  DC.B      $FD,$7F,$00,$F2,$01,$F4,$FD,$C0 
                  DC.B      $00,$F2,$02,$40,$FE,$0C,$00,$F2 
                  DC.B      $02,$81,$FE,$64,$00,$F2,$02,$B5 
                  DC.B      $FE,$C3,$00,$F2,$02,$DB,$FF,$29 
                  DC.B      $00,$F2,$02,$F3,$FF,$93,$00,$F2 
                  DC.B      $02,$D2,$00,$00,$01,$58,$02,$CB 
                  DC.B      $00,$67,$01,$58,$02,$B5,$00,$CC 
                  DC.B      $01,$58,$02,$91,$01,$2C,$01,$58 
                  DC.B      $02,$60,$01,$87,$01,$58,$02,$22 
                  DC.B      $01,$D9,$01,$58,$01,$D9,$02,$22 
                  DC.B      $01,$58,$01,$87,$02,$60,$01,$58 
                  DC.B      $01,$2C,$02,$91,$01,$58,$00,$CC 
                  DC.B      $02,$B5,$01,$58,$00,$67,$02,$CB 
                  DC.B      $01,$58,$00,$00,$02,$D2,$01,$58 
                  DC.B      $FF,$99,$02,$CB,$01,$58,$FF,$34 
                  DC.B      $02,$B5,$01,$58,$FE,$D4,$02,$91 
                  DC.B      $01,$58,$FE,$79,$02,$60,$01,$58 
                  DC.B      $FE,$27,$02,$22,$01,$58,$FD,$DE 
                  DC.B      $01,$D9,$01,$58,$FD,$A0,$01,$87 
                  DC.B      $01,$58,$FD,$6F,$01,$2C,$01,$58 
                  DC.B      $FD,$4B,$00,$CC,$01,$58,$FD,$35 
                  DC.B      $00,$67,$01,$58,$FD,$2E,$00,$00 
                  DC.B      $01,$58,$FD,$35,$FF,$99,$01,$58 
                  DC.B      $FD,$4B,$FF,$34,$01,$58,$FD,$6F 
                  DC.B      $FE,$D4,$01,$58,$FD,$A0,$FE,$79 
                  DC.B      $01,$58,$FD,$DE,$FE,$27,$01,$58 
                  DC.B      $FE,$27,$FD,$DE,$01,$58,$FE,$79 
                  DC.B      $FD,$A0,$01,$58,$FE,$D4,$FD,$6F 
                  DC.B      $01,$58,$FF,$34,$FD,$4B,$01,$58 
                  DC.B      $FF,$99,$FD,$35,$01,$58,$00,$00 
                  DC.B      $FD,$2E,$01,$58,$00,$67,$FD,$35 
                  DC.B      $01,$58,$00,$CC,$FD,$4B,$01,$58 
                  DC.B      $01,$2C,$FD,$6F,$01,$58,$01,$87 
                  DC.B      $FD,$A0,$01,$58,$01,$D9,$FD,$DE 
                  DC.B      $01,$58,$02,$22,$FE,$27,$01,$58 
                  DC.B      $02,$60,$FE,$79,$01,$58,$02,$91 
                  DC.B      $FE,$D4,$01,$58,$02,$B5,$FF,$34 
                  DC.B      $01,$58,$02,$CB,$FF,$99,$01,$58 
                  DC.B      $02,$9D,$00,$00,$01,$B7,$02,$96 
                  DC.B      $00,$5F,$01,$B7,$02,$82,$00,$BD 
                  DC.B      $01,$B7,$02,$60,$01,$16,$01,$B7 
                  DC.B      $02,$33,$01,$6A,$01,$B7,$01,$F9 
                  DC.B      $01,$B6,$01,$B7,$01,$B6,$01,$F9 
                  DC.B      $01,$B7,$01,$6A,$02,$33,$01,$B7 
                  DC.B      $01,$16,$02,$60,$01,$B7,$00,$BD 
                  DC.B      $02,$82,$01,$B7,$00,$5F,$02,$96 
                  DC.B      $01,$B7,$00,$00,$02,$9D,$01,$B7 
                  DC.B      $FF,$A1,$02,$96,$01,$B7,$FF,$43 
                  DC.B      $02,$82,$01,$B7,$FE,$EA,$02,$60 
                  DC.B      $01,$B7,$FE,$96,$02,$33,$01,$B7 
                  DC.B      $FE,$4A,$01,$F9,$01,$B7,$FE,$07 
                  DC.B      $01,$B6,$01,$B7,$FD,$CD,$01,$6A 
                  DC.B      $01,$B7,$FD,$A0,$01,$16,$01,$B7 
                  DC.B      $FD,$7E,$00,$BD,$01,$B7,$FD,$6A 
                  DC.B      $00,$5F,$01,$B7,$FD,$63,$00,$00 
                  DC.B      $01,$B7,$FD,$6A,$FF,$A1,$01,$B7 
                  DC.B      $FD,$7E,$FF,$43,$01,$B7,$FD,$A0 
                  DC.B      $FE,$EA,$01,$B7,$FD,$CD,$FE,$96 
                  DC.B      $01,$B7,$FE,$07,$FE,$4A,$01,$B7 
                  DC.B      $FE,$4A,$FE,$07,$01,$B7,$FE,$96 
                  DC.B      $FD,$CD,$01,$B7,$FE,$EA,$FD,$A0 
                  DC.B      $01,$B7,$FF,$43,$FD,$7E,$01,$B7 
                  DC.B      $FF,$A1,$FD,$6A,$01,$B7,$00,$00 
                  DC.B      $FD,$63,$01,$B7,$00,$5F,$FD,$6A 
                  DC.B      $01,$B7,$00,$BD,$FD,$7E,$01,$B7 
                  DC.B      $01,$16,$FD,$A0,$01,$B7,$01,$6A 
                  DC.B      $FD,$CD,$01,$B7,$01,$B6,$FE,$07 
                  DC.B      $01,$B7,$01,$F9,$FE,$4A,$01,$B7 
                  DC.B      $02,$33,$FE,$96,$01,$B7,$02,$60 
                  DC.B      $FE,$EA,$01,$B7,$02,$82,$FF,$43 
                  DC.B      $01,$B7,$02,$96,$FF,$A1,$01,$B7 
                  DC.B      $02,$5B,$00,$00,$02,$0E,$02,$55 
                  DC.B      $00,$56,$02,$0E,$02,$43,$00,$AA 
                  DC.B      $02,$0E,$02,$25,$00,$FB,$02,$0E 
                  DC.B      $01,$FB,$01,$46,$02,$0E,$01,$C8 
                  DC.B      $01,$8B,$02,$0E,$01,$8B,$01,$C8 
                  DC.B      $02,$0E,$01,$46,$01,$FB,$02,$0E 
                  DC.B      $00,$FB,$02,$25,$02,$0E,$00,$AA 
                  DC.B      $02,$43,$02,$0E,$00,$56,$02,$55 
                  DC.B      $02,$0E,$00,$00,$02,$5B,$02,$0E 
                  DC.B      $FF,$AA,$02,$55,$02,$0E,$FF,$56 
                  DC.B      $02,$43,$02,$0E,$FF,$05,$02,$25 
                  DC.B      $02,$0E,$FE,$BA,$01,$FB,$02,$0E 
                  DC.B      $FE,$75,$01,$C8,$02,$0E,$FE,$38 
                  DC.B      $01,$8B,$02,$0E,$FE,$05,$01,$46 
                  DC.B      $02,$0E,$FD,$DB,$00,$FB,$02,$0E 
                  DC.B      $FD,$BD,$00,$AA,$02,$0E,$FD,$AB 
                  DC.B      $00,$56,$02,$0E,$FD,$A5,$00,$00 
                  DC.B      $02,$0E,$FD,$AB,$FF,$AA,$02,$0E 
                  DC.B      $FD,$BD,$FF,$56,$02,$0E,$FD,$DB 
                  DC.B      $FF,$05,$02,$0E,$FE,$05,$FE,$BA 
                  DC.B      $02,$0E,$FE,$38,$FE,$75,$02,$0E 
                  DC.B      $FE,$75,$FE,$38,$02,$0E,$FE,$BA 
                  DC.B      $FE,$05,$02,$0E,$FF,$05,$FD,$DB 
                  DC.B      $02,$0E,$FF,$56,$FD,$BD,$02,$0E 
                  DC.B      $FF,$AA,$FD,$AB,$02,$0E,$00,$00 
                  DC.B      $FD,$A5,$02,$0E,$00,$56,$FD,$AB 
                  DC.B      $02,$0E,$00,$AA,$FD,$BD,$02,$0E 
                  DC.B      $00,$FB,$FD,$DB,$02,$0E,$01,$46 
                  DC.B      $FE,$05,$02,$0E,$01,$8B,$FE,$38 
                  DC.B      $02,$0E,$01,$C8,$FE,$75,$02,$0E 
                  DC.B      $01,$FB,$FE,$BA,$02,$0E,$02,$25 
                  DC.B      $FF,$05,$02,$0E,$02,$43,$FF,$56 
                  DC.B      $02,$0E,$02,$55,$FF,$AA,$02,$0E 
                  DC.B      $02,$0E,$00,$00,$02,$5B,$02,$08 
                  DC.B      $00,$4B,$02,$5B,$01,$F8,$00,$94 
                  DC.B      $02,$5B,$01,$DE,$00,$DA,$02,$5B 
                  DC.B      $01,$BA,$01,$1C,$02,$5B,$01,$8D 
                  DC.B      $01,$58,$02,$5B,$01,$58,$01,$8D 
                  DC.B      $02,$5B,$01,$1C,$01,$BA,$02,$5B 
                  DC.B      $00,$DA,$01,$DE,$02,$5B,$00,$94 
                  DC.B      $01,$F8,$02,$5B,$00,$4B,$02,$08 
                  DC.B      $02,$5B,$00,$00,$02,$0E,$02,$5B 
                  DC.B      $FF,$B5,$02,$08,$02,$5B,$FF,$6C 
                  DC.B      $01,$F8,$02,$5B,$FF,$26,$01,$DE 
                  DC.B      $02,$5B,$FE,$E4,$01,$BA,$02,$5B 
                  DC.B      $FE,$A8,$01,$8D,$02,$5B,$FE,$73 
                  DC.B      $01,$58,$02,$5B,$FE,$46,$01,$1C 
                  DC.B      $02,$5B,$FE,$22,$00,$DA,$02,$5B 
                  DC.B      $FE,$08,$00,$94,$02,$5B,$FD,$F8 
                  DC.B      $00,$4B,$02,$5B,$FD,$F2,$00,$00 
                  DC.B      $02,$5B,$FD,$F8,$FF,$B5,$02,$5B 
                  DC.B      $FE,$08,$FF,$6C,$02,$5B,$FE,$22 
                  DC.B      $FF,$26,$02,$5B,$FE,$46,$FE,$E4 
                  DC.B      $02,$5B,$FE,$73,$FE,$A8,$02,$5B 
                  DC.B      $FE,$A8,$FE,$73,$02,$5B,$FE,$E4 
                  DC.B      $FE,$46,$02,$5B,$FF,$26,$FE,$22 
                  DC.B      $02,$5B,$FF,$6C,$FE,$08,$02,$5B 
                  DC.B      $FF,$B5,$FD,$F8,$02,$5B,$00,$00 
                  DC.B      $FD,$F2,$02,$5B,$00,$4B,$FD,$F8 
                  DC.B      $02,$5B,$00,$94,$FE,$08,$02,$5B 
                  DC.B      $00,$DA,$FE,$22,$02,$5B,$01,$1C 
                  DC.B      $FE,$46,$02,$5B,$01,$58,$FE,$73 
                  DC.B      $02,$5B,$01,$8D,$FE,$A8,$02,$5B 
                  DC.B      $01,$BA,$FE,$E4,$02,$5B,$01,$DE 
                  DC.B      $FF,$26,$02,$5B,$01,$F8,$FF,$6C 
                  DC.B      $02,$5B,$02,$08,$FF,$B5,$02,$5B 
                  DC.B      $01,$B7,$00,$00,$02,$9D,$01,$B2 
                  DC.B      $00,$3E,$02,$9D,$01,$A5,$00,$7C 
                  DC.B      $02,$9D,$01,$8F,$00,$B6,$02,$9D 
                  DC.B      $01,$71,$00,$ED,$02,$9D,$01,$4B 
                  DC.B      $01,$1F,$02,$9D,$01,$1F,$01,$4B 
                  DC.B      $02,$9D,$00,$ED,$01,$71,$02,$9D 
                  DC.B      $00,$B6,$01,$8F,$02,$9D,$00,$7C 
                  DC.B      $01,$A5,$02,$9D,$00,$3E,$01,$B2 
                  DC.B      $02,$9D,$00,$00,$01,$B7,$02,$9D 
                  DC.B      $FF,$C2,$01,$B2,$02,$9D,$FF,$84 
                  DC.B      $01,$A5,$02,$9D,$FF,$4A,$01,$8F 
                  DC.B      $02,$9D,$FF,$13,$01,$71,$02,$9D 
                  DC.B      $FE,$E1,$01,$4B,$02,$9D,$FE,$B5 
                  DC.B      $01,$1F,$02,$9D,$FE,$8F,$00,$ED 
                  DC.B      $02,$9D,$FE,$71,$00,$B6,$02,$9D 
                  DC.B      $FE,$5B,$00,$7C,$02,$9D,$FE,$4E 
                  DC.B      $00,$3E,$02,$9D,$FE,$49,$00,$00 
                  DC.B      $02,$9D,$FE,$4E,$FF,$C2,$02,$9D 
                  DC.B      $FE,$5B,$FF,$84,$02,$9D,$FE,$71 
                  DC.B      $FF,$4A,$02,$9D,$FE,$8F,$FF,$13 
                  DC.B      $02,$9D,$FE,$B5,$FE,$E1,$02,$9D 
                  DC.B      $FE,$E1,$FE,$B5,$02,$9D,$FF,$13 
                  DC.B      $FE,$8F,$02,$9D,$FF,$4A,$FE,$71 
                  DC.B      $02,$9D,$FF,$84,$FE,$5B,$02,$9D 
                  DC.B      $FF,$C2,$FE,$4E,$02,$9D,$00,$00 
                  DC.B      $FE,$49,$02,$9D,$00,$3E,$FE,$4E 
                  DC.B      $02,$9D,$00,$7C,$FE,$5B,$02,$9D 
                  DC.B      $00,$B6,$FE,$71,$02,$9D,$00,$ED 
                  DC.B      $FE,$8F,$02,$9D,$01,$1F,$FE,$B5 
                  DC.B      $02,$9D,$01,$4B,$FE,$E1,$02,$9D 
                  DC.B      $01,$71,$FF,$13,$02,$9D,$01,$8F 
                  DC.B      $FF,$4A,$02,$9D,$01,$A5,$FF,$84 
                  DC.B      $02,$9D,$01,$B2,$FF,$C2,$02,$9D 
                  DC.B      $01,$58,$00,$00,$02,$D2,$01,$54 
                  DC.B      $00,$31,$02,$D2,$01,$4A,$00,$61 
                  DC.B      $02,$D2,$01,$39,$00,$8F,$02,$D2 
                  DC.B      $01,$21,$00,$BA,$02,$D2,$01,$04 
                  DC.B      $00,$E1,$02,$D2,$00,$E1,$01,$04 
                  DC.B      $02,$D2,$00,$BA,$01,$21,$02,$D2 
                  DC.B      $00,$8F,$01,$39,$02,$D2,$00,$61 
                  DC.B      $01,$4A,$02,$D2,$00,$31,$01,$54 
                  DC.B      $02,$D2,$00,$00,$01,$58,$02,$D2 
                  DC.B      $FF,$CF,$01,$54,$02,$D2,$FF,$9F 
                  DC.B      $01,$4A,$02,$D2,$FF,$71,$01,$39 
                  DC.B      $02,$D2,$FF,$46,$01,$21,$02,$D2 
                  DC.B      $FF,$1F,$01,$04,$02,$D2,$FE,$FC 
                  DC.B      $00,$E1,$02,$D2,$FE,$DF,$00,$BA 
                  DC.B      $02,$D2,$FE,$C7,$00,$8F,$02,$D2 
                  DC.B      $FE,$B6,$00,$61,$02,$D2,$FE,$AC 
                  DC.B      $00,$31,$02,$D2,$FE,$A8,$00,$00 
                  DC.B      $02,$D2,$FE,$AC,$FF,$CF,$02,$D2 
                  DC.B      $FE,$B6,$FF,$9F,$02,$D2,$FE,$C7 
                  DC.B      $FF,$71,$02,$D2,$FE,$DF,$FF,$46 
                  DC.B      $02,$D2,$FE,$FC,$FF,$1F,$02,$D2 
                  DC.B      $FF,$1F,$FE,$FC,$02,$D2,$FF,$46 
                  DC.B      $FE,$DF,$02,$D2,$FF,$71,$FE,$C7 
                  DC.B      $02,$D2,$FF,$9F,$FE,$B6,$02,$D2 
                  DC.B      $FF,$CF,$FE,$AC,$02,$D2,$00,$00 
                  DC.B      $FE,$A8,$02,$D2,$00,$31,$FE,$AC 
                  DC.B      $02,$D2,$00,$61,$FE,$B6,$02,$D2 
                  DC.B      $00,$8F,$FE,$C7,$02,$D2,$00,$BA 
                  DC.B      $FE,$DF,$02,$D2,$00,$E1,$FE,$FC 
                  DC.B      $02,$D2,$01,$04,$FF,$1F,$02,$D2 
                  DC.B      $01,$21,$FF,$46,$02,$D2,$01,$39 
                  DC.B      $FF,$71,$02,$D2,$01,$4A,$FF,$9F 
                  DC.B      $02,$D2,$01,$54,$FF,$CF,$02,$D2 
                  DC.B      $00,$F2,$00,$00,$02,$FA,$00,$F0 
                  DC.B      $00,$22,$02,$FA,$00,$E8,$00,$44 
                  DC.B      $02,$FA,$00,$DC,$00,$65,$02,$FA 
                  DC.B      $00,$CC,$00,$83,$02,$FA,$00,$B7 
                  DC.B      $00,$9F,$02,$FA,$00,$9F,$00,$B7 
                  DC.B      $02,$FA,$00,$83,$00,$CC,$02,$FA 
                  DC.B      $00,$65,$00,$DC,$02,$FA,$00,$44 
                  DC.B      $00,$E8,$02,$FA,$00,$22,$00,$F0 
                  DC.B      $02,$FA,$00,$00,$00,$F2,$02,$FA 
                  DC.B      $FF,$DE,$00,$F0,$02,$FA,$FF,$BC 
                  DC.B      $00,$E8,$02,$FA,$FF,$9B,$00,$DC 
                  DC.B      $02,$FA,$FF,$7D,$00,$CC,$02,$FA 
                  DC.B      $FF,$61,$00,$B7,$02,$FA,$FF,$49 
                  DC.B      $00,$9F,$02,$FA,$FF,$34,$00,$83 
                  DC.B      $02,$FA,$FF,$24,$00,$65,$02,$FA 
                  DC.B      $FF,$18,$00,$44,$02,$FA,$FF,$10 
                  DC.B      $00,$22,$02,$FA,$FF,$0E,$00,$00 
                  DC.B      $02,$FA,$FF,$10,$FF,$DE,$02,$FA 
                  DC.B      $FF,$18,$FF,$BC,$02,$FA,$FF,$24 
                  DC.B      $FF,$9B,$02,$FA,$FF,$34,$FF,$7D 
                  DC.B      $02,$FA,$FF,$49,$FF,$61,$02,$FA 
                  DC.B      $FF,$61,$FF,$49,$02,$FA,$FF,$7D 
                  DC.B      $FF,$34,$02,$FA,$FF,$9B,$FF,$24 
                  DC.B      $02,$FA,$FF,$BC,$FF,$18,$02,$FA 
                  DC.B      $FF,$DE,$FF,$10,$02,$FA,$00,$00 
                  DC.B      $FF,$0E,$02,$FA,$00,$22,$FF,$10 
                  DC.B      $02,$FA,$00,$44,$FF,$18,$02,$FA 
                  DC.B      $00,$65,$FF,$24,$02,$FA,$00,$83 
                  DC.B      $FF,$34,$02,$FA,$00,$9F,$FF,$49 
                  DC.B      $02,$FA,$00,$B7,$FF,$61,$02,$FA 
                  DC.B      $00,$CC,$FF,$7D,$02,$FA,$00,$DC 
                  DC.B      $FF,$9B,$02,$FA,$00,$E8,$FF,$BC 
                  DC.B      $02,$FA,$00,$F0,$FF,$DE,$02,$FA 
                  DC.B      $00,$88,$00,$00,$03,$14,$00,$87 
                  DC.B      $00,$13,$03,$14,$00,$83,$00,$26 
                  DC.B      $03,$14,$00,$7C,$00,$39,$03,$14 
                  DC.B      $00,$73,$00,$4A,$03,$14,$00,$67 
                  DC.B      $00,$59,$03,$14,$00,$59,$00,$67 
                  DC.B      $03,$14,$00,$4A,$00,$73,$03,$14 
                  DC.B      $00,$39,$00,$7C,$03,$14,$00,$26 
                  DC.B      $00,$83,$03,$14,$00,$13,$00,$87 
                  DC.B      $03,$14,$00,$00,$00,$88,$03,$14 
                  DC.B      $FF,$ED,$00,$87,$03,$14,$FF,$DA 
                  DC.B      $00,$83,$03,$14,$FF,$C7,$00,$7C 
                  DC.B      $03,$14,$FF,$B6,$00,$73,$03,$14 
                  DC.B      $FF,$A7,$00,$67,$03,$14,$FF,$99 
                  DC.B      $00,$59,$03,$14,$FF,$8D,$00,$4A 
                  DC.B      $03,$14,$FF,$84,$00,$39,$03,$14 
                  DC.B      $FF,$7D,$00,$26,$03,$14,$FF,$79 
                  DC.B      $00,$13,$03,$14,$FF,$78,$00,$00 
                  DC.B      $03,$14,$FF,$79,$FF,$ED,$03,$14 
                  DC.B      $FF,$7D,$FF,$DA,$03,$14,$FF,$84 
                  DC.B      $FF,$C7,$03,$14,$FF,$8D,$FF,$B6 
                  DC.B      $03,$14,$FF,$99,$FF,$A7,$03,$14 
                  DC.B      $FF,$A7,$FF,$99,$03,$14,$FF,$B6 
                  DC.B      $FF,$8D,$03,$14,$FF,$C7,$FF,$84 
                  DC.B      $03,$14,$FF,$DA,$FF,$7D,$03,$14 
                  DC.B      $FF,$ED,$FF,$79,$03,$14,$00,$00 
                  DC.B      $FF,$78,$03,$14,$00,$13,$FF,$79 
                  DC.B      $03,$14,$00,$26,$FF,$7D,$03,$14 
                  DC.B      $00,$39,$FF,$84,$03,$14,$00,$4A 
                  DC.B      $FF,$8D,$03,$14,$00,$59,$FF,$99 
                  DC.B      $03,$14,$00,$67,$FF,$A7,$03,$14 
                  DC.B      $00,$73,$FF,$B6,$03,$14,$00,$7C 
                  DC.B      $FF,$C7,$03,$14,$00,$83,$FF,$DA 
                  DC.B      $03,$14,$00,$87,$FF,$ED,$03,$14 
TRIG_TAB:         DC.B      $00,$00,$00,$C9,$01,$92,$02,$5B 
                  DC.B      $03,$24,$03,$ED,$04,$B6,$05,$7E 
                  DC.B      $06,$47,$07,$10,$07,$D9,$08,$A1 
                  DC.B      $09,$6A,$0A,$32,$0A,$FB,$0B,$C3 
                  DC.B      $0C,$8B,$0D,$53,$0E,$1B,$0E,$E3 
                  DC.B      $0F,$AB,$10,$72,$11,$39,$12,$00 
                  DC.B      $12,$C7,$13,$8E,$14,$55,$15,$1B 
                  DC.B      $15,$E1,$16,$A7,$17,$6D,$18,$33 
                  DC.B      $18,$F8,$19,$BD,$1A,$82,$1B,$46 
                  DC.B      $1C,$0B,$1C,$CF,$1D,$93,$1E,$56 
                  DC.B      $1F,$19,$1F,$DC,$20,$9F,$21,$61 
                  DC.B      $22,$23,$22,$E4,$23,$A6,$24,$67 
                  DC.B      $25,$27,$25,$E7,$26,$A7,$27,$67 
                  DC.B      $28,$26,$28,$E5,$29,$A3,$2A,$61 
                  DC.B      $2B,$1E,$2B,$DB,$2C,$98,$2D,$54 
                  DC.B      $2E,$10,$2E,$CC,$2F,$86,$30,$41 
                  DC.B      $30,$FB,$31,$B4,$32,$6D,$33,$26 
                  DC.B      $33,$DE,$34,$96,$35,$4D,$36,$03 
                  DC.B      $36,$B9,$37,$6F,$38,$24,$38,$D8 
                  DC.B      $39,$8C,$3A,$3F,$3A,$F2,$3B,$A4 
                  DC.B      $3C,$56,$3D,$07,$3D,$B7,$3E,$67 
                  DC.B      $3F,$16,$3F,$C5,$40,$73,$41,$20 
                  DC.B      $41,$CD,$42,$79,$43,$25,$43,$D0 
                  DC.B      $44,$7A,$45,$23,$45,$CC,$46,$74 
                  DC.B      $47,$1C,$47,$C3,$48,$69,$49,$0E 
                  DC.B      $49,$B3,$4A,$57,$4A,$FA,$4B,$9D 
                  DC.B      $4C,$3F,$4C,$E0,$4D,$80,$4E,$20 
                  DC.B      $4E,$BF,$4F,$5D,$4F,$FA,$50,$97 
                  DC.B      $51,$33,$51,$CE,$52,$68,$53,$01 
                  DC.B      $53,$9A,$54,$32,$54,$C9,$55,$5F 
                  DC.B      $55,$F4,$56,$89,$57,$1D,$57,$B0 
                  DC.B      $58,$42,$58,$D3,$59,$63,$59,$F3 
                  DC.B      $5A,$81,$5B,$0F,$5B,$9C,$5C,$28 
                  DC.B      $5C,$B3,$5D,$3D,$5D,$C6,$5E,$4F 
                  DC.B      $5E,$D6,$5F,$5D,$5F,$E2,$60,$67 
                  DC.B      $60,$EB,$61,$6E,$61,$F0,$62,$71 
                  DC.B      $62,$F1,$63,$70,$63,$EE,$64,$6B 
                  DC.B      $64,$E7,$65,$62,$65,$DD,$66,$56 
                  DC.B      $66,$CE,$67,$45,$67,$BC,$68,$31 
                  DC.B      $68,$A5,$69,$19,$69,$8B,$69,$FC 
                  DC.B      $6A,$6C,$6A,$DB,$6B,$4A,$6B,$B7 
                  DC.B      $6C,$23,$6C,$8E,$6C,$F8,$6D,$61 
                  DC.B      $6D,$C9,$6E,$30,$6E,$95,$6E,$FA 
                  DC.B      $6F,$5E,$6F,$C0,$70,$22,$70,$82 
                  DC.B      $70,$E1,$71,$40,$71,$9D,$71,$F9 
                  DC.B      $72,$54,$72,$AE,$73,$06,$73,$5E 
                  DC.B      $73,$B5,$74,$0A,$74,$5E,$74,$B1 
                  DC.B      $75,$03,$75,$54,$75,$A4,$75,$F3 
                  DC.B      $76,$40,$76,$8D,$76,$D8,$77,$22 
                  DC.B      $77,$6B,$77,$B3,$77,$F9,$78,$3F 
                  DC.B      $78,$83,$78,$C6,$79,$08,$79,$49 
                  DC.B      $79,$89,$79,$C7,$7A,$04,$7A,$41 
                  DC.B      $7A,$7C,$7A,$B5,$7A,$EE,$7B,$25 
                  DC.B      $7B,$5C,$7B,$91,$7B,$C4,$7B,$F7 
                  DC.B      $7C,$29,$7C,$59,$7C,$88,$7C,$B6 
                  DC.B      $7C,$E2,$7D,$0E,$7D,$38,$7D,$61 
                  DC.B      $7D,$89,$7D,$B0,$7D,$D5,$7D,$F9 
                  DC.B      $7E,$1C,$7E,$3E,$7E,$5E,$7E,$7E 
                  DC.B      $7E,$9C,$7E,$B9,$7E,$D4,$7E,$EF 
                  DC.B      $7F,$08,$7F,$20,$7F,$37,$7F,$4C 
                  DC.B      $7F,$61,$7F,$74,$7F,$86,$7F,$96 
                  DC.B      $7F,$A6,$7F,$B4,$7F,$C1,$7F,$CD 
                  DC.B      $7F,$D7,$7F,$E0,$7F,$E8,$7F,$EF 
                  DC.B      $7F,$F5,$7F,$F9,$7F,$FC,$7F,$FE 
                  DC.B      $7F,$FF,$7F,$FE,$7F,$FC,$7F,$F9 
                  DC.B      $7F,$F5,$7F,$EF,$7F,$E8,$7F,$E0 
                  DC.B      $7F,$D7,$7F,$CD,$7F,$C1,$7F,$B4 
                  DC.B      $7F,$A6,$7F,$96,$7F,$86,$7F,$74 
                  DC.B      $7F,$61,$7F,$4C,$7F,$37,$7F,$20 
                  DC.B      $7F,$08,$7E,$EF,$7E,$D4,$7E,$B9 
                  DC.B      $7E,$9C,$7E,$7E,$7E,$5E,$7E,$3E 
                  DC.B      $7E,$1C,$7D,$F9,$7D,$D5,$7D,$B0 
                  DC.B      $7D,$89,$7D,$61,$7D,$38,$7D,$0E 
                  DC.B      $7C,$E2,$7C,$B6,$7C,$88,$7C,$59 
                  DC.B      $7C,$29,$7B,$F7,$7B,$C4,$7B,$91 
                  DC.B      $7B,$5C,$7B,$25,$7A,$EE,$7A,$B5 
                  DC.B      $7A,$7C,$7A,$41,$7A,$04,$79,$C7 
                  DC.B      $79,$89,$79,$49,$79,$08,$78,$C6 
                  DC.B      $78,$83,$78,$3F,$77,$F9,$77,$B3 
                  DC.B      $77,$6B,$77,$22,$76,$D8,$76,$8D 
                  DC.B      $76,$40,$75,$F3,$75,$A4,$75,$54 
                  DC.B      $75,$03,$74,$B1,$74,$5E,$74,$0A 
                  DC.B      $73,$B5,$73,$5E,$73,$06,$72,$AE 
                  DC.B      $72,$54,$71,$F9,$71,$9D,$71,$40 
                  DC.B      $70,$E1,$70,$82,$70,$22,$6F,$C0 
                  DC.B      $6F,$5E,$6E,$FA,$6E,$95,$6E,$30 
                  DC.B      $6D,$C9,$6D,$61,$6C,$F8,$6C,$8E 
                  DC.B      $6C,$23,$6B,$B7,$6B,$4A,$6A,$DB 
                  DC.B      $6A,$6C,$69,$FC,$69,$8B,$69,$19 
                  DC.B      $68,$A5,$68,$31,$67,$BC,$67,$45 
                  DC.B      $66,$CE,$66,$56,$65,$DD,$65,$62 
                  DC.B      $64,$E7,$64,$6B,$63,$EE,$63,$70 
                  DC.B      $62,$F1,$62,$71,$61,$F0,$61,$6E 
                  DC.B      $60,$EB,$60,$67,$5F,$E2,$5F,$5D 
                  DC.B      $5E,$D6,$5E,$4F,$5D,$C6,$5D,$3D 
                  DC.B      $5C,$B3,$5C,$28,$5B,$9C,$5B,$0F 
                  DC.B      $5A,$81,$59,$F3,$59,$63,$58,$D3 
                  DC.B      $58,$42,$57,$B0,$57,$1D,$56,$89 
                  DC.B      $55,$F4,$55,$5F,$54,$C9,$54,$32 
                  DC.B      $53,$9A,$53,$01,$52,$68,$51,$CE 
                  DC.B      $51,$33,$50,$97,$4F,$FA,$4F,$5D 
                  DC.B      $4E,$BF,$4E,$20,$4D,$80,$4C,$E0 
                  DC.B      $4C,$3F,$4B,$9D,$4A,$FA,$4A,$57 
                  DC.B      $49,$B3,$49,$0E,$48,$69,$47,$C3 
                  DC.B      $47,$1C,$46,$74,$45,$CC,$45,$23 
                  DC.B      $44,$7A,$43,$D0,$43,$25,$42,$79 
                  DC.B      $41,$CD,$41,$20,$40,$73,$3F,$C5 
                  DC.B      $3F,$16,$3E,$67,$3D,$B7,$3D,$07 
                  DC.B      $3C,$56,$3B,$A4,$3A,$F2,$3A,$3F 
                  DC.B      $39,$8C,$38,$D8,$38,$24,$37,$6F 
                  DC.B      $36,$B9,$36,$03,$35,$4D,$34,$96 
                  DC.B      $33,$DE,$33,$26,$32,$6D,$31,$B4 
                  DC.B      $30,$FB,$30,$41,$2F,$86,$2E,$CC 
                  DC.B      $2E,$10,$2D,$54,$2C,$98,$2B,$DB 
                  DC.B      $2B,$1E,$2A,$61,$29,$A3,$28,$E5 
                  DC.B      $28,$26,$27,$67,$26,$A7,$25,$E7 
                  DC.B      $25,$27,$24,$67,$23,$A6,$22,$E4 
                  DC.B      $22,$23,$21,$61,$20,$9F,$1F,$DC 
                  DC.B      $1F,$19,$1E,$56,$1D,$93,$1C,$CF 
                  DC.B      $1C,$0B,$1B,$46,$1A,$82,$19,$BD 
                  DC.B      $18,$F8,$18,$33,$17,$6D,$16,$A7 
                  DC.B      $15,$E1,$15,$1B,$14,$55,$13,$8E 
                  DC.B      $12,$C7,$12,$00,$11,$39,$10,$72 
                  DC.B      $0F,$AB,$0E,$E3,$0E,$1B,$0D,$53 
                  DC.B      $0C,$8B,$0B,$C3,$0A,$FB,$0A,$32 
                  DC.B      $09,$6A,$08,$A1,$07,$D9,$07,$10 
                  DC.B      $06,$47,$05,$7E,$04,$B6,$03,$ED 
                  DC.B      $03,$24,$02,$5B,$01,$92,$00,$C9 
                  DC.B      $00,$00,$FF,$37,$FE,$6E,$FD,$A5 
                  DC.B      $FC,$DC,$FC,$13,$FB,$4A,$FA,$82 
                  DC.B      $F9,$B9,$F8,$F0,$F8,$27,$F7,$5F 
                  DC.B      $F6,$96,$F5,$CE,$F5,$05,$F4,$3D 
                  DC.B      $F3,$75,$F2,$AD,$F1,$E5,$F1,$1D 
                  DC.B      $F0,$55,$EF,$8E,$EE,$C7,$EE,$00 
                  DC.B      $ED,$39,$EC,$72,$EB,$AB,$EA,$E5 
                  DC.B      $EA,$1F,$E9,$59,$E8,$93,$E7,$CD 
                  DC.B      $E7,$08,$E6,$43,$E5,$7E,$E4,$BA 
                  DC.B      $E3,$F5,$E3,$31,$E2,$6D,$E1,$AA 
                  DC.B      $E0,$E7,$E0,$24,$DF,$61,$DE,$9F 
                  DC.B      $DD,$DD,$DD,$1C,$DC,$5A,$DB,$99 
                  DC.B      $DA,$D9,$DA,$19,$D9,$59,$D8,$99 
                  DC.B      $D7,$DA,$D7,$1B,$D6,$5D,$D5,$9F 
                  DC.B      $D4,$E2,$D4,$25,$D3,$68,$D2,$AC 
                  DC.B      $D1,$F0,$D1,$34,$D0,$7A,$CF,$BF 
                  DC.B      $CF,$05,$CE,$4C,$CD,$93,$CC,$DA 
                  DC.B      $CC,$22,$CB,$6A,$CA,$B3,$C9,$FD 
                  DC.B      $C9,$47,$C8,$91,$C7,$DC,$C7,$28 
                  DC.B      $C6,$74,$C5,$C1,$C5,$0E,$C4,$5C 
                  DC.B      $C3,$AA,$C2,$F9,$C2,$49,$C1,$99 
                  DC.B      $C0,$EA,$C0,$3B,$BF,$8D,$BE,$E0 
                  DC.B      $BE,$33,$BD,$87,$BC,$DB,$BC,$30 
                  DC.B      $BB,$86,$BA,$DD,$BA,$34,$B9,$8C 
                  DC.B      $B8,$E4,$B8,$3D,$B7,$97,$B6,$F2 
                  DC.B      $B6,$4D,$B5,$A9,$B5,$06,$B4,$63 
                  DC.B      $B3,$C1,$B3,$20,$B2,$80,$B1,$E0 
                  DC.B      $B1,$41,$B0,$A3,$B0,$06,$AF,$69 
                  DC.B      $AE,$CD,$AE,$32,$AD,$98,$AC,$FF 
                  DC.B      $AC,$66,$AB,$CE,$AB,$37,$AA,$A1 
                  DC.B      $AA,$0C,$A9,$77,$A8,$E3,$A8,$50 
                  DC.B      $A7,$BE,$A7,$2D,$A6,$9D,$A6,$0D 
                  DC.B      $A5,$7F,$A4,$F1,$A4,$64,$A3,$D8 
                  DC.B      $A3,$4D,$A2,$C3,$A2,$3A,$A1,$B1 
                  DC.B      $A1,$2A,$A0,$A3,$A0,$1E,$9F,$99 
                  DC.B      $9F,$15,$9E,$92,$9E,$10,$9D,$8F 
                  DC.B      $9D,$0F,$9C,$90,$9C,$12,$9B,$95 
                  DC.B      $9B,$19,$9A,$9E,$9A,$23,$99,$AA 
                  DC.B      $99,$32,$98,$BB,$98,$44,$97,$CF 
                  DC.B      $97,$5B,$96,$E7,$96,$75,$96,$04 
                  DC.B      $95,$94,$95,$25,$94,$B6,$94,$49 
                  DC.B      $93,$DD,$93,$72,$93,$08,$92,$9F 
                  DC.B      $92,$37,$91,$D0,$91,$6B,$91,$06 
                  DC.B      $90,$A2,$90,$40,$8F,$DE,$8F,$7E 
                  DC.B      $8F,$1F,$8E,$C0,$8E,$63,$8E,$07 
                  DC.B      $8D,$AC,$8D,$52,$8C,$FA,$8C,$A2 
                  DC.B      $8C,$4B,$8B,$F6,$8B,$A2,$8B,$4F 
                  DC.B      $8A,$FD,$8A,$AC,$8A,$5C,$8A,$0D 
                  DC.B      $89,$C0,$89,$73,$89,$28,$88,$DE 
                  DC.B      $88,$95,$88,$4D,$88,$07,$87,$C1 
                  DC.B      $87,$7D,$87,$3A,$86,$F8,$86,$B7 
                  DC.B      $86,$77,$86,$39,$85,$FC,$85,$BF 
                  DC.B      $85,$84,$85,$4B,$85,$12,$84,$DB 
                  DC.B      $84,$A4,$84,$6F,$84,$3C,$84,$09 
                  DC.B      $83,$D7,$83,$A7,$83,$78,$83,$4A 
                  DC.B      $83,$1E,$82,$F2,$82,$C8,$82,$9F 
                  DC.B      $82,$77,$82,$50,$82,$2B,$82,$07 
                  DC.B      $81,$E4,$81,$C2,$81,$A2,$81,$82 
                  DC.B      $81,$64,$81,$47,$81,$2C,$81,$11 
                  DC.B      $80,$F8,$80,$E0,$80,$C9,$80,$B4 
                  DC.B      $80,$9F,$80,$8C,$80,$7A,$80,$6A 
                  DC.B      $80,$5A,$80,$4C,$80,$3F,$80,$33 
                  DC.B      $80,$29,$80,$20,$80,$18,$80,$11 
                  DC.B      $80,$0B,$80,$07,$80,$04,$80,$02 
                  DC.B      $80,$01,$80,$02,$80,$04,$80,$07 
                  DC.B      $80,$0B,$80,$11,$80,$18,$80,$20 
                  DC.B      $80,$29,$80,$33,$80,$3F,$80,$4C 
                  DC.B      $80,$5A,$80,$6A,$80,$7A,$80,$8C 
                  DC.B      $80,$9F,$80,$B4,$80,$C9,$80,$E0 
                  DC.B      $80,$F8,$81,$11,$81,$2C,$81,$47 
                  DC.B      $81,$64,$81,$82,$81,$A2,$81,$C2 
                  DC.B      $81,$E4,$82,$07,$82,$2B,$82,$50 
                  DC.B      $82,$77,$82,$9F,$82,$C8,$82,$F2 
                  DC.B      $83,$1E,$83,$4A,$83,$78,$83,$A7 
                  DC.B      $83,$D7,$84,$09,$84,$3C,$84,$6F 
                  DC.B      $84,$A4,$84,$DB,$85,$12,$85,$4B 
                  DC.B      $85,$84,$85,$BF,$85,$FC,$86,$39 
                  DC.B      $86,$77,$86,$B7,$86,$F8,$87,$3A 
                  DC.B      $87,$7D,$87,$C1,$88,$07,$88,$4D 
                  DC.B      $88,$95,$88,$DE,$89,$28,$89,$73 
                  DC.B      $89,$C0,$8A,$0D,$8A,$5C,$8A,$AC 
                  DC.B      $8A,$FD,$8B,$4F,$8B,$A2,$8B,$F6 
                  DC.B      $8C,$4B,$8C,$A2,$8C,$FA,$8D,$52 
                  DC.B      $8D,$AC,$8E,$07,$8E,$63,$8E,$C0 
                  DC.B      $8F,$1F,$8F,$7E,$8F,$DE,$90,$40 
                  DC.B      $90,$A2,$91,$06,$91,$6B,$91,$D0 
                  DC.B      $92,$37,$92,$9F,$93,$08,$93,$72 
                  DC.B      $93,$DD,$94,$49,$94,$B6,$95,$25 
                  DC.B      $95,$94,$96,$04,$96,$75,$96,$E7 
                  DC.B      $97,$5B,$97,$CF,$98,$44,$98,$BB 
                  DC.B      $99,$32,$99,$AA,$9A,$23,$9A,$9E 
                  DC.B      $9B,$19,$9B,$95,$9C,$12,$9C,$90 
                  DC.B      $9D,$0F,$9D,$8F,$9E,$10,$9E,$92 
                  DC.B      $9F,$15,$9F,$99,$A0,$1E,$A0,$A3 
                  DC.B      $A1,$2A,$A1,$B1,$A2,$3A,$A2,$C3 
                  DC.B      $A3,$4D,$A3,$D8,$A4,$64,$A4,$F1 
                  DC.B      $A5,$7F,$A6,$0D,$A6,$9D,$A7,$2D 
                  DC.B      $A7,$BE,$A8,$50,$A8,$E3,$A9,$77 
                  DC.B      $AA,$0C,$AA,$A1,$AB,$37,$AB,$CE 
                  DC.B      $AC,$66,$AC,$FF,$AD,$98,$AE,$32 
                  DC.B      $AE,$CD,$AF,$69,$B0,$06,$B0,$A3 
                  DC.B      $B1,$41,$B1,$E0,$B2,$80,$B3,$20 
                  DC.B      $B3,$C1,$B4,$63,$B5,$06,$B5,$A9 
                  DC.B      $B6,$4D,$B6,$F2,$B7,$97,$B8,$3D 
                  DC.B      $B8,$E4,$B9,$8C,$BA,$34,$BA,$DD 
                  DC.B      $BB,$86,$BC,$30,$BC,$DB,$BD,$87 
                  DC.B      $BE,$33,$BE,$E0,$BF,$8D,$C0,$3B 
                  DC.B      $C0,$EA,$C1,$99,$C2,$49,$C2,$F9 
                  DC.B      $C3,$AA,$C4,$5C,$C5,$0E,$C5,$C1 
                  DC.B      $C6,$74,$C7,$28,$C7,$DC,$C8,$91 
                  DC.B      $C9,$47,$C9,$FD,$CA,$B3,$CB,$6A 
                  DC.B      $CC,$22,$CC,$DA,$CD,$93,$CE,$4C 
                  DC.B      $CF,$05,$CF,$BF,$D0,$7A,$D1,$34 
                  DC.B      $D1,$F0,$D2,$AC,$D3,$68,$D4,$25 
                  DC.B      $D4,$E2,$D5,$9F,$D6,$5D,$D7,$1B 
                  DC.B      $D7,$DA,$D8,$99,$D9,$59,$DA,$19 
                  DC.B      $DA,$D9,$DB,$99,$DC,$5A,$DD,$1C 
                  DC.B      $DD,$DD,$DE,$9F,$DF,$61,$E0,$24 
                  DC.B      $E0,$E7,$E1,$AA,$E2,$6D,$E3,$31 
                  DC.B      $E3,$F5,$E4,$BA,$E5,$7E,$E6,$43 
                  DC.B      $E7,$08,$E7,$CD,$E8,$93,$E9,$59 
                  DC.B      $EA,$1F,$EA,$E5,$EB,$AB,$EC,$72 
                  DC.B      $ED,$39,$EE,$00,$EE,$C7,$EF,$8E 
                  DC.B      $F0,$55,$F1,$1D,$F1,$E5,$F2,$AD 
                  DC.B      $F3,$75,$F4,$3D,$F5,$05,$F5,$CE 
                  DC.B      $F6,$96,$F7,$5F,$F8,$27,$F8,$F0 
                  DC.B      $F9,$B9,$FA,$82,$FB,$4A,$FC,$13 
                  DC.B      $FC,$DC,$FD,$A5,$FE,$6E,$FF,$37 
                  DC.B      $00,$00,$00,$C9,$01,$92,$02,$5B 
                  DC.B      $03,$24,$03,$ED,$04,$B6,$05,$7E 
                  DC.B      $06,$47,$07,$10,$07,$D9,$08,$A1 
                  DC.B      $09,$6A,$0A,$32,$0A,$FB,$0B,$C3 
                  DC.B      $0C,$8B,$0D,$53,$0E,$1B,$0E,$E3 
                  DC.B      $0F,$AB,$10,$72,$11,$39,$12,$00 
                  DC.B      $12,$C7,$13,$8E,$14,$55,$15,$1B 
                  DC.B      $15,$E1,$16,$A7,$17,$6D,$18,$33 
                  DC.B      $18,$F8,$19,$BD,$1A,$82,$1B,$46 
                  DC.B      $1C,$0B,$1C,$CF,$1D,$93,$1E,$56 
                  DC.B      $1F,$19,$1F,$DC,$20,$9F,$21,$61 
                  DC.B      $22,$23,$22,$E4,$23,$A6,$24,$67 
                  DC.B      $25,$27,$25,$E7,$26,$A7,$27,$67 
                  DC.B      $28,$26,$28,$E5,$29,$A3,$2A,$61 
                  DC.B      $2B,$1E,$2B,$DB,$2C,$98,$2D,$54 
                  DC.B      $2E,$10,$2E,$CC,$2F,$86,$30,$41 
                  DC.B      $30,$FB,$31,$B4,$32,$6D,$33,$26 
                  DC.B      $33,$DE,$34,$96,$35,$4D,$36,$03 
                  DC.B      $36,$B9,$37,$6F,$38,$24,$38,$D8 
                  DC.B      $39,$8C,$3A,$3F,$3A,$F2,$3B,$A4 
                  DC.B      $3C,$56,$3D,$07,$3D,$B7,$3E,$67 
                  DC.B      $3F,$16,$3F,$C5,$40,$73,$41,$20 
                  DC.B      $41,$CD,$42,$79,$43,$25,$43,$D0 
                  DC.B      $44,$7A,$45,$23,$45,$CC,$46,$74 
                  DC.B      $47,$1C,$47,$C3,$48,$69,$49,$0E 
                  DC.B      $49,$B3,$4A,$57,$4A,$FA,$4B,$9D 
                  DC.B      $4C,$3F,$4C,$E0,$4D,$80,$4E,$20 
                  DC.B      $4E,$BF,$4F,$5D,$4F,$FA,$50,$97 
                  DC.B      $51,$33,$51,$CE,$52,$68,$53,$01 
                  DC.B      $53,$9A,$54,$32,$54,$C9,$55,$5F 
                  DC.B      $55,$F4,$56,$89,$57,$1D,$57,$B0 
                  DC.B      $58,$42,$58,$D3,$59,$63,$59,$F3 
                  DC.B      $5A,$81,$5B,$0F,$5B,$9C,$5C,$28 
                  DC.B      $5C,$B3,$5D,$3D,$5D,$C6,$5E,$4F 
                  DC.B      $5E,$D6,$5F,$5D,$5F,$E2,$60,$67 
                  DC.B      $60,$EB,$61,$6E,$61,$F0,$62,$71 
                  DC.B      $62,$F1,$63,$70,$63,$EE,$64,$6B 
                  DC.B      $64,$E7,$65,$62,$65,$DD,$66,$56 
                  DC.B      $66,$CE,$67,$45,$67,$BC,$68,$31 
                  DC.B      $68,$A5,$69,$19,$69,$8B,$69,$FC 
                  DC.B      $6A,$6C,$6A,$DB,$6B,$4A,$6B,$B7 
                  DC.B      $6C,$23,$6C,$8E,$6C,$F8,$6D,$61 
                  DC.B      $6D,$C9,$6E,$30,$6E,$95,$6E,$FA 
                  DC.B      $6F,$5E,$6F,$C0,$70,$22,$70,$82 
                  DC.B      $70,$E1,$71,$40,$71,$9D,$71,$F9 
                  DC.B      $72,$54,$72,$AE,$73,$06,$73,$5E 
                  DC.B      $73,$B5,$74,$0A,$74,$5E,$74,$B1 
                  DC.B      $75,$03,$75,$54,$75,$A4,$75,$F3 
                  DC.B      $76,$40,$76,$8D,$76,$D8,$77,$22 
                  DC.B      $77,$6B,$77,$B3,$77,$F9,$78,$3F 
                  DC.B      $78,$83,$78,$C6,$79,$08,$79,$49 
                  DC.B      $79,$89,$79,$C7,$7A,$04,$7A,$41 
                  DC.B      $7A,$7C,$7A,$B5,$7A,$EE,$7B,$25 
                  DC.B      $7B,$5C,$7B,$91,$7B,$C4,$7B,$F7 
                  DC.B      $7C,$29,$7C,$59,$7C,$88,$7C,$B6 
                  DC.B      $7C,$E2,$7D,$0E,$7D,$38,$7D,$61 
                  DC.B      $7D,$89,$7D,$B0,$7D,$D5,$7D,$F9 
                  DC.B      $7E,$1C,$7E,$3E,$7E,$5E,$7E,$7E 
                  DC.B      $7E,$9C,$7E,$B9,$7E,$D4,$7E,$EF 
                  DC.B      $7F,$08,$7F,$20,$7F,$37,$7F,$4C 
                  DC.B      $7F,$61,$7F,$74,$7F,$86,$7F,$96 
                  DC.B      $7F,$A6,$7F,$B4,$7F,$C1,$7F,$CD 
                  DC.B      $7F,$D7,$7F,$E0,$7F,$E8,$7F,$EF 
                  DC.B      $7F,$F5,$7F,$F9,$7F,$FC,$7F,$FE 
DSPPROG:          DC.B      $0A,$F0,$80,$00,$00,$40,$00,$00 
                  DS.W      92
                  DC.B      $08,$F4,$BE,$00,$00,$00,$08,$F4 
                  DC.B      $A0,$00,$00,$01,$00,$FC,$B8,$0A 
                  DC.B      $A9,$80,$00,$00,$45,$08,$45,$2B 
                  DC.B      $0B,$F0,$80,$00,$00,$4C,$0A,$F0 
                  DC.B      $80,$00,$00,$45,$62,$F4,$00,$00 
                  DC.B      $05,$00,$05,$08,$A2,$64,$F4,$00 
                  DC.B      $00,$05,$10,$05,$02,$A4,$06,$09 
                  DC.B      $80,$00,$00,$56,$0A,$A9,$80,$00 
                  DC.B      $00,$54,$08,$5A,$AB,$0A,$A9,$80 
                  DC.B      $00,$00,$57,$08,$58,$2B,$06,$D8 
                  DC.B      $00,$00,$00,$77,$0A,$A9,$80,$00 
                  DC.B      $00,$5C,$08,$5C,$EB,$0A,$A9,$80 
                  DC.B      $00,$00,$5F,$08,$5C,$EB,$0A,$A9 
                  DC.B      $80,$00,$00,$62,$08,$5C,$EB,$F0 
                  DC.B      $9A,$00,$F0,$9A,$D0,$F0,$9A,$D2 
                  DC.B      $F0,$9A,$D3,$0A,$A9,$81,$00,$00 
                  DC.B      $69,$08,$CE,$2B,$F0,$9A,$D0,$F0 
                  DC.B      $9A,$D2,$F0,$9A,$D3,$0A,$A9,$81 
                  DC.B      $00,$00,$6F,$08,$CE,$2B,$F0,$9A 
                  DC.B      $D0,$F0,$9A,$D2,$20,$00,$D3,$0A 
                  DC.B      $A9,$81,$00,$00,$75,$08,$CE,$2B 
                  DC.B      $00,$00,$0C,$00 
 BSS
PERSTABL:         DS.B      64896 
BIT_OFFS:         DS.B      1536
L0024:            DS.B      65996 
MY_STACK:         DS.B      16
ZUEND: END
