sound:
	dc.b    $06,$1f,$07,$2f,$09,$10,$0c,$20,$0d,$00,$81,$12,$02,$f8,$ff,$00
