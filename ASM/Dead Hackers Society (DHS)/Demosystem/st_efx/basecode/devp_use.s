;
; SYSTEM FOR ST-DEMOSCREEN ONLINE COMPETITION
;
; Devpac and Assemble version
;
; Anders Eriksson (Evil / Dead Hackers Society)
; ae@dhs.nu
;
; July 1, 2001
;


playmusic:	equ	1	; 0 = Silent 
				; 1 = Play SNDH-music (good to see total CPU-useage)


; --------------------------------------------------------------
; ------------- Section TEXT -----------------------------------
; --------------------------------------------------------------

		section	text

		include	'devp_sys.s'	; demo system include, keep it here!

		
; --------------------------------------------------------------
; ------------- Effect INIT ------------------------------------
; --------------------------------------------------------------
		
compo_init:

; Pur your init code here.

		rts


; --------------------------------------------------------------
; ------------- Mainloop ---------------------------------------
; --------------------------------------------------------------
		
compo_mainrout:

; Put your main loop here.

		rts

; --------------------------------------------------------------
; ------------- VBL 50/60Hz ------------------------------------
; --------------------------------------------------------------

compo_vblrout:

; Put your VBL routine here.

		rts


; --------------------------------------------------------------
; ------------- Timer-C 200Hz ----------------------------------
; --------------------------------------------------------------
		
compo_timerrout:

; Put your 200Hz routine here.

		rts


		
; --------------------------------------------------------------
; ------------- Section DATA -----------------------------------
; --------------------------------------------------------------
		
		section	data

; Put your data here.


; --------------------------------------------------------------
; ------------- Section BSS ------------------------------------
; --------------------------------------------------------------

		section	bss

; Put your BSS buffers here.



		end