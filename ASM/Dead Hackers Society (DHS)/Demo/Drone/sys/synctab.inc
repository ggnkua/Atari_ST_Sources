 dc.b 0,0,0,0,0,0,0,0  ; 0
 dc.b 6,4,3,1,1,1,0,0  ; 2
 dc.b 6,4,3,1,1,0,0,0  ; 4
 dc.b 6,4,3,1,0,0,0,0  ; 6
 dc.b 6,4,3,0,0,0,0,0  ; 8
 dc.b 6,4,2,2,1,0,0,0  ; 10
 dc.b 6,4,2,2,0,0,0,0  ; 12
 dc.b 6,5,4,2,0,0,0,0  ; 14
 dc.b 6,5,5,4,0,0,0,0  ; 16
 dc.b 2,1,1,1,0,0,0,0  ; 18
 dc.b 2,1,1,0,0,0,0,0  ; 20
 dc.b 2,1,0,0,0,0,0,0  ; 22
 dc.b 2,0,0,0,0,0,0,0  ; 24
 dc.b 5,0,0,0,0,0,0,0  ; 26
 dc.b 6,4,4,1,1,1,0,0  ; 28
 dc.b 6,4,4,1,1,0,0,0  ; 30
 dc.b 6,4,4,1,0,0,0,0  ; 32
 dc.b 6,4,4,0,0,0,0,0  ; 34
 dc.b 3,1,1,1,1,0,0,0  ; 36
 dc.b 3,1,1,1,0,0,0,0  ; 38
 dc.b 3,1,1,0,0,0,0,0  ; 40
 dc.b 3,1,0,0,0,0,0,0  ; 42
 dc.b 3,0,0,0,0,0,0,0  ; 44
 dc.b 2,2,1,0,0,0,0,0  ; 46
 dc.b 2,2,0,0,0,0,0,0  ; 48
 dc.b 5,2,0,0,0,0,0,0  ; 50
 dc.b 5,5,0,0,0,0,0,0  ; 52
 dc.b 6,4,4,2,1,1,0,0  ; 54
 dc.b 6,4,4,2,1,0,0,0  ; 56
 dc.b 6,4,4,2,0,0,0,0  ; 58
 dc.b 6,5,4,4,0,0,0,0  ; 60
 dc.b 4,1,1,1,1,0,0,0  ; 62
 dc.b 4,1,1,1,0,0,0,0  ; 64
 dc.b 4,1,1,0,0,0,0,0  ; 66
 dc.b 4,1,0,0,0,0,0,0  ; 68
 dc.b 4,0,0,0,0,0,0,0  ; 70
 dc.b 2,2,2,0,0,0,0,0  ; 72
 dc.b 5,2,2,0,0,0,0,0  ; 74
 dc.b 5,5,2,0,0,0,0,0  ; 76
 dc.b 5,5,5,0,0,0,0,0  ; 78
 dc.b 3,3,1,1,1,1,0,0  ; 80
 dc.b 3,3,1,1,1,0,0,0  ; 82
 dc.b 3,3,1,1,0,0,0,0  ; 84
 dc.b 3,3,1,0,0,0,0,0  ; 86
 dc.b 3,3,0,0,0,0,0,0  ; 88
 dc.b 4,2,1,1,0,0,0,0  ; 90
 dc.b 4,2,1,0,0,0,0,0  ; 92
 dc.b 4,2,0,0,0,0,0,0  ; 94
 dc.b 5,4,0,0,0,0,0,0  ; 96
 dc.b 5,2,2,2,0,0,0,0  ; 98
 dc.b 5,5,2,2,0,0,0,0  ; 100
 dc.b 5,5,5,2,0,0,0,0  ; 102
 dc.b 6,4,4,4,0,0,0,0  ; 104
 dc.b 4,3,1,1,1,1,0,0  ; 106
 dc.b 4,3,1,1,1,0,0,0  ; 108
 dc.b 4,3,1,1,0,0,0,0  ; 110
 dc.b 4,3,1,0,0,0,0,0  ; 112
 dc.b 4,3,0,0,0,0,0,0  ; 114
 dc.b 4,2,2,1,0,0,0,0  ; 116
 dc.b 4,2,2,0,0,0,0,0  ; 118
 dc.b 5,4,2,0,0,0,0,0  ; 120
 dc.b 5,5,4,0,0,0,0,0  ; 122
 dc.b 5,5,2,2,2,0,0,0  ; 124
 dc.b 5,5,5,2,2,0,0,0  ; 126
 dc.b 3,3,3,1,1,0,0,0  ; 128
 dc.b 3,3,3,1,0,0,0,0  ; 130
 dc.b 3,3,3,0,0,0,0,0  ; 132
 dc.b 4,4,1,1,1,0,0,0  ; 134
 dc.b 4,4,1,1,0,0,0,0  ; 136
 dc.b 4,4,1,0,0,0,0,0  ; 138
 dc.b 4,4,0,0,0,0,0,0  ; 140
 dc.b 4,2,2,2,0,0,0,0  ; 142
 dc.b 5,4,2,2,0,0,0,0  ; 144
 dc.b 5,5,4,2,0,0,0,0  ; 146
 dc.b 5,5,5,4,0,0,0,0  ; 148
 dc.b 5,5,5,2,2,2,0,0  ; 150
 dc.b 4,3,3,1,1,1,0,0  ; 152
 dc.b 4,3,3,1,1,0,0,0  ; 154
 dc.b 4,3,3,1,0,0,0,0  ; 156
 dc.b 4,3,3,0,0,0,0,0  ; 158
 dc.b 4,4,2,1,1,0,0,0  ; 160
 dc.b 4,4,2,1,0,0,0,0  ; 162
 dc.b 4,4,2,0,0,0,0,0  ; 164
 dc.b 5,4,4,0,0,0,0,0  ; 166
 dc.b 5,4,2,2,2,0,0,0  ; 168
 dc.b 5,5,4,2,2,0,0,0  ; 170
 dc.b 5,5,5,4,2,0,0,0  ; 172
 dc.b 3,3,3,3,1,0,0,0  ; 174
 dc.b 3,3,3,3,0,0,0,0  ; 176
 dc.b 4,4,3,1,1,1,0,0  ; 178
 dc.b 4,4,3,1,1,0,0,0  ; 180
 dc.b 4,4,3,1,0,0,0,0  ; 182
 dc.b 4,4,3,0,0,0,0,0  ; 184
 dc.b 4,4,2,2,1,0,0,0  ; 186
 dc.b 4,4,2,2,0,0,0,0  ; 188
 dc.b 5,4,4,2,0,0,0,0  ; 190
 dc.b 5,5,4,4,0,0,0,0  ; 192
 dc.b 5,5,4,2,2,2,0,0  ; 194
 dc.b 5,5,5,4,2,2,0,0  ; 196
 dc.b 4,3,3,3,1,1,0,0  ; 198
 dc.b 4,3,3,3,1,0,0,0  ; 200
 dc.b 4,3,3,3,0,0,0,0  ; 202
 dc.b 4,4,4,1,1,1,0,0  ; 204
 dc.b 4,4,4,1,1,0,0,0  ; 206
 dc.b 4,4,4,1,0,0,0,0  ; 208
 dc.b 4,4,4,0,0,0,0,0  ; 210
 dc.b 4,4,2,2,2,0,0,0  ; 212
 dc.b 5,4,4,2,2,0,0,0  ; 214
 dc.b 5,5,4,4,2,0,0,0  ; 216
 dc.b 5,5,5,4,4,0,0,0  ; 218
 dc.b 3,3,3,3,3,0,0,0  ; 220
 dc.b 4,4,3,3,1,1,1,0  ; 222
 dc.b 4,4,3,3,1,1,0,0  ; 224
 dc.b 4,4,3,3,1,0,0,0  ; 226
 dc.b 4,4,3,3,0,0,0,0  ; 228
 dc.b 4,4,4,2,1,1,0,0  ; 230
 dc.b 4,4,4,2,1,0,0,0  ; 232
 dc.b 4,4,4,2,0,0,0,0  ; 234
 dc.b 5,4,4,4,0,0,0,0  ; 236
 dc.b 5,4,4,2,2,2,0,0  ; 238
 dc.b 5,5,4,4,2,2,0,0  ; 240
 dc.b 5,5,5,4,4,2,0,0  ; 242
 dc.b 4,3,3,3,3,1,0,0  ; 244
 dc.b 4,3,3,3,3,0,0,0  ; 246
 dc.b 4,4,4,3,1,1,1,0  ; 248
 dc.b 4,4,4,3,1,1,0,0  ; 250
 dc.b 4,4,4,3,1,0,0,0  ; 252
 dc.b 4,4,4,3,0,0,0,0  ; 254
