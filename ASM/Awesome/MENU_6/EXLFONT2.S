;Palette of EXLFONT2.TNC: Saved by NEOchrome V2.27 by Chaos, Inc.
		dc.w	$0000,$0766,$0655,$0544,$0433,$0322,$0211,$0200
		dc.w	$0700,$0730,$0770,$0030,$0777,$0067,$0007,$0E0E
