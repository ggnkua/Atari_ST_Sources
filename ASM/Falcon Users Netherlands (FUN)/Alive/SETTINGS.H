/* Resource Datei Indizes f�r SETTINGS */

#define FUNDEMOSETTER 0   /* Formulier/Dialoog */
#define DEMOSETTERBOX 0   /* BOX in boom FUNDEMOSETTER */
#define TITEL    1   /* BOXTEXT in boom FUNDEMOSETTER */
#define EXITBUTTON 3   /* BUTTON in boom FUNDEMOSETTER */
#define RUNBUTTON 4   /* BUTTON in boom FUNDEMOSETTER */
#define VIDEOGROUPBOX 5   /* BOX in boom FUNDEMOSETTER */
#define VIDEOSELECT 6   /* BUTTON in boom FUNDEMOSETTER */
#define DETAILSELECT 7   /* BUTTON in boom FUNDEMOSETTER */
#define VDOMODESTRING 8   /* STRING in boom FUNDEMOSETTER */
#define DETAILSTRING 9   /* STRING in boom FUNDEMOSETTER */
#define AUDIOGROUPBOX 10  /* BOX in boom FUNDEMOSETTER */
#define SURROUNDBUTTON 11  /* BUTTON in boom FUNDEMOSETTER */
#define INTERPOLBUTTON 12  /* BUTTON in boom FUNDEMOSETTER */
#define COGWHEEL_L 13  /* IMAGE in boom FUNDEMOSETTER */
#define COGWHEEL_R 14  /* IMAGE in boom FUNDEMOSETTER */

#define VIDEOMODES 1   /* Formulier/Dialoog */
#define VDORGB50 2   /* STRING in boom VIDEOMODES */
#define VDOVGA60 3   /* STRING in boom VIDEOMODES */
#define VDOVGA100 4   /* STRING in boom VIDEOMODES */

#define DETAILLEVELS 2   /* Formulier/Dialoog */
#define DETAILLOW 2   /* STRING in boom DETAILLEVELS */
#define DETAILMID 3   /* STRING in boom DETAILLEVELS */
#define DETAILHIGH 4   /* STRING in boom DETAILLEVELS */
