
	dc.w	$0000,$7FFF,$006B,$7FFF,$00D6,$7FFE,$011D,$7FFD
	dc.w	$0189,$7FFC,$01F4,$7FFB,$025F,$7FFA,$02CA,$7FF7
	dc.w	$0336,$7FF4,$037D,$7FF2,$03E8,$7FEF,$0453,$7FEC
	dc.w	$04BF,$7FE8,$052A,$7FE4,$0571,$7FE1,$05DC,$7FDC
	dc.w	$0647,$7FD7,$06B2,$7FD3,$071D,$7FCC,$0765,$7FC8
	dc.w	$07D0,$7FC1,$083B,$7FBB,$08A6,$7FB4,$0911,$7FAD
	dc.w	$097C,$7FA4,$09C3,$7F9F,$0A2E,$7F96,$0A99,$7F8E
	dc.w	$0B04,$7F86,$0B6F,$7F7C,$0BB6,$7F75,$0C20,$7F6B
	dc.w	$0C8B,$7F61,$0CF6,$7F56,$0D61,$7F4C,$0DA8,$7F44
	dc.w	$0E12,$7F38,$0E7D,$7F2C,$0EE7,$7F1F,$0F52,$7F13
	dc.w	$0FBC,$7F07,$1003,$7EFD,$106E,$7EEF,$10D8,$7EE1
	dc.w	$1142,$7ED3,$11AC,$7EC5,$11F3,$7EBB,$125D,$7EAB
	dc.w	$12C7,$7E9C,$1331,$7E8C,$139B,$7E7C,$13E2,$7E71
	dc.w	$144C,$7E60,$14B6,$7E4F,$1520,$7E3D,$1589,$7E2B
	dc.w	$15F3,$7E19,$163A,$7E0E,$16A3,$7DFA,$170C,$7DE7
	dc.w	$1776,$7DD3,$17DF,$7DBF,$1826,$7DB2,$188F,$7D9E
	dc.w	$18F8,$7D89,$1961,$7D74,$19CA,$7D5E,$1A10,$7D50
	dc.w	$1A79,$7D3B,$1AE2,$7D24,$1B4B,$7D0D,$1BB4,$7CF6
	dc.w	$1C1C,$7CDE,$1C62,$7CCF,$1CCB,$7CB8,$1D33,$7C9F
	dc.w	$1D9B,$7C86,$1E03,$7C6D,$1E49,$7C5C,$1EB1,$7C43
	dc.w	$1F19,$7C29,$1F81,$7C0E,$1FE9,$7BF3,$202E,$7BE2
	dc.w	$2096,$7BC7,$20FE,$7BAC,$2165,$7B90,$21CD,$7B73
	dc.w	$2234,$7B57,$2279,$7B43,$22E0,$7B27,$2348,$7B0A
	dc.w	$23AE,$7AEC,$2415,$7ACD,$245A,$7AB9,$24C1,$7A9A
	dc.w	$2527,$7A7C,$258E,$7A5D,$25F4,$7A3D,$2638,$7A27
	dc.w	$269F,$7A07,$2705,$79E7,$276B,$79C6,$27D1,$79A5
	dc.w	$2837,$7983,$287B,$796C,$28E0,$794A,$2946,$7928
	dc.w	$29AC,$7906,$2A11,$78E2,$2A54,$78CB,$2AB9,$78A7
	dc.w	$2B1E,$7883,$2B83,$785F,$2BE8,$783B,$2C2B,$7822
	dc.w	$2C90,$77FC,$2CF4,$77D7,$2D59,$77B1,$2DBD,$778C
	dc.w	$2E21,$7765,$2E64,$774B,$2EC7,$7723,$2F2B,$76FC
	dc.w	$2F8F,$76D5,$2FF3,$76AD,$3035,$7692,$3098,$7669
	dc.w	$30FB,$7640,$315E,$7617,$31C1,$75EE,$3203,$75D3
	dc.w	$3265,$75A8,$32C8,$757D,$332A,$7552,$338C,$7528
	dc.w	$33EF,$74FD,$3430,$74E0,$3492,$74B3,$34F3,$7487
	dc.w	$3555,$745A,$35B6,$742E,$35F7,$7410,$3658,$73E3
	dc.w	$36B9,$73B4,$371A,$7386,$377B,$7358,$37BB,$7339
	dc.w	$381C,$730B,$387C,$72DB,$38DC,$72AB,$393C,$727C
	dc.w	$399C,$724C,$39DC,$722C,$3A3C,$71FB,$3A9B,$71CA
	dc.w	$3AFA,$7198,$3B59,$7167,$3B98,$7146,$3BF7,$7114
	dc.w	$3C56,$70E2,$3CB4,$70AF,$3D12,$707B,$3D51,$7059
	dc.w	$3DAF,$7026,$3E0E,$6FF3,$3E6B,$6FBE,$3EC8,$6F89
	dc.w	$3F26,$6F55,$3F64,$6F31,$3FC1,$6EFD,$401E,$6EC7
	dc.w	$407B,$6E91,$40D7,$6E5A,$4115,$6E36,$4171,$6E00
	dc.w	$41CD,$6DC9,$4229,$6D92,$4285,$6D5A,$42C2,$6D34
	dc.w	$431D,$6CFC,$4378,$6CC4,$43D4,$6C8C,$442E,$6C53
	dc.w	$4489,$6C19,$44C5,$6BF3,$451F,$6BB9,$457A,$6B7F
	dc.w	$45D4,$6B45,$462D,$6B0A,$4669,$6AE3,$46C2,$6AA7
	dc.w	$471C,$6A6C,$4775,$6A31,$47CE,$69F5,$4809,$69CC
	dc.w	$4861,$6990,$48BA,$6953,$4912,$6916,$496A,$68D9
	dc.w	$49C2,$689B,$49FC,$6872,$4A53,$6833,$4AAB,$67F5
	dc.w	$4B02,$67B7,$4B59,$6778,$4B92,$674E,$4BE8,$670E
	dc.w	$4C3F,$66CE,$4C95,$668E,$4CEB,$664E,$4D24,$6623
	dc.w	$4D79,$65E2,$4DCE,$65A1,$4E23,$6560,$4E78,$651E
	dc.w	$4ECD,$64DD,$4F05,$64B1,$4F59,$646E,$4FAD,$642B
	dc.w	$5001,$63E8,$5055,$63A5,$508D,$6379,$50E0,$6335
	dc.w	$5133,$62F1,$5185,$62AC,$51D8,$6268,$520F,$623B
	dc.w	$5262,$61F6,$52B3,$61B0,$5305,$616B,$5356,$6125
	dc.w	$53A8,$60DF,$53DE,$60B1,$542F,$606A,$547F,$6023
	dc.w	$54CF,$5FDC,$5520,$5F95,$5555,$5F66,$55A6,$5F1F
	dc.w	$55F5,$5ED6,$5644,$5E8E,$5693,$5E46,$56C7,$5E15
	dc.w	$5716,$5DCD,$5765,$5D84,$57B3,$5D3A,$5801,$5CF0
	dc.w	$584E,$5CA6,$5882,$5C75,$58D0,$5C2B,$591D,$5BE1
	dc.w	$596A,$5B96,$59B6,$5B4A,$59E9,$5B18,$5A35,$5ACD
	dc.w	$5A82,$5A82,$5ACD,$5A35,$5B18,$59E9,$5B4A,$59B6
	dc.w	$5B96,$596A,$5BE1,$591D,$5C2B,$58D0,$5C75,$5882
	dc.w	$5CBF,$5835,$5CF0,$5801,$5D3A,$57B3,$5D84,$5765
	dc.w	$5DCD,$5716,$5E15,$56C7,$5E46,$5693,$5E8E,$5644
	dc.w	$5ED6,$55F5,$5F1F,$55A6,$5F66,$5555,$5F95,$5520
	dc.w	$5FDC,$54CF,$6023,$547F,$606A,$542F,$60B1,$53DE
	dc.w	$60F7,$538D,$6125,$5356,$616B,$5305,$61B0,$52B3
	dc.w	$61F6,$5262,$623B,$520F,$6268,$51D8,$62AC,$5185
	dc.w	$62F1,$5133,$6335,$50E0,$6379,$508D,$63A5,$5055
	dc.w	$63E8,$5001,$642B,$4FAD,$646E,$4F59,$64B1,$4F05
	dc.w	$64F3,$4EB1,$651E,$4E78,$6560,$4E23,$65A1,$4DCE
	dc.w	$65E2,$4D79,$6623,$4D24,$664E,$4CEB,$668E,$4C95
	dc.w	$66CE,$4C3F,$670E,$4BE8,$674E,$4B92,$6778,$4B59
	dc.w	$67B7,$4B02,$67F5,$4AAB,$6833,$4A53,$6872,$49FC
	dc.w	$68B0,$49A5,$68D9,$496A,$6916,$4912,$6953,$48BA
	dc.w	$6990,$4861,$69CC,$4809,$69F5,$47CE,$6A31,$4775
	dc.w	$6A6C,$471C,$6AA7,$46C2,$6AE3,$4669,$6B0A,$462D
	dc.w	$6B45,$45D4,$6B7F,$457A,$6BB9,$451F,$6BF3,$44C5
	dc.w	$6C2C,$446B,$6C53,$442E,$6C8C,$43D4,$6CC4,$4378
	dc.w	$6CFC,$431D,$6D34,$42C2,$6D5A,$4285,$6D92,$4229
	dc.w	$6DC9,$41CD,$6E00,$4171,$6E36,$4115,$6E5A,$40D7
	dc.w	$6E91,$407B,$6EC7,$401E,$6EFD,$3FC1,$6F31,$3F64
	dc.w	$6F66,$3F07,$6F89,$3EC8,$6FBE,$3E6B,$6FF3,$3E0E
	dc.w	$7026,$3DAF,$7059,$3D51,$707B,$3D12,$70AF,$3CB4
	dc.w	$70E2,$3C56,$7114,$3BF7,$7146,$3B98,$7167,$3B59
	dc.w	$7198,$3AFA,$71CA,$3A9B,$71FB,$3A3C,$722C,$39DC
	dc.w	$725C,$397C,$727C,$393C,$72AB,$38DC,$72DB,$387C
	dc.w	$730B,$381C,$7339,$37BB,$7358,$377B,$7386,$371A
	dc.w	$73B4,$36B9,$73E3,$3658,$7410,$35F7,$742E,$35B6
	dc.w	$745A,$3555,$7487,$34F3,$74B3,$3492,$74E0,$3430
	dc.w	$750B,$33CE,$7528,$338C,$7552,$332A,$757D,$32C8
	dc.w	$75A8,$3265,$75D3,$3203,$75EE,$31C1,$7617,$315E
	dc.w	$7640,$30FB,$7669,$3098,$7692,$3035,$76AD,$2FF3
	dc.w	$76D5,$2F8F,$76FC,$2F2B,$7723,$2EC7,$774B,$2E64
	dc.w	$7772,$2E00,$778C,$2DBD,$77B1,$2D59,$77D7,$2CF4
	dc.w	$77FC,$2C90,$7822,$2C2B,$783B,$2BE8,$785F,$2B83
	dc.w	$7883,$2B1E,$78A7,$2AB9,$78CB,$2A54,$78E2,$2A11
	dc.w	$7906,$29AC,$7928,$2946,$794A,$28E0,$796C,$287B
	dc.w	$798E,$2815,$79A5,$27D1,$79C6,$276B,$79E7,$2705
	dc.w	$7A07,$269F,$7A27,$2638,$7A3D,$25F4,$7A5D,$258E
	dc.w	$7A7C,$2527,$7A9A,$24C1,$7AB9,$245A,$7ACD,$2415
	dc.w	$7AEC,$23AE,$7B0A,$2348,$7B27,$22E0,$7B43,$2279
	dc.w	$7B60,$2212,$7B73,$21CD,$7B90,$2165,$7BAC,$20FE
	dc.w	$7BC7,$2096,$7BE2,$202E,$7BF3,$1FE9,$7C0E,$1F81
	dc.w	$7C29,$1F19,$7C43,$1EB1,$7C5C,$1E49,$7C6D,$1E03
	dc.w	$7C86,$1D9B,$7C9F,$1D33,$7CB8,$1CCB,$7CCF,$1C62
	dc.w	$7CE6,$1BF9,$7CF6,$1BB4,$7D0D,$1B4B,$7D24,$1AE2
	dc.w	$7D3B,$1A79,$7D50,$1A10,$7D5E,$19CA,$7D74,$1961
	dc.w	$7D89,$18F8,$7D9E,$188F,$7DB2,$1826,$7DBF,$17DF
	dc.w	$7DD3,$1776,$7DE7,$170C,$7DFA,$16A3,$7E0E,$163A
	dc.w	$7E1F,$15D0,$7E2B,$1589,$7E3D,$1520,$7E4F,$14B6
	dc.w	$7E60,$144C,$7E71,$13E2,$7E7C,$139B,$7E8C,$1331
	dc.w	$7E9C,$12C7,$7EAB,$125D,$7EBB,$11F3,$7EC5,$11AC
	dc.w	$7ED3,$1142,$7EE1,$10D8,$7EEF,$106E,$7EFD,$1003
	dc.w	$7F0B,$0F99,$7F13,$0F52,$7F1F,$0EE7,$7F2C,$0E7D
	dc.w	$7F38,$0E12,$7F44,$0DA8,$7F4C,$0D61,$7F56,$0CF6
	dc.w	$7F61,$0C8B,$7F6B,$0C20,$7F75,$0BB6,$7F7C,$0B6F
	dc.w	$7F86,$0B04,$7F8E,$0A99,$7F96,$0A2E,$7F9F,$09C3
	dc.w	$7FA7,$0958,$7FAD,$0911,$7FB4,$08A6,$7FBB,$083B
	dc.w	$7FC1,$07D0,$7FC8,$0765,$7FCC,$071D,$7FD3,$06B2
	dc.w	$7FD7,$0647,$7FDC,$05DC,$7FE1,$0571,$7FE4,$052A
	dc.w	$7FE8,$04BF,$7FEC,$0453,$7FEF,$03E8,$7FF2,$037D
	dc.w	$7FF5,$0312,$7FF7,$02CA,$7FFA,$025F,$7FFB,$01F4
	dc.w	$7FFC,$0189,$7FFD,$011D,$7FFE,$00D6,$7FFF,$006B
	dc.w	$7FFF,$0000,$7FFF,$FF94,$7FFE,$FF29,$7FFD,$FEE2
	dc.w	$7FFC,$FE76,$7FFB,$FE0B,$7FFA,$FDA0,$7FF7,$FD35
	dc.w	$7FF4,$FCC9,$7FF2,$FC82,$7FEF,$FC17,$7FEC,$FBAC
	dc.w	$7FE8,$FB40,$7FE4,$FAD5,$7FE1,$FA8E,$7FDC,$FA23
	dc.w	$7FD7,$F9B8,$7FD3,$F94D,$7FCC,$F8E2,$7FC8,$F89A
	dc.w	$7FC1,$F82F,$7FBB,$F7C4,$7FB4,$F759,$7FAD,$F6EE
	dc.w	$7FA4,$F683,$7F9F,$F63C,$7F96,$F5D1,$7F8E,$F566
	dc.w	$7F86,$F4FB,$7F7C,$F490,$7F75,$F449,$7F6B,$F3DF
	dc.w	$7F61,$F374,$7F56,$F309,$7F4C,$F29E,$7F44,$F257
	dc.w	$7F38,$F1ED,$7F2C,$F182,$7F1F,$F118,$7F13,$F0AD
	dc.w	$7F07,$F043,$7EFD,$EFFC,$7EEF,$EF91,$7EE1,$EF27
	dc.w	$7ED3,$EEBD,$7EC5,$EE53,$7EBB,$EE0C,$7EAB,$EDA2
	dc.w	$7E9C,$ED38,$7E8C,$ECCE,$7E7C,$EC64,$7E71,$EC1D
	dc.w	$7E60,$EBB3,$7E4F,$EB49,$7E3D,$EADF,$7E2B,$EA76
	dc.w	$7E19,$EA0C,$7E0E,$E9C5,$7DFA,$E95C,$7DE7,$E8F3
	dc.w	$7DD3,$E889,$7DBF,$E820,$7DB2,$E7D9,$7D9E,$E770
	dc.w	$7D89,$E707,$7D74,$E69E,$7D5E,$E635,$7D50,$E5EF
	dc.w	$7D3B,$E586,$7D24,$E51D,$7D0D,$E4B4,$7CF6,$E44B
	dc.w	$7CDE,$E3E3,$7CCF,$E39D,$7CB8,$E334,$7C9F,$E2CC
	dc.w	$7C86,$E264,$7C6D,$E1FC,$7C5C,$E1B6,$7C43,$E14E
	dc.w	$7C29,$E0E6,$7C0E,$E07E,$7BF3,$E016,$7BE2,$DFD1
	dc.w	$7BC7,$DF69,$7BAC,$DF01,$7B90,$DE9A,$7B73,$DE32
	dc.w	$7B57,$DDCB,$7B43,$DD86,$7B27,$DD1F,$7B0A,$DCB7
	dc.w	$7AEC,$DC51,$7ACD,$DBEA,$7AB9,$DBA5,$7A9A,$DB3E
	dc.w	$7A7C,$DAD8,$7A5D,$DA71,$7A3D,$DA0B,$7A27,$D9C7
	dc.w	$7A07,$D960,$79E7,$D8FA,$79C6,$D894,$79A5,$D82E
	dc.w	$7983,$D7C8,$796C,$D784,$794A,$D71F,$7928,$D6B9
	dc.w	$7906,$D653,$78E2,$D5EE,$78CB,$D5AB,$78A7,$D546
	dc.w	$7883,$D4E1,$785F,$D47C,$783B,$D417,$7822,$D3D4
	dc.w	$77FC,$D36F,$77D7,$D30B,$77B1,$D2A6,$778C,$D242
	dc.w	$7765,$D1DE,$774B,$D19B,$7723,$D138,$76FC,$D0D4
	dc.w	$76D5,$D070,$76AD,$D00C,$7692,$CFCA,$7669,$CF67
	dc.w	$7640,$CF04,$7617,$CEA1,$75EE,$CE3E,$75D3,$CDFC
	dc.w	$75A8,$CD9A,$757D,$CD37,$7552,$CCD5,$7528,$CC73
	dc.w	$74FD,$CC10,$74E0,$CBCF,$74B3,$CB6D,$7487,$CB0C
	dc.w	$745A,$CAAA,$742E,$CA49,$7410,$CA08,$73E3,$C9A7
	dc.w	$73B4,$C946,$7386,$C8E5,$7358,$C884,$7339,$C844
	dc.w	$730B,$C7E3,$72DB,$C783,$72AB,$C723,$727C,$C6C3
	dc.w	$724C,$C663,$722C,$C623,$71FB,$C5C3,$71CA,$C564
	dc.w	$7198,$C505,$7167,$C4A6,$7146,$C467,$7114,$C408
	dc.w	$70E2,$C3A9,$70AF,$C34B,$707B,$C2ED,$7059,$C2AE
	dc.w	$7026,$C250,$6FF3,$C1F1,$6FBE,$C194,$6F89,$C137
	dc.w	$6F55,$C0D9,$6F31,$C09B,$6EFD,$C03E,$6EC7,$BFE1
	dc.w	$6E91,$BF84,$6E5A,$BF28,$6E36,$BEEA,$6E00,$BE8E
	dc.w	$6DC9,$BE32,$6D92,$BDD6,$6D5A,$BD7A,$6D34,$BD3D
	dc.w	$6CFC,$BCE2,$6CC4,$BC87,$6C8C,$BC2B,$6C53,$BBD1
	dc.w	$6C19,$BB76,$6BF3,$BB3A,$6BB9,$BAE0,$6B7F,$BA85
	dc.w	$6B45,$BA2B,$6B0A,$B9D2,$6AE3,$B996,$6AA7,$B93D
	dc.w	$6A6C,$B8E3,$6A31,$B88A,$69F5,$B831,$69CC,$B7F6
	dc.w	$6990,$B79E,$6953,$B745,$6916,$B6ED,$68D9,$B695
	dc.w	$689B,$B63D,$6872,$B603,$6833,$B5AC,$67F5,$B554
	dc.w	$67B7,$B4FD,$6778,$B4A6,$674E,$B46D,$670E,$B417
	dc.w	$66CE,$B3C0,$668E,$B36A,$664E,$B314,$6623,$B2DB
	dc.w	$65E2,$B286,$65A1,$B231,$6560,$B1DC,$651E,$B187
	dc.w	$64DD,$B132,$64B1,$B0FA,$646E,$B0A6,$642B,$B052
	dc.w	$63E8,$AFFE,$63A5,$AFAA,$6379,$AF72,$6335,$AF1F
	dc.w	$62F1,$AECC,$62AC,$AE7A,$6268,$AE27,$623B,$ADF0
	dc.w	$61F6,$AD9D,$61B0,$AD4C,$616B,$ACFA,$6125,$ACA9
	dc.w	$60DF,$AC57,$60B1,$AC21,$606A,$ABD0,$6023,$AB80
	dc.w	$5FDC,$AB30,$5F95,$AADF,$5F66,$AAAA,$5F1F,$AA59
	dc.w	$5ED6,$AA0A,$5E8E,$A9BB,$5E46,$A96C,$5E15,$A938
	dc.w	$5DCD,$A8E9,$5D84,$A89A,$5D3A,$A84C,$5CF0,$A7FE
	dc.w	$5CA6,$A7B1,$5C75,$A77D,$5C2B,$A72F,$5BE1,$A6E2
	dc.w	$5B96,$A695,$5B4A,$A649,$5B18,$A616,$5ACD,$A5CA
	dc.w	$5A82,$A57D,$5A35,$A532,$59E9,$A4E7,$59B6,$A4B5
	dc.w	$596A,$A469,$591D,$A41E,$58D0,$A3D4,$5882,$A38A
	dc.w	$5835,$A340,$5801,$A30F,$57B3,$A2C5,$5765,$A27B
	dc.w	$5716,$A232,$56C7,$A1EA,$5693,$A1B9,$5644,$A171
	dc.w	$55F5,$A129,$55A6,$A0E0,$5555,$A099,$5520,$A06A
	dc.w	$54CF,$A023,$547F,$9FDC,$542F,$9F95,$53DE,$9F4E
	dc.w	$538D,$9F08,$5356,$9EDA,$5305,$9E94,$52B3,$9E4F
	dc.w	$5262,$9E09,$520F,$9DC4,$51D8,$9D97,$5185,$9D53
	dc.w	$5133,$9D0E,$50E0,$9CCA,$508D,$9C86,$5055,$9C5A
	dc.w	$5001,$9C17,$4FAD,$9BD4,$4F59,$9B91,$4F05,$9B4E
	dc.w	$4EB1,$9B0C,$4E78,$9AE1,$4E23,$9A9F,$4DCE,$9A5E
	dc.w	$4D79,$9A1D,$4D24,$99DC,$4CEB,$99B1,$4C95,$9971
	dc.w	$4C3F,$9931,$4BE8,$98F1,$4B92,$98B1,$4B59,$9887
	dc.w	$4B02,$9848,$4AAB,$980A,$4A53,$97CC,$49FC,$978D
	dc.w	$49A5,$974F,$496A,$9726,$4912,$96E9,$48BA,$96AC
	dc.w	$4861,$966F,$4809,$9633,$47CE,$960A,$4775,$95CE
	dc.w	$471C,$9593,$46C2,$9558,$4669,$951C,$462D,$94F5
	dc.w	$45D4,$94BA,$457A,$9480,$451F,$9446,$44C5,$940C
	dc.w	$446B,$93D3,$442E,$93AC,$43D4,$9373,$4378,$933B
	dc.w	$431D,$9303,$42C2,$92CB,$4285,$92A5,$4229,$926D
	dc.w	$41CD,$9236,$4171,$91FF,$4115,$91C9,$40D7,$91A5
	dc.w	$407B,$916E,$401E,$9138,$3FC1,$9102,$3F64,$90CE
	dc.w	$3F07,$9099,$3EC8,$9076,$3E6B,$9041,$3E0E,$900C
	dc.w	$3DAF,$8FD9,$3D51,$8FA6,$3D12,$8F84,$3CB4,$8F50
	dc.w	$3C56,$8F1D,$3BF7,$8EEB,$3B98,$8EB9,$3B59,$8E98
	dc.w	$3AFA,$8E67,$3A9B,$8E35,$3A3C,$8E04,$39DC,$8DD3
	dc.w	$397C,$8DA3,$393C,$8D83,$38DC,$8D54,$387C,$8D24
	dc.w	$381C,$8CF4,$37BB,$8CC6,$377B,$8CA7,$371A,$8C79
	dc.w	$36B9,$8C4B,$3658,$8C1C,$35F7,$8BEF,$35B6,$8BD1
	dc.w	$3555,$8BA5,$34F3,$8B78,$3492,$8B4C,$3430,$8B1F
	dc.w	$33CE,$8AF4,$338C,$8AD7,$332A,$8AAD,$32C8,$8A82
	dc.w	$3265,$8A57,$3203,$8A2C,$31C1,$8A11,$315E,$89E8
	dc.w	$30FB,$89BF,$3098,$8996,$3035,$896D,$2FF3,$8952
	dc.w	$2F8F,$892A,$2F2B,$8903,$2EC7,$88DC,$2E64,$88B4
	dc.w	$2E00,$888D,$2DBD,$8873,$2D59,$884E,$2CF4,$8828
	dc.w	$2C90,$8803,$2C2B,$87DD,$2BE8,$87C4,$2B83,$87A0
	dc.w	$2B1E,$877C,$2AB9,$8758,$2A54,$8734,$2A11,$871D
	dc.w	$29AC,$86F9,$2946,$86D7,$28E0,$86B5,$287B,$8693
	dc.w	$2815,$8671,$27D1,$865A,$276B,$8639,$2705,$8618
	dc.w	$269F,$85F8,$2638,$85D8,$25F4,$85C2,$258E,$85A2
	dc.w	$2527,$8583,$24C1,$8565,$245A,$8546,$2415,$8532
	dc.w	$23AE,$8513,$2348,$84F5,$22E0,$84D8,$2279,$84BC
	dc.w	$2212,$849F,$21CD,$848C,$2165,$846F,$20FE,$8453
	dc.w	$2096,$8438,$202E,$841D,$1FE9,$840C,$1F81,$83F1
	dc.w	$1F19,$83D6,$1EB1,$83BC,$1E49,$83A3,$1E03,$8392
	dc.w	$1D9B,$8379,$1D33,$8360,$1CCB,$8347,$1C62,$8330
	dc.w	$1BF9,$8319,$1BB4,$8309,$1B4B,$82F2,$1AE2,$82DB
	dc.w	$1A79,$82C4,$1A10,$82AF,$19CA,$82A1,$1961,$828B
	dc.w	$18F8,$8276,$188F,$8261,$1826,$824D,$17DF,$8240
	dc.w	$1776,$822C,$170C,$8218,$16A3,$8205,$163A,$81F1
	dc.w	$15D0,$81E0,$1589,$81D4,$1520,$81C2,$14B6,$81B0
	dc.w	$144C,$819F,$13E2,$818E,$139B,$8183,$1331,$8173
	dc.w	$12C7,$8163,$125D,$8154,$11F3,$8144,$11AC,$813A
	dc.w	$1142,$812C,$10D8,$811E,$106E,$8110,$1003,$8102
	dc.w	$0F99,$80F4,$0F52,$80EC,$0EE7,$80E0,$0E7D,$80D3
	dc.w	$0E12,$80C7,$0DA8,$80BB,$0D61,$80B3,$0CF6,$80A9
	dc.w	$0C8B,$809E,$0C20,$8094,$0BB6,$808A,$0B6F,$8083
	dc.w	$0B04,$8079,$0A99,$8071,$0A2E,$8069,$09C3,$8060
	dc.w	$0958,$8058,$0911,$8052,$08A6,$804B,$083B,$8044
	dc.w	$07D0,$803E,$0765,$8037,$071D,$8033,$06B2,$802C
	dc.w	$0647,$8028,$05DC,$8023,$0571,$801E,$052A,$801B
	dc.w	$04BF,$8017,$0453,$8013,$03E8,$8010,$037D,$800D
	dc.w	$0312,$800A,$02CA,$8008,$025F,$8005,$01F4,$8004
	dc.w	$0189,$8003,$011D,$8002,$00D6,$8001,$006B,$8000
	dc.w	$0000,$8000,$FF94,$8000,$FF29,$8001,$FEE2,$8002
	dc.w	$FE76,$8003,$FE0B,$8004,$FDA0,$8005,$FD35,$8008
	dc.w	$FCC9,$800B,$FC82,$800D,$FC17,$8010,$FBAC,$8013
	dc.w	$FB40,$8017,$FAD5,$801B,$FA8E,$801E,$FA23,$8023
	dc.w	$F9B8,$8028,$F94D,$802C,$F8E2,$8033,$F89A,$8037
	dc.w	$F82F,$803E,$F7C4,$8044,$F759,$804B,$F6EE,$8052
	dc.w	$F683,$805B,$F63C,$8060,$F5D1,$8069,$F566,$8071
	dc.w	$F4FB,$8079,$F490,$8083,$F449,$808A,$F3DF,$8094
	dc.w	$F374,$809E,$F309,$80A9,$F29E,$80B3,$F257,$80BB
	dc.w	$F1ED,$80C7,$F182,$80D3,$F118,$80E0,$F0AD,$80EC
	dc.w	$F043,$80F8,$EFFC,$8102,$EF91,$8110,$EF27,$811E
	dc.w	$EEBD,$812C,$EE53,$813A,$EE0C,$8144,$EDA2,$8154
	dc.w	$ED38,$8163,$ECCE,$8173,$EC64,$8183,$EC1D,$818E
	dc.w	$EBB3,$819F,$EB49,$81B0,$EADF,$81C2,$EA76,$81D4
	dc.w	$EA0C,$81E6,$E9C5,$81F1,$E95C,$8205,$E8F3,$8218
	dc.w	$E889,$822C,$E820,$8240,$E7D9,$824D,$E770,$8261
	dc.w	$E707,$8276,$E69E,$828B,$E635,$82A1,$E5EF,$82AF
	dc.w	$E586,$82C4,$E51D,$82DB,$E4B4,$82F2,$E44B,$8309
	dc.w	$E3E3,$8321,$E39D,$8330,$E334,$8347,$E2CC,$8360
	dc.w	$E264,$8379,$E1FC,$8392,$E1B6,$83A3,$E14E,$83BC
	dc.w	$E0E6,$83D6,$E07E,$83F1,$E016,$840C,$DFD1,$841D
	dc.w	$DF69,$8438,$DF01,$8453,$DE9A,$846F,$DE32,$848C
	dc.w	$DDCB,$84A8,$DD86,$84BC,$DD1F,$84D8,$DCB7,$84F5
	dc.w	$DC51,$8513,$DBEA,$8532,$DBA5,$8546,$DB3E,$8565
	dc.w	$DAD8,$8583,$DA71,$85A2,$DA0B,$85C2,$D9C7,$85D8
	dc.w	$D960,$85F8,$D8FA,$8618,$D894,$8639,$D82E,$865A
	dc.w	$D7C8,$867C,$D784,$8693,$D71F,$86B5,$D6B9,$86D7
	dc.w	$D653,$86F9,$D5EE,$871D,$D5AB,$8734,$D546,$8758
	dc.w	$D4E1,$877C,$D47C,$87A0,$D417,$87C4,$D3D4,$87DD
	dc.w	$D36F,$8803,$D30B,$8828,$D2A6,$884E,$D242,$8873
	dc.w	$D1DE,$889A,$D19B,$88B4,$D138,$88DC,$D0D4,$8903
	dc.w	$D070,$892A,$D00C,$8952,$CFCA,$896D,$CF67,$8996
	dc.w	$CF04,$89BF,$CEA1,$89E8,$CE3E,$8A11,$CDFC,$8A2C
	dc.w	$CD9A,$8A57,$CD37,$8A82,$CCD5,$8AAD,$CC73,$8AD7
	dc.w	$CC10,$8B02,$CBCF,$8B1F,$CB6D,$8B4C,$CB0C,$8B78
	dc.w	$CAAA,$8BA5,$CA49,$8BD1,$CA08,$8BEF,$C9A7,$8C1C
	dc.w	$C946,$8C4B,$C8E5,$8C79,$C884,$8CA7,$C844,$8CC6
	dc.w	$C7E3,$8CF4,$C783,$8D24,$C723,$8D54,$C6C3,$8D83
	dc.w	$C663,$8DB3,$C623,$8DD3,$C5C3,$8E04,$C564,$8E35
	dc.w	$C505,$8E67,$C4A6,$8E98,$C467,$8EB9,$C408,$8EEB
	dc.w	$C3A9,$8F1D,$C34B,$8F50,$C2ED,$8F84,$C2AE,$8FA6
	dc.w	$C250,$8FD9,$C1F1,$900C,$C194,$9041,$C137,$9076
	dc.w	$C0D9,$90AA,$C09B,$90CE,$C03E,$9102,$BFE1,$9138
	dc.w	$BF84,$916E,$BF28,$91A5,$BEEA,$91C9,$BE8E,$91FF
	dc.w	$BE32,$9236,$BDD6,$926D,$BD7A,$92A5,$BD3D,$92CB
	dc.w	$BCE2,$9303,$BC87,$933B,$BC2B,$9373,$BBD1,$93AC
	dc.w	$BB76,$93E6,$BB3A,$940C,$BAE0,$9446,$BA85,$9480
	dc.w	$BA2B,$94BA,$B9D2,$94F5,$B996,$951C,$B93D,$9558
	dc.w	$B8E3,$9593,$B88A,$95CE,$B831,$960A,$B7F6,$9633
	dc.w	$B79E,$966F,$B745,$96AC,$B6ED,$96E9,$B695,$9726
	dc.w	$B63D,$9764,$B603,$978D,$B5AC,$97CC,$B554,$980A
	dc.w	$B4FD,$9848,$B4A6,$9887,$B46D,$98B1,$B417,$98F1
	dc.w	$B3C0,$9931,$B36A,$9971,$B314,$99B1,$B2DB,$99DC
	dc.w	$B286,$9A1D,$B231,$9A5E,$B1DC,$9A9F,$B187,$9AE1
	dc.w	$B132,$9B22,$B0FA,$9B4E,$B0A6,$9B91,$B052,$9BD4
	dc.w	$AFFE,$9C17,$AFAA,$9C5A,$AF72,$9C86,$AF1F,$9CCA
	dc.w	$AECC,$9D0E,$AE7A,$9D53,$AE27,$9D97,$ADF0,$9DC4
	dc.w	$AD9D,$9E09,$AD4C,$9E4F,$ACFA,$9E94,$ACA9,$9EDA
	dc.w	$AC57,$9F20,$AC21,$9F4E,$ABD0,$9F95,$AB80,$9FDC
	dc.w	$AB30,$A023,$AADF,$A06A,$AAAA,$A099,$AA59,$A0E0
	dc.w	$AA0A,$A129,$A9BB,$A171,$A96C,$A1B9,$A938,$A1EA
	dc.w	$A8E9,$A232,$A89A,$A27B,$A84C,$A2C5,$A7FE,$A30F
	dc.w	$A7B1,$A359,$A77D,$A38A,$A72F,$A3D4,$A6E2,$A41E
	dc.w	$A695,$A469,$A649,$A4B5,$A616,$A4E7,$A5CA,$A532
	dc.w	$A57D,$A57D,$A532,$A5CA,$A4E7,$A616,$A4B5,$A649
	dc.w	$A469,$A695,$A41E,$A6E2,$A3D4,$A72F,$A38A,$A77D
	dc.w	$A340,$A7CA,$A30F,$A7FE,$A2C5,$A84C,$A27B,$A89A
	dc.w	$A232,$A8E9,$A1EA,$A938,$A1B9,$A96C,$A171,$A9BB
	dc.w	$A129,$AA0A,$A0E0,$AA59,$A099,$AAAA,$A06A,$AADF
	dc.w	$A023,$AB30,$9FDC,$AB80,$9F95,$ABD0,$9F4E,$AC21
	dc.w	$9F08,$AC72,$9EDA,$ACA9,$9E94,$ACFA,$9E4F,$AD4C
	dc.w	$9E09,$AD9D,$9DC4,$ADF0,$9D97,$AE27,$9D53,$AE7A
	dc.w	$9D0E,$AECC,$9CCA,$AF1F,$9C86,$AF72,$9C5A,$AFAA
	dc.w	$9C17,$AFFE,$9BD4,$B052,$9B91,$B0A6,$9B4E,$B0FA
	dc.w	$9B0C,$B14E,$9AE1,$B187,$9A9F,$B1DC,$9A5E,$B231
	dc.w	$9A1D,$B286,$99DC,$B2DB,$99B1,$B314,$9971,$B36A
	dc.w	$9931,$B3C0,$98F1,$B417,$98B1,$B46D,$9887,$B4A6
	dc.w	$9848,$B4FD,$980A,$B554,$97CC,$B5AC,$978D,$B603
	dc.w	$974F,$B65A,$9726,$B695,$96E9,$B6ED,$96AC,$B745
	dc.w	$966F,$B79E,$9633,$B7F6,$960A,$B831,$95CE,$B88A
	dc.w	$9593,$B8E3,$9558,$B93D,$951C,$B996,$94F5,$B9D2
	dc.w	$94BA,$BA2B,$9480,$BA85,$9446,$BAE0,$940C,$BB3A
	dc.w	$93D3,$BB94,$93AC,$BBD1,$9373,$BC2B,$933B,$BC87
	dc.w	$9303,$BCE2,$92CB,$BD3D,$92A5,$BD7A,$926D,$BDD6
	dc.w	$9236,$BE32,$91FF,$BE8E,$91C9,$BEEA,$91A5,$BF28
	dc.w	$916E,$BF84,$9138,$BFE1,$9102,$C03E,$90CE,$C09B
	dc.w	$9099,$C0F8,$9076,$C137,$9041,$C194,$900C,$C1F1
	dc.w	$8FD9,$C250,$8FA6,$C2AE,$8F84,$C2ED,$8F50,$C34B
	dc.w	$8F1D,$C3A9,$8EEB,$C408,$8EB9,$C467,$8E98,$C4A6
	dc.w	$8E67,$C505,$8E35,$C564,$8E04,$C5C3,$8DD3,$C623
	dc.w	$8DA3,$C683,$8D83,$C6C3,$8D54,$C723,$8D24,$C783
	dc.w	$8CF4,$C7E3,$8CC6,$C844,$8CA7,$C884,$8C79,$C8E5
	dc.w	$8C4B,$C946,$8C1C,$C9A7,$8BEF,$CA08,$8BD1,$CA49
	dc.w	$8BA5,$CAAA,$8B78,$CB0C,$8B4C,$CB6D,$8B1F,$CBCF
	dc.w	$8AF4,$CC31,$8AD7,$CC73,$8AAD,$CCD5,$8A82,$CD37
	dc.w	$8A57,$CD9A,$8A2C,$CDFC,$8A11,$CE3E,$89E8,$CEA1
	dc.w	$89BF,$CF04,$8996,$CF67,$896D,$CFCA,$8952,$D00C
	dc.w	$892A,$D070,$8903,$D0D4,$88DC,$D138,$88B4,$D19B
	dc.w	$888D,$D1FF,$8873,$D242,$884E,$D2A6,$8828,$D30B
	dc.w	$8803,$D36F,$87DD,$D3D4,$87C4,$D417,$87A0,$D47C
	dc.w	$877C,$D4E1,$8758,$D546,$8734,$D5AB,$871D,$D5EE
	dc.w	$86F9,$D653,$86D7,$D6B9,$86B5,$D71F,$8693,$D784
	dc.w	$8671,$D7EA,$865A,$D82E,$8639,$D894,$8618,$D8FA
	dc.w	$85F8,$D960,$85D8,$D9C7,$85C2,$DA0B,$85A2,$DA71
	dc.w	$8583,$DAD8,$8565,$DB3E,$8546,$DBA5,$8532,$DBEA
	dc.w	$8513,$DC51,$84F5,$DCB7,$84D8,$DD1F,$84BC,$DD86
	dc.w	$849F,$DDED,$848C,$DE32,$846F,$DE9A,$8453,$DF01
	dc.w	$8438,$DF69,$841D,$DFD1,$840C,$E016,$83F1,$E07E
	dc.w	$83D6,$E0E6,$83BC,$E14E,$83A3,$E1B6,$8392,$E1FC
	dc.w	$8379,$E264,$8360,$E2CC,$8347,$E334,$8330,$E39D
	dc.w	$8319,$E406,$8309,$E44B,$82F2,$E4B4,$82DB,$E51D
	dc.w	$82C4,$E586,$82AF,$E5EF,$82A1,$E635,$828B,$E69E
	dc.w	$8276,$E707,$8261,$E770,$824D,$E7D9,$8240,$E820
	dc.w	$822C,$E889,$8218,$E8F3,$8205,$E95C,$81F1,$E9C5
	dc.w	$81E0,$EA2F,$81D4,$EA76,$81C2,$EADF,$81B0,$EB49
	dc.w	$819F,$EBB3,$818E,$EC1D,$8183,$EC64,$8173,$ECCE
	dc.w	$8163,$ED38,$8154,$EDA2,$8144,$EE0C,$813A,$EE53
	dc.w	$812C,$EEBD,$811E,$EF27,$8110,$EF91,$8102,$EFFC
	dc.w	$80F4,$F066,$80EC,$F0AD,$80E0,$F118,$80D3,$F182
	dc.w	$80C7,$F1ED,$80BB,$F257,$80B3,$F29E,$80A9,$F309
	dc.w	$809E,$F374,$8094,$F3DF,$808A,$F449,$8083,$F490
	dc.w	$8079,$F4FB,$8071,$F566,$8069,$F5D1,$8060,$F63C
	dc.w	$8058,$F6A7,$8052,$F6EE,$804B,$F759,$8044,$F7C4
	dc.w	$803E,$F82F,$8037,$F89A,$8033,$F8E2,$802C,$F94D
	dc.w	$8028,$F9B8,$8023,$FA23,$801E,$FA8E,$801B,$FAD5
	dc.w	$8017,$FB40,$8013,$FBAC,$8010,$FC17,$800D,$FC82
	dc.w	$800A,$FCED,$8008,$FD35,$8005,$FDA0,$8004,$FE0B
	dc.w	$8003,$FE76,$8002,$FEE2,$8001,$FF29,$8000,$FF94
	dc.w	$8000,$0000,$8000,$006B,$8001,$00D6,$8002,$011D
	dc.w	$8003,$0189,$8004,$01F4,$8005,$025F,$8008,$02CA
	dc.w	$800B,$0336,$800D,$037D,$8010,$03E8,$8013,$0453
	dc.w	$8017,$04BF,$801B,$052A,$801E,$0571,$8023,$05DC
	dc.w	$8028,$0647,$802C,$06B2,$8033,$071D,$8037,$0765
	dc.w	$803E,$07D0,$8044,$083B,$804B,$08A6,$8052,$0911
	dc.w	$805B,$097C,$8060,$09C3,$8069,$0A2E,$8071,$0A99
	dc.w	$8079,$0B04,$8083,$0B6F,$808A,$0BB6,$8094,$0C20
	dc.w	$809E,$0C8B,$80A9,$0CF6,$80B3,$0D61,$80BB,$0DA8
	dc.w	$80C7,$0E12,$80D3,$0E7D,$80E0,$0EE7,$80EC,$0F52
	dc.w	$80F8,$0FBC,$8102,$1003,$8110,$106E,$811E,$10D8
	dc.w	$812C,$1142,$813A,$11AC,$8144,$11F3,$8154,$125D
	dc.w	$8163,$12C7,$8173,$1331,$8183,$139B,$818E,$13E2
	dc.w	$819F,$144C,$81B0,$14B6,$81C2,$1520,$81D4,$1589
	dc.w	$81E6,$15F3,$81F1,$163A,$8205,$16A3,$8218,$170C
	dc.w	$822C,$1776,$8240,$17DF,$824D,$1826,$8261,$188F
	dc.w	$8276,$18F8,$828B,$1961,$82A1,$19CA,$82AF,$1A10
	dc.w	$82C4,$1A79,$82DB,$1AE2,$82F2,$1B4B,$8309,$1BB4
	dc.w	$8321,$1C1C,$8330,$1C62,$8347,$1CCB,$8360,$1D33
	dc.w	$8379,$1D9B,$8392,$1E03,$83A3,$1E49,$83BC,$1EB1
	dc.w	$83D6,$1F19,$83F1,$1F81,$840C,$1FE9,$841D,$202E
	dc.w	$8438,$2096,$8453,$20FE,$846F,$2165,$848C,$21CD
	dc.w	$84A8,$2234,$84BC,$2279,$84D8,$22E0,$84F5,$2348
	dc.w	$8513,$23AE,$8532,$2415,$8546,$245A,$8565,$24C1
	dc.w	$8583,$2527,$85A2,$258E,$85C2,$25F4,$85D8,$2638
	dc.w	$85F8,$269F,$8618,$2705,$8639,$276B,$865A,$27D1
	dc.w	$867C,$2837,$8693,$287B,$86B5,$28E0,$86D7,$2946
	dc.w	$86F9,$29AC,$871D,$2A11,$8734,$2A54,$8758,$2AB9
	dc.w	$877C,$2B1E,$87A0,$2B83,$87C4,$2BE8,$87DD,$2C2B
	dc.w	$8803,$2C90,$8828,$2CF4,$884E,$2D59,$8873,$2DBD
	dc.w	$889A,$2E21,$88B4,$2E64,$88DC,$2EC7,$8903,$2F2B
	dc.w	$892A,$2F8F,$8952,$2FF3,$896D,$3035,$8996,$3098
	dc.w	$89BF,$30FB,$89E8,$315E,$8A11,$31C1,$8A2C,$3203
	dc.w	$8A57,$3265,$8A82,$32C8,$8AAD,$332A,$8AD7,$338C
	dc.w	$8B02,$33EF,$8B1F,$3430,$8B4C,$3492,$8B78,$34F3
	dc.w	$8BA5,$3555,$8BD1,$35B6,$8BEF,$35F7,$8C1C,$3658
	dc.w	$8C4B,$36B9,$8C79,$371A,$8CA7,$377B,$8CC6,$37BB
	dc.w	$8CF4,$381C,$8D24,$387C,$8D54,$38DC,$8D83,$393C
	dc.w	$8DB3,$399C,$8DD3,$39DC,$8E04,$3A3C,$8E35,$3A9B
	dc.w	$8E67,$3AFA,$8E98,$3B59,$8EB9,$3B98,$8EEB,$3BF7
	dc.w	$8F1D,$3C56,$8F50,$3CB4,$8F84,$3D12,$8FA6,$3D51
	dc.w	$8FD9,$3DAF,$900C,$3E0E,$9041,$3E6B,$9076,$3EC8
	dc.w	$90AA,$3F26,$90CE,$3F64,$9102,$3FC1,$9138,$401E
	dc.w	$916E,$407B,$91A5,$40D7,$91C9,$4115,$91FF,$4171
	dc.w	$9236,$41CD,$926D,$4229,$92A5,$4285,$92CB,$42C2
	dc.w	$9303,$431D,$933B,$4378,$9373,$43D4,$93AC,$442E
	dc.w	$93E6,$4489,$940C,$44C5,$9446,$451F,$9480,$457A
	dc.w	$94BA,$45D4,$94F5,$462D,$951C,$4669,$9558,$46C2
	dc.w	$9593,$471C,$95CE,$4775,$960A,$47CE,$9633,$4809
	dc.w	$966F,$4861,$96AC,$48BA,$96E9,$4912,$9726,$496A
	dc.w	$9764,$49C2,$978D,$49FC,$97CC,$4A53,$980A,$4AAB
	dc.w	$9848,$4B02,$9887,$4B59,$98B1,$4B92,$98F1,$4BE8
	dc.w	$9931,$4C3F,$9971,$4C95,$99B1,$4CEB,$99DC,$4D24
	dc.w	$9A1D,$4D79,$9A5E,$4DCE,$9A9F,$4E23,$9AE1,$4E78
	dc.w	$9B22,$4ECD,$9B4E,$4F05,$9B91,$4F59,$9BD4,$4FAD
	dc.w	$9C17,$5001,$9C5A,$5055,$9C86,$508D,$9CCA,$50E0
	dc.w	$9D0E,$5133,$9D53,$5185,$9D97,$51D8,$9DC4,$520F
	dc.w	$9E09,$5262,$9E4F,$52B3,$9E94,$5305,$9EDA,$5356
	dc.w	$9F20,$53A8,$9F4E,$53DE,$9F95,$542F,$9FDC,$547F
	dc.w	$A023,$54CF,$A06A,$5520,$A099,$5555,$A0E0,$55A6
	dc.w	$A129,$55F5,$A171,$5644,$A1B9,$5693,$A1EA,$56C7
	dc.w	$A232,$5716,$A27B,$5765,$A2C5,$57B3,$A30F,$5801
	dc.w	$A359,$584E,$A38A,$5882,$A3D4,$58D0,$A41E,$591D
	dc.w	$A469,$596A,$A4B5,$59B6,$A4E7,$59E9,$A532,$5A35
	dc.w	$A57D,$5A82,$A5CA,$5ACD,$A616,$5B18,$A649,$5B4A
	dc.w	$A695,$5B96,$A6E2,$5BE1,$A72F,$5C2B,$A77D,$5C75
	dc.w	$A7CA,$5CBF,$A7FE,$5CF0,$A84C,$5D3A,$A89A,$5D84
	dc.w	$A8E9,$5DCD,$A938,$5E15,$A96C,$5E46,$A9BB,$5E8E
	dc.w	$AA0A,$5ED6,$AA59,$5F1F,$AAAA,$5F66,$AADF,$5F95
	dc.w	$AB30,$5FDC,$AB80,$6023,$ABD0,$606A,$AC21,$60B1
	dc.w	$AC72,$60F7,$ACA9,$6125,$ACFA,$616B,$AD4C,$61B0
	dc.w	$AD9D,$61F6,$ADF0,$623B,$AE27,$6268,$AE7A,$62AC
	dc.w	$AECC,$62F1,$AF1F,$6335,$AF72,$6379,$AFAA,$63A5
	dc.w	$AFFE,$63E8,$B052,$642B,$B0A6,$646E,$B0FA,$64B1
	dc.w	$B14E,$64F3,$B187,$651E,$B1DC,$6560,$B231,$65A1
	dc.w	$B286,$65E2,$B2DB,$6623,$B314,$664E,$B36A,$668E
	dc.w	$B3C0,$66CE,$B417,$670E,$B46D,$674E,$B4A6,$6778
	dc.w	$B4FD,$67B7,$B554,$67F5,$B5AC,$6833,$B603,$6872
	dc.w	$B65A,$68B0,$B695,$68D9,$B6ED,$6916,$B745,$6953
	dc.w	$B79E,$6990,$B7F6,$69CC,$B831,$69F5,$B88A,$6A31
	dc.w	$B8E3,$6A6C,$B93D,$6AA7,$B996,$6AE3,$B9D2,$6B0A
	dc.w	$BA2B,$6B45,$BA85,$6B7F,$BAE0,$6BB9,$BB3A,$6BF3
	dc.w	$BB94,$6C2C,$BBD1,$6C53,$BC2B,$6C8C,$BC87,$6CC4
	dc.w	$BCE2,$6CFC,$BD3D,$6D34,$BD7A,$6D5A,$BDD6,$6D92
	dc.w	$BE32,$6DC9,$BE8E,$6E00,$BEEA,$6E36,$BF28,$6E5A
	dc.w	$BF84,$6E91,$BFE1,$6EC7,$C03E,$6EFD,$C09B,$6F31
	dc.w	$C0F8,$6F66,$C137,$6F89,$C194,$6FBE,$C1F1,$6FF3
	dc.w	$C250,$7026,$C2AE,$7059,$C2ED,$707B,$C34B,$70AF
	dc.w	$C3A9,$70E2,$C408,$7114,$C467,$7146,$C4A6,$7167
	dc.w	$C505,$7198,$C564,$71CA,$C5C3,$71FB,$C623,$722C
	dc.w	$C683,$725C,$C6C3,$727C,$C723,$72AB,$C783,$72DB
	dc.w	$C7E3,$730B,$C844,$7339,$C884,$7358,$C8E5,$7386
	dc.w	$C946,$73B4,$C9A7,$73E3,$CA08,$7410,$CA49,$742E
	dc.w	$CAAA,$745A,$CB0C,$7487,$CB6D,$74B3,$CBCF,$74E0
	dc.w	$CC31,$750B,$CC73,$7528,$CCD5,$7552,$CD37,$757D
	dc.w	$CD9A,$75A8,$CDFC,$75D3,$CE3E,$75EE,$CEA1,$7617
	dc.w	$CF04,$7640,$CF67,$7669,$CFCA,$7692,$D00C,$76AD
	dc.w	$D070,$76D5,$D0D4,$76FC,$D138,$7723,$D19B,$774B
	dc.w	$D1FF,$7772,$D242,$778C,$D2A6,$77B1,$D30B,$77D7
	dc.w	$D36F,$77FC,$D3D4,$7822,$D417,$783B,$D47C,$785F
	dc.w	$D4E1,$7883,$D546,$78A7,$D5AB,$78CB,$D5EE,$78E2
	dc.w	$D653,$7906,$D6B9,$7928,$D71F,$794A,$D784,$796C
	dc.w	$D7EA,$798E,$D82E,$79A5,$D894,$79C6,$D8FA,$79E7
	dc.w	$D960,$7A07,$D9C7,$7A27,$DA0B,$7A3D,$DA71,$7A5D
	dc.w	$DAD8,$7A7C,$DB3E,$7A9A,$DBA5,$7AB9,$DBEA,$7ACD
	dc.w	$DC51,$7AEC,$DCB7,$7B0A,$DD1F,$7B27,$DD86,$7B43
	dc.w	$DDED,$7B60,$DE32,$7B73,$DE9A,$7B90,$DF01,$7BAC
	dc.w	$DF69,$7BC7,$DFD1,$7BE2,$E016,$7BF3,$E07E,$7C0E
	dc.w	$E0E6,$7C29,$E14E,$7C43,$E1B6,$7C5C,$E1FC,$7C6D
	dc.w	$E264,$7C86,$E2CC,$7C9F,$E334,$7CB8,$E39D,$7CCF
	dc.w	$E406,$7CE6,$E44B,$7CF6,$E4B4,$7D0D,$E51D,$7D24
	dc.w	$E586,$7D3B,$E5EF,$7D50,$E635,$7D5E,$E69E,$7D74
	dc.w	$E707,$7D89,$E770,$7D9E,$E7D9,$7DB2,$E820,$7DBF
	dc.w	$E889,$7DD3,$E8F3,$7DE7,$E95C,$7DFA,$E9C5,$7E0E
	dc.w	$EA2F,$7E1F,$EA76,$7E2B,$EADF,$7E3D,$EB49,$7E4F
	dc.w	$EBB3,$7E60,$EC1D,$7E71,$EC64,$7E7C,$ECCE,$7E8C
	dc.w	$ED38,$7E9C,$EDA2,$7EAB,$EE0C,$7EBB,$EE53,$7EC5
	dc.w	$EEBD,$7ED3,$EF27,$7EE1,$EF91,$7EEF,$EFFC,$7EFD
	dc.w	$F066,$7F0B,$F0AD,$7F13,$F118,$7F1F,$F182,$7F2C
	dc.w	$F1ED,$7F38,$F257,$7F44,$F29E,$7F4C,$F309,$7F56
	dc.w	$F374,$7F61,$F3DF,$7F6B,$F449,$7F75,$F490,$7F7C
	dc.w	$F4FB,$7F86,$F566,$7F8E,$F5D1,$7F96,$F63C,$7F9F
	dc.w	$F6A7,$7FA7,$F6EE,$7FAD,$F759,$7FB4,$F7C4,$7FBB
	dc.w	$F82F,$7FC1,$F89A,$7FC8,$F8E2,$7FCC,$F94D,$7FD3
	dc.w	$F9B8,$7FD7,$FA23,$7FDC,$FA8E,$7FE1,$FAD5,$7FE4
	dc.w	$FB40,$7FE8,$FBAC,$7FEC,$FC17,$7FEF,$FC82,$7FF2
	dc.w	$FCED,$7FF5,$FD35,$7FF7,$FDA0,$7FFA,$FE0B,$7FFB
	dc.w	$FE76,$7FFC,$FEE2,$7FFD,$FF29,$7FFE,$FF94,$7FFF