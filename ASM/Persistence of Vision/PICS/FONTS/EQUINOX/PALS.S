* palettes for equinox font

pal_1	dc.w	$000,$302,$413,$524,$635,$746,$757,$767
	dc.w	$000,$000,$000,$000,$000,$000,$000,$777

pal_2	dc.w	$000,$011,$022,$033,$044,$055,$066,$077
	dc.w	$000,$000,$000,$000,$000,$000,$000,$777

pal_3	dc.w	$000,$112,$223,$334,$445,$556,$667,$777
	dc.w	$000,$000,$000,$000,$000,$000,$000,$777

pal_4	dc.w	$000,$002,$750,$112,$224,$335,$446,$557
	dc.w	$667,$777,$200,$300,$400,$500,$600,$700

