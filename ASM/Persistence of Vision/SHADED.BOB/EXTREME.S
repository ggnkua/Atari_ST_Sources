*/ extreme bob code /*

	clr.l	-(a7)		;set super
	move.w	#$20,-(a7)
	trap	#1
	adda.l	#6,a7
	move.l	d0,$1D1B72

	clr.w	-(a7)		;low rez
	move.l	#$78000,-(a7)
	move.l	#$78000,-(a7)
	move.w	#5,-(a7)
	trap	#14
	adda.l	#$C,a7

	move.l	$70,$1D1B76	;stash old VBL

	movea.l	#$1D89A6,a0	;stash old pal
	movea.l	#$FF8240,a1
	move.l	(a0)+,(a1)+
	move.l	(a0)+,(a1)+
	move.l	(a0)+,(a1)+
	move.l	(a0)+,(a1)+
	move.l	(a0)+,(a1)+
	move.l	(a0)+,(a1)+
	move.l	(a0)+,(a1)+
	move.l	(a0)+,(a1)+

	move.w	#$2700,sr
	move.l	#l190C84,$70	;new VBL
	jsr	l19149E

	move.w	#$2300,sr
	movea.l	#$1D1B86,a0
	movea.l	#$1D2B86,a1
	move.w	#$3FF,d0
l190A64	addi.l	#$1D3B86,(a0)+
	addi.l	#$1D5B86,(a1)+
	dbf	d0,l190A64

	movea.l	#$1D6B86,a0
	movea.l	#$78000,a1
	move.l	#$77F,d0
l190A86	move.l	(a0)+,(a1)+
	dbf	d0,l190A86

	movea.l	#$1D89A6,a0
	move.w	#7,d1
l190A96	movea.l	#$FF8240,a1
	move.w	#$F,d0
l190AA0	move.w	(a0)+,(a1)+
	dbf	d0,l190AA0

	move.w	#2,d0
l190AAA	cmpi.l	#0,$1D1B7A
	beq.s	l190AAA
	move.l	#0,$1D1B7A
	dbf	d0,l190AAA
	dbf	d1,l190A96

l190AC8	movea.l	#$1D8AA6,a0
	move.l	$1D8986,d0
	move.l	d0,d1
	addi.l	#$34,d0
	cmp.l	#$23C,d0
	bne	l190AEC
	move.l	#$34,d0
l190AEC	move.l	d0,$1D8986
	adda.l	d1,a0
	movem.l	(a0),d0-d4/a2-a4
	movea.l	#$FF8240,a1
	movem.l	d0-d4/a2-a4,(a1)
	adda.l	#$20,a0
	move.l	(a0)+,d0
	move.l	(a0)+,d1
	move.l	d0,$1D898A
	move.l	d1,$1D8992
	lsl.l	#6,d0
	lsl.l	#6,d1
	move.l	d0,$1D899A
	move.l	d1,$1D899E
	move.l	(a0)+,$1D898E
	move.l	(a0)+,$1D8996
	move.l	(a0)+,d4
	move.l	#0,$1D1B7E
	move.l	#0,$1D1B82

	move.l	#$3F,d2
l190B50	cmpi.l	#0,$1D1B7A
	beq	l190B50
	move.l	#0,$1D1B7A
	bsr	l190C90
	cmpi.b	#$39,$FFFC02
	beq	l190C46
	dbf	d2,l190B50

l190B7C	bsr	l190C90
	bsr	l1910E4
	cmpi.b	#$39,$FFFC02
	beq	l190C46
	dbf	d4,l190B7C

	move.l	#$3F,d2
l190B9A	cmpi.l	#0,$1D1B7A
	beq	l190B9A
	move.l	#0,$1D1B7A
	move.l	$1D1B7E,d0
	add.l	$1D898A,d0
	andi.l	#$FFF,d0
	move.l	d0,$1D1B7E
	move.l	$1D1B82,d0
	add.l	$1D8992,d0
	andi.l	#$FFF,d0
	move.l	d0,$1D1B82
	bsr	l1910E4
	cmpi.b	#$39,$FFFC02
	beq.s	l190C46
	dbf	d2,l190B9A
	movea.l	#$1D8AA6,a0
	move.w	#7,d1
l190BFE	movea.l	#$FF8260,a1
	move.w	#$F,d0
l190C08	move.w	-(a0),-(a1)
	dbf	d0,l190C08
	move.w	#2,d0
l190C12	cmpi.l	#0,$1D1B7A
	beq.s	l190C12
	move.l	#0,$1D1B7A
	dbf	d0,l190C12
	dbf	d1,l190BFE
	movea.l	#$78000,a0
	clr.l	d0
	move.w	#$77F,d1
l190C3C	move.l	d0,(a0)+
	dbf	d1,l190C3C
	bra	l190AC8
l190C46	jsr	l191532
	move.w	#$2700,sr
	move.w	#$777,$FF8240
	move.w	#0,$FF8246
	move.l	$1D1B76,$70
	move.w	#$2300,sr
	move.l	$1D1B72,-(a7)
	move.w	#$20,-(a7)
	trap	#1
	adda.l	#6,a7
	clr.w	-(a7)
	trap	#1
l190C84	move.l	#1,$1D1B7A
	rte
do_bobs
l190C90	movea.l	#$78000,a0	;scr_now
	move.l	$1D1B7E,d0	;sine table?
	add.l	$1D898A,d0	;sine table offset?
	andi.l	#$FFF,d0	;mask
	move.l	d0,$1D1B7E	;put back sine table offset?

	movea.l	#$1D1B86,a1	;table of some kinf
	movea.l	0(a1,d0.w),a1	;offset into table (offset set above)
	move.l	$1D1B82,d0	;some position
	add.l	$1D8992,d0	;offset
	andi.l	#$FFF,d0	;mask off to stop going past end of table
	move.l	d0,$1D1B82	;put back position

	movea.l	#$1D2B86,a2
	movea.l	0(a2,d0.w),a2
	move.l	#9,d3
l190CE0	movea.l	a0,a3		;move scr_now into A3
	move.w	(a1)+,d0
	add.w	(a2)+,d0
	adda.l	d0,a3
	movea.l	#$1D8CE2,a4
	move.w	(a1)+,d0
	adda.l	d0,a4
	adda.l	$1D898E,a1
	adda.l	$1D8996,a2

	rept	2
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	not.w	d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	endr
	adda.l	#$90,a3

	rept	2
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	not.w	d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	endr

	adda.l	#$90,a3

	rept	2
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	not.w	d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	endr

	adda.l	#$90,a3

	rept	2
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	not.w	d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	endr

	adda.l	#$90,a3

	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	not.w	d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	not.w	d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	adda.l	#$90,a3
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	not.w	d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	not.w	d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	adda.l	#$90,a3
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	not.w	d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	not.w	d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	adda.l	#$90,a3
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	not.w	d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	not.w	d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	adda.l	#$90,a3
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	not.w	d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	not.w	d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	adda.l	#$90,a3
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	not.w	d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	not.w	d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	adda.l	#$90,a3
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	not.w	d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	not.w	d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	adda.l	#$90,a3
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	not.w	d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	not.w	d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	adda.l	#$90,a3
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	not.w	d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	not.w	d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	adda.l	#$90,a3
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	not.w	d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	not.w	d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	adda.l	#$90,a3
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	not.w	d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	not.w	d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	adda.l	#$90,a3
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	not.w	d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	not.w	d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	not.w	d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	adda.l	#$90,a3
	dbf	d3,l190CE0
	rts

l1910E4	movea.l	#$78000,a0
	move.l	$1D1B7E,d0
	sub.l	$1D899A,d0
	andi.l	#$FFF,d0
	movea.l	#$1D1B86,a1
	movea.l	0(a1,d0.w),a1
	move.l	$1D1B82,d0
	sub.l	$1D899E,d0
	andi.l	#$FFF,d0
	movea.l	#$1D2B86,a2
	movea.l	0(a2,d0.w),a2
	move.l	#9,d3
l191128	movea.l	a0,a3
	move.w	(a1)+,d0
	add.w	(a2)+,d0
	adda.l	d0,a3
	movea.l	#$1D8CE2,a4
	move.w	(a1)+,d0
	adda.l	d0,a4
	adda.l	$1D898E,a1
	adda.l	$1D8996,a2
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	adda.l	#$90,a3
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	adda.l	#$90,a3
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	adda.l	#$90,a3
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	adda.l	#$90,a3
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	adda.l	#$90,a3
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	adda.l	#$90,a3
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	adda.l	#$90,a3
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	adda.l	#$90,a3
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	adda.l	#$90,a3
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	adda.l	#$90,a3
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	adda.l	#$90,a3
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	adda.l	#$90,a3
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	adda.l	#$90,a3
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	adda.l	#$90,a3
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	adda.l	#$90,a3
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	move.w	(a4)+,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)
	move.w	(a3)+,d0
	and.w	d1,d0
	eor.w	d0,(a3)
	move.w	(a3)+,d1
	and.w	d0,d1
	eor.w	d1,(a3)+
	adda.l	#$90,a3
	dbf	d3,l191128
	rts
	clr.l	-(a7)
	move.w	#$20,-(a7)
	trap	#1
	addq.w	#6,a7
	move.l	d0,-(a7)
	bsr.s	l19149E
l19147A	btst	#0,$FFFFFC00.w
	beq.s	l19147A
	cmpi.b	#$B9,$FFFFFC02.w
	bne.s	l19147A
	bsr	l191532
	move.w	#$20,-(a7)
	trap	#1
	addq.w	#6,a7
	pea	$4C0000
	trap	#1
l19149E	bsr	l19159A
	bsr	$1956BE
	bsr	l191572
	jsr	$19AD1A
	jsr	$19AC76
	move.w	#$2700,sr
	move.l	$FFFFFA06.w,l191560
	move.l	$FFFFFA12.w,l191564
	move.b	$FFFFFA1D.w,l191568
	move.l	#$FF20FF10,$FFFFFA06.w
	move.l	#$FF20FF10,$FFFFFA12.w
	bclr	#3,$FFFFFA17.w
	clr.b	$FFFFFA19.w
	clr.b	$FFFFFA1D.w
	move.b	#$14,$FFFFFA1F.w
	move.b	#$52,$FFFFFA25.w
	move.b	#2,$FFFFFA19.w
	move.b	#6,$FFFFFA1D.w
	move.l	$110.w,l19156A
	move.l	$134.w,l19156E
	move.l	#$19656E,$110.w
	move.l	#$196C64,$134.w
	lea	$196BC0(pc),a6
	move.w	#$2500,sr
	rts
l191532	move.w	#$2700,sr
	move.l	l19156A(pc),$110.w
	move.l	l19156E(pc),$134.w
	move.l	l191560(pc),$FFFFFA06.w
	move.l	l191564(pc),$FFFFFA12.w
	move.b	l191568(pc),$FFFFFA1D.w
	bset	#3,$FFFFFA17.w
	move.w	#$2300,sr
	rts
l191560	ori.b	#0,d0
l191564	ori.b	#0,d0
l191568	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#$FC,d0
	move.l	d0,-(a3)
	moveq	#$A,d0
l191578	move.b	d0,$FFFF8800.w
	clr.b	$FFFF8802.w
	dbf	d0,l191578
	clr.b	$FFFF8800.w
	clr.b	$FFFF8802.w
	move.b	#7,$FFFF8800.w
	move.b	#$FF,$FFFF8802.w
	rts
l19159A	moveq	#$40,d0
	lea	$1956BE(pc),a0
l1915A0	move.w	#$FF,d1
l1915A4	move.w	d1,d2
	ext.w	d2
	muls.w	d0,d2
	divs.w	#$60,d2
	addi.b	#$80,d2
	move.b	d2,-(a0)
	dbf	d1,l1915A4
	dbf	d0,l1915A0
	rts
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
	ori.b	#0,d0
