----------------------------------------
  WELCOME TO PERSISTENCE OF VISION 125
----------------------------------------

		CREDITS:

	     MENU CODED BY:

	      MAC SYS DATA


		ART BY:

	      OZYMANDIAS


	       MUSIC BY:

	       BIG ALEC^----------------------------------------
	      1: BEACHTRO

  2: TECH ANARCHY DEMO (4 SUB DEMOS)

	3: CHRONICLE MUSIC DEMO

  4: MEDWAY BOYS STAR TREK SLIDESHOW

	      5: KGB INTRO

    6: POMPEY PIRATES GAMEBOY EMULATOR

	    7: SIGMA 5 INTRO

	      8: INFO 125...

	      9: COPIER
----------------------------------------^



----------------------------------------
THE ANARCHY DEMO HAS 4 SCREENS TO IT BUT
 YOU CAN RUN THE SEPERATE SCREENS FROM
THIS MENU BY PRESSING THE FUNCTION KEYS
		F1 - F4.
	('COS I'M KIND TO YOU!)
----------------------------------------
^



----------------------------------------
	      CONTACT US AT:

	  PERSISTENCE OF VISION
		P.O. BOX 40
	    THORNTON-CLEVELEYS
		LANCASHIRE
		 FY5 3PH
		 ENGLAND

----------------------------------------^
