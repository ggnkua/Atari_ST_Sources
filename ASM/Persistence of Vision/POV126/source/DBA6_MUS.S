music	CMPI.B	#3,L001C
	BNE	L00DD
	MOVE.B	#$E,$ffff8800.W
	MOVE.B	$ffff8800.W,D0
	BSET	#6,D0
	MOVE.B	D0,$FFFF8802.W
L00DD	MOVEA.L	L019B,A0
	LEA	516(A0),A0
	MOVE.L	A0,L0128
	MOVEA.L	L019A,A0	;get song data address
	ADDQ.L	#4,A0
	MOVE.L	A0,L00EC
	MOVE.L	A0,L012D
	ADDQ.L	#2,A0
	MOVE.L	A0,L014A
	ADDQ.L	#2,A0
	MOVE.L	A0,L0148
	ADDQ.L	#2,A0
	MOVE.L	A0,L00E2
	ADDQ.L	#2,A0
	MOVE.L	A0,L014D
	LEA	120(A0),A0		;patterns
	MOVE.L	A0,L00E4
	MOVE.L	A0,L00E7
	MOVE.L	A0,L00E9
	BSR	L00E1 
	CLR.W	L0240 
	CLR.B	L0150 
	BSR	L014C 
	MOVE	SR,-(A7)
	MOVE	#$2700,SR 
	BSR.S	L00DE 
	MOVE.L	#L014E,$110.W 
	ANDI.B	#$F0,$FFFFFA1D.W
	ORI.B	#1,$FFFFFA1D.W
	CLR.B	$FFFFFA25.W 
	BCLR	#3,$fffffa17.W
	BSET	#4,$FFFFFA15.W
	BCLR	#4,$FFFFFA09.W
	MOVE	(A7)+,SR
	rts
	MOVE	SR,-(A7)
	MOVE	#$2700,SR 
	BCLR	#4,$FFFFFA09.W
	BCLR	#4,$FFFFFA0D.W
	BCLR	#4,$FFFFFA11.W
	BSET	#3,$fffffa17.W
	BSR.S	L00DE 
	MOVE	(A7)+,SR
	rts
L00DE:
	MOVE	SR,-(A7)
	MOVE	#$2700,SR 
	BCLR	#4,$FFFFFA09.W
	BSET	#0,L023A
	BCLR	#1,L023A
	BSET	#0,L0222
	BSET	#0,L022E
	ST	L0239 
	ST	L0221 
	ST	L022D 
	LEA	$ffff8800.W,A0
	LEA	L00E0(PC),A1
	MOVEQ	#$C,D1
L00DF	MOVE.W	(A1)+,D0
	MOVEP.W	D0,0(A0)
	DBF	D1,L00DF
	MOVE.B	#7,(A0) 
	MOVE.B	(A0),D0 
	ANDI.B	#$C0,D0 
	OR.B	#$3F,D0 
	MOVE.B	D0,2(A0)
	MOVE	(A7)+,SR
	rts
L00E0:
	DC.B	$00,$00,$01,$00,$02,$00,$03,$00 
	DC.B	$04,$00,$05,$00,$06,$00,$08,$00 
	DC.B	$09,$00,$0A,$00,$0B,$00,$0C,$00 
	DC.B	$0D,$00 

L00E1	DC.B	'3',$FC,$00,$01
L00E2	DC.L	L00E1
	DC.B	'0<',$00,$1F
L00E3	DC.B	'A',$F9
L00E4	DC.L	L00E3
	LEA	L023E,A1
L00E5	MOVE.L	A0,(A1)+
	ADDA.L	#$300,A0
	DBF	D0,L00E5
	MOVE.W	#1,L023B
L00E6	MOVE.L	#L00E6,L0241
L00E7	EQU	*-8
L00E8	MOVE.L	#L00E8,L023F
L00E9	EQU	*-8
	CLR.B	L0238
	MOVE.L	#L0242,L0230
	MOVE.W	#2,L0231
	MOVE.W	#5,L0232
	MOVE.W	#9,L0233
	MOVE.L	#L0242,L0234
	MOVE.W	#2,L0235
	MOVE.W	#5,L0236
	MOVE.W	#9,L0237
	CLR.B	L0220 
	MOVE.L	#L0242,L0218
	MOVE.W	#2,L0219
	MOVE.W	#5,L021A
	MOVE.W	#9,L021B
	MOVE.L	#L0242,L021C
	MOVE.W	#2,L021D
	MOVE.W	#5,L021E
	MOVE.W	#9,L021F
	CLR.B	L022C 
	MOVE.L	#L0242,L0224
	MOVE.W	#2,L0225
	MOVE.W	#5,L0226
	MOVE.W	#9,L0227
	MOVE.L	#L0242,L0228
	MOVE.W	#2,L0229
	MOVE.W	#5,L022A
	MOVE.W	#9,L022B
	rts

L00EA:
	ADDQ.W	#1,L0244
	SUBQ.W	#1,L023B
	BNE.S	L00EE 
L00EB:
	MOVE.W	L00EB,L023B 
L00EC EQU	*-8 
	MOVEA.L	L023F,A1
	MOVE.W	L0240,D0
	MOVE.W	D0,D1 
	LSL.W	#3,D0 
	ADD.W	D1,D1 
	ADD.W	D1,D1 
	ADD.W	D1,D0 
	ADDA.W	D0,A1 
	MOVE.L	A1,L0241
	ADDQ.W	#1,L0240
	CMPI.W	#$40,L0240
	BNE.S	L00ED 
	BSR	L0146 
L00ED:
	LEA	L022F,A0
	BSR	L0123 
	LEA	L0217,A0
	BSR	L0123 
	LEA	L0223,A0
	BSR	L0123 
L00EE:
	LEA	$ffff8800.W,A5
	LEA	L0217,A0
	BSR	L010D 
	BSR	L00F9 
	BSR	L00FF 
	LEA	L0223,A0
	BSR	L010D 
	BSR	L00F9 
	BSR	L00FF 
	LEA	L022F,A0
	BSR	L010D 
	BSR	L00F9 
	BSR	L00FF 
	MOVE	#$2700,SR 
	LEA	L0217,A0
	TST.B	58(A0)
	BNE.S	L00F1 
	CMPI.B	#3,63(A0) 
	BNE.S	L00F1 
	LEA	L010C,A6
	MOVE.W	0(A0),D1
L00EF:
	TST.W	(A6)
	BMI.S	L00F1 
	CMP.W	(A6)+,D1
	BLT.S	L00F0 
	ADDQ.L	#4,A6 
	BRA.S	L00EF 
L00F0:
	MOVE.W	(A6)+,D2
	MOVE.W	(A6)+,D3
	MOVE.L	#$1900000,D0
	MULU	#$A3,D2 
	DIVU	D2,D0 
	MULU	D1,D0 
	ADD.L	#$2000,D0 
	LSL.L	#2,D0 
	SWAP	D0
	MOVE.B	14(A0),L0150
	MOVE.B	D0,$FFFFFA25.W
	MOVE.B	D3,$FFFFFA1D.W
	BSET	#4,$FFFFFA09.W
	BRA.S	L00F2 
L00F1:
	BCLR	#4,$FFFFFA09.W
	CMPI.B	#3,63(A0) 
	BNE.S	L00F2 
	BCLR	#0,44(A0) 
L00F2:
	MOVE	#$2300,SR 
	MOVE.B	#$FF,D0 
	LEA	L0223,A0
	MOVEQ	#2,D6 
	MOVEQ	#5,D7 
	BSR	L0103 
	LEA	L0217,A0
	MOVEQ	#1,D6 
	MOVEQ	#4,D7 
	BSR	L0103 
	LEA	L022F,A0
	BTST	#1,58(A0) 
	BNE.S	L00F3 
	MOVEQ	#0,D6 
	MOVEQ	#3,D7 
	BSR	L0103 
L00F3:
	MOVE.W	#$700,D7
	MOVE.B	D0,D7 
	MOVEP.W	D7,0(A5)
	LEA	$ffff8800.W,A1
	LEA	$FFFF8802.W,A2
	LEA	L022F,A0
	BTST	#1,58(A0) 
	BNE.S	L00F5 
	MOVE.W	0(A0),D0
	MOVE.B	0(A0),D1
	MOVEQ	#0,D7 
	MOVE.B	D0,D7 
	MOVEP.W	D7,0(A5)
	MOVE.W	#$100,D7
	MOVE.B	D1,D7 
	MOVEP.W	D7,0(A5)
	TST.B	58(A0)
	BNE.S	L00F4 
	TST.B	80(A0)
	BEQ.S	L00F4 
	BTST	#2,44(A0) 
	BEQ.S	L00F4 
	BTST	#3,44(A0) 
	BEQ.S	L00F4 
	LSR.W	#4,D0 
	MOVE.W	#$B00,D7
	MOVE.B	D0,D7 
	MOVEP.W	D7,0(A5)
	MOVE.W	#$C00,D7
	MOVEP.W	D7,0(A5)
L00F4:
	MOVE.W	#$800,D7
	MOVE.B	14(A0),D7 
	MOVEP.W	D7,0(A5)
L00F5:
	LEA	L0217,A0
	MOVE.W	0(A0),D0
	MOVE.B	0(A0),D1
	MOVE.W	#$200,D7
	MOVE.B	D0,D7 
	MOVEP.W	D7,0(A5)
	MOVE.W	#$300,D7
	MOVE.B	D1,D7 
	MOVEP.W	D7,0(A5)
	TST.B	58(A0)
	BNE.S	L00F6 
	TST.B	80(A0)
	BEQ.S	L00F6 
	BTST	#2,44(A0) 
	BEQ.S	L00F6 
	BTST	#3,44(A0) 
	BEQ.S	L00F6 
	LSR.W	#4,D0 
	MOVE.W	#$B00,D7
	MOVE.B	D0,D7 
	MOVEP.W	D7,0(A5)
	MOVE.W	#$C00,D7
	MOVEP.W	D7,0(A5)
L00F6:
	CMPI.B	#3,63(A0) 
	BEQ.S	L00F7 
	MOVE.W	#$900,D7
	MOVE.B	14(A0),D7 
	MOVEP.W	D7,0(A5)
L00F7:
	LEA	L0223,A0
	MOVE.W	0(A0),D0
	MOVE.B	0(A0),D1
	MOVE.W	#$400,D7
	MOVE.B	D0,D7 
	MOVEP.W	D7,0(A5)
	MOVE.W	#$500,D7
	MOVE.B	D1,D7 
	MOVEP.W	D7,0(A5)
	TST.B	58(A0)
	BNE.S	L00F8 
	TST.B	80(A0)
	BEQ.S	L00F8 
	BTST	#2,44(A0) 
	BEQ.S	L00F8 
	BTST	#3,44(A0) 
	BEQ.S	L00F8 
	LSR.W	#4,D0 
	MOVE.W	#$B00,D7
	MOVE.B	D0,D7 
	MOVEP.W	D7,0(A5)
	MOVE.W	#$C00,D7
	MOVEP.W	D7,0(A5)
L00F8:
	MOVE.W	#$A00,D7
	MOVE.B	14(A0),D7 
	MOVEP.W	D7,0(A5)
	rts
L00F9:
	TST.B	61(A0)
	BEQ.S	L00FB 
	MOVEA.L	68(A0),A6 
	MOVEQ	#0,D1 
	MOVE.B	(A6)+,D1
	CMP.B	#$FF,D1 
	BNE.S	L00FA 
	MOVEQ	#0,D1 
	CMP.B	#$FE,D1 
	BNE.S	L00FA 
	SUBQ.L	#1,A6 
	MOVE.B	-1(A6),D1 
L00FA:
	MOVE.L	A6,68(A0) 
	MULU	#3,D1 
	MOVE.B	L00FC(PC,D1.W),78(A0) 
	MOVE.B	L00FD(PC,D1.W),79(A0) 
	MOVE.B	L00FE(PC,D1.W),80(A0) 
	rts
L00FB:
	MOVE.B	#1,78(A0) 
	MOVE.B	#1,79(A0) 
	MOVE.B	#1,80(A0) 
	rts
L00FC:
	DC.B	$00 
L00FD:
	DC.B	$00 
L00FE:
	DC.B	$00,$01,$00,$00,$00,$01,$00,$01 
	DC.B	$01,$00,$00,$00,$01,$01,$00,$01 
	DC.B	$00,$01,$01,$01,$01,$01 
L00FF:
	TST.B	62(A0)
	BEQ.S	L0102 
	MOVEA.L	72(A0),A6 
	MOVE.B	(A6)+,D1
	CMP.B	#$FF,D1 
	BEQ.S	L0101 
	CMP.B	#$FE,D1 
	BNE.S	L0100 
	SUBQ.B	#1,D1 
	MOVE.B	-1(A6),D1 
L0100:
	MOVE.L	A6,72(A0) 
	TST.B	D1
	BNE.S	L0102 
L0101:
	BCLR	#2,44(A0) 
L0102:
	rts
L0103:
	BTST	#0,44(A0) 
	BEQ.S	L0105 
	TST.B	61(A0)
	BNE.S	L0104 
	TST.B	79(A0)
	BEQ.S	L0105 
L0104:
	BCLR	D6,D0 
L0105:
	BTST	#1,44(A0) 
	BEQ.S	L0109 
	TST.B	60(A0)
	BNE.S	L0106 
	MOVE.W	#$600,D5
	MOVE.B	43(A0),D5 
	MOVEP.W	D5,0(A5)
	BRA.S	L0108 
L0106:
	MOVEA.L	64(A0),A6 
	MOVE.B	(A6)+,D1
	CMP.B	#$FF,D1 
	BEQ.S	L0109 
	CMP.B	#$FE,D1 
	BNE.S	L0107 
	SUBQ.L	#1,A6 
	MOVE.B	-1(A6),D1 
L0107:
	MOVE.L	A6,64(A0) 
	MOVE.W	#$600,D5
	MOVE.B	D1,D5 
	MOVEP.W	D5,0(A5)
	TST.B	78(A0)
	BEQ.S	L0109 
L0108:
	BCLR	D7,D0 
L0109:
	rts
L010A	DC.B	$00,$00
L010B:
	DC.B	$00,$00
L010C:
	DC.B	$00,'h',$00,$04,$00,$01,$01,$05 
	DC.B	$00,$0A,$00,$02,$01,$A2,$00,$10 
	DC.B	$00,$03,$05,$1A,$00,'2',$00,$04 
	DC.B	$06,$88,$00,'@',$00,$05,$0A,'5'
	DC.B	$00,'d',$00,$06,$0E,$EF,$00,$C8 
	DC.B	$00,$07,$FF,$FF 
L010D:
	TST.B	58(A0)
	BNE	L0120 
	BTST	#2,44(A0) 
	BEQ.S	L010E 
	MOVE.B	#$10,14(A0) 
	BRA.S	L0111 
L010E:
	MOVE.W	20(A0),D0 
	MOVEA.L	16(A0),A2 
	MOVE.B	0(A2,D0.W),D1 
	MOVE.B	15(A0),D2 
	ASL.B	#4,D2 
	ADD.B	D1,D2 
	ANDI.W	#$FF,D2 
	LEA	VOLS,A2
	MOVE.B	0(A2,D2.W),14(A0) 
	ADDQ.W	#1,D0 
	CMP.W	24(A0),D0 
	BNE.S	L010F 
	MOVE.W	22(A0),D0 
L010F:
	CMP.W	26(A0),D0 
	BCS.S	L0110 
	BSET	#0,58(A0) 
L0110:
	MOVE.W	D0,20(A0) 
L0111:
	MOVE.W	6(A0),D0
	BEQ.S	L0115 
	BMI.S	L0113 
	ADD.W	4(A0),D0
	CMP.W	2(A0),D0
	BLT.S	L0112 
	CLR.W	6(A0) 
	MOVE.W	2(A0),D0
L0112:
	MOVE.W	D0,4(A0)
	BRA.S	L0115 
L0113:
	ADD.W	4(A0),D0
	CMP.W	2(A0),D0
	BGT.S	L0114 
	CLR.W	6(A0) 
	MOVE.W	2(A0),D0
L0114:
	MOVE.W	D0,4(A0)
L0115:
	MOVE.W	8(A0),D1
	ADD.W	10(A0),D1 
	CMPI.W	#$3B,D1 
	BLS.S	L0116 
	CLR.W	D1
L0116:
	MOVE.W	D1,8(A0)
	ASL.W	#1,D1 
	LEA	TREM_TAB,A2
	MOVE.W	0(A2,D1.W),D1 
	MOVE.W	12(A0),D2 
	ASR.W	D2,D1 
	ADD.W	4(A0),D1
	CMPI.B	#1,63(A0) 
	BNE.S	L0117 
	LEA	L0121,A1
	MOVE.B	76(A0),D7 
	EXT.W	D7
	MOVE.B	0(A1,D7.W),56(A0) 
	ADDQ.B	#1,76(A0) 
	CMPI.B	#1,76(A0) 
	BLT.S	L0117 
	MOVE.B	#1,76(A0) 
L0117:
	CMPI.B	#2,63(A0) 
	BNE.S	L0118 
	LEA	L0122,A1
	MOVE.B	77(A0),D7 
	EXT.W	D7
	MOVE.B	0(A1,D7.W),56(A0) 
	ADDQ.B	#2,77(A0) 
	CMPI.B	#$C,77(A0)
	BLT.S	L0118 
	CLR.B	77(A0)
L0118:
	MOVE.B	56(A0),D0 
	BEQ.S	L011A 
	CMPI.B	#1,D0 
	BEQ.S	L0119 
	ADD.W	54(A0),D1 
	CLR.B	56(A0)
	BRA.S	L011B 
L0119:
	ADD.W	52(A0),D1 
L011A:
	ADDI.B	#1,56(A0) 
L011B:
	TST.B	40(A0)
	BEQ.S	L011F 
	MOVE.W	32(A0),D0 
	MOVEA.L	28(A0),A2 
	MOVE.B	0(A2,D0.W),D2 
	EXT.W	D2
	TST.B	60(A0)
	BEQ.S	L011C 
	ADD.W	D2,D1 
	ADD.W	D2,D1 
	ADD.W	D2,D1 
L011C:
	ADD.W	D2,D1 
	ADDQ.W	#1,D0 
	CMP.W	36(A0),D0 
	BNE.S	L011D 
	MOVE.W	34(A0),D0 
L011D:
	CMP.W	38(A0),D0 
	BCS.S	L011E 
	CLR.B	40(A0)
L011E:
	MOVE.W	D0,32(A0) 
L011F:
	MOVE.W	D1,0(A0)
	rts
L0120:
	CLR.B	14(A0)
	rts
L0121:
	DC.B	$01,$00 
L0122:
	DC.B	$00,$00,$01,$01,$02,$02 
L0123:
	TST.B	(A1)
	BEQ	L0130 
	BMI	L0140 
	MOVE.B	2(A1),D1
	CMP.B	#$3F,D1 
	BHI	L012B 
	MOVE.B	D1,57(A0) 
	CLR.B	56(A0)
	CLR.B	76(A0)
	CLR.B	77(A0)
	LEA	L0151,A6
	CLR.W	D0
	MOVE.B	57(A0),D0 
	ADD.W	D0,D0 
	ADD.W	D0,D0 
	MOVE.L	0(A6,D0.W),D0 
	MOVE.L	D0,60(A0) 
	LSR.L	#8,D0 
	TST.B	D0
	BEQ.S	L0124 
	LEA	L0154,A6
	CLR.W	D1
	MOVE.B	D0,D1 
	SUBQ.B	#1,D1 
	ADD.W	D1,D1 
	ADD.W	D1,D1 
	MOVE.L	0(A6,D1.W),72(A0) 
L0124:
	LSR.L	#8,D0 
	TST.B	D0
	BEQ.S	L0125 
	LEA	L0153,A6
	CLR.W	D1
	MOVE.B	D0,D1 
	SUBQ.B	#1,D1 
	ADD.W	D1,D1 
	ADD.W	D1,D1 
	MOVE.L	0(A6,D1.W),68(A0) 
L0125:
	LSR.W	#8,D0 
	TST.B	D0
	BEQ.S	L0126 
	LEA	L0152,A6
	CLR.W	D1
	MOVE.B	D0,D1 
	SUBQ.W	#1,D1 
	ADD.W	D1,D1 
	ADD.W	D1,D1 
	MOVE.L	0(A6,D1.W),64(A0) 
L0126:
	MOVE.B	57(A0),D1 
	ANDI.W	#$3F,D1 
L0127:
	LEA	L0127,A2
L0128 EQU	*-4 
	ASL.W	#8,D1 
	ADDA.W	D1,A2 
	MOVE.W	0(A2),D0
	MOVE.W	D0,42(A0) 
	MOVE.B	2(A2),44(A0)
	MOVE.W	4(A2),46(A0)
	MOVE.B	3(A2),45(A0)
	MOVE.W	6(A2),10(A0)
	MOVE.W	8(A2),12(A0)
	MOVE.W	252(A2),48(A0)
	MOVE.W	254(A2),50(A0)
	CLR.W	20(A0)
	MOVE.W	10(A2),22(A0) 
	MOVE.W	12(A2),24(A0) 
	MOVE.W	14(A2),26(A0) 
	LEA	16(A2),A3 
	MOVE.L	A3,16(A0) 
	CLR.W	32(A0)
	MOVE.W	240(A2),34(A0)
	MOVE.W	242(A2),36(A0)
	MOVE.W	244(A2),38(A0)
	LEA	128(A2),A3
	MOVE.L	A3,28(A0) 
	ST	40(A0)
	MOVEQ	#0,D0 
	MOVE.B	(A1),D0 
	MOVE.W	D0,D1 
	LSR.W	#4,D1 
	CMPA.L	#L0217,A0
	BNE.S	L0129 
	MOVE.W	D1,L010B
L0129:
	LEA	NOTE_2_FREQ,A2
	ANDI.W	#$F,D0
	CMPA.L	#L0217,A0
	BNE.S	L012A 
	MOVE.W	D0,L010A
L012A:
	MOVE.W	D0,D2 
	ASL.W	#1,D2 
	MOVE.W	0(A2,D2.W),D2 
	LSR.W	D1,D2 
	MOVE.W	D2,2(A0)
	MOVE.W	D0,D3 
	ADD.W	48(A0),D3 
	ASL.W	#1,D3 
	MOVE.W	0(A2,D3.W),D3 
	LSR.W	D1,D3 
	SUB.W	D2,D3 
	MOVE.W	D3,52(A0) 
	ADD.W	50(A0),D0 
	ASL.W	#1,D0 
	MOVE.W	0(A2,D0.W),D0 
	LSR.W	D1,D0 
	SUB.W	D2,D0 
	MOVE.W	D0,54(A0) 
L012B:
	MOVE.B	1(A1),D1
	BEQ.S	L012E 
	SUB.W	4(A0),D2
	EXT.L	D2
	ANDI.L	#$FF,D1 
L012C:
	MULS	L012C,D1
L012D EQU	*-4 
	DIVS	D1,D2 
	BEQ.S	L012E 
	MOVE.W	D2,6(A0)
	BRA.S	L012F 
L012E:
	MOVE.W	2(A0),4(A0) 
	CLR.W	6(A0) 
L012F:
	MOVE.B	3(A1),D0
	ANDI.W	#$1F,D0 
	MOVE.B	D0,15(A0) 
L0130:
	ADDQ.L	#3,A1 
	MOVE.B	(A1)+,D1
	LSR.B	#6,D1 
	TST.B	D1
	BEQ.S	L0133 
	BTST	#2,44(A0) 
	BNE.S	L0134 
	CMPI.B	#1,D1 
	BEQ.S	L0132 
	CMPI.B	#2,D1 
	BEQ.S	L0131 
	MOVE.W	24(A0),20(A0) 
	MOVE.W	36(A0),32(A0) 
	BCLR	#0,58(A0) 
	ST	40(A0)
	rts
L0131:
	MOVE.W	22(A0),20(A0) 
	MOVE.W	34(A0),32(A0) 
	BCLR	#0,58(A0) 
	ST	40(A0)
	rts
L0132:
	CLR.W	20(A0)
	CLR.W	32(A0)
	CLR.W	8(A0) 
	BCLR	#0,58(A0) 
	ST	40(A0)
	BCLR	#1,58(A0) 
	NOP 
L0133:
	rts
L0134:
	TST.B	D1
	BEQ.S	L0139 
	CMPI.B	#2,D1 
	BEQ.S	L013A 
	CMPI.B	#3,D1 
	BEQ	L013F 
	MOVE	#$2700,SR 
	BTST	#3,44(A0) 
	BNE.S	L0135 
	MOVE.B	#$B,$ffff8800.W
	MOVE.B	47(A0),$FFFF8802.W
	MOVE.B	#$C,$ffff8800.W
	MOVE.B	46(A0),$FFFF8802.W
L0135:
	MOVE.B	#$D,$ffff8800.W 
	BTST	#0,45(A0) 
	BNE.S	L0136 
	MOVE.B	$ffff8800.W,D0
	CMP.B	45(A0),D0 
	BEQ.S	L0137 
L0136:
	MOVE.B	45(A0),$FFFF8802.W
L0137:
	CLR.W	8(A0) 
	CLR.W	32(A0)
	ST	40(A0)
	BCLR	#0,58(A0) 
	BCLR	#1,58(A0) 
	BEQ.S	L0138 
	BCLR	#4,$FFFFFA09.W
L0138:
	MOVE	#$2300,SR 
L0139:
	rts
L013A:
	MOVE	#$2700,SR 
	BTST	#3,44(A0) 
	BNE.S	L013B 
	MOVE.B	#$B,$ffff8800.W 
	MOVE.B	47(A0),$FFFF8802.W
	MOVE.B	#$C,$ffff8800.W 
	MOVE.B	46(A0),$FFFF8802.W
L013B:
	MOVE.B	#$D,$ffff8800.W 
	BTST	#0,45(A0) 
	BNE.S	L013C 
	MOVE.B	$ffff8800.W,D0
	CMP.B	45(A0),D0 
	BEQ.S	L013D 
L013C:
	MOVE.B	45(A0),$FFFF8802.W
L013D:
	CLR.W	8(A0) 
	MOVE.W	34(A0),32(A0) 
	ST	40(A0)
	BCLR	#0,58(A0) 
	BCLR	#1,58(A0) 
	BEQ.S	L013E 
	BCLR	#4,$FFFFFA09.W
L013E:
	MOVE	#$2300,SR 
	rts
L013F:
	BSET	#0,58(A0) 
	rts
L0140:
	BTST	#2,58(A0) 
	BNE.S	L0141 
	MOVE.B	2(A1),D0
	ANDI.W	#$F,D0
	LEA	L0243,A2
	ADD.W	D0,D0 
	ADD.W	D0,D0 
	MOVE	#$2700,SR 
	MOVE.L	0(A2,D0.W),L0143
	MOVE.B	1(A1),D0
	ANDI.W	#$F,D0
	LEA	HERTZ,A2
	MOVE.B	0(A2,D0.W),$FFFFFA25.W
	MOVE.B	#2,58(A0) 
	BSET	#4,$FFFFFA09.W
	MOVE	#$2300,SR 
L0141:
	ADDQ.L	#4,A1 
	rts
	MOVE.B	#8,$ffff8800.W
L0142:
	MOVE.B	L0142,$FFFF8802.W 
L0143 EQU	*-6 
L0144 EQU	*-4 
	BMI.S	L0145 
	ADDQ.W	#1,L0144
	RTE 
L0145:
	CLR.B	$FFFF8802.W 
	MOVE.B	#1,L023A
	BCLR	#4,$FFFFFA09.W
	RTE 
L0146:
	CLR.W	L0240 
	MOVE.W	L023C,D0
	ADDQ.W	#1,D0 
L0147:
	CMP.W	L0147,D0
L0148 EQU	*-4 
	BLS.S	L014B 
L0149:
	MOVE.W	L0149,D0
L014A EQU	*-4 
L014B:
	MOVE.W	D0,L023C
L014C:
	LEA	L014C,A0
L014D EQU	*-4 
	MOVE.W	L023C,D0
	MOVE.B	0(A0,D0.W),D0 
	ANDI.W	#$7F,D0 
	MOVE.W	D0,L023D
	LEA	L023E,A0
	ADD.W	D0,D0 
	ADD.W	D0,D0 
	MOVE.L	0(A0,D0.W),L023F
	rts
L014E	MOVE.L	#$9090000,$ffff8800.W
	MOVE.L	#L014F,$110.W
	RTE
L014F	MOVE.L	#$9090F00,$ffff8800.W
L0150	EQU	*-4
	MOVE.L	#L014E,$110.W
	RTE

L0151	DC.B	$01,$01,$00,$00,$02,$02,$00,$00 
	DC.B	$00,$00,$01,$00,$00,$00,$00,$03 
	DC.B	$00,$00,$00,$03,$00,$03,$00,$01 
	DC.B	$00,$00,$00,$01,$00,$00,$00,$02 
	DC.B	$00,$00,$00,$02,$00,$00,$00,$02 
	DC.B	$00,$00,$00,$02,$00,$00,$00,$01 
	DC.B	$00,$00,$00,$03,$00,$00,$00,$00 
	dcb.w	17,0
	DC.B	$00,$03,$00,$00,$00,$00,$00,$00 
	dcb.w	77,0
L0152:
	DC.L	L0155 
	DC.L	L0156 
	DC.L	L0157 
	DC.L	L0158 
L0153:
	DC.L	L0159 
	DC.L	L015A 
	DC.L	L015B 
	DC.L	L015C 
L0154:
	DC.L	L015D 
L0155:
	DC.B	$10,$FF 
L0156:
	DC.B	$0A,$11,$0F,$11,$0D,$0C,$08,$FF 
L0157:
	DC.B	$04,$FF 
L0158:
	DC.B	$03,$FF 
L0159:
	DC.B	$01,$02,$FE 
L015A:
	DC.B	$03,$02,$02,$02,$01,$01,$FE 
L015B:
	DC.B	$03,$02,$FE 
L015C:
	DC.B	$07,$04,$04,$04,$02,$02,$FF 
L015D:
	DC.B	$01,$01,$01,$FF 

L019A	DC.L	SONG 
L019B	DC.L	VOICE_SET 

VOLS	DC.B	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	DC.B	0,0,0,0,0,0,0,0,1,1,1,1,1,1,1,1
	DC.B	0,0,0,0,1,1,1,1,1,1,1,1,2,2,2,2
	DC.B	0,0,0,1,1,1,1,1,2,2,2,2,2,3,3,3
	DC.B	0,0,1,1,1,1,2,2,2,2,3,3,3,3,4,4
	DC.B	0,0,1,1,1,2,2,2,3,3,3,4,4,4,5,5
	DC.B	0,0,1,1,2,2,2,3,3,4,4,4,5,5,6,6
	DC.B	0,0,1,1,2,2,3,3,4,4,5,5,6,6,7,7
	DC.B	0,1,1,2,2,3,3,4,4,5,5,6,6,7,7,8
	DC.B	0,1,1,2,2,3,4,4,5,5,6,7,7,8,8,9
	DC.B	0,1,1,2,3,3,4,5,5,6,7,7,8,8,9,10
	DC.B	0,1,1,2,3,4,4,5,6,7,7,8,9,10,10,11
	DC.B	0,1,2,2,3,4,5,6,6,7,8,9,10,10,11,12
	DC.B	0,1,2,3,3,4,5,6,7,8,9,10,10,11,12,13
	DC.B	0,1,2,3,4,5,6,7,7,8,9,10,11,12,13,14
	DC.B	0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15
	EVEN

NOTE_2_FREQ
	ds.W	1	LEGE RUIMTE WANT ALS NOOT=0 -> GEEN VERANDERING
;		C     C#   D    D#   E    F
	DC.W	3822,3607,3405,3214,3033,2863
	DC.W	2702,2551,2407,2272,2145,2024
;		F#   G	G#   A	A#   B
;			ZELFDE NOTEN IN VOLGENDE OCTAAF VOOR INTERVALLEN
	DC.W	1991,1804,1703,1607,1517,1432
	DC.W	1351,1276,1204,1136,1073,1012
;
	EVEN
* TABLE CONVERSION FREQUENCE KHZ(0...15)->TIMER A DATA REGISTER

HERTZ	dc.b	110,110,110,110
	dc.b	110,110,94,82
	dc.b	73,66,60,55
	dc.b	51,47,44,41

TREM_TAB
	DC.W	0, 428, 852,1266,1666,2048,2408,2741,3044,3314
	DC.W	3547,3742,3896,4006,4074,4096,4074,4006,3896,3742
	DC.W	3547,3314,3044,2741,2408,2048,1666,1266,0852,0428
	DC.W	0, -428, -852,-1266,-1666,-2048,-2408,-2741,-3044,-3314
	DC.W	-3547,-3742,-3896,-4006,-4074,-4096,-4074,-4006,-3896,-3742
	DC.W	-3547,-3314,-3044,-2741,-2408,-2048,-1666,-1266, -852, -428
	EVEN


SONG		INCBIN	dba6.TRI
	even
VOICE_SET	INCBIN	dba6.tvs

L001C	ds.l	1
L0217	ds.B	16
L0218	ds.B	6
L0219	ds.W	1
L021A	ds.W	1 
L021B	ds.W	1 
L021C	ds.B	6 
L021D	ds.W	1 
L021E	ds.W	1 
L021F	ds.B	6 
L0220	ds.B	13
L0221	ds.B	1 
L0222	ds.B	24
L0223	ds.B	16
L0224	ds.B	6 
L0225	ds.W	1 
L0226	ds.W	1 
L0227	ds.W	1 
L0228	ds.B	6 
L0229	ds.W	1 
L022A	ds.W	1 
L022B	ds.B	6 
L022C	ds.B	13
L022D	ds.B	1 
L022E	ds.B	24
L022F	ds.B	16
L0230	ds.B	6 
L0231	ds.W	1 
L0232	ds.W	1 
L0233	ds.W	1 
L0234	ds.B	6 

L0235	ds.W	1 
L0236	ds.W	1 
L0237	ds.B	6 
L0238	ds.B	13
L0239	ds.B	1 
L023A	ds.B	24
L023B	ds.W	1 
L023C	ds.W	1 
L023D	ds.W	1 
L023E	ds.B	480 
L023F	ds.L	1
L0240	ds.W	1
L0241	ds.L	1
L0242	ds.B	10
L0243	ds.B	132
L0244	ds.W	1
