*POVerty STE 80/10 version

Boot sector loads start TRACK 6
                        SECTOR 1
                  Loads 3 sectors
              Load addr $20000

LOADER
       Side:	 0
Start track:     6
  End track:     8
  Load addr:     $20000
Loader moves load code for each part to a different memory location
	
INTRO
       Side:	 0
Start track:	10
  End track:	38

CHANGER
       Side:     0
Start track:    75
  End track:    79

MAIN	573678 bytes long
       Side:	 0
Start track:	40
  End track:	78

       Side:	 1
Start track:	 1
  End track:	74


END
       Side:	 0
Start track:	30
  End track:	61

DISC ID:
       Side:     1
Start track:     0
  End track:     0
