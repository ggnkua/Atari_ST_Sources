              P.O.V DISC 1

               MICROMIX 1
               MICROMIX 2

              MUSIC=VIXEN^
              P.O.V DISC 2

       INTERNATIONAL RESCUE DEMO
             1 MEG RAM ONLY

            MUSIC=THUNDERCATS^
              P.O.V DISC 3

                 TEX 1
                 TEX 2
                 TEX 3
          XXX INTERNATIONAL 1

            MUSIC=QUADRALIEN^
              P.O.V DISC 4

           GHOSTBUSTERS DEMO
             1 MEG RAM ONLY

              MUSIC=E.C.O.^
              P.O.V DISC 5

         A~HA 'YOU ARE THE ONE'
             1 MEG RAM ONLY

             MUSIC=CUSTODIAN^
              P.O.V DISC 6

          SPACE ACE SOUND DEMO
             STARWARS RAP V1
        BOUNCING BALL ON MIRROR
      XXX INTERNATIONAL GLOBE DEMO
            FLYING BIRD DEMO
            MANY BOINK DEMO

               MUSIC=ZOMBI^
              P.O.V DISC 7

     ART MACHINE - SYNTHETIC VISIONS
                SAS DEMO
            PRO REPLAY DEMO

            MUSIC=ARMY MOVES^
              P.O.V DISC 8

            MEGABANG DEMO 1
        LIVING ON VIDEO (1 MEG)

              MUSIC=PANDORA^
              P.O.V DISC 9

              ROBOMIX DEMO
                BAT-DEMO
           FUJIBOINK - 1 MEG

              MUSIC=MAD MAX^
              P.O.V DISC 10

               MODEL DEMO
             JOE 90 - 1 MEG
               POWER DEMO
                 INFO..

       MUSIC=BEYOND THE ICE PALACE^
              P.O.V DISC 11

            AXEL FULL SCREEN
           OUTRUN SOUND DEMO
               MEGABANG 2
               JUNK DEMO
             AXEL WAVE DEMO

           MUSIC=GOLDRUNNER 2^
              P.O.V DISC 12

             STINGRAY DEMO
           TRANSYLVANIA DEMO
          SPHERE DEMO - 1 MEG
            AXELS DOC DEMO 2

              MUSIC=XENON 2^
              P.O.V DISC 13

               R-RAP DEMO
             PRO SOUND DEMO
           MASTER SOUND DEMO

       MUSIC=BEYOND THE ICE PALACE^
              P.O.V DISC 14

            CAPTAIN SCARLET
           GHOSTBUSTERS DEMO
              BAPAUG DEMO

       MUSIC=BEYOND THE ICE PALACE^
              P.O.V DISC 15

              V8 TUNE DEMO
                007 DEMO
         ST FORMAT - NO BORDERS
         LEVEL 16 - NO BORDER 2

              MUSIC=MAD MAX^
              P.O.V DISC 16

        S.U.C.C.E.S.S DEMO (TLB)
               RENDEZVOUS
          TEX DEMO 3 VERSION 2

             MUSIC=F.O.F.T.^
              P.O.V DISC 17

         FOREIGN AFFAIR - 1 MEG
              CRASHING ROB

               MUSIC=VIXEN^
              P.O.V DISC 18

           TNT DEMO 5 - 1 MEG
         STARWARS RAP VERSION 2
              HOLBURN DEMO
           POV 'FILLER' DEMO 1

           MUSIC=BMX SIMULATOR^
              P.O.V DISC 19

            ATG DEMO - 1 MEG
               TNT DEMO 3
               TNT DEMO 4
          NO-NAME DEMO - 1 MEG

             MUSIC=CUSTODIAN^
              P.O.V DISC 20

            ALF DEMO - 1 MEG
     PSYCHEDELIK DEMO 2 - STE ONLY
                INFO... 

          MUSIC=SUPER STUNTMAN^
              P.O.V DISC 21

          SNOWMAN DEMO - 1 MEG
             MEGA BOB DEMO
              SYNC DEMO 2

              MUSIC=DUGGER^
              P.O.V DISC 22

      ST CONNEXIONS SOUND TRACKER
      OFFICIAL STE DEMO - STE ONLY

              MUSIC=DUGGER^
              P.O.V DISC 23

         TCB SOUND TRACKER DEMO
               MICROMIX 3
                TLT DEMO
               YELLO DEMO

              MUSIC=DUGGER^
              P.O.V DISC 24

          OXYGENE REMIX - 1 MEG
       POMPEY PIRATES MUSIC DEMO

              MUSIC=RAMPAGE^
              P.O.V DISC 25

      AN COOL STE DEMO - STE ONLY
             SHINY BUBBLES
         42 CREW FINALCUT DEMO
               SCC DEMO 1
              DISC COPIER

            MUSIC=DOGS OF WAR^
              P.O.V DISC 26

             ULTIMATE DEMO
        FINGERBOBS NEW YEAR DEMO
             F.O.F.T DEMO 7
              WIZARDS DEMO
              DISC COPIER

              MUSIC=RAMPAGE^
              P.O.V DISC 27

       ALIENS DIGI-DEMO 2 - 1 MEG
               TNT DEMO 2
              DISC COPIER

    MUSIC=MAD MAX - TCB TRACKER DEMO^
              P.O.V DISC 28

            THE RACE - 1 MEG
     P.O.V. FILLER 3 - JUNGLE DEMO
               SYNC DEMO
              DISC COPIER

        MUSIC=MAD MAX - IRONLORD^
              P.O.V DISC 29

       ALWAYS ON MY MIND - 1 MEG
           HIGH VOLTAGE DEMOs
              DISC COPIER

        MUSIC=MAD MAX - SO WATT 4^
              P.O.V DISC 30

              ACID BURN 2
               DEMON DEMO
              COUNTERPOINT
                CST DEMO
                INFO... 
              DISC COPIER

        MUSIC=MAD MAX - SO WATT 3^
              P.O.V DISC 31

      LAY YOUR HANDS ON ME - 1 MEG
     P.O.V. FILLER 2 - ISLAND DEMO
              DISC COPIER

        MUSIC=MAD MAX - SO WATT 2^
              P.O.V DISC 32

        TNT LOVESPY DEMO - 1 MEG
         DEATH OF DR.SYNE DEMO
             EQUINOX INTRO
              DISC COPIER

        MUSIC=MAD MAX - SO WATT 1^
              P.O.V DISC 33

 AN COOL's BREAKFAST CLUB DEMO - 1 MEG
               ONYX INTRO
              3D SCROLLER
              DISC COPIER

        MUSIC=MAD MAX - SO WATT 0^
              P.O.V DISC 34

        DOLLS ANIMATION - 1 MEG
            MIAMI VICE DEMO
   P.O.V. FILLER 4 'BYG SPRYTES' DEMO
              RIPPLER DEMO
              DISC COPIER

           MUSIC=COSMIC PIRATE^
              P.O.V DISC 35

          POLICE SQUAD - 1 MEG
          MAGIC EYE - NOT STE
                 GRUSEL
          BANAFISK - STE ONLY
       DESKTOP CENTRE - STE ONLY
              DISC COPIER

             MUSIC=SPEEDBALL^
              P.O.V DISC 36

 PHANTOM OF THE OPERA - 1 MEG *NOT STE*
        AMIGA JOKE DEMO - 1 MEG
            BRAINPOWER DEMO 
              DISC COPIER

            MUSIC=SWITCHBLADE^
              P.O.V DISC 37

         STE PRESENTATION DEMOS
               NITROWAVE
        MOB MUSIC DEMO - NOT STE
               TCB INTRO
              DISC COPIER

            MUSIC=SWITCHBLADE^
              P.O.V DISC 38

             BEAT BOX DEMO
                UFO DEMO
              CRADLE DEMO
         WEIRD SINES - STE ONLY
              DISC COPIER

            MUSIC=TCB TRACKER^
              P.O.V DISC 39

                ACID MIX
             SCREE - 1 MEG
              DISC COPIER

              MUSIC=MENACE^
             P.O.V DISC 40

            CEBIT DEMO (TLB)
               ZUUL DEMO
      BLACK WIZARDS DEMO - NOT STE
                INFO...
              DISC COPIER

   MUSIC=UNKNOWN (FROM DELIRIUS DEMO)^

