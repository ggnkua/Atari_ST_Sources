	lea	stext,a0
loop	sub.b	#32,(a0)+
	cmp.l	#textend,a0
	bne.s	loop
bp
	clr.w	-(sp)
	trap	#1
stext
 dc.b "                  UK'S NUMBER 1 DEMO PACKERS PRESENT ______"
 DC.B "   PERSISTENCE OF VISION DISC 57.       "
 DC.B "    GREETINGS TO -   EMPIRE,   MEDWAY BOYS,   POMPEY PIRATES,   "
 DC.B "THE LOST BOYS,   THE CAREBEARS,   INNER CIRCLE,   THE REPLICANTS,   "
 DC.B "SEWER SOFTWARE,   THE EXCEPTIONS   AND   DR.SYNE.      "
 dc.b "IF YOU READ P.O.V. DISC 56 SCROLLTEXT YOU MAY REMEMBER I MENTIONED "
 DC.B "SOME BOBS AND NOT HAVING ENOUGH DISC SPACE.... WELL AS YOU CAN SEE "
 DC.B "THE BOBS HAVE APPEARED - OK SO THEY ARE NOT EXCITING BUT "
 DC.B "THEY ARE IN THE DEVELOPMENT STAGE AND WILL APPEAR SOON ON ANOTHER "
 DC.B "MENU IN A FULL BLOWN MEGA-BOB INTRO    (WELL MAYBE!!!).   PRESS KEYS F1-F10 "
 dc.b "FOR DIFFERENT PATHS...       "
 DC.B "TODAYS DATE IS 2_2_91 AND WE ARE BEHIND MY ESTIMATED OUTPUT. "
 DC.B "THE DELAY IS BEING CAUSED BY P.O.V. 50 WHICH STILL HASN'T "
 DC.B "BEEN RELEASED.   I AM MEANT TO BE WRITING A WICKED MUSIC "
 DC.B "DEMO BUT I CAN'T BE BOTHERED AS I GET BORED "
 DC.B "WORKING ON THE SAME ROUTINES ALL THE TIME. "
 DC.B "  SO FAR THE TUNE DEMO HAS 188 TUNES BUT I SHOULD BE ABLE "
 DC.B "TO GET 200 AND STILL MAKE IT WORK IN 512K.   THE TUNE "
 DC.B "DEMO HAS OVER 535K OF DATA WHICH I PACK DOWN TO JUST OVER 300K. "
 DC.B " ONCE THE CODE HAS BEEN ASSEMBLED AND THEN THE WHOLE LOT "
 DC.B "PACKED THE SIZE IS REDUCED TO 280K. I'VE WRITTEN THE "
 DC.B "MAIN SELECTER CODE WHICH STEPS THROUGH THE TUNES "
 DC.B "WHEN A KEY IS PRESSED, ALL I NEED NOW IS A USER "
 DC.B "TYPE SELECTOR AND ALL THE TUNE NAMES INSERTING..... "
 DC.B "   IF YOU DIDN'T UNDERSTAND THAT THEN I'LL JUST "
 DC.B "SWITCH MYSELF OVER TO 'THICK BASTARD USER MODE (ARE "
 DC.B "YOU READING THIS ALY?).....   RIGHT, THE TUNE "
 DC.B "DEMO WILL HAVE 200 TUNES AND WORK ON A STANDARD STM _ "
 DC.B "STFM _ STE.       OK - BACK INTO PROGRAMMING MODE AGAIN.. "
 DC.B "CLUNK, WHIRRRR, CLANG, POP, TINKLE..    "
 DC.B "MOVE.L SCREEN_BASE,A0          LEA 32000(A0),A0          "
 DC.B "LEA -16384(A0),A1     !'()*,-.?       EH?         "
 DC.B "OOPS, WRONG MODE _ I SHOULD BE IN SUPERVISOR!!!!!! "
 DC.B "  bb     CREDITS FOR THIS MENU GOTO      MAC SYS DATA (ME) FOR ALL THE "
 DC.B "CODE,    GRAFIX BY OZYMANDIAS    AND   MUSIC RIPPED FROM "
 DC.B "POMPEY PIRATES MENU 62! (CAN SOMEONE PLEASE TELL ME WHAT GAME "
 DC.B "IT'S FROM 'CAUSE I LOVE IT?)       "
 DC.B "HEY, IT'S TIME FOR SOME MORE BOMBS bbbbbbbb I THINK THEY LOOK "
 DC.B "A BIT ROUGH AROUND THE EDGES....  aaaaaaaaaaaa  THERE YOU ARE, "
 DC.B "SOME SMOOTH BOMBS  OR  SOME OZ BOMBS cccccccccccccccccccc.  "
 dc.b "HEY I LIKE THOSE cccccccccccccccc HA-HA!!!!        "
 DC.B "HEY HAVE YOU HEARD ABOUT THE IRISH?    THEY'RE JOINING THE "
 DC.B "GULF WAR - APPARENTLY THEY HEARD ABOUT ALL THAT SAND AND SO "
 DC.B "ARE TAKING 3000 BAGS OF CEMENT OVER TO IRAQ ---- THEY'RE "
 DC.B "GOING TO MAKE THE BIGGEST MORTAR ATTACK EVER.    HA-HA-HA-HA. "
 DC.B "     OK, SO IT WASN'T THAT FUNNY BUT THE ONLY OTHER JOKE "
 DC.B "I CAN REMEMBER IS A BIT LEUD.       OH WELL WHO CARES?   "
 DC.B "      THERE WERE 3 MEN (GEORGE, JOCK AND PADDY) GOING TO "
 DC.B "WORK IN A LIGHT HOUSE FOR 3 MONTHS. "
 DC.B "  THEIR BOSS SAID 'IT CAN BE VERY BORING ON A LIGHT HOUSE "
 DC.B "SO YOU BETTER TAKE SOMETHING WITH YOU TO KEEP YOURSELVES AMUSED'. "
 DC.B "   WHEN THE DAY CAME FOR THEM TO GO TO THE LIGHT HOUSE, THEIR "
 dc.b "BOSS ASKED THEM IN TURN WHAT THEY "
 DC.B "HAD BROUGHT..     GEORGE HAD BROUGHT A PACK OF CARDS, THE BOSS "
 DC.B "EXCLAIMED 'WELL DONE, YOU CAN PLAY LOADS OF GAMES WITH CARDS', "
 DC.B "    NEXT HE ASKED JOCK, 'I'VE BROUGHT SOME DOMINOES' SAID JOCK. "
 DC.B "  'GREAT' SAID HIS BOSS, 'WITH DARTS AND DOMINOES WE WILL "
 DC.B "HAVE PLENTY TO KEEP OURSELVES AMUSED'.  FINALLY HE ASKED PADDY "
 DC.B "WHAT HE HAD.. PADDY REPLIED 'A PACK OF TAMPONS'..... 'WHAT!'    "
 DC.B "ASKED HIS BOSS, 'WHY THE HELL DID YOU BRING THOSE?',   PADDY "
 DC.B "REPLIED 'WELL IT SAYS ON THE SIDE THAT WITH THESE YOU CAN GO "
 DC.B "HORSE RIDING, SWIMMING, WALKING, ...... "
 DC.B "    cccccccccccccc  AND I THOUGHT ONLY ALY NEW CRAP JOKES! "
 DC.B "ccccccccccccccccc "
 DC.B "    WELL YOU MAY BE GLAD TO KNOW THAT BORIS HAS JUST "
 DC.B "VISITED AND BROUGHT WITH HIM 10 DISCS OF DEMOS, HE ALSO "
 DC.B "BROUGHT 4 'RIPPED OFF' DISCS FOR ME TO LAUGH AT!    "
 DC.B "MANY OF THE NEW DEMOS LOAD FILES AND NOT SECTORS SO I'LL GET THEM "
 DC.B "PACKED AND ONTO A P.O.V. DISC AS SOON AS MY STFM HAS PACKED THEM.  "
 DC.B "     HAVE YOU NOTICED THAT OUR LAST 7 MENUS HAVE BEEN "
 DC.B "CONSISTENTLY BETTER?    IF YOU HAVEN'T THEN YOU MUST BE BLIND! "
 DC.B "  THE REASON FOR THE BETTER QUALITY IS THAT BORIS HAS BEEN MOANING THAT I "
 DC.B "DON'T GET MANY THINGS MOVING ON THE MENU SO I'VE BEEN SPENDING A LITTLE "
 DC.B "OF MY PRECIOUS TIME WRITING BETTER LOOKING MENUS.    AFTER "
 DC.B "LOOKING AT THE COMPETITIONS MENUS I'VE DECIDED THAT "
 DC.B "OUR MENUS LOOK BRILLIANT.  IF YOU ARE ONE OF THE 'COMPETITION' "
 DC.B "THEN GET YOUR ARSE INTO GEAR AND WRITE A GOOD MENU OF YOUR OWN "
 DC.B "AND DON'T GET SOMEBODY ELSE TO WRITE IT FOR YOU!      "
 DC.B "OK FANS, IT'S TIME TO WRAP THIS THING UP AND GET IT TESTED. "
 DC.B "UNTIL NEXT TIME...... BYE!!!!  cccccccccccccccccccccccccccc"
 dc.b "ccccccccccccccccccccccccccccccccccccc                     "
 DC.B "                                                          "
textend