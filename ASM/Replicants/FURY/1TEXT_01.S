	DC.B	"3...   2...   1...   0...   "
	DC.B	"ANTI-WRAP!!! YEAH! HERE WE GO AGAIN FOR A "
	DC.B	"LONG LONG SCROLLTEXT WRITTEN BY FURY. "
	DC.B	"FIRST, TO GET RID OF ALL THE BORING THINGS ALL "
	DC.B	"SCROLLTEXTS NEED TO CONTAIN FOR THE SAKE OF "
	DC.B	"ALL EGO TRIPPERS, HERE COMES MY GREETINGS "
	DC.B	"LIST... SO, FIRST, TERA GREETS TO: "
	DC.B	"TCB (NICK, ARE YOU HUMAN OR AN E.T.??? ONE "
	DC.B	"DAY FOR A SCREEN THAT SEEMS TO BE TREMENDOUS FROM "
	DC.B	"WHAT I WAS TOLD, THAT MAKES ME SICK!!! STILL "
	DC.B	"SOMETHING TO TELL YOU, DO YOU COME TO MARSEILLE "
	DC.B	"THIS SUMMER? I STILL GOT A COCA COLA CAN RIGHT "
	DC.B	"FROM THE USA FOR YOU (AM I WRONG OR ARE YOU "
	DC.B	"A COLLECTOR OF COCA COLA CANS?). ANYWAY, I HOPE "
	DC.B	"TO SEE YOU SOON), SYNC (HEY! GUYS "
	DC.B	"DO YOU STILL THINK WE'RE JUST 'IMPROVING' CODING"
	DC.B	"??? ANYWAY, THANKS FOR WHAT YOU'VE WRITTEN IN "
	DC.B	"YOUR SOWATT SCREEN, BECAUSE IT'S WHAT PUSHED ME "
	DC.B	"TO FIND NEW CODING TECHNIQUES!!! I NOW KNOW FAR "
	DC.B	"MORE THINGS THAN I WOULD IF I HAD PUSHED "
	DC.B	"CODING ASIDE BECAUSE OF THAT F.....G SCHOOL. "
	DC.B	"HOPE TO MEET YOU ONE DAY), OMEGA (HOPE TO MEET "
	DC.B	"YOU TOO!!!), PHALANX (VECTOR (HI ZHZ! YOUR LAST "
	DC.B	"LETTER DISGUSTED ME EVEN MORE THAN THE FIRST ONE! "
	DC.B	"AND I DIDN'T THINK IT WAS POSSIBLE!!!), GHOST), "
	DC.B	"ST CONNEXION (HI THERE MARLON! STILL WORKING THIS "
	DC.B	"SUMMER? I THINK GOING TO THE BEACH IS BETTER! "
	DC.B	"ALSO, HI TO KRAZY REX (I WAS TOLD YOU WERE "
	DC.B	"SUPPORTING BREZIL FOR THE 'MONDIALE', I'M "
	DC.B	"SORRY THEY LOST), BELZEBUB (THE BRAIN!), AND THE "
	DC.B	"OTHERS), THE LOST BOYS (HOPE TO MEET MANIKIN "
	DC.B	"SOME DAY, ALSO, SEE YA IN A FEW WEEKS TO SAMMY "
	DC.B	"JOE, BE CAREFULL, THE SUN IS VERY VERY HOT IN "
	DC.B	"JULY IN THE SOUTH OF FRANCE. SO HOT THAT IT'S "
	DC.B	"ALMOST IMPOSSIBLE TO GET OUT BETWEEN 12 AND "
	DC.B	"16. YOU WERE WARNED, SO DON'T COME WITH "
	DC.B	"HEAVY CLOTHES!!!), DMA (HI THERE LARCOCIEL, "
	DC.B	"TOO BAD YOU QUIT THE ST SCENE. ALSO A BIG "
	DC.B	"HI TO LOCKBUSTER (STILL ANGRY AFTER ME? PLEASE, "
	DC.B	"ACCEPT MY EXCUSES HERE!)), AND FINALLY, ALL "
	DC.B	"OTHER MEMBERS OF THE UNION, THAT IS, TEX (YOU "
	DC.B	"ARE THE ONES WHO MADE ME LOVE DEMOS 2 YEARS AND "
	DC.B	"A HALF AGO. FOR THAT, I WILL FOREVER "
	DC.B	"THANK YOU), DELTA FORCE (I'M SORRY, BUT "
	DC.B	"I KNOW SO LITTLE ABOUT YOU, THAT I'M UNABLE "
	DC.B	"OF TELLING ANYTHING . TOO BAD!!!), "
	DC.B	"LEVEL 16 (SAME REMARK AS DELTA FORCE), TNT ("
	DC.B	"SAME REMARK AS BEFORE), OUPS!!! I FORGOT TO MENTION "
	DC.B	"THE PENDRAGONS (HI TO CRYSTAR AND SILVER, I'M "
	DC.B	"GETTING READY FOR YOUR 2 HOURS PHONE CALL "
	DC.B	"TOMOROW!!!), WELL, THE TERA GREETS ARE "
	DC.B	"NOW OVER, SO LET'S START WITH THE NORMAL GREETS "
	DC.B	"(AARGH! IT'S GONNA BE EVEN LONGER!!!), SO GREETS "
	DC.B	"GO TO: TRB (REALLY NICE DEMO FOR GEN-4, THEY "
	DC.B	"DO NOT DESERVE IT: FLUSHING THALION GAMES "
	DC.B	"LIKE THEY DID DISGUSTS ME), ZIGGY (FROM "
	DC.B	"OVER......., YOU'RE THE ONLY GUY I KNOW THERE "
	DC.B	"AND YOU ARE A REAL COOL ONE), FUZION, IONIX"
	DC.B	", IT IS NOW 0:20 AM, AND I'VE DECIDED TO GO "
	DC.B	"TO BED, I'M REALLY TIRED SO I'LL FINISH THE "
	DC.B	"GREETINGS LIST TOMOROW!!! THE SCROLLTEXT IS "
	DC.B	"ACTUALLY 2725 BYTES LONG..."
