* ENLEVER: PATRICK

 DC.B	"YO LAMER!... NAH! THAT'S NO GOOD START, IT'S ALLREADY BEEN "
 DC.B	"USED BY SOME SWEDDISH WEIRDOS! SO, HOW DO YOU LIKE: "
 DC.B	"HELLO THERE, I AM VERY HAPPY TO BE HERE IN THIS DEMO "
 DC.B	"WITH THE BEST GUYS AROUND, WHICH MEANS THAT I'M ONE OF THEM "
 DC.B	"NOW... AAARRGGGHH! DEFINELY TOO LAME, IT REMINDS ME OF "
 DC.B	"THE LAMEST CREWS AROUND STARTING WITH AN OV... OR A "
 DC.B	"STAR... IF YOU DON'T KNOW WHO I MEAN, DON'T CRY, YOUR BRAIN "
 DC.B	"WON'T HAVE TO ERASE THESE LAMERS NAMES FROM ITS CELLS... "
 DC.B	"WELL, THAT DOESN'T SOLVES MY PROBLEM, HOW AM I TO INTRODUCE "
 DC.B	"THIS SCROLLTEXT IN A DIFFERENT WAY THAN ALL THE ALLREADY "
 DC.B	"WRITTEN SCROLLTEXTS THE WORLD HAS READ???...... "
 DC.B	"I KNOW!!! I'LL JUST HAVE TO CREATE THE ANTI WRAP "
 DC.B	"SO, LET'S PARW!!!..."
 DC.B	"SO, NOW THAT THE SCROLL HAS REALLY STARTED, GET READY FOR A "
 DC.B	"LONG LONG ONE BECAUSE I'VE GOT LOTS OF STUFF TO SPEAK ABOUT!!! "
 DC.B	"LET'S START WITH THE LITTLE STORRY OF THIS DEMO SCREEN "
 DC.B	"IT ALL STARTED ON SUNDAY THE 10TH OF JUNE. AT THAT TIME, I "
 DC.B	"KNEW THERE WOULD BE A COPY PARTY DEMO FOR DELTA FORCE'S CP "
 DC.B	"BUT, WHEN I LEARNED THAT NO SCREEN FROM US WOULD BE FINISHED, "
 DC.B	"I DECIDED TO CODE A LITTLE THINGY, EVEN THOUGH I HAD BIG "
 DC.B	"EXAMS A WEEK LATER AND THAT IT WOULD HAVE BEEN BETTER FOR ME "
 DC.B	"TO STUDY THAN CODE. BUT, NEVERTHELESS, I THOUGHT THAT, FOR "
 DC.B	"ONCE, I WOULD BE ABLE TO EXPRESS MYSELF IN A SCROLLTEXT "
 DC.B	"WITH NO LIMITS LIKE: 'THIS GAME WAS CRACKED BY... CREDITS "
 DC.B	"FOR THIS INTRO GO TO... GREETS TO...' (BORING, ISN'T IT?). "
 DC.B	"SO, I STARTED CODING ON THE EVENING OF THE 10TH OF JUNE "
 DC.B	"(I KNOW, THIS WASN'T CODED DURING THE CP BUT I COULDN'T "
 DC.B	"COME ANYWAY, AND SOMETHING IS ALWAYS BETTER THAN NOTHING). "
 DC.B	"MY INITIAL PROJECT WAS TO MAKE A SCRAPPY SCROLLER AND "
 DC.B	"SOME VECTOR GRAPHIXX WITH COMMENTS LIKE RED SECTOR'S "
 DC.B	"VECTOR BALLS DEMO (AMIGA), BUT, MAKING UP OBJECTS WAS "
 DC.B	"SUCH A BORING THING THAT I DECIDED TO LET THE USER "
 DC.B	"CHOOSE BETWEEN THE OBJECTS I ALLREADY HAD DESIGNED. "
 DC.B	"THEN, I STARTED CODING THE SCRAPPY SCROLLER BUT (DID I "
 DC.B	"TELL YOU I ONLY HAD 3 DAYS TO MAKE THE WHOLE DEMO, AND "
 DC.B	"THAT I STARTED WITH NOTHING MADE, NOT EVEN GRAPHIXX???), "
 DC.B	"AS ALWAYS, I REALISED THAT I WOULD MISS THE TIME (SHIT! "
 DC.B	"IT'S HARD TO TYPE A BIG SCROLLER WITH ONLY ONE HAND! WAIT "
 DC.B	"TILL I FINISHED DRINKING..........................AHHHH! "
 DC.B	"I FEEL BETTER NOW, IT'S REALLY HOT AROUND HERE IN MARSEILLE "
 DC.B	"IN JUNE, AND IT'S GONNA BE HOTTER IN JULY. ACTUALLY, THE "
 DC.B	"TEMPERATURE IS OF 25 DEGREES (IN THE DARK, SO, IN "
 DC.B	"OPEN GROUND, THERE MUST BE A COOL 35 DEGREES (THIS MEANS I "
 DC.B	"WON'T GO TO THE BEACH!!!)). SO, WHAT WAS I TELLING YOU??? "
 DC.B	"OH, I REMEMBER, LET'S CONTINUE TO BORE YOU TO DEATH FOR A "
 DC.B	"FEW MORE KILOBYTES BEFORE GETTING TO OTHER SUBJECTS!!! NO! "
 DC.B	"DON'T LEAVE! I'M KIDDING), LET'S RESTART WHERE WE LEFT: 'I "
 DC.B	"WOULD MISS "
 DC.B	"THE TIME (REAL TIME: HOURS, MINUTES, SECONDS) TO MAKE "
 DC.B	"THAT FUCKY SCRAPPY SCROLLER, SO, I DECIDED TO STOP "
 DC.B	"THE SCRAPPY AND ADD A FEW OPTIONS TO THE VECTOR GRAPHIXX. ( "
 DC.B	"YES, THERE ARE HIDDEN SHAPES!!! PRESS DIAGONAL KEYS!) "
 DC.B	"FINALLY, IT TOOK ME 3 MORNINGS AND 3 EVENINGS TO COMPLETE "
 DC.B	"THIS NOT-VERY-GOOD-SCREEN-BUT-YET-NOT-SO-BAD-EITHER (WHAT A "
 DC.B	"NAME! IT BEATS THE KVACK-KVACK AND GRODAN DEMO FROM TCB) "
 DC.B	"THAT MAKES ABOUT 20 HOURS OF WORK ON THIS STUFF, STARTING "
 DC.B	"WITH NOTHING ELSE BUT MY VERY FIRST 3D ROUT (IT HAS SOME BUGS "
 DC.B	"LIKE: NO CLIPPING AND APPROXIMATIONS ERRORS, BUT HEY, THAT'S "
 DC.B	"MY FIRST ROUT, I'LL IMPROVE IT WHEN I'M FINISHED WITH "
 DC.B	"THE PHALEON DEMO'S MAIN MENU (ANOTHER BIG WORK TO FINISH!)). "
 DC.B	"FINALLY, ON THE 13TH OF JUNE (NIGHT), THE DEMO SEEMED TO "
 DC.B	"WORK PROPERLY , AND I "
 DC.B	"DECIDED IT WOULD BE EASY (WHAT A MISTAKE TO THINK THAT!!!) "
 DC.B	"TO REMOVE THE TRAPS AND THEN "
 DC.B	"WRITE A SCROLLTEXT NEXT MORNING, JUST BEFORE GIVING THE "
 DC.B	"DEMO TO PATRICK. BUT, OF COURSE, THE REPLACEMENT OF THE "
 DC.B	"SYSTEM VSYNC BY MY OWN ROUTINE DIDN'T WORK AT ALL!!! "
 DC.B	"MY ROUT WAS GOOD AS LONG AS THE VECTOR OBJECTS DIDN'T NEED "
 DC.B	"MORE THAN A FRAME TO BE CALCULATED. WHEN THEY DID, THE "
 DC.B	"WHOLE STUFF WASN'T SYNCHRON!!! AND THAT HAPPENED 1 HOUR "
 DC.B	"BEFORE THE MEETING WITH PATRICK. I DIDN'T FIND A WAY "
 DC.B	"TO MAKE IT WORK IN TIME, SO I HAD TO REPEAT TWICE MY "
 DC.B	"SYNCHRO ROUT TO FIX THE MESS. BUT THAT MEANT ALL "
 DC.B	"MY OBJECTS CALCULATION TIMES WERE DOUBLED (AARRGH!!!) "
 DC.B	"ANYWAY, I GAVE THE SCREEN AND OFF IT WAS TOWARDS THE COPY "
 DC.B	"PARTY, AND OFF I WAS TO LEARN FOR MY EXAMS ALL I DIDN'T "
 DC.B	"LEARN DURING CODING. NOW THAT THESE F.....G EXAMS ARE "
 DC.B	"OVER, I WAS QUITE PLEASED TO LEARN THE CP DEMO WASN'T "
 DC.B	"FINISHED, AND THUS, I'VE DECIDED TO FIX ALL THAT DIDN'T "
 DC.B	"WORK. THERE WERE ONLY 3 BUGS!!! AND NONE OF GREAT IMPORTANCE "
 DC.B	"ELSE THAN FROM AN ESTHETIC POINT OF VIEW. ANYWAY, IT TOOK "
 DC.B	"ME 4 HOURS TO FIX 'EM: 1 MINUTE FOR THE SCREEN WIPING "
 DC.B	"ROUT BUG (YES, I'VE INCLUDED THAT ROUT BECAUSE, WHILE I WAS "
 DC.B	"TESTING SOME OPTIONS OF THE DEMO CONTROL PANEL (WHAT? "
 DC.B	"I DIDN'T TELL YOU THERE WAS A CONTROL PANEL? TOO BAD, I "
 DC.B	"WON'T GIVE YOU THE KEY TO IT UNTIL THE END (GNARF!!! ARF!!! "
 DC.B	"SADISTIC LAUGH))"
 DC.B	" I HAD SOME GRAPHIXX BUG (THERE ARE NO MORE NOW BUT THE "
 DC.B	"OPTION IS STILL HERE)), THE HARDEST BUG TO FIND WAS A "
 DC.B	"STRANGE THING HAPPENING TO THE SCROLLER: LITTLE DOTS WERE "
 DC.B	"APPEARING FROM NOWHERE!!! IT TOOK ME 3 HOURS TO GET TO "
 DC.B	"IT, I JUST HAD FORGOTTEN TO WIPE THE EXTEND BIT OF THE "
 DC.B	"SR!!! (YES! I USE THE LAME ROXL METHOD, BUT LOOK AT THE "
 DC.B	"SIZE AND NUMBER OF PLANES OF THIS SCROLL! PRESHIFTING "
 DC.B	"IT WOULD HAVE BEEN OF NO INTEREST AT ALL!!!), LAST, THE "
 DC.B	"SYNCHRO BUG, IT TOOK ME 1 HOUR TO MAKE A NEW ROUT WORKING "
 DC.B	"WHATEVER THE NUMBER OF FRAMES HAD PASSED. "
 DC.B	"AND NOW, I'M ABLE TO WRITE THIS SILLY SCROLLER IN MY DEMO. "
 DC.B	"PHWIEW! THAT WAS A LONG TALK ABOUT CODING, SO LET'S "
 DC.B	"HAVE A PAUSE BEFORE CONTINUEING!!! (THE SCROLL IS ACTUALLY "
 DC.B	"5462 BYTES LONG)."

	