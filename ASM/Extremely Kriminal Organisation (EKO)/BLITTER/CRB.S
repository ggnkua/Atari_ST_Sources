	dc.w            15
	dc.w            14864
	dc.w            14
	dc.w            15824
	dc.w            14
	dc.w            16784
	dc.w            14
	dc.w            17904
	dc.w            14
	dc.w            18864
	dc.w            14
	dc.w            19824
	dc.w            14
	dc.w            20784
	dc.w            13
	dc.w            21584
	dc.w            13
	dc.w            22544
	dc.w            13
	dc.w            23344
	dc.w            12
	dc.w            24144
	dc.w            12
	dc.w            24944
	dc.w            11
	dc.w            25584
	dc.w            11
	dc.w            26384
	dc.w            10
	dc.w            26864
	dc.w            9
	dc.w            27504
	dc.w            9
	dc.w            27984
	dc.w            8
	dc.w            28304
	dc.w            7
	dc.w            28784
	dc.w            6
	dc.w            28944
	dc.w            5
	dc.w            29264
	dc.w            4
	dc.w            29264
	dc.w            3
	dc.w            29424
	dc.w            2
	dc.w            29424
	dc.w            1
	dc.w            29264
	dc.w            0
	dc.w            29264
	dc.w            15
	dc.w            28936
	dc.w            14
	dc.w            28776
	dc.w            13
	dc.w            28296
	dc.w            12
	dc.w            27976
	dc.w            10
	dc.w            27496
	dc.w            9
	dc.w            26856
	dc.w            7
	dc.w            26376
	dc.w            6
	dc.w            25576
	dc.w            5
	dc.w            24936
	dc.w            3
	dc.w            24136
	dc.w            2
	dc.w            23336
	dc.w            0
	dc.w            22536
	dc.w            14
	dc.w            21568
	dc.w            13
	dc.w            20768
	dc.w            11
	dc.w            19808
	dc.w            9
	dc.w            18848
	dc.w            8
	dc.w            17888
	dc.w            6
	dc.w            16768
	dc.w            4
	dc.w            15808
	dc.w            2
	dc.w            14848
	dc.w            0
	dc.w            13728
	dc.w            14
	dc.w            12760
	dc.w            12
	dc.w            11640
	dc.w            10
	dc.w            10680
	dc.w            8
	dc.w            9720
	dc.w            6
	dc.w            8760
	dc.w            4
	dc.w            7960
	dc.w            2
	dc.w            7000
	dc.w            0
	dc.w            6200
	dc.w            14
	dc.w            5392
	dc.w            12
	dc.w            4592
	dc.w            10
	dc.w            3952
	dc.w            7
	dc.w            3152
	dc.w            5
	dc.w            2672
	dc.w            3
	dc.w            2032
	dc.w            0
	dc.w            1552
	dc.w            14
	dc.w            1224
	dc.w            12
	dc.w            744
	dc.w            9
	dc.w            584
	dc.w            7
	dc.w            264
	dc.w            5
	dc.w            264
	dc.w            2
	dc.w            104
	dc.w            0
	dc.w            104
	dc.w            13
	dc.w            256
	dc.w            11
	dc.w            256
	dc.w            8
	dc.w            576
	dc.w            6
	dc.w            736
	dc.w            3
	dc.w            1216
	dc.w            1
	dc.w            1536
	dc.w            14
	dc.w            2008
	dc.w            12
	dc.w            2648
	dc.w            9
	dc.w            3128
	dc.w            6
	dc.w            3928
	dc.w            4
	dc.w            4568
	dc.w            1
	dc.w            5368
	dc.w            15
	dc.w            6160
	dc.w            12
	dc.w            6960
	dc.w            9
	dc.w            7920
	dc.w            7
	dc.w            8720
	dc.w            4
	dc.w            9680
	dc.w            2
	dc.w            10640
	dc.w            15
	dc.w            11592
	dc.w            12
	dc.w            12712
	dc.w            10
	dc.w            13672
	dc.w            7
	dc.w            14792
	dc.w            4
	dc.w            15752
	dc.w            2
	dc.w            16712
	dc.w            15
	dc.w            17824
	dc.w            12
	dc.w            18784
	dc.w            10
	dc.w            19744
	dc.w            7
	dc.w            20704
	dc.w            5
	dc.w            21504
	dc.w            2
	dc.w            22464
	dc.w            15
	dc.w            23256
	dc.w            13
	dc.w            24056
	dc.w            10
	dc.w            24856
	dc.w            8
	dc.w            25496
	dc.w            5
	dc.w            26296
	dc.w            2
	dc.w            26776
	dc.w            0
	dc.w            27416
	dc.w            13
	dc.w            27888
	dc.w            11
	dc.w            28208
	dc.w            8
	dc.w            28688
	dc.w            6
	dc.w            28848
	dc.w            3
	dc.w            29168
	dc.w            1
	dc.w            29168
	dc.w            14
	dc.w            29320
	dc.w            12
	dc.w            29320
	dc.w            9
	dc.w            29160
	dc.w            7
	dc.w            29160
	dc.w            5
	dc.w            28840
	dc.w            2
	dc.w            28680
	dc.w            0
	dc.w            28200
	dc.w            14
	dc.w            27872
	dc.w            11
	dc.w            27392
	dc.w            9
	dc.w            26752
	dc.w            7
	dc.w            26272
	dc.w            4
	dc.w            25472
	dc.w            2
	dc.w            24832
	dc.w            0
	dc.w            24032
	dc.w            14
	dc.w            23224
	dc.w            12
	dc.w            22424
	dc.w            10
	dc.w            21464
	dc.w            8
	dc.w            20664
	dc.w            6
	dc.w            19704
	dc.w            4
	dc.w            18744
	dc.w            2
	dc.w            17784
	dc.w            0
	dc.w            16664
	dc.w            14
	dc.w            15696
	dc.w            12
	dc.w            14736
	dc.w            10
	dc.w            13616
	dc.w            8
	dc.w            12656
	dc.w            6
	dc.w            11536
	dc.w            5
	dc.w            10576
	dc.w            3
	dc.w            9616
	dc.w            1
	dc.w            8656
	dc.w            0
	dc.w            7856
	dc.w            14
	dc.w            6888
	dc.w            12
	dc.w            6088
	dc.w            11
	dc.w            5288
	dc.w            9
	dc.w            4488
	dc.w            8
	dc.w            3848
	dc.w            7
	dc.w            3048
	dc.w            5
	dc.w            2568
	dc.w            4
	dc.w            1928
	dc.w            2
	dc.w            1448
	dc.w            1
	dc.w            1128
	dc.w            0
	dc.w            648
	dc.w            15
	dc.w            480
	dc.w            14
	dc.w            160
	dc.w            13
	dc.w            160
	dc.w            12
	dc.w            0
	dc.w            11
	dc.w            0
	dc.w            10
	dc.w            160
	dc.w            9
	dc.w            160
	dc.w            8
	dc.w            480
	dc.w            7
	dc.w            640
	dc.w            6
	dc.w            1120
	dc.w            5
	dc.w            1440
	dc.w            5
	dc.w            1920
	dc.w            4
	dc.w            2560
	dc.w            3
	dc.w            3040
	dc.w            3
	dc.w            3840
	dc.w            2
	dc.w            4480
	dc.w            2
	dc.w            5280
	dc.w            1
	dc.w            6080
	dc.w            1
	dc.w            6880
	dc.w            1
	dc.w            7840
	dc.w            0
	dc.w            8640
	dc.w            0
	dc.w            9600
	dc.w            0
	dc.w            10560
	dc.w            0
	dc.w            11520
	dc.w            0
	dc.w            12640
	dc.w            0
	dc.w            13600
	dc.w            0
	dc.w            14720
	dc.w            0
	dc.w            15680
	dc.w            0
	dc.w            16640
	dc.w            0
	dc.w            17760
	dc.w            0
	dc.w            18720
	dc.w            0
	dc.w            19680
	dc.w            0
	dc.w            20640
	dc.w            1
	dc.w            21440
	dc.w            1
	dc.w            22400
	dc.w            1
	dc.w            23200
	dc.w            2
	dc.w            24000
	dc.w            2
	dc.w            24800
	dc.w            3
	dc.w            25440
	dc.w            3
	dc.w            26240
	dc.w            4
	dc.w            26720
	dc.w            5
	dc.w            27360
	dc.w            5
	dc.w            27840
	dc.w            6
	dc.w            28160
	dc.w            7
	dc.w            28640
	dc.w            8
	dc.w            28800
	dc.w            9
	dc.w            29120
	dc.w            10
	dc.w            29120
	dc.w            11
	dc.w            29280
	dc.w            12
	dc.w            29280
	dc.w            13
	dc.w            29120
	dc.w            14
	dc.w            29120
	dc.w            15
	dc.w            28800
	dc.w            0
	dc.w            28648
	dc.w            1
	dc.w            28168
	dc.w            2
	dc.w            27848
	dc.w            4
	dc.w            27368
	dc.w            5
	dc.w            26728
	dc.w            7
	dc.w            26248
	dc.w            8
	dc.w            25448
	dc.w            9
	dc.w            24808
	dc.w            11
	dc.w            24008
	dc.w            12
	dc.w            23208
	dc.w            14
	dc.w            22408
	dc.w            0
	dc.w            21456
	dc.w            1
	dc.w            20656
	dc.w            3
	dc.w            19696
	dc.w            5
	dc.w            18736
	dc.w            6
	dc.w            17776
	dc.w            8
	dc.w            16656
	dc.w            10
	dc.w            15696
	dc.w            12
	dc.w            14736
	dc.w            14
	dc.w            13616
	dc.w            0
	dc.w            12664
	dc.w            2
	dc.w            11544
	dc.w            4
	dc.w            10584
	dc.w            6
	dc.w            9624
	dc.w            8
	dc.w            8664
	dc.w            10
	dc.w            7864
	dc.w            12
	dc.w            6904
	dc.w            14
	dc.w            6104
	dc.w            0
	dc.w            5312
	dc.w            2
	dc.w            4512
	dc.w            4
	dc.w            3872
	dc.w            7
	dc.w            3072
	dc.w            9
	dc.w            2592
	dc.w            11
	dc.w            1952
	dc.w            14
	dc.w            1472
	dc.w            0
	dc.w            1160
	dc.w            2
	dc.w            680
	dc.w            5
	dc.w            520
	dc.w            7
	dc.w            200
	dc.w            9
	dc.w            200
	dc.w            12
	dc.w            40
	dc.w            14
	dc.w            40
	dc.w            1
	dc.w            208
	dc.w            3
	dc.w            208
	dc.w            6
	dc.w            528
	dc.w            8
	dc.w            688
	dc.w            11
	dc.w            1168
	dc.w            13
	dc.w            1488
	dc.w            0
	dc.w            1976
	dc.w            2
	dc.w            2616
	dc.w            5
	dc.w            3096
	dc.w            8
	dc.w            3896
	dc.w            10
	dc.w            4536
	dc.w            13
	dc.w            5336
	dc.w            15
	dc.w            6136
	dc.w            2
	dc.w            6944
	dc.w            5
	dc.w            7904
	dc.w            7
	dc.w            8704
	dc.w            10
	dc.w            9664
	dc.w            12
	dc.w            10624
	dc.w            15
	dc.w            11584
	dc.w            2
	dc.w            12712
	dc.w            4
	dc.w            13672
	dc.w            7
	dc.w            14792
	dc.w            10
	dc.w            15752
	dc.w            12
	dc.w            16712
	dc.w            15
	dc.w            17832
	dc.w            2
	dc.w            18800
	dc.w            4
	dc.w            19760
	dc.w            7
	dc.w            20720
	dc.w            9
	dc.w            21520
	dc.w            12
	dc.w            22480
	dc.w            15
	dc.w            23280
	dc.w            1
	dc.w            24088
	dc.w            4
	dc.w            24888
	dc.w            6
	dc.w            25528
	dc.w            9
	dc.w            26328
	dc.w            12
	dc.w            26808
	dc.w            14
	dc.w            27448
	dc.w            1
	dc.w            27936
	dc.w            3
	dc.w            28256
	dc.w            6
	dc.w            28736
	dc.w            8
	dc.w            28896
	dc.w            11
	dc.w            29216
	dc.w            13
	dc.w            29216
	dc.w            0
	dc.w            29384
	dc.w            2
	dc.w            29384
	dc.w            5
	dc.w            29224
	dc.w            7
	dc.w            29224
	dc.w            9
	dc.w            28904
	dc.w            12
	dc.w            28744
	dc.w            14
	dc.w            28264
	dc.w            0
	dc.w            27952
	dc.w            3
	dc.w            27472
	dc.w            5
	dc.w            26832
	dc.w            7
	dc.w            26352
	dc.w            10
	dc.w            25552
	dc.w            12
	dc.w            24912
	dc.w            14
	dc.w            24112
	dc.w            0
	dc.w            23320
	dc.w            2
	dc.w            22520
	dc.w            4
	dc.w            21560
	dc.w            6
	dc.w            20760
	dc.w            8
	dc.w            19800
	dc.w            10
	dc.w            18840
	dc.w            12
	dc.w            17880
	dc.w            14
	dc.w            16760
	dc.w            0
	dc.w            15808
	dc.w            2
	dc.w            14848
	dc.w            4
	dc.w            13728
	dc.w            6
	dc.w            12768
	dc.w            8
	dc.w            11648
	dc.w            9
	dc.w            10688
	dc.w            11
	dc.w            9728
	dc.w            13
	dc.w            8768
	dc.w            14
	dc.w            7968
	dc.w            0
	dc.w            7016
	dc.w            2
	dc.w            6216
	dc.w            3
	dc.w            5416
	dc.w            5
	dc.w            4616
	dc.w            6
	dc.w            3976
	dc.w            7
	dc.w            3176
	dc.w            9
	dc.w            2696
	dc.w            10
	dc.w            2056
	dc.w            12
	dc.w            1576
	dc.w            13
	dc.w            1256
	dc.w            14
	dc.w            776
	dc.w            15
	dc.w            616
	dc.w            0
	dc.w            304
	dc.w            1
	dc.w            304
	dc.w            2
	dc.w            144
	dc.w            3
	dc.w            144
	dc.w            4
	dc.w            304
	dc.w            5
	dc.w            304
	dc.w            6
	dc.w            624
	dc.w            7
	dc.w            784
	dc.w            8
	dc.w            1264
	dc.w            9
	dc.w            1584
	dc.w            9
	dc.w            2064
	dc.w            10
	dc.w            2704
	dc.w            11
	dc.w            3184
	dc.w            11
	dc.w            3984
	dc.w            12
	dc.w            4624
	dc.w            12
	dc.w            5424
	dc.w            13
	dc.w            6224
	dc.w            13
	dc.w            7024
	dc.w            13
	dc.w            7984
	dc.w            14
	dc.w            8784
	dc.w            14
	dc.w            9744
	dc.w            14
	dc.w            10704
	dc.w            14
	dc.w            11664
	dc.w            14
	dc.w            12784
	dc.w            14
	dc.w            13744
	dc.w            15
	dc.w            14864
