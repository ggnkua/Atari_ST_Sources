;**************************************************************************
;*     Motorola Austin DSP Operation  June 06, 1991                       *
;*                                                                        *
;*       *  ALTHOUGH THE INFORMATION CONTAINED HEREIN,    *               *
;*       *  AS WELL AS ANY INFORMATION PROVIDED RELATIVE  *               *
;*       *  THERETO, HAS BEEN CAREFULLY REVIEWED AND IS   *               *
;*       *  BELIEVED ACCURATE, MOTOROLA ASSUMES NO        *               *
;*       *  LIABILITY ARISING OUT OF ITS APPLICATION OR   *               *
;*       *  USE, NEITHER DOES IT CONVEY ANY LICENSE UNDER *               *
;*       *  ITS PATENT RIGHTS NOR THE RIGHTS OF OTHERS.   *               *
;*                                                                        *
;*  This program originally available on the Motorola DSP bulletin board. *
;*  It is provided under a DISCLAMER OF WARRANTY available from           *
;*  Motorola DSP Operation, 6501 Wm. Cannon Drive W., Austin, Tx., 78735. *
;*                                                                        *

;  Blackman window coefficients N/2 =  1024
  dc   -1.49012e-08     ; = window(  1  )
  dc    8.33045e-07     ; = window(  2  )
  dc    3.37692e-06     ; = window(  3  )
  dc    7.61682e-06     ; = window(  4  )
  dc    1.35529e-05     ; = window(  5  )
  dc    2.11855e-05     ; = window(  6  )
  dc    3.05148e-05     ; = window(  7  )
  dc    4.15412e-05     ; = window(  8  )
  dc    5.42653e-05     ; = window(  9  )
  dc    6.86874e-05     ; = window(  10  )
  dc    8.48082e-05     ; = window(  11  )
  dc    1.02628e-04     ; = window(  12  )
  dc    1.22149e-04     ; = window(  13  )
  dc    1.43370e-04     ; = window(  14  )
  dc    1.66293e-04     ; = window(  15  )
  dc    1.90918e-04     ; = window(  16  )
  dc    2.17247e-04     ; = window(  17  )
  dc    2.45281e-04     ; = window(  18  )
  dc    2.75021e-04     ; = window(  19  )
  dc    3.06468e-04     ; = window(  20  )
  dc    3.39623e-04     ; = window(  21  )
  dc    3.74489e-04     ; = window(  22  )
  dc    4.11065e-04     ; = window(  23  )
  dc    4.49353e-04     ; = window(  24  )
  dc    4.89356e-04     ; = window(  25  )
  dc    5.31075e-04     ; = window(  26  )
  dc    5.74511e-04     ; = window(  27  )
  dc    6.19667e-04     ; = window(  28  )
  dc    6.66543e-04     ; = window(  29  )
  dc    7.15142e-04     ; = window(  30  )
  dc    7.65467e-04     ; = window(  31  )
  dc    8.17518e-04     ; = window(  32  )
  dc    8.71298e-04     ; = window(  33  )
  dc    9.26809e-04     ; = window(  34  )
  dc    9.84054e-04     ; = window(  35  )
  dc    1.04303e-03     ; = window(  36  )
  dc    1.10375e-03     ; = window(  37  )
  dc    1.16621e-03     ; = window(  38  )
  dc    1.23041e-03     ; = window(  39  )
  dc    1.29636e-03     ; = window(  40  )
  dc    1.36406e-03     ; = window(  41  )
  dc    1.43350e-03     ; = window(  42  )
  dc    1.50470e-03     ; = window(  43  )
  dc    1.57766e-03     ; = window(  44  )
  dc    1.65238e-03     ; = window(  45  )
  dc    1.72885e-03     ; = window(  46  )
  dc    1.80710e-03     ; = window(  47  )
  dc    1.88711e-03     ; = window(  48  )
  dc    1.96889e-03     ; = window(  49  )
  dc    2.05245e-03     ; = window(  50  )
  dc    2.13779e-03     ; = window(  51  )
  dc    2.22491e-03     ; = window(  52  )
  dc    2.31381e-03     ; = window(  53  )
  dc    2.40450e-03     ; = window(  54  )
  dc    2.49698e-03     ; = window(  55  )
  dc    2.59126e-03     ; = window(  56  )
  dc    2.68734e-03     ; = window(  57  )
  dc    2.78522e-03     ; = window(  58  )
  dc    2.88491e-03     ; = window(  59  )
  dc    2.98641e-03     ; = window(  60  )
  dc    3.08972e-03     ; = window(  61  )
  dc    3.19485e-03     ; = window(  62  )
  dc    3.30180e-03     ; = window(  63  )
  dc    3.41058e-03     ; = window(  64  )
  dc    3.52119e-03     ; = window(  65  )
  dc    3.63364e-03     ; = window(  66  )
  dc    3.74792e-03     ; = window(  67  )
  dc    3.86405e-03     ; = window(  68  )
  dc    3.98203e-03     ; = window(  69  )
  dc    4.10186e-03     ; = window(  70  )
  dc    4.22354e-03     ; = window(  71  )
  dc    4.34709e-03     ; = window(  72  )
  dc    4.47250e-03     ; = window(  73  )
  dc    4.59979e-03     ; = window(  74  )
  dc    4.72895e-03     ; = window(  75  )
  dc    4.85999e-03     ; = window(  76  )
  dc    4.99292e-03     ; = window(  77  )
  dc    5.12774e-03     ; = window(  78  )
  dc    5.26445e-03     ; = window(  79  )
  dc    5.40307e-03     ; = window(  80  )
  dc    5.54358e-03     ; = window(  81  )
  dc    5.68602e-03     ; = window(  82  )
  dc    5.83036e-03     ; = window(  83  )
  dc    5.97663e-03     ; = window(  84  )
  dc    6.12483e-03     ; = window(  85  )
  dc    6.27495e-03     ; = window(  86  )
  dc    6.42702e-03     ; = window(  87  )
  dc    6.58103e-03     ; = window(  88  )
  dc    6.73698e-03     ; = window(  89  )
  dc    6.89489e-03     ; = window(  90  )
  dc    7.05477e-03     ; = window(  91  )
  dc    7.21660e-03     ; = window(  92  )
  dc    7.38041e-03     ; = window(  93  )
  dc    7.54620e-03     ; = window(  94  )
  dc    7.71397e-03     ; = window(  95  )
  dc    7.88373e-03     ; = window(  96  )
  dc    8.05548e-03     ; = window(  97  )
  dc    8.22924e-03     ; = window(  98  )
  dc    8.40500e-03     ; = window(  99  )
  dc    8.58278e-03     ; = window(  100  )
  dc    8.76258e-03     ; = window(  101  )
  dc    8.94440e-03     ; = window(  102  )
  dc    9.12826e-03     ; = window(  103  )
  dc    9.31415e-03     ; = window(  104  )
  dc    9.50209e-03     ; = window(  105  )
  dc    9.69208e-03     ; = window(  106  )
  dc    9.88413e-03     ; = window(  107  )
  dc    1.00782e-02     ; = window(  108  )
  dc    1.02744e-02     ; = window(  109  )
  dc    1.04727e-02     ; = window(  110  )
  dc    1.06730e-02     ; = window(  111  )
  dc    1.08755e-02     ; = window(  112  )
  dc    1.10800e-02     ; = window(  113  )
  dc    1.12867e-02     ; = window(  114  )
  dc    1.14954e-02     ; = window(  115  )
  dc    1.17063e-02     ; = window(  116  )
  dc    1.19193e-02     ; = window(  117  )
  dc    1.21344e-02     ; = window(  118  )
  dc    1.23517e-02     ; = window(  119  )
  dc    1.25711e-02     ; = window(  120  )
  dc    1.27927e-02     ; = window(  121  )
  dc    1.30165e-02     ; = window(  122  )
  dc    1.32424e-02     ; = window(  123  )
  dc    1.34704e-02     ; = window(  124  )
  dc    1.37007e-02     ; = window(  125  )
  dc    1.39332e-02     ; = window(  126  )
  dc    1.41678e-02     ; = window(  127  )
  dc    1.44047e-02     ; = window(  128  )
  dc    1.46438e-02     ; = window(  129  )
  dc    1.48851e-02     ; = window(  130  )
  dc    1.51286e-02     ; = window(  131  )
  dc    1.53744e-02     ; = window(  132  )
  dc    1.56224e-02     ; = window(  133  )
  dc    1.58726e-02     ; = window(  134  )
  dc    1.61251e-02     ; = window(  135  )
  dc    1.63799e-02     ; = window(  136  )
  dc    1.66370e-02     ; = window(  137  )
  dc    1.68963e-02     ; = window(  138  )
  dc    1.71579e-02     ; = window(  139  )
  dc    1.74219e-02     ; = window(  140  )
  dc    1.76881e-02     ; = window(  141  )
  dc    1.79566e-02     ; = window(  142  )
  dc    1.82275e-02     ; = window(  143  )
  dc    1.85007e-02     ; = window(  144  )
  dc    1.87763e-02     ; = window(  145  )
  dc    1.90541e-02     ; = window(  146  )
  dc    1.93344e-02     ; = window(  147  )
  dc    1.96170e-02     ; = window(  148  )
  dc    1.99020e-02     ; = window(  149  )
  dc    2.01893e-02     ; = window(  150  )
  dc    2.04790e-02     ; = window(  151  )
  dc    2.07712e-02     ; = window(  152  )
  dc    2.10657e-02     ; = window(  153  )
  dc    2.13627e-02     ; = window(  154  )
  dc    2.16620e-02     ; = window(  155  )
  dc    2.19639e-02     ; = window(  156  )
  dc    2.22681e-02     ; = window(  157  )
  dc    2.25748e-02     ; = window(  158  )
  dc    2.28839e-02     ; = window(  159  )
  dc    2.31955e-02     ; = window(  160  )
  dc    2.35096e-02     ; = window(  161  )
  dc    2.38262e-02     ; = window(  162  )
  dc    2.41452e-02     ; = window(  163  )
  dc    2.44667e-02     ; = window(  164  )
  dc    2.47908e-02     ; = window(  165  )
  dc    2.51174e-02     ; = window(  166  )
  dc    2.54464e-02     ; = window(  167  )
  dc    2.57781e-02     ; = window(  168  )
  dc    2.61122e-02     ; = window(  169  )
  dc    2.64489e-02     ; = window(  170  )
  dc    2.67882e-02     ; = window(  171  )
  dc    2.71300e-02     ; = window(  172  )
  dc    2.74744e-02     ; = window(  173  )
  dc    2.78214e-02     ; = window(  174  )
  dc    2.81710e-02     ; = window(  175  )
  dc    2.85232e-02     ; = window(  176  )
  dc    2.88780e-02     ; = window(  177  )
  dc    2.92354e-02     ; = window(  178  )
  dc    2.95955e-02     ; = window(  179  )
  dc    2.99582e-02     ; = window(  180  )
  dc    3.03235e-02     ; = window(  181  )
  dc    3.06915e-02     ; = window(  182  )
  dc    3.10622e-02     ; = window(  183  )
  dc    3.14355e-02     ; = window(  184  )
  dc    3.18115e-02     ; = window(  185  )
  dc    3.21902e-02     ; = window(  186  )
  dc    3.25716e-02     ; = window(  187  )
  dc    3.29557e-02     ; = window(  188  )
  dc    3.33426e-02     ; = window(  189  )
  dc    3.37321e-02     ; = window(  190  )
  dc    3.41244e-02     ; = window(  191  )
  dc    3.45195e-02     ; = window(  192  )
  dc    3.49173e-02     ; = window(  193  )
  dc    3.53178e-02     ; = window(  194  )
  dc    3.57212e-02     ; = window(  195  )
  dc    3.61273e-02     ; = window(  196  )
  dc    3.65362e-02     ; = window(  197  )
  dc    3.69479e-02     ; = window(  198  )
  dc    3.73624e-02     ; = window(  199  )
  dc    3.77798e-02     ; = window(  200  )
  dc    3.81999e-02     ; = window(  201  )
  dc    3.86229e-02     ; = window(  202  )
  dc    3.90488e-02     ; = window(  203  )
  dc    3.94775e-02     ; = window(  204  )
  dc    3.99090e-02     ; = window(  205  )
  dc    4.03435e-02     ; = window(  206  )
  dc    4.07808e-02     ; = window(  207  )
  dc    4.12210e-02     ; = window(  208  )
  dc    4.16641e-02     ; = window(  209  )
  dc    4.21102e-02     ; = window(  210  )
  dc    4.25591e-02     ; = window(  211  )
  dc    4.30110e-02     ; = window(  212  )
  dc    4.34658e-02     ; = window(  213  )
  dc    4.39235e-02     ; = window(  214  )
  dc    4.43842e-02     ; = window(  215  )
  dc    4.48479e-02     ; = window(  216  )
  dc    4.53145e-02     ; = window(  217  )
  dc    4.57842e-02     ; = window(  218  )
  dc    4.62568e-02     ; = window(  219  )
  dc    4.67324e-02     ; = window(  220  )
  dc    4.72110e-02     ; = window(  221  )
  dc    4.76927e-02     ; = window(  222  )
  dc    4.81774e-02     ; = window(  223  )
  dc    4.86651e-02     ; = window(  224  )
  dc    4.91558e-02     ; = window(  225  )
  dc    4.96496e-02     ; = window(  226  )
  dc    5.01465e-02     ; = window(  227  )
  dc    5.06464e-02     ; = window(  228  )
  dc    5.11495e-02     ; = window(  229  )
  dc    5.16556e-02     ; = window(  230  )
  dc    5.21648e-02     ; = window(  231  )
  dc    5.26771e-02     ; = window(  232  )
  dc    5.31925e-02     ; = window(  233  )
  dc    5.37111e-02     ; = window(  234  )
  dc    5.42328e-02     ; = window(  235  )
  dc    5.47577e-02     ; = window(  236  )
  dc    5.52857e-02     ; = window(  237  )
  dc    5.58168e-02     ; = window(  238  )
  dc    5.63511e-02     ; = window(  239  )
  dc    5.68886e-02     ; = window(  240  )
  dc    5.74293e-02     ; = window(  241  )
  dc    5.79732e-02     ; = window(  242  )
  dc    5.85203e-02     ; = window(  243  )
  dc    5.90706e-02     ; = window(  244  )
  dc    5.96241e-02     ; = window(  245  )
  dc    6.01809e-02     ; = window(  246  )
  dc    6.07409e-02     ; = window(  247  )
  dc    6.13041e-02     ; = window(  248  )
  dc    6.18706e-02     ; = window(  249  )
  dc    6.24404e-02     ; = window(  250  )
  dc    6.30134e-02     ; = window(  251  )
  dc    6.35898e-02     ; = window(  252  )
  dc    6.41694e-02     ; = window(  253  )
  dc    6.47523e-02     ; = window(  254  )
  dc    6.53385e-02     ; = window(  255  )
  dc    6.59280e-02     ; = window(  256  )
  dc    6.65209e-02     ; = window(  257  )
  dc    6.71171e-02     ; = window(  258  )
  dc    6.77166e-02     ; = window(  259  )
  dc    6.83195e-02     ; = window(  260  )
  dc    6.89257e-02     ; = window(  261  )
  dc    6.95353e-02     ; = window(  262  )
  dc    7.01483e-02     ; = window(  263  )
  dc    7.07646e-02     ; = window(  264  )
  dc    7.13844e-02     ; = window(  265  )
  dc    7.20075e-02     ; = window(  266  )
  dc    7.26341e-02     ; = window(  267  )
  dc    7.32640e-02     ; = window(  268  )
  dc    7.38974e-02     ; = window(  269  )
  dc    7.45342e-02     ; = window(  270  )
  dc    7.51745e-02     ; = window(  271  )
  dc    7.58181e-02     ; = window(  272  )
  dc    7.64653e-02     ; = window(  273  )
  dc    7.71159e-02     ; = window(  274  )
  dc    7.77700e-02     ; = window(  275  )
  dc    7.84275e-02     ; = window(  276  )
  dc    7.90885e-02     ; = window(  277  )
  dc    7.97531e-02     ; = window(  278  )
  dc    8.04211e-02     ; = window(  279  )
  dc    8.10926e-02     ; = window(  280  )
  dc    8.17676e-02     ; = window(  281  )
  dc    8.24462e-02     ; = window(  282  )
  dc    8.31283e-02     ; = window(  283  )
  dc    8.38139e-02     ; = window(  284  )
  dc    8.45030e-02     ; = window(  285  )
  dc    8.51958e-02     ; = window(  286  )
  dc    8.58920e-02     ; = window(  287  )
  dc    8.65919e-02     ; = window(  288  )
  dc    8.72953e-02     ; = window(  289  )
  dc    8.80022e-02     ; = window(  290  )
  dc    8.87128e-02     ; = window(  291  )
  dc    8.94269e-02     ; = window(  292  )
  dc    9.01447e-02     ; = window(  293  )
  dc    9.08661e-02     ; = window(  294  )
  dc    9.15910e-02     ; = window(  295  )
  dc    9.23196e-02     ; = window(  296  )
  dc    9.30518e-02     ; = window(  297  )
  dc    9.37877e-02     ; = window(  298  )
  dc    9.45272e-02     ; = window(  299  )
  dc    9.52703e-02     ; = window(  300  )
  dc    9.60171e-02     ; = window(  301  )
  dc    9.67675e-02     ; = window(  302  )
  dc    9.75216e-02     ; = window(  303  )
  dc    9.82794e-02     ; = window(  304  )
  dc    9.90408e-02     ; = window(  305  )
  dc    9.98060e-02     ; = window(  306  )
  dc   0.100575     ; = window(  307  )
  dc   0.101347     ; = window(  308  )
  dc   0.102123     ; = window(  309  )
  dc   0.102903     ; = window(  310  )
  dc   0.103687     ; = window(  311  )
  dc   0.104474     ; = window(  312  )
  dc   0.105265     ; = window(  313  )
  dc   0.106060     ; = window(  314  )
  dc   0.106859     ; = window(  315  )
  dc   0.107661     ; = window(  316  )
  dc   0.108467     ; = window(  317  )
  dc   0.109277     ; = window(  318  )
  dc   0.110090     ; = window(  319  )
  dc   0.110908     ; = window(  320  )
  dc   0.111729     ; = window(  321  )
  dc   0.112554     ; = window(  322  )
  dc   0.113382     ; = window(  323  )
  dc   0.114215     ; = window(  324  )
  dc   0.115051     ; = window(  325  )
  dc   0.115891     ; = window(  326  )
  dc   0.116734     ; = window(  327  )
  dc   0.117582     ; = window(  328  )
  dc   0.118433     ; = window(  329  )
  dc   0.119289     ; = window(  330  )
  dc   0.120148     ; = window(  331  )
  dc   0.121010     ; = window(  332  )
  dc   0.121877     ; = window(  333  )
  dc   0.122747     ; = window(  334  )
  dc   0.123622     ; = window(  335  )
  dc   0.124500     ; = window(  336  )
  dc   0.125382     ; = window(  337  )
  dc   0.126268     ; = window(  338  )
  dc   0.127157     ; = window(  339  )
  dc   0.128051     ; = window(  340  )
  dc   0.128948     ; = window(  341  )
  dc   0.129849     ; = window(  342  )
  dc   0.130755     ; = window(  343  )
  dc   0.131663     ; = window(  344  )
  dc   0.132576     ; = window(  345  )
  dc   0.133493     ; = window(  346  )
  dc   0.134414     ; = window(  347  )
  dc   0.135338     ; = window(  348  )
  dc   0.136266     ; = window(  349  )
  dc   0.137199     ; = window(  350  )
  dc   0.138135     ; = window(  351  )
  dc   0.139075     ; = window(  352  )
  dc   0.140019     ; = window(  353  )
  dc   0.140966     ; = window(  354  )
  dc   0.141918     ; = window(  355  )
  dc   0.142874     ; = window(  356  )
  dc   0.143833     ; = window(  357  )
  dc   0.144796     ; = window(  358  )
  dc   0.145764     ; = window(  359  )
  dc   0.146735     ; = window(  360  )
  dc   0.147710     ; = window(  361  )
  dc   0.148689     ; = window(  362  )
  dc   0.149672     ; = window(  363  )
  dc   0.150659     ; = window(  364  )
  dc   0.151650     ; = window(  365  )
  dc   0.152644     ; = window(  366  )
  dc   0.153643     ; = window(  367  )
  dc   0.154646     ; = window(  368  )
  dc   0.155652     ; = window(  369  )
  dc   0.156663     ; = window(  370  )
  dc   0.157677     ; = window(  371  )
  dc   0.158695     ; = window(  372  )
  dc   0.159717     ; = window(  373  )
  dc   0.160743     ; = window(  374  )
  dc   0.161774     ; = window(  375  )
  dc   0.162808     ; = window(  376  )
  dc   0.163845     ; = window(  377  )
  dc   0.164887     ; = window(  378  )
  dc   0.165933     ; = window(  379  )
  dc   0.166983     ; = window(  380  )
  dc   0.168037     ; = window(  381  )
  dc   0.169094     ; = window(  382  )
  dc   0.170156     ; = window(  383  )
  dc   0.171221     ; = window(  384  )
  dc   0.172291     ; = window(  385  )
  dc   0.173364     ; = window(  386  )
  dc   0.174441     ; = window(  387  )
  dc   0.175522     ; = window(  388  )
  dc   0.176608     ; = window(  389  )
  dc   0.177697     ; = window(  390  )
  dc   0.178790     ; = window(  391  )
  dc   0.179887     ; = window(  392  )
  dc   0.180987     ; = window(  393  )
  dc   0.182092     ; = window(  394  )
  dc   0.183201     ; = window(  395  )
  dc   0.184314     ; = window(  396  )
  dc   0.185430     ; = window(  397  )
  dc   0.186551     ; = window(  398  )
  dc   0.187675     ; = window(  399  )
  dc   0.188803     ; = window(  400  )
  dc   0.189936     ; = window(  401  )
  dc   0.191072     ; = window(  402  )
  dc   0.192212     ; = window(  403  )
  dc   0.193356     ; = window(  404  )
  dc   0.194504     ; = window(  405  )
  dc   0.195656     ; = window(  406  )
  dc   0.196811     ; = window(  407  )
  dc   0.197971     ; = window(  408  )
  dc   0.199135     ; = window(  409  )
  dc   0.200302     ; = window(  410  )
  dc   0.201473     ; = window(  411  )
  dc   0.202649     ; = window(  412  )
  dc   0.203828     ; = window(  413  )
  dc   0.205011     ; = window(  414  )
  dc   0.206198     ; = window(  415  )
  dc   0.207388     ; = window(  416  )
  dc   0.208583     ; = window(  417  )
  dc   0.209782     ; = window(  418  )
  dc   0.210984     ; = window(  419  )
  dc   0.212190     ; = window(  420  )
  dc   0.213400     ; = window(  421  )
  dc   0.214614     ; = window(  422  )
  dc   0.215832     ; = window(  423  )
  dc   0.217054     ; = window(  424  )
  dc   0.218279     ; = window(  425  )
  dc   0.219509     ; = window(  426  )
  dc   0.220742     ; = window(  427  )
  dc   0.221979     ; = window(  428  )
  dc   0.223220     ; = window(  429  )
  dc   0.224465     ; = window(  430  )
  dc   0.225713     ; = window(  431  )
  dc   0.226965     ; = window(  432  )
  dc   0.228221     ; = window(  433  )
  dc   0.229481     ; = window(  434  )
  dc   0.230745     ; = window(  435  )
  dc   0.232013     ; = window(  436  )
  dc   0.233284     ; = window(  437  )
  dc   0.234559     ; = window(  438  )
  dc   0.235838     ; = window(  439  )
  dc   0.237121     ; = window(  440  )
  dc   0.238407     ; = window(  441  )
  dc   0.239697     ; = window(  442  )
  dc   0.240991     ; = window(  443  )
  dc   0.242289     ; = window(  444  )
  dc   0.243590     ; = window(  445  )
  dc   0.244895     ; = window(  446  )
  dc   0.246204     ; = window(  447  )
  dc   0.247516     ; = window(  448  )
  dc   0.248833     ; = window(  449  )
  dc   0.250153     ; = window(  450  )
  dc   0.251476     ; = window(  451  )
  dc   0.252804     ; = window(  452  )
  dc   0.254135     ; = window(  453  )
  dc   0.255469     ; = window(  454  )
  dc   0.256808     ; = window(  455  )
  dc   0.258150     ; = window(  456  )
  dc   0.259495     ; = window(  457  )
  dc   0.260845     ; = window(  458  )
  dc   0.262198     ; = window(  459  )
  dc   0.263554     ; = window(  460  )
  dc   0.264915     ; = window(  461  )
  dc   0.266278     ; = window(  462  )
  dc   0.267646     ; = window(  463  )
  dc   0.269017     ; = window(  464  )
  dc   0.270391     ; = window(  465  )
  dc   0.271769     ; = window(  466  )
  dc   0.273151     ; = window(  467  )
  dc   0.274536     ; = window(  468  )
  dc   0.275925     ; = window(  469  )
  dc   0.277318     ; = window(  470  )
  dc   0.278713     ; = window(  471  )
  dc   0.280113     ; = window(  472  )
  dc   0.281516     ; = window(  473  )
  dc   0.282922     ; = window(  474  )
  dc   0.284332     ; = window(  475  )
  dc   0.285746     ; = window(  476  )
  dc   0.287162     ; = window(  477  )
  dc   0.288583     ; = window(  478  )
  dc   0.290006     ; = window(  479  )
  dc   0.291434     ; = window(  480  )
  dc   0.292864     ; = window(  481  )
  dc   0.294298     ; = window(  482  )
  dc   0.295736     ; = window(  483  )
  dc   0.297177     ; = window(  484  )
  dc   0.298621     ; = window(  485  )
  dc   0.300068     ; = window(  486  )
  dc   0.301519     ; = window(  487  )
  dc   0.302974     ; = window(  488  )
  dc   0.304431     ; = window(  489  )
  dc   0.305892     ; = window(  490  )
  dc   0.307356     ; = window(  491  )
  dc   0.308824     ; = window(  492  )
  dc   0.310295     ; = window(  493  )
  dc   0.311769     ; = window(  494  )
  dc   0.313246     ; = window(  495  )
  dc   0.314727     ; = window(  496  )
  dc   0.316211     ; = window(  497  )
  dc   0.317698     ; = window(  498  )
  dc   0.319189     ; = window(  499  )
  dc   0.320682     ; = window(  500  )
  dc   0.322179     ; = window(  501  )
  dc   0.323679     ; = window(  502  )
  dc   0.325182     ; = window(  503  )
  dc   0.326688     ; = window(  504  )
  dc   0.328197     ; = window(  505  )
  dc   0.329710     ; = window(  506  )
  dc   0.331226     ; = window(  507  )
  dc   0.332744     ; = window(  508  )
  dc   0.334266     ; = window(  509  )
  dc   0.335791     ; = window(  510  )
  dc   0.337319     ; = window(  511  )
  dc   0.338850     ; = window(  512  )
  dc   0.340384     ; = window(  513  )
  dc   0.341921     ; = window(  514  )
  dc   0.343461     ; = window(  515  )
  dc   0.345004     ; = window(  516  )
  dc   0.346550     ; = window(  517  )
  dc   0.348099     ; = window(  518  )
  dc   0.349650     ; = window(  519  )
  dc   0.351205     ; = window(  520  )
  dc   0.352763     ; = window(  521  )
  dc   0.354323     ; = window(  522  )
  dc   0.355887     ; = window(  523  )
  dc   0.357453     ; = window(  524  )
  dc   0.359022     ; = window(  525  )
  dc   0.360594     ; = window(  526  )
  dc   0.362169     ; = window(  527  )
  dc   0.363746     ; = window(  528  )
  dc   0.365327     ; = window(  529  )
  dc   0.366910     ; = window(  530  )
  dc   0.368496     ; = window(  531  )
  dc   0.370084     ; = window(  532  )
  dc   0.371676     ; = window(  533  )
  dc   0.373270     ; = window(  534  )
  dc   0.374866     ; = window(  535  )
  dc   0.376466     ; = window(  536  )
  dc   0.378068     ; = window(  537  )
  dc   0.379672     ; = window(  538  )
  dc   0.381280     ; = window(  539  )
  dc   0.382889     ; = window(  540  )
  dc   0.384502     ; = window(  541  )
  dc   0.386117     ; = window(  542  )
  dc   0.387734     ; = window(  543  )
  dc   0.389354     ; = window(  544  )
  dc   0.390977     ; = window(  545  )
  dc   0.392602     ; = window(  546  )
  dc   0.394230     ; = window(  547  )
  dc   0.395860     ; = window(  548  )
  dc   0.397492     ; = window(  549  )
  dc   0.399127     ; = window(  550  )
  dc   0.400764     ; = window(  551  )
  dc   0.402404     ; = window(  552  )
  dc   0.404046     ; = window(  553  )
  dc   0.405690     ; = window(  554  )
  dc   0.407337     ; = window(  555  )
  dc   0.408986     ; = window(  556  )
  dc   0.410637     ; = window(  557  )
  dc   0.412290     ; = window(  558  )
  dc   0.413946     ; = window(  559  )
  dc   0.415604     ; = window(  560  )
  dc   0.417264     ; = window(  561  )
  dc   0.418927     ; = window(  562  )
  dc   0.420591     ; = window(  563  )
  dc   0.422258     ; = window(  564  )
  dc   0.423927     ; = window(  565  )
  dc   0.425598     ; = window(  566  )
  dc   0.427271     ; = window(  567  )
  dc   0.428946     ; = window(  568  )
  dc   0.430623     ; = window(  569  )
  dc   0.432302     ; = window(  570  )
  dc   0.433983     ; = window(  571  )
  dc   0.435666     ; = window(  572  )
  dc   0.437351     ; = window(  573  )
  dc   0.439038     ; = window(  574  )
  dc   0.440727     ; = window(  575  )
  dc   0.442418     ; = window(  576  )
  dc   0.444111     ; = window(  577  )
  dc   0.445806     ; = window(  578  )
  dc   0.447502     ; = window(  579  )
  dc   0.449201     ; = window(  580  )
  dc   0.450901     ; = window(  581  )
  dc   0.452602     ; = window(  582  )
  dc   0.454306     ; = window(  583  )
  dc   0.456011     ; = window(  584  )
  dc   0.457718     ; = window(  585  )
  dc   0.459427     ; = window(  586  )
  dc   0.461138     ; = window(  587  )
  dc   0.462850     ; = window(  588  )
  dc   0.464563     ; = window(  589  )
  dc   0.466279     ; = window(  590  )
  dc   0.467995     ; = window(  591  )
  dc   0.469714     ; = window(  592  )
  dc   0.471434     ; = window(  593  )
  dc   0.473155     ; = window(  594  )
  dc   0.474878     ; = window(  595  )
  dc   0.476602     ; = window(  596  )
  dc   0.478328     ; = window(  597  )
  dc   0.480055     ; = window(  598  )
  dc   0.481784     ; = window(  599  )
  dc   0.483514     ; = window(  600  )
  dc   0.485245     ; = window(  601  )
  dc   0.486978     ; = window(  602  )
  dc   0.488712     ; = window(  603  )
  dc   0.490447     ; = window(  604  )
  dc   0.492184     ; = window(  605  )
  dc   0.493922     ; = window(  606  )
  dc   0.495660     ; = window(  607  )
  dc   0.497401     ; = window(  608  )
  dc   0.499142     ; = window(  609  )
  dc   0.500884     ; = window(  610  )
  dc   0.502628     ; = window(  611  )
  dc   0.504372     ; = window(  612  )
  dc   0.506118     ; = window(  613  )
  dc   0.507865     ; = window(  614  )
  dc   0.509612     ; = window(  615  )
  dc   0.511361     ; = window(  616  )
  dc   0.513111     ; = window(  617  )
  dc   0.514861     ; = window(  618  )
  dc   0.516613     ; = window(  619  )
  dc   0.518365     ; = window(  620  )
  dc   0.520118     ; = window(  621  )
  dc   0.521872     ; = window(  622  )
  dc   0.523627     ; = window(  623  )
  dc   0.525383     ; = window(  624  )
  dc   0.527139     ; = window(  625  )
  dc   0.528896     ; = window(  626  )
  dc   0.530654     ; = window(  627  )
  dc   0.532413     ; = window(  628  )
  dc   0.534172     ; = window(  629  )
  dc   0.535932     ; = window(  630  )
  dc   0.537692     ; = window(  631  )
  dc   0.539454     ; = window(  632  )
  dc   0.541215     ; = window(  633  )
  dc   0.542977     ; = window(  634  )
  dc   0.544740     ; = window(  635  )
  dc   0.546503     ; = window(  636  )
  dc   0.548267     ; = window(  637  )
  dc   0.550031     ; = window(  638  )
  dc   0.551795     ; = window(  639  )
  dc   0.553560     ; = window(  640  )
  dc   0.555325     ; = window(  641  )
  dc   0.557090     ; = window(  642  )
  dc   0.558856     ; = window(  643  )
  dc   0.560622     ; = window(  644  )
  dc   0.562388     ; = window(  645  )
  dc   0.564155     ; = window(  646  )
  dc   0.565921     ; = window(  647  )
  dc   0.567688     ; = window(  648  )
  dc   0.569455     ; = window(  649  )
  dc   0.571222     ; = window(  650  )
  dc   0.572989     ; = window(  651  )
  dc   0.574756     ; = window(  652  )
  dc   0.576524     ; = window(  653  )
  dc   0.578291     ; = window(  654  )
  dc   0.580058     ; = window(  655  )
  dc   0.581825     ; = window(  656  )
  dc   0.583592     ; = window(  657  )
  dc   0.585359     ; = window(  658  )
  dc   0.587126     ; = window(  659  )
  dc   0.588892     ; = window(  660  )
  dc   0.590659     ; = window(  661  )
  dc   0.592425     ; = window(  662  )
  dc   0.594191     ; = window(  663  )
  dc   0.595957     ; = window(  664  )
  dc   0.597722     ; = window(  665  )
  dc   0.599487     ; = window(  666  )
  dc   0.601252     ; = window(  667  )
  dc   0.603016     ; = window(  668  )
  dc   0.604780     ; = window(  669  )
  dc   0.606543     ; = window(  670  )
  dc   0.608306     ; = window(  671  )
  dc   0.610069     ; = window(  672  )
  dc   0.611831     ; = window(  673  )
  dc   0.613592     ; = window(  674  )
  dc   0.615353     ; = window(  675  )
  dc   0.617113     ; = window(  676  )
  dc   0.618873     ; = window(  677  )
  dc   0.620632     ; = window(  678  )
  dc   0.622390     ; = window(  679  )
  dc   0.624147     ; = window(  680  )
  dc   0.625904     ; = window(  681  )
  dc   0.627660     ; = window(  682  )
  dc   0.629415     ; = window(  683  )
  dc   0.631169     ; = window(  684  )
  dc   0.632923     ; = window(  685  )
  dc   0.634675     ; = window(  686  )
  dc   0.636427     ; = window(  687  )
  dc   0.638178     ; = window(  688  )
  dc   0.639927     ; = window(  689  )
  dc   0.641676     ; = window(  690  )
  dc   0.643423     ; = window(  691  )
  dc   0.645170     ; = window(  692  )
  dc   0.646916     ; = window(  693  )
  dc   0.648660     ; = window(  694  )
  dc   0.650403     ; = window(  695  )
  dc   0.652145     ; = window(  696  )
  dc   0.653886     ; = window(  697  )
  dc   0.655625     ; = window(  698  )
  dc   0.657364     ; = window(  699  )
  dc   0.659101     ; = window(  700  )
  dc   0.660836     ; = window(  701  )
  dc   0.662571     ; = window(  702  )
  dc   0.664304     ; = window(  703  )
  dc   0.666035     ; = window(  704  )
  dc   0.667765     ; = window(  705  )
  dc   0.669493     ; = window(  706  )
  dc   0.671221     ; = window(  707  )
  dc   0.672946     ; = window(  708  )
  dc   0.674670     ; = window(  709  )
  dc   0.676392     ; = window(  710  )
  dc   0.678113     ; = window(  711  )
  dc   0.679832     ; = window(  712  )
  dc   0.681550     ; = window(  713  )
  dc   0.683266     ; = window(  714  )
  dc   0.684979     ; = window(  715  )
  dc   0.686692     ; = window(  716  )
  dc   0.688402     ; = window(  717  )
  dc   0.690111     ; = window(  718  )
  dc   0.691818     ; = window(  719  )
  dc   0.693522     ; = window(  720  )
  dc   0.695225     ; = window(  721  )
  dc   0.696926     ; = window(  722  )
  dc   0.698625     ; = window(  723  )
  dc   0.700323     ; = window(  724  )
  dc   0.702017     ; = window(  725  )
  dc   0.703710     ; = window(  726  )
  dc   0.705401     ; = window(  727  )
  dc   0.707090     ; = window(  728  )
  dc   0.708777     ; = window(  729  )
  dc   0.710461     ; = window(  730  )
  dc   0.712143     ; = window(  731  )
  dc   0.713823     ; = window(  732  )
  dc   0.715501     ; = window(  733  )
  dc   0.717176     ; = window(  734  )
  dc   0.718850     ; = window(  735  )
  dc   0.720520     ; = window(  736  )
  dc   0.722189     ; = window(  737  )
  dc   0.723855     ; = window(  738  )
  dc   0.725518     ; = window(  739  )
  dc   0.727179     ; = window(  740  )
  dc   0.728838     ; = window(  741  )
  dc   0.730494     ; = window(  742  )
  dc   0.732147     ; = window(  743  )
  dc   0.733798     ; = window(  744  )
  dc   0.735446     ; = window(  745  )
  dc   0.737092     ; = window(  746  )
  dc   0.738735     ; = window(  747  )
  dc   0.740375     ; = window(  748  )
  dc   0.742013     ; = window(  749  )
  dc   0.743648     ; = window(  750  )
  dc   0.745280     ; = window(  751  )
  dc   0.746909     ; = window(  752  )
  dc   0.748535     ; = window(  753  )
  dc   0.750158     ; = window(  754  )
  dc   0.751779     ; = window(  755  )
  dc   0.753396     ; = window(  756  )
  dc   0.755011     ; = window(  757  )
  dc   0.756623     ; = window(  758  )
  dc   0.758231     ; = window(  759  )
  dc   0.759837     ; = window(  760  )
  dc   0.761439     ; = window(  761  )
  dc   0.763038     ; = window(  762  )
  dc   0.764635     ; = window(  763  )
  dc   0.766228     ; = window(  764  )
  dc   0.767818     ; = window(  765  )
  dc   0.769404     ; = window(  766  )
  dc   0.770988     ; = window(  767  )
  dc   0.772568     ; = window(  768  )
  dc   0.774144     ; = window(  769  )
  dc   0.775718     ; = window(  770  )
  dc   0.777288     ; = window(  771  )
  dc   0.778854     ; = window(  772  )
  dc   0.780418     ; = window(  773  )
  dc   0.781977     ; = window(  774  )
  dc   0.783534     ; = window(  775  )
  dc   0.785086     ; = window(  776  )
  dc   0.786636     ; = window(  777  )
  dc   0.788181     ; = window(  778  )
  dc   0.789723     ; = window(  779  )
  dc   0.791262     ; = window(  780  )
  dc   0.792796     ; = window(  781  )
  dc   0.794327     ; = window(  782  )
  dc   0.795855     ; = window(  783  )
  dc   0.797378     ; = window(  784  )
  dc   0.798898     ; = window(  785  )
  dc   0.800414     ; = window(  786  )
  dc   0.801927     ; = window(  787  )
  dc   0.803435     ; = window(  788  )
  dc   0.804939     ; = window(  789  )
  dc   0.806440     ; = window(  790  )
  dc   0.807937     ; = window(  791  )
  dc   0.809429     ; = window(  792  )
  dc   0.810918     ; = window(  793  )
  dc   0.812403     ; = window(  794  )
  dc   0.813883     ; = window(  795  )
  dc   0.815360     ; = window(  796  )
  dc   0.816832     ; = window(  797  )
  dc   0.818301     ; = window(  798  )
  dc   0.819765     ; = window(  799  )
  dc   0.821225     ; = window(  800  )
  dc   0.822681     ; = window(  801  )
  dc   0.824132     ; = window(  802  )
  dc   0.825579     ; = window(  803  )
  dc   0.827022     ; = window(  804  )
  dc   0.828461     ; = window(  805  )
  dc   0.829895     ; = window(  806  )
  dc   0.831325     ; = window(  807  )
  dc   0.832751     ; = window(  808  )
  dc   0.834172     ; = window(  809  )
  dc   0.835588     ; = window(  810  )
  dc   0.837000     ; = window(  811  )
  dc   0.838408     ; = window(  812  )
  dc   0.839811     ; = window(  813  )
  dc   0.841210     ; = window(  814  )
  dc   0.842604     ; = window(  815  )
  dc   0.843993     ; = window(  816  )
  dc   0.845378     ; = window(  817  )
  dc   0.846758     ; = window(  818  )
  dc   0.848133     ; = window(  819  )
  dc   0.849504     ; = window(  820  )
  dc   0.850869     ; = window(  821  )
  dc   0.852230     ; = window(  822  )
  dc   0.853587     ; = window(  823  )
  dc   0.854938     ; = window(  824  )
  dc   0.856285     ; = window(  825  )
  dc   0.857626     ; = window(  826  )
  dc   0.858963     ; = window(  827  )
  dc   0.860295     ; = window(  828  )
  dc   0.861622     ; = window(  829  )
  dc   0.862944     ; = window(  830  )
  dc   0.864261     ; = window(  831  )
  dc   0.865573     ; = window(  832  )
  dc   0.866880     ; = window(  833  )
  dc   0.868182     ; = window(  834  )
  dc   0.869478     ; = window(  835  )
  dc   0.870770     ; = window(  836  )
  dc   0.872056     ; = window(  837  )
  dc   0.873337     ; = window(  838  )
  dc   0.874613     ; = window(  839  )
  dc   0.875884     ; = window(  840  )
  dc   0.877150     ; = window(  841  )
  dc   0.878410     ; = window(  842  )
  dc   0.879665     ; = window(  843  )
  dc   0.880914     ; = window(  844  )
  dc   0.882159     ; = window(  845  )
  dc   0.883397     ; = window(  846  )
  dc   0.884631     ; = window(  847  )
  dc   0.885859     ; = window(  848  )
  dc   0.887082     ; = window(  849  )
  dc   0.888299     ; = window(  850  )
  dc   0.889510     ; = window(  851  )
  dc   0.890716     ; = window(  852  )
  dc   0.891917     ; = window(  853  )
  dc   0.893112     ; = window(  854  )
  dc   0.894302     ; = window(  855  )
  dc   0.895485     ; = window(  856  )
  dc   0.896663     ; = window(  857  )
  dc   0.897836     ; = window(  858  )
  dc   0.899003     ; = window(  859  )
  dc   0.900164     ; = window(  860  )
  dc   0.901319     ; = window(  861  )
  dc   0.902469     ; = window(  862  )
  dc   0.903613     ; = window(  863  )
  dc   0.904751     ; = window(  864  )
  dc   0.905883     ; = window(  865  )
  dc   0.907010     ; = window(  866  )
  dc   0.908130     ; = window(  867  )
  dc   0.909245     ; = window(  868  )
  dc   0.910354     ; = window(  869  )
  dc   0.911457     ; = window(  870  )
  dc   0.912553     ; = window(  871  )
  dc   0.913644     ; = window(  872  )
  dc   0.914729     ; = window(  873  )
  dc   0.915808     ; = window(  874  )
  dc   0.916881     ; = window(  875  )
  dc   0.917948     ; = window(  876  )
  dc   0.919009     ; = window(  877  )
  dc   0.920063     ; = window(  878  )
  dc   0.921112     ; = window(  879  )
  dc   0.922154     ; = window(  880  )
  dc   0.923191     ; = window(  881  )
  dc   0.924221     ; = window(  882  )
  dc   0.925245     ; = window(  883  )
  dc   0.926262     ; = window(  884  )
  dc   0.927274     ; = window(  885  )
  dc   0.928279     ; = window(  886  )
  dc   0.929278     ; = window(  887  )
  dc   0.930270     ; = window(  888  )
  dc   0.931256     ; = window(  889  )
  dc   0.932236     ; = window(  890  )
  dc   0.933210     ; = window(  891  )
  dc   0.934177     ; = window(  892  )
  dc   0.935138     ; = window(  893  )
  dc   0.936092     ; = window(  894  )
  dc   0.937040     ; = window(  895  )
  dc   0.937982     ; = window(  896  )
  dc   0.938917     ; = window(  897  )
  dc   0.939845     ; = window(  898  )
  dc   0.940767     ; = window(  899  )
  dc   0.941683     ; = window(  900  )
  dc   0.942591     ; = window(  901  )
  dc   0.943494     ; = window(  902  )
  dc   0.944390     ; = window(  903  )
  dc   0.945279     ; = window(  904  )
  dc   0.946161     ; = window(  905  )
  dc   0.947037     ; = window(  906  )
  dc   0.947906     ; = window(  907  )
  dc   0.948769     ; = window(  908  )
  dc   0.949625     ; = window(  909  )
  dc   0.950474     ; = window(  910  )
  dc   0.951317     ; = window(  911  )
  dc   0.952152     ; = window(  912  )
  dc   0.952981     ; = window(  913  )
  dc   0.953803     ; = window(  914  )
  dc   0.954619     ; = window(  915  )
  dc   0.955427     ; = window(  916  )
  dc   0.956229     ; = window(  917  )
  dc   0.957024     ; = window(  918  )
  dc   0.957812     ; = window(  919  )
  dc   0.958593     ; = window(  920  )
  dc   0.959368     ; = window(  921  )
  dc   0.960135     ; = window(  922  )
  dc   0.960896     ; = window(  923  )
  dc   0.961649     ; = window(  924  )
  dc   0.962396     ; = window(  925  )
  dc   0.963135     ; = window(  926  )
  dc   0.963868     ; = window(  927  )
  dc   0.964594     ; = window(  928  )
  dc   0.965313     ; = window(  929  )
  dc   0.966024     ; = window(  930  )
  dc   0.966729     ; = window(  931  )
  dc   0.967426     ; = window(  932  )
  dc   0.968117     ; = window(  933  )
  dc   0.968800     ; = window(  934  )
  dc   0.969477     ; = window(  935  )
  dc   0.970146     ; = window(  936  )
  dc   0.970808     ; = window(  937  )
  dc   0.971463     ; = window(  938  )
  dc   0.972111     ; = window(  939  )
  dc   0.972752     ; = window(  940  )
  dc   0.973385     ; = window(  941  )
  dc   0.974011     ; = window(  942  )
  dc   0.974631     ; = window(  943  )
  dc   0.975242     ; = window(  944  )
  dc   0.975847     ; = window(  945  )
  dc   0.976445     ; = window(  946  )
  dc   0.977035     ; = window(  947  )
  dc   0.977618     ; = window(  948  )
  dc   0.978194     ; = window(  949  )
  dc   0.978762     ; = window(  950  )
  dc   0.979323     ; = window(  951  )
  dc   0.979877     ; = window(  952  )
  dc   0.980423     ; = window(  953  )
  dc   0.980963     ; = window(  954  )
  dc   0.981494     ; = window(  955  )
  dc   0.982019     ; = window(  956  )
  dc   0.982536     ; = window(  957  )
  dc   0.983046     ; = window(  958  )
  dc   0.983548     ; = window(  959  )
  dc   0.984043     ; = window(  960  )
  dc   0.984531     ; = window(  961  )
  dc   0.985011     ; = window(  962  )
  dc   0.985484     ; = window(  963  )
  dc   0.985949     ; = window(  964  )
  dc   0.986407     ; = window(  965  )
  dc   0.986857     ; = window(  966  )
  dc   0.987300     ; = window(  967  )
  dc   0.987736     ; = window(  968  )
  dc   0.988164     ; = window(  969  )
  dc   0.988584     ; = window(  970  )
  dc   0.988997     ; = window(  971  )
  dc   0.989403     ; = window(  972  )
  dc   0.989801     ; = window(  973  )
  dc   0.990191     ; = window(  974  )
  dc   0.990574     ; = window(  975  )
  dc   0.990950     ; = window(  976  )
  dc   0.991318     ; = window(  977  )
  dc   0.991678     ; = window(  978  )
  dc   0.992031     ; = window(  979  )
  dc   0.992376     ; = window(  980  )
  dc   0.992714     ; = window(  981  )
  dc   0.993044     ; = window(  982  )
  dc   0.993367     ; = window(  983  )
  dc   0.993682     ; = window(  984  )
  dc   0.993989     ; = window(  985  )
  dc   0.994289     ; = window(  986  )
  dc   0.994581     ; = window(  987  )
  dc   0.994865     ; = window(  988  )
  dc   0.995142     ; = window(  989  )
  dc   0.995412     ; = window(  990  )
  dc   0.995673     ; = window(  991  )
  dc   0.995927     ; = window(  992  )
  dc   0.996174     ; = window(  993  )
  dc   0.996412     ; = window(  994  )
  dc   0.996643     ; = window(  995  )
  dc   0.996867     ; = window(  996  )
  dc   0.997082     ; = window(  997  )
  dc   0.997291     ; = window(  998  )
  dc   0.997491     ; = window(  999  )
  dc   0.997684     ; = window(  1000  )
  dc   0.997869     ; = window(  1001  )
  dc   0.998046     ; = window(  1002  )
  dc   0.998216     ; = window(  1003  )
  dc   0.998378     ; = window(  1004  )
  dc   0.998532     ; = window(  1005  )
  dc   0.998679     ; = window(  1006  )
  dc   0.998818     ; = window(  1007  )
  dc   0.998949     ; = window(  1008  )
  dc   0.999072     ; = window(  1009  )
  dc   0.999188     ; = window(  1010  )
  dc   0.999296     ; = window(  1011  )
  dc   0.999397     ; = window(  1012  )
  dc   0.999489     ; = window(  1013  )
  dc   0.999574     ; = window(  1014  )
  dc   0.999651     ; = window(  1015  )
  dc   0.999721     ; = window(  1016  )
  dc   0.999783     ; = window(  1017  )
  dc   0.999837     ; = window(  1018  )
  dc   0.999883     ; = window(  1019  )
  dc   0.999922     ; = window(  1020  )
  dc   0.999953     ; = window(  1021  )
  dc   0.999976     ; = window(  1022  )
  dc   0.999991     ; = window(  1023  )
  dc   0.999999     ; = window(  1024  )
