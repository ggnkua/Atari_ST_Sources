  ORG       X:$0020
  DC $000001
  DC $000001
  DC $000001
  DC $000001
  DC $000001
  DC $000001
  DC $000001
  DC $000001
  DC $FFFFDF
  ORG       Y:$0028
  DC $000000
  ORG       X:$0029
  DC $000000
  ORG       Y:$0029
  DC $005730
  ORG       X:$002A
  DC $047AE0
  DC $000000
  DC $000000
  ORG       P:$0000
 P:0000 JMP $0200
  ORG       P:$000C
 P:000C JSR <$0253
 P:000D NOP 
  ORG       P:$0010
 P:0010 JSR <$0263
 P:0011 NOP 
  ORG       P:$0200
 P:0200 MOVEP X:<<$FFEB,X0
 P:0201 MOVEC #<00,SP
 P:0202 MOVEP #>$004100,X:<<$FFEC
 P:0204 MOVEP #>$0001F8,X:<<$FFE1
 P:0206 BTST #$04,X:<<$FFEE
 P:0207 MOVEP #>$00F800,X:<<$FFED
 P:0209 MOVEP #>$000000,X:<<$FFFE
 P:020B MOVEP #>$003000,X:<<$FFFF
 P:020D ANDI #$FC,MR
 P:020E MOVE  #>$002000,R1
 P:0210 MOVEC #>$001FFF,M1
 P:0212 MOVE  #>$FFFFDF,N1
 P:0214 JCLR #$00,X:<<$FFE9,$0218
 P:0216 MOVEP X:<<$FFEB,R7
 P:0217 MOVE  R7,X:<$2A
 P:0218 CLR A #$38,X1
 P:0219 CLR B #$40,Y1
 P:021A MOVE  X:<$2C,Y0
 P:021B MOVE  #>$733333,X0
 P:021D MACR +Y0,X0,A 
 P:021E MACR +Y0,X0,A 
 P:021F MOVE  #>$6CCCCD,X0
 P:0221 MACR +Y0,X0,B X:<$20,X0
 P:0222 MACR +X0,Y1,B B,Y0
 P:0223 MACR +X1,X0,A B,X:<$22
 P:0224 MOVE  Y0,B
 P:0225 NEG B X:<$21,X0
 P:0226 MACR +X0,Y1,B 
 P:0227 MACR +X1,X0,A B,X:<$23
 P:0228 MOVE  A,X:(R1)+
 P:0229 MOVE  L:<$28,A
 P:022A MOVE  L:<$29,X
 P:022B ADD X,A 
 P:022C MOVE  A,L:<$28
 P:022D MOVE  A1,N1
 P:022E MOVE  X1,B
 P:022F MOVE  Y:<$28,A
 P:0230 LSR A #$80,X0
 P:0231 OR X0,A #$40,X1
 P:0232 MOVE  A1,X0
 P:0233 MPY -X1,X0,A 
 P:0234 TST B A,Y0
 P:0235 JPL $0240
 P:0237 MOVE  (R1)-
 P:0238 MOVE  X:(R1+N1),X0
 P:0239 MPY +Y0,X0,A #$40,B
 P:023A SUB Y0,B (R1)+
 P:023B MOVE  B,Y0
 P:023C MOVE  X:(R1+N1),X0
 P:023D MAC +Y0,X0,A 
 P:023E JMP $0246
 P:0240 MOVE  X:(R1+N1),X0
 P:0241 MPY +Y0,X0,A #$40,B
 P:0242 SUB Y0,B (R1)+
 P:0243 MOVE  B,Y0
 P:0244 MOVE  X:(R1+N1),X0
 P:0245 MAC +Y0,X0,A (R1)-
 P:0246 MOVE  A,X:<$2C
 P:0247 MOVE  X:<$2B,A
 P:0248 MOVE  #>$000001,X0
 P:024A SUB X0,A 
 P:024B MOVE  A,X:<$2B
 P:024C JGT $0252
 P:024E MOVE  X:<$2A,X0
 P:024F MOVE  L:<$29,A
 P:0250 NEG A X0,X:<$2B
 P:0251 MOVE  A,L:<$29
 P:0252 JMP <$0214
 P:0253 MOVE  X0,X:<$24
 P:0254 MOVE  X1,X:<$25
 P:0255 JCLR #$00,X:<$26,$025D
 P:0257 MOVEP X:<<$FFEF,X1
 P:0258 MOVE  X1,X:<$21
 P:0259 BCLR #$00,X:<$26
 P:025A MOVE  X:<$24,X0
 P:025B MOVE  X:<$25,X1
 P:025C RTI 
 P:025D MOVEP X:<<$FFEF,X0
 P:025E MOVE  X0,X:<$20
 P:025F BSET #$00,X:<$26
 P:0260 MOVE  X:<$24,X0
 P:0261 MOVE  X:<$25,X1
 P:0262 RTI 
 P:0263 MOVE  X0,X:<$24
 P:0264 MOVE  X1,X:<$25
 P:0265 JCLR #$00,X:<$27,$026D
 P:0267 MOVE  X:<$23,X1
 P:0268 MOVEP X1,X:<<$FFEF
 P:0269 BCLR #$00,X:<$27
 P:026A MOVE  X:<$24,X0
 P:026B MOVE  X:<$25,X1
 P:026C RTI 
 P:026D MOVE  X:<$22,X0
 P:026E MOVEP X0,X:<<$FFEF
 P:026F BSET #$00,X:<$27
 P:0270 MOVE  X:<$24,X0
 P:0271 MOVE  X:<$25,X1
 P:0272 RTI 
