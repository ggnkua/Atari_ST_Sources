  ORG       P:$0140
 P:0140 MOVE  L:<$0D,B
 P:0141 MOVE  L:<$0C,A
 P:0142 ADD A,B 
 P:0143 TST B 
 P:0144 JGT $014A
 P:0146 NEG A 
 P:0147 TFR A,B 
 P:0148 JMP $0151
 P:014A MOVE  #>$000043,X0
 P:014C CMP X0,B 
 P:014D JLT $0151
 P:014F NEG A 
 P:0150 ADD A,B 
 P:0151 MOVE  B,L:<$0D
 P:0152 MOVE  A,L:<$0C
 P:0153 MOVE  B1,N2
 P:0154 MOVE  X:<$00,X0
 P:0155 MOVE  X0,X:(R2+N2)
 P:0156 MOVE  (R2)+
 P:0157 MOVE  X0,X:(R2+N2)
 P:0158 MOVE  (R2)-
 P:0159 MOVE  #$22,N2
 P:015A MOVE  X:<$01,X0
 P:015B MOVE  X0,Y:(R2+N2)
 P:015C MOVE  Y:(R2),X0
 P:015D MOVE  X0,X:<$01
 P:015E MOVE  X:(R2)+,X0
 P:015F MOVE  X0,X:<$00
 P:0160 RTS 
 P:0161 MOVE  L:<$00,A10
  ORG       P:$03A0
 P:03A0 JSET #$0D,Y:<$01,$03B3
 P:03A2 JSET #$05,Y:<$00,$03B3
 P:03A4 CLR B 
 P:03A5 MOVE  B,L:<$0D
 P:03A6 MOVE  #>$00B242,B0
 P:03A8 MOVE  B,L:<$0C
 P:03A9 MOVE  #>$000400,R2
 P:03AB MOVEC #<FF,M2
 P:03AC MOVE  #$80,Y1
 P:03AD DO Y1,$03B1
 P:03AF MOVE  Y0,X:(R2)
 P:03B0 MOVE  Y0,Y:(R2)+
 P:03B1 BSET #$05,Y:<$00
 P:03B2 RTS 
 P:03B3 BCLR #$05,Y:<$00
 P:03B4 RTS 
 P:03B5 MOVE  L:<$00,A10
 P:03B6 MOVE  Y:<$01,B0
 P:03B7 REP #$006
 P:03B8 ASL B 
 P:03B9 MOVE  #$00,B1
 P:03BA MOVE  B,L:<$0C
 P:03BB CLR B 
 P:03BC MOVE  B,Y:<$01
 P:03BD RTS 
 P:03BE MOVE  L:<$00,A10
