  ORG       X:$0020
  DC $000001
  DC $000001
  DC $000001
  DC $000001
  DC $000001
  DC $000001
  DC $000001
  DC $000001
  DC $000000
  DC $000190
  DC $400000
  ORG       Y:$0028
  DC $000000
  DC $005730
  ORG       P:$0000
 P:0000 JMP $0200
  ORG       P:$000C
 P:000C JSR $0232
  ORG       P:$0010
 P:0010 JSR $0243
  ORG       P:$0200
 P:0200 MOVEP X:<<$FFEB,X0
 P:0201 MOVEC #<00,SP
 P:0202 MOVEP #>$004100,X:<<$FFEC
 P:0204 MOVEP #>$0001F8,X:<<$FFE1
 P:0206 BTST #$04,X:<<$FFEE
 P:0207 MOVEP #>$00F800,X:<<$FFED
 P:0209 MOVEP #>$000000,X:<<$FFFE
 P:020B MOVEP #>$003000,X:<<$FFFF
 P:020D MOVEP #>$000001,X:<<$FFE0
 P:020F ANDI #$FC,MR
 P:0210 MOVE  #>$000100,R1
 P:0212 MOVEC #>$0000FF,M1
 P:0214 MOVE  #$29,R2
 P:0215 MOVEC #>$000001,M2
 P:0217 BSET #$02,OMR
 P:0218 MOVE  #>$7FFFFF,Y0
 P:021A JCLR #$00,X:<<$FFE9,$021D
 P:021C MOVEP X:<<$FFEB,X:(R2)+
 P:021D MOVE  X:<$28,A
 P:021E MOVE  #>$000001,X0
 P:0220 MOVE  X:<$29,X1
 P:0221 ADD X0,A 
 P:0222 CMP X1,A 
 P:0223 JNE $022A
 P:0225 CLR A 
 P:0226 MOVE  Y:(R1)+,Y0
 P:0227 MOVE  X:<$2A,X0
 P:0228 MPY +Y0,X0,B 
 P:0229 MOVE  B,Y0
 P:022A MOVE  A,X:<$28
 P:022B MOVE  X:<$20,X0
 P:022C MPY +Y0,X0,B 
 P:022D MOVE  B,X:<$22
 P:022E MOVE  X:<$21,X0
 P:022F MPY +Y0,X0,B 
 P:0230 MOVE  B,X:<$23
 P:0231 JMP <$021A
 P:0232 MOVE  (R2)+
 P:0233 MOVE  X0,X:<$24
 P:0234 MOVE  X1,X:<$25
 P:0235 JCLR #$00,X:<$26,$023D
 P:0237 MOVEP X:<<$FFEF,X1
 P:0238 MOVE  X1,X:<$21
 P:0239 BCLR #$00,X:<$26
 P:023A MOVE  X:<$24,X0
 P:023B MOVE  X:<$25,X1
 P:023C RTI 
 P:023D MOVEP X:<<$FFEF,X0
 P:023E MOVE  X0,X:<$20
 P:023F BSET #$00,X:<$26
 P:0240 MOVE  X:<$24,X0
 P:0241 MOVE  X:<$25,X1
 P:0242 RTI 
 P:0243 MOVE  X0,X:<$24
 P:0244 MOVE  X1,X:<$25
 P:0245 JCLR #$00,X:<$27,$024D
 P:0247 MOVE  X:<$23,X1
 P:0248 MOVEP X1,X:<<$FFEF
 P:0249 BCLR #$00,X:<$27
 P:024A MOVE  X:<$24,X0
 P:024B MOVE  X:<$25,X1
 P:024C RTI 
 P:024D MOVE  X:<$22,X0
 P:024E MOVEP X0,X:<<$FFEF
 P:024F BSET #$00,X:<$27
 P:0250 MOVE  X:<$24,X0
 P:0251 MOVE  X:<$25,X1
 P:0252 RTI 
