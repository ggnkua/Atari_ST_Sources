  ORG       Y:$0000
  DC $000000
  DC $000000
  DC $000000
  DC $000000
  DC $000000
  DC $000000
  DC $000000
  DC $000000
  ORG       P:$0000
 P:0000 JMP $0055
  ORG       P:$000C
 P:000C JSR <$0040
  ORG       P:$000E
 P:000E JSR <$0046
  ORG       P:$0010
 P:0010 JSR <$0047
  ORG       P:$0012
 P:0012 JSR <$004D
  ORG       P:$0020
 P:0020 JSR <$004E
  ORG       P:$0026
 P:0026 JSR <$0050
  ORG       P:$0028
 P:0028 JSR <$0052
  ORG       P:$0040
 P:0040 JCLR #$03,X:<<$FFEE,$0044
 P:0042 MOVE  #$00,R4
 P:0043 NOP 
 P:0044 MOVEP X:<<$FFEF,Y:(R4)+
 P:0045 RTI 
 P:0046 JMP <$0040
 P:0047 JCLR #$02,X:<<$FFEE,$004B
 P:0049 MOVE  #$03,R1
 P:004A NOP 
 P:004B MOVEP Y:(R1)+,X:<<$FFEF
 P:004C RTI 
 P:004D JMP <$0047
 P:004E MOVEP X:<<$FFEB,X:(R3)+
 P:004F RTI 
 P:0050 MOVE  #$00,R3
 P:0051 RTI 
 P:0052 JSR $0082
 P:0054 RTI 
 P:0055 ORI #$03,MR
 P:0056 MOVEP #>$000000,X:<<$FFFE
 P:0058 MOVEP #>$003800,X:<<$FFFF
 P:005A MOVEP #>$000001,X:<<$FFE0
 P:005C MOVEP #>$000005,X:<<$FFE8
 P:005E MOVE  #$00,R3
 P:005F MOVEC #<03,M3
 P:0060 MOVE  #$00,R4
 P:0061 MOVEC #<01,M4
 P:0062 MOVE  #$02,R1
 P:0063 MOVEC #<01,M1
 P:0064 MOVEP #>$004100,X:<<$FFEC
 P:0066 MOVEP #>$0001F8,X:<<$FFE1
 P:0068 BTST #$04,X:<<$FFEE
 P:0069 MOVEP X:(R1)+,X:<<$FFEF
 P:006A MOVEP #>$00F800,X:<<$FFED
 P:006C ORI #$04,OMR
 P:006D ANDI #$F0,MR
 P:006E JSR $0082
 P:0070 MOVE  #$00,B
 P:0071 MOVE  R4,A
 P:0072 CMP B,A 
 P:0073 JNE <$0071
 P:0074 MOVE  R4,A
 P:0075 CMP B,A 
 P:0076 JEQ <$0074
 P:0077 MOVE  Y:<$00,X0
 P:0078 MOVE  X0,Y:<$04
 P:0079 MOVE  Y:<$01,X0
 P:007A MOVE  X0,Y:<$05
 P:007B JSR $009C
 P:007D MOVE  Y:<$06,X0
 P:007E MOVE  X0,Y:<$02
 P:007F MOVE  Y:<$07,X0
 P:0080 MOVE  X0,Y:<$03
 P:0081 JMP <$0070
 P:0082 JSR $0093
 P:0084 MOVE  #$00,A
 P:0085 MOVEC #>$00FFFF,M2
 P:0087 MOVEC #>$00FFFF,M6
 P:0089 DO X0,$008C
 P:008B MOVE  A,X:(R2)+
 P:008C NOP 
 P:008D NOP 
 P:008E NOP 
 P:008F DO Y0,$0092
 P:0091 MOVE  A,Y:(R6)+
 P:0092 RTI 
  ORG       X:$0000
  DC $500000
  DC $000000
  DC $000000
  DC $000000
  ORG       X:$0040
  DC $300000
  DC $001000
  DC $001800
  DC $002000
  DC $002800
  DC $003000
  DC $003800
  DC $004000
  DC $004800
  DC $005000
  ORG       P:$0093
 P:0093 MOVE  #>$001000,R2
 P:0095 MOVE  #>$002E00,X0
 P:0097 MOVE  #>$001000,R6
 P:0099 MOVE  #>$000001,Y0
 P:009B RTS 
 P:009C MOVE  #>$7FDF3B,A
 P:009E MOVE  X:<$00,B
 P:009F SUB B,A 
 P:00A0 MOVE  A,X:$0040
 P:00A2 CLR A #>$1C28F6,X1
 P:00A4 MOVE  Y:<$04,X0
 P:00A5 MACR +X1,X0,A Y:<$05,X0
 P:00A6 MACR +X1,X0,A 
 P:00A7 CLR B A,Y0
 P:00A8 MOVE  X:$0041,R0
 P:00AA MOVEC #>$0003B6,M0
 P:00AC MOVE  Y0,A
 P:00AD MOVE  X:(R0),X1
 P:00AE ADD X1,B #>$738698,X0
 P:00B0 MACR -X1,X0,A 
 P:00B1 MOVE  A,X:(R0)+
 P:00B2 MOVE  R0,X:$0041
 P:00B4 MOVE  X:$0042,R0
 P:00B6 MOVEC #>$000410,M0
 P:00B8 MOVE  Y0,A
 P:00B9 MOVE  X:(R0),X1
 P:00BA ADD X1,B #>$7268B2,X0
 P:00BC MACR -X1,X0,A 
 P:00BD MOVE  A,X:(R0)+
 P:00BE MOVE  R0,X:$0042
 P:00C0 MOVE  X:$0043,R0
 P:00C2 MOVEC #>$000456,M0
 P:00C4 MOVE  Y0,A
 P:00C5 MOVE  X:(R0),X1
 P:00C6 ADD X1,B #>$718C3B,X0
 P:00C8 MACR -X1,X0,A 
 P:00C9 MOVE  A,X:(R0)+
 P:00CA MOVE  R0,X:$0043
 P:00CC MOVE  X:$0044,R0
 P:00CE MOVEC #>$0004A3,M0
 P:00D0 MOVE  Y0,A
 P:00D1 MOVE  X:(R0),X1
 P:00D2 ADD X1,B #>$709BA6,X0
 P:00D4 MACR -X1,X0,A 
 P:00D5 MOVE  A,X:(R0)+
 P:00D6 MOVE  R0,X:$0044
 P:00D8 MOVE  X:$0045,R0
 P:00DA MOVEC #>$00051D,M0
 P:00DC MOVE  Y0,A
 P:00DD MOVE  X:(R0),X1
 P:00DE ADD X1,B #>$6F228E,X0
 P:00E0 MACR -X1,X0,A 
 P:00E1 MOVE  A,X:(R0)+
 P:00E2 MOVE  R0,X:$0045
 P:00E4 MOVE  X:$0046,R0
 P:00E6 MOVEC #>$000576,M0
 P:00E8 MOVE  Y0,A
 P:00E9 MOVE  X:(R0),X1
 P:00EA ADD X1,B #>$6E129D,X0
 P:00EC MACR -X1,X0,A 
 P:00ED MOVE  A,X:(R0)+
 P:00EE MOVE  R0,X:$0046
 P:00F0 MOVE  X:$0047,R0
 P:00F2 MOVEC #>$0001F6,M0
 P:00F4 MOVE  Y0,A
 P:00F5 MOVE  X:(R0),X1
 P:00F6 ADD X1,B #>$7C92B6,X0
 P:00F8 MACR -X1,X0,A 
 P:00F9 MOVE  A,X:(R0)+
 P:00FA MOVE  R0,X:$0047
 P:00FC MOVE  #>$0CCCCD,X0 B,Y0
 P:00FE MPYR +Y0,X0,B 
 P:00FF MOVE  B,X0
 P:0100 MOVE  X:<$00,Y0
 P:0101 MPYR +Y0,X0,B X:$0040,Y0
 P:0103 MOVE  Y:<$04,X0
 P:0104 MOVE  B,A
 P:0105 NEG B 
 P:0106 MACR +Y0,X0,A Y:<$05,X0
 P:0107 MACR +Y0,X0,B A,Y:<$06
 P:0108 MOVE  B,Y:<$07
 P:0109 RTS 
