	ORG	P:$0000
P:0000	JMP	$0200
	ORG	P:$000C
P:000C	JSR	$0040
	ORG	P:$0010
P:0010	JSR	$0060
	ORG	P:$0040
P:0040	JSET	#$08,Y:<$00,$0046
P:0042	MOVEP	X:<<$FFEF,X:$0000
P:0044	BCHG	#$08,Y:<$00
P:0045	RTI
P:0046	MOVEP	X:<<$FFEF,X:$0001
P:0048	BCHG	#$08,Y:<$00
P:0049	MOVE	B,L:<$02
P:004A	MOVE	Y,L:<$03
P:004B	JSSET	#$06,Y:<$00,$01A0
P:004D	JSSET	#$05,Y:<$00,$0140
P:004F	JSSET	#$04,Y:<$00,$00E0
P:0051	JSSET	#$03,Y:<$00,$00AC
P:0053	JSSET	#$02,Y:<$00,$009C
P:0055	JSSET	#$01,Y:<$00,$0092
P:0057	JSSET	#$00,Y:<$00,$006A
P:0059	MOVE	X:<$01,X0
P:005A	MOVE	X0,X:<$09
P:005B	MOVE	X:<$00,X0
P:005C	MOVE	X0,X:<$08
P:005D	MOVE	L:<$02,B
P:005E	MOVE	L:<$03,Y
P:005F	RTI
P:0060	JSET	#$09,Y:<$00,$0066
P:0062	MOVEP	X:$0008,X:<<$FFEF
P:0064	BCHG	#$09,Y:<$00
P:0065	RTI
P:0066	MOVEP	X:$0009,X:<<$FFEF
P:0068	BCHG	#$09,Y:<$00
P:0069	RTI
P:006A	CLR	A	X:<$00,X0
P:006B	MOVE	Y:(R4)+,Y0
P:006C	ORI	#$08,MR
P:006D	DO	#$008,$0075
P:006F	MPY	+Y0,X0,B	X:(R0),X1	Y:(R4)+,Y1
P:0070	MAC	-X1,Y0,B	X:(R1)+,X1	Y:(R4)+,Y0
P:0071	MAC	+Y1,X1,B	X:(R1),X1
P:0072	MACR	-X1,Y0,B	Y:(R5)+,X1
P:0073	MOVE	B,X:(R1)+	B,Y1
P:0074	MAC	+Y1,X1,A	X:(R1)+N1,X1	Y:(R4)+,Y0
P:0075	MOVE	X0,X:(R0)+
P:0076	ANDI	#$F7,MR
P:0077	MOVE	A,X:<$04
P:0078	CLR	A	X:<$01,X0
P:0079	ORI	#$08,MR
P:007A	DO	#$008,$0082
P:007C	MPY	+Y0,X0,B	X:(R0),X1	Y:(R4)+,Y1
P:007D	MAC	-X1,Y0,B	X:(R1)+,X1	Y:(R4)+,Y0
P:007E	MAC	+Y1,X1,B	X:(R1),X1
P:007F	MACR	-X1,Y0,B	Y:(R5)+,X1
P:0080	MOVE	B,X:(R1)+	B,Y1
P:0081	MAC	+Y1,X1,A	X:(R1)+N1,X1	Y:(R4)+,Y0
P:0082	ANDI	#$F7,MR
P:0083	MOVE	X0,X:(R0)+	Y:(R4)-,Y0
P:0084	MOVE	X:<$20,Y0
P:0085	MOVE	X:<$04,B
P:0086	MACR	+Y0,X0,A	X:<$00,X0
P:0087	MACR	+Y0,X0,B	X:<$21,Y0
P:0088	MOVE	A,X0	Y:(R1)+,Y1
P:0089	MPY	+Y0,X0,A	B,X1
P:008A	MPY	+X1,Y0,B	#$20,N1
P:008B	ASL	A
P:008C	ASL	A	(R1)-N1
P:008D	ASL	B	#$02,N1
P:008E	ASL	B
P:008F	MOVE	A,X:<$01
P:0090	MOVE	B,X:<$00
P:0091	RTS
P:0092	MOVE	X:<$00,A
P:0093	MOVE	A,X:(R2+N2)
P:0094	MOVE	Y:(R2),Y1
P:0095	MOVE	Y:<$08,Y0
P:0096	MACR	+Y1,Y0,A	X:<$01,B
P:0097	MOVE	B,Y:(R2+N2)
P:0098	MOVE	X:(R2)+,Y1
P:0099	MACR	+Y1,Y0,B	A,X:<$00
P:009A	MOVE	B,X:<$01
P:009B	RTS
P:009C	MOVE	X:<$00,A
P:009D	MOVE	Y:<$08,Y0
P:009E	MOVE	Y:<$09,X1
P:009F	MOVE	A,X:(R2+N2)
P:00A0	MOVE	X:(R6),X0	Y:(R6),Y1
P:00A1	MAC	+Y0,X0,A
P:00A2	MACR	+Y1,X1,A	X:(R2),X0	Y:(R6),Y1
P:00A3	MOVE	A,X:(R6+N6)
P:00A4	MOVE	A,X:<$00
P:00A5	MOVE	X:<$01,A
P:00A6	MAC	+X1,X0,A	A,Y:(R2+N2)
P:00A7	MACR	+Y1,Y0,A	(R2)+
P:00A8	MOVE	A,Y:(R6+N6)
P:00A9	MOVE	A,X:<$01
P:00AA	MOVE	(R6)+
P:00AB	RTS
P:00AC	MOVE	L:<$0B,B
P:00AD	MOVE	L:<$0A,A
P:00AE	ADD	A,B
P:00AF	TST	B
P:00B0	JGT	$00B5
P:00B2	NEG	A
P:00B3	JMP	$00BC
P:00B5	MOVE	#>$000100,X0
P:00B7	CMP	X0,B
P:00B8	JMI	$00BC
P:00BA	NEG	A
P:00BB	ADD	A,B
P:00BC	MOVE	B1,N3
P:00BD	MOVE	B,L:<$0B
P:00BE	MOVE	A,L:<$0A
P:00BF	MOVE	X:<$00,X0
P:00C0	MOVE	X:<$01,X1
P:00C1	MOVE	X0,X:(R3)
P:00C2	MOVE	X1,Y:(R3)
P:00C3	TFR	X0,A	X:(R3+N3),X0
P:00C4	ADD	X0,A
P:00C5	TFR	X1,A	A,X:<$00
P:00C6	MOVE	Y:(R3+N3),X1
P:00C7	ADD	X1,A	(R3)+
P:00C8	MOVE	A,X:<$01
P:00C9	RTS
	ORG	P:$0200
P:0200	ORI	#$04,OMR
P:0201	NOP
P:0202	NOP
P:0203	NOP
P:0204	MOVEP	X:<<$FFFF,X:$0011
P:0206	MOVE	#$00,X0
P:0207	MOVE	X0,Y:<$00
P:0208	MOVEP	#>$001000,X:<<$FFFF
P:020A	MOVEP	#>$0001F8,X:<<$FFE1
P:020C	MOVEP	#>$004100,X:<<$FFEC
P:020E	MOVEP	#>$000000,X:<<$FFE8
P:0210	MOVEP	#>$000001,X:<<$FFE0
P:0212	MOVEP	#>$00F800,X:<<$FFED
P:0214	ANDI	#$FC,MR
P:0215	JCLR	#$00,X:<<$FFE9,$0215
P:0217	MOVEP	X:<<$FFEB,Y:$0001
P:0219	JSSET	#$17,Y:<$01,$026C
P:021B	JSSET	#$16,Y:<$01,$02F2
P:021D	JSSET	#$15,Y:<$01,$031B
P:021F	JSSET	#$14,Y:<$01,$032F
P:0221	JSSET	#$13,Y:<$01,$0390
P:0223	JSSET	#$12,Y:<$01,$03C0
P:0225	JSSET	#$11,Y:<$01,$03F0
P:0227	JSSET	#$10,Y:<$01,$0336
P:0229	JSSET	#$0E,Y:<$01,$03D0
P:022B	JSSET	#$0D,Y:<$01,$03A0
P:022D	JSSET	#$0C,Y:<$01,$0370
P:022F	JSSET	#$0B,Y:<$01,$032D
P:0231	JSSET	#$0A,Y:<$01,$0319
P:0233	JSSET	#$09,Y:<$01,$02F0
P:0235	JSSET	#$08,Y:<$01,$026A
P:0237	JSSET	#$06,Y:<$01,$03D0
P:0239	JSSET	#$05,Y:<$01,$03A0
P:023B	JSSET	#$04,Y:<$01,$0370
P:023D	JSSET	#$03,Y:<$01,$0321
P:023F	JSSET	#$02,Y:<$01,$02FF
P:0241	JSSET	#$01,Y:<$01,$02E4
P:0243	JSSET	#$00,Y:<$01,$0246
P:0245	JMP	<$0215
P:0246	JSET	#$00,Y:<$00,$026A
P:0248	JSET	#$16,Y:<$00,$025E
P:024A	MOVE	#>$0002AC,R0
P:024C	MOVE	#$40,R4
P:024D	MOVE	#$00,Y0
P:024E	DO	#$020,$0253
P:0250	MOVEM	P:(R0)+,Y1
P:0251	MOVE	Y0,X:(R4)
P:0252	MOVE	Y1,Y:(R4)+
P:0253	MOVE	#$20,R4
P:0254	REP	#$010
P:0255	MOVE	Y0,Y:(R4)+
P:0256	MOVE	#$20,Y0
P:0257	MOVE	Y0,X:<$20
P:0258	MOVE	#>$7FFFFF,Y0
P:025A	MOVE	Y0,X:<$21
P:025B	MOVE	#>$000040,Y0
P:025D	MOVE	Y0,X:<$22
P:025E	MOVE	#$20,R5
P:025F	MOVEC	#<0F,M5
P:0260	MOVE	#$40,R4
P:0261	MOVEC	#<17,M4
P:0262	MOVE	#$3C,R0
P:0263	MOVEC	#<03,M0
P:0264	MOVE	#$40,R1
P:0265	MOVEC	#<01,M1
P:0266	MOVE	#$02,N1
P:0267	BSET	#$16,Y:<$00
P:0268	BSET	#$00,Y:<$00
P:0269	RTS
P:026A	BCLR	#$00,Y:<$00
P:026B	RTS
P:026C	JSET	#$16,Y:<$01,$029A
P:026E	JSET	#$15,Y:<$01,$027F
P:0270	JSET	#$14,Y:<$01,$0277
P:0272	JSR	$027A
P:0274	CLR	B
P:0275	MOVE	B,Y:<$01
P:0276	RTS
P:0277	MOVEP	X:$0011,X:<<$FFFF
P:0279	STOP
P:027A	MOVE	#$20,R7
P:027B	MOVE	#$00,Y0
P:027C	REP	#$010
P:027D	MOVE	Y0,Y:(R7)+
P:027E	RTS
P:027F	MOVE	X:<$22,R7
P:0280	CLR	B
P:0281	MOVE	B,X:<$10
P:0282	MOVE	#>$000800,Y1
P:0284	DO	#$FFF,$028C
P:0286	MOVE	X:(R7),B
P:0287	ABS	B
P:0288	MOVE	X:$0010,B	B,Y0
P:028A	MACR	+Y1,Y0,B
P:028B	MOVE	B,X:<$10
P:028C	MOVEP	B,X:<<$FFEB
P:028D	CLR	B	(R7)+
P:028E	MOVE	(R7)+
P:028F	MOVE	R7,B1
P:0290	MOVE	#>$000060,Y1
P:0292	CMP	Y1,B
P:0293	JEQ	$0297
P:0295	MOVE	R7,X:<$22
P:0296	JMP	<$0274
P:0297	MOVE	#$40,R7
P:0298	MOVE	R7,X:<$22
P:0299	JMP	<$0274
P:029A	CLR	B	#>$001F00,Y1
P:029C	MOVE	Y:<$01,B1
P:029D	AND	Y1,B
P:029E	REP	#$008
P:029F	ASR	B
P:02A0	MOVE	B1,N7
P:02A1	MOVE	#>$0002C4,R7
P:02A3	MOVE	#>$00000F,B1
P:02A5	MOVEM	P:(R7+N7),Y0
P:02A6	MOVE	Y:<$01,Y1
P:02A7	AND	Y1,B	#$20,R7
P:02A8	MOVE	B1,N7
P:02A9	NOP
P:02AA	MOVE	Y0,Y:(R7+N7)
P:02AB	JMP	<$0274
P:02AC	ANDI	#$16,CCR
P:02AD	MACR	+Y0,Y0,B	Y:(R1)-,N7
P:02AE	MAC	-Y1,Y0,A	#$D2,N7
P:02AF	ANDI	#$2D,OMR
P:02B0	ASR	A	Y:<$21,N7
P:02B1	MPY	-X0,X0,B	#$A5,N7
P:02B2	ANDI	#$5A,MR
P:02B3	MACR	+Y1,X1,B	N7,Y:<$39
P:02B4	MACR	-Y0,Y0,A	#$4B,N7
P:02B5	ORI	#$B3,OMR
P:02B6	SUB	X,B	N6,Y:(R3)-
P:02B7	SBC	Y,A	#$99,N6
P:02B8	NORM	R2,B
P:02B9	MACR	+Y1,Y0,A	N4,Y:<$25
P:02BA	MACR	+X0,X0,A	#$3A,N5
	DC	$02B531
P:02BC	AND	X1,B	N6,X:(R6)+
P:02BD	MACR	-Y0,Y0,B	#$95,N2
P:02BE	MOVEC	#<28,M1
P:02BF	MACR	+X1,X0,A	X:(R5)-N5,R5
P:02C0	AND	Y1,B	#$AE,R5
P:02C1	MOVEP	Y:<<$FFE4,P:(R2)+N2
P:02C2	MACR	+Y0,Y0,A	#$3F,R6
P:02C3	ADD	Y,B	#$6B,B1
P:02C4	ADDL	B,A	X1,X:(R4)-	Y:(R4)-,B
P:02C5	ADD	X,A	X:(R2)-,X1	Y:(R6)-,B
P:02C6	CMP	X1,A	X:(R2)+N2,A	Y:(R5)-,Y0
	DC	$E9930C
P:02C8	MAC	+X1,Y0,B	X:(R5)-,A	Y:(R4)-,A
P:02C9	AND	X0,A	X:(R6)-,A	Y:(R5)-,B
P:02CA	NOT	B	X:(R4)-,B	Y:(R7)-,Y0
P:02CB	MPYR	-Y1,Y0,B	B,X:(R2)-	Y:(R6)-,A
P:02CC	CMPM	X1,A	X:(R5)-,B	Y:(R6)-,B
P:02CD	EOR	X1,A	X0,X:(R7)+	Y:(R7)+,Y1
P:02CE	ASL	A	X0,X:(R2)+	Y:(R6)+,B
P:02CF	EOR	Y1,B	X1,X:(R6)	Y:(R7)+,Y1
P:02D0	ABS	A	X:(R2)+N2,X1	Y:(R5)+,B
P:02D1	NOT	A	A,X:(R3)+N3	Y:(R5)+,A
P:02D2	ADD	Y,A	X:(R0)-,B	Y:(R7)+,Y0
P:02D3	NOP
P:02D4	TLC	A,B	R3,R3
P:02D5	MOVEM	BA,P:(R1)
P:02D6	JSCLR	#$0D,X:(R5)-N5,$XXXX
P:02D8	EOR	X0,B	A,X1	Y:(R2+N2),Y0
P:02D9	TFR	X0,A	X:(R2)-N2,A	B,Y0
P:02DA	ADC	Y,B	X1,R4
P:02DB	ADD	Y0,A	#$8D,Y1
P:02DC	MACR	-X1,Y0,A	#$1D,B
P:02DD	SUB	Y,A	#$80,R7
P:02DE	MPY	-Y0,Y0,B	L:(R4)-N4,A10
P:02DF	MPYR	-X0,Y1,A	L:-(R6),AB
P:02E0	MPYR	-Y1,Y0,B	A,X:(R2)-
P:02E1	EOR	Y1,A	X:(R7)-,R2
P:02E2	MAC	+Y1,X1,A	X:<$30,N0
P:02E3	MPYR	+Y1,Y0,B	Y:-(R4),N7
P:02E4	JSET	#$01,Y:<$00,$02F0
P:02E6	MOVE	#>$002000,R2
P:02E8	MOVE	#>$000F00,N2
P:02EA	MOVEC	#>$001DFF,M2
P:02EC	MOVE	#$40,Y0
P:02ED	MOVE	Y0,Y:<$08
P:02EE	BSET	#$01,Y:<$00
P:02EF	RTS
P:02F0	BCLR	#$01,Y:<$00
P:02F1	RTS
P:02F2	MOVE	Y:<$01,B
P:02F3	REP	#$003
P:02F4	LSL	B
P:02F5	MOVE	#>$001DFF,Y1
P:02F7	CMP	Y1,B
P:02F8	JLT	$02FB
P:02FA	MOVE	Y1,B1
P:02FB	MOVE	B1,N2
P:02FC	CLR	B
P:02FD	MOVE	B,Y:<$01
P:02FE	RTS
P:02FF	JSET	#$02,Y:<$00,$0319
P:0301	MOVE	#$00,Y0
P:0302	MOVE	X0,Y0
P:0303	MOVE	#>$001000,R2
P:0305	MOVEC	#<22,M2
P:0306	MOVE	#$22,N2
P:0307	MOVE	#>$001200,R6
P:0309	MOVEC	#>$0001F4,M6
P:030B	MOVE	#>$0001F3,N6
P:030D	MOVE	#>$0001F3,Y1
P:030F	DO	Y1,$0313
P:0311	MOVE	X0,X:(R2)	Y0,Y:(R6)
P:0312	MOVE	X0,X:(R6)+	Y0,Y:(R6)+
P:0313	MOVE	#$70,Y0
P:0314	MOVE	Y0,Y:<$08
P:0315	MOVE	#$40,Y0
P:0316	MOVE	Y0,Y:<$09
P:0317	BSET	#$02,Y:<$00
P:0318	RTS
P:0319	BCLR	#$02,Y:<$00
P:031A	RTS
P:031B	MOVE	Y:<$01,B
P:031C	ASR	B
P:031D	MOVE	B1,N6
P:031E	CLR	B
P:031F	MOVE	B,Y:<$01
P:0320	RTS
P:0321	JSET	#$03,Y:<$00,$032D
P:0323	CLR	B
P:0324	MOVE	B,L:<$0B
P:0325	MOVE	#>$010000,B0
P:0327	MOVE	B,L:<$0A
P:0328	MOVE	#>$000800,R3
P:032A	MOVEC	#<FF,M3
P:032B	BSET	#$03,Y:<$00
P:032C	RTS
P:032D	BCLR	#$03,Y:<$00
P:032E	RTS
P:032F	MOVE	Y:<$01,B
P:0330	REP	#$010
P:0331	ASR	B
P:0332	MOVE	#$00,B1
P:0333	CLR	B	B,L:<$0A
P:0334	MOVE	B,Y:<$01
P:0335	RTS
P:0336	CLR	B
P:0337	MOVE	Y:<$01,Y0
P:0338	MOVE	#>$000030,Y1
P:033A	MOVE	#>$0000E0,B0
P:033C	MAC	+Y1,Y0,B
P:033D	MOVE	B0,R7
P:033E	CLR	B
P:033F	MOVE	#>$408000,Y1
P:0341	JSR	$0369
P:0343	JEQ	$0347
P:0345	MOVEM	B1,P:(R7)+
P:0346	JMP	<$0341
P:0347	CLR	B
P:0348	MOVE	#>$000370,B0
P:034A	MOVE	#>$000018,Y1
P:034C	MAC	+Y1,Y0,B
P:034D	MOVE	B0,R7
P:034E	MOVE	B0,Y0
P:034F	CLR	B
P:0350	MOVE	#>$408000,Y1
P:0352	JSR	$0369
P:0354	JEQ	$0358
P:0356	MOVEM	B1,P:(R7)+
P:0357	JMP	<$0352
P:0358	CLR	B
P:0359	MOVE	#>$000020,B1
P:035B	ADD	Y0,B
P:035C	MOVE	B1,R7
P:035D	CLR	B
P:035E	JSR	$0369
P:0360	JEQ	$0364
P:0362	MOVEM	B1,P:(R7)+
P:0363	JMP	<$035E
P:0364	MOVEP	#>$AAAAAA,X:<<$FFEB
P:0366	CLR	B
P:0367	MOVE	B,Y:<$01
P:0368	RTS
P:0369	JCLR	#$00,X:<<$FFE9,$0369
P:036B	MOVEP	X:<<$FFEB,B
P:036C	CMP	Y1,B
P:036D	RTS
