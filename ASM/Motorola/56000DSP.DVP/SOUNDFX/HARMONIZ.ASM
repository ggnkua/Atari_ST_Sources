  ORG       X:$0020
  DC $000001
  DC $000001
  DC $000001
  DC $000001
  DC $000001
  DC $000001
  DC $000000
  DC $000000
  DC $000000
  DC $000000
  DC $000000
  DC $000000
  DC $000000
  DC $59999A
  DC $19999A
  DC $000004
  DC $19999A
  DC $000007
  DC $0003E8
  DC $0003CC
  DC $0003B0
  DC $000394
  DC $000378
  DC $00035C
  DC $000340
  DC $000324
  DC $000308
  DC $0002EC
  DC $0002D0
  DC $0002B4
  DC $000298
  ORG       P:$0000
 P:0000 JMP $0200
  ORG       P:$000C
 P:000C JSR $02CF
  ORG       P:$000E
 P:000E MOVEP X:<<$FFEE,A
 P:000F JSR $02CF
  ORG       P:$0010
 P:0010 JSR $02E0
  ORG       P:$0012
 P:0012 MOVEP X:<<$FFEE,A
 P:0013 JSR $02E0
  ORG       P:$0200
 P:0200 MOVEP X:<<$FFEB,X0
 P:0201 MOVEC #<00,SP
 P:0202 MOVEP #>$004100,X:<<$FFEC
 P:0204 MOVEP #>$0001F8,X:<<$FFE1
 P:0206 BTST #$04,X:<<$FFEE
 P:0207 MOVEP #>$00F800,X:<<$FFED
 P:0209 MOVEP #>$000000,X:<<$FFFE
 P:020B MOVEP #>$003000,X:<<$FFFF
 P:020D MOVEP #>$000001,X:<<$FFE0
 P:020F ANDI #$FC,MR
 P:0210 JSR $027B
 P:0212 JSR $02BD
 P:0214 MOVE  #$2D,R3
 P:0215 MOVE  #$32,R0
 P:0216 JCLR #$00,X:<<$FFE9,$021C
 P:0218 MOVEP X:<<$FFEB,N3
 P:0219 JCLR #$00,X:<<$FFE9,$0219
 P:021B MOVEP X:<<$FFEB,X:(R3+N3)
 P:021C JCLR #$00,X:<$28,$0216
 P:021E MOVE  X:<$2F,N0
 P:021F MOVE  X:<$20,X0
 P:0220 MOVE  X0,X:<$00
 P:0221 MOVE  X:<$21,X0
 P:0222 MOVE  X0,X:<$01
 P:0223 MOVE  X:(R0+N0),X0
 P:0224 MOVE  X0,Y:<$0E
 P:0225 JSR $024B
 P:0227 MOVE  X:<$00,X0
 P:0228 MOVE  X0,X:<$29
 P:0229 MOVE  X:<$01,X0
 P:022A MOVE  X0,X:<$2A
 P:022B MOVE  X:<$31,N0
 P:022C MOVE  X:<$20,X0
 P:022D MOVE  X0,X:<$00
 P:022E MOVE  X:<$21,X0
 P:022F MOVE  X0,X:<$01
 P:0230 MOVE  X:(R0+N0),X0
 P:0231 MOVE  X0,Y:<$10
 P:0232 JSR $028D
 P:0234 MOVE  X:<$00,X0
 P:0235 MOVE  X0,X:<$2B
 P:0236 MOVE  X:<$01,X0
 P:0237 MOVE  X0,X:<$2C
 P:0238 MOVE  X:<$2D,X0
 P:0239 MOVE  X:<$20,X1
 P:023A MPY +X1,X0,A 
 P:023B MOVE  X:<$21,X1
 P:023C MPY +X1,X0,B 
 P:023D MOVE  X:<$2E,X0
 P:023E MOVE  X:<$29,X1
 P:023F MAC +X1,X0,A 
 P:0240 MOVE  X:<$2A,X1
 P:0241 MAC +X1,X0,B 
 P:0242 MOVE  X:<$30,X0
 P:0243 MOVE  X:<$2B,X1
 P:0244 MAC +X1,X0,A 
 P:0245 MOVE  X:<$2C,X1
 P:0246 MAC +X1,X0,B 
 P:0247 MOVE  A,X:<$22
 P:0248 MOVE  B,X:<$23
 P:0249 BCLR #$00,X:<$28
 P:024A JMP <$0216
 P:024B MOVE  X:<$00,X0
 P:024C MOVE  X0,X:(R2)
 P:024D MOVE  X:<$01,X0
 P:024E MOVE  X0,Y:(R2)+
 P:024F MOVE  X:<$0E,B
 P:0250 MOVE  Y:<$0E,Y0
 P:0251 SUB Y0,B #>$0007D2,Y1
 P:0253 JLT $0257
 P:0255 MOVE  (R6)+
 P:0256 JMP <$0251
 P:0257 ADD Y1,B #$01,X0
 P:0258 MOVE  B,X:<$0E
 P:0259 MOVE  R2,B
 P:025A MOVE  R6,X1
 P:025B SUB X1,B #>$00003F,Y0
 P:025D JLE $0272
 P:025F JSET #$00,X:<$0F,$0265
 P:0261 CMP Y0,B 
 P:0262 JGT $0276
 P:0264 BSET #$00,X:<$0F
 P:0265 MOVE  #>$800000,X1 B,Y0
 P:0267 MPY +Y0,X0,B 
 P:0268 MOVE  B0,B1
 P:0269 ADD X1,B B1,X0
 P:026A NEG B X:(R6),X1
 P:026B MPY +X1,X0,A X:(R6+N6),X1
 P:026C MOVE  B,Y0
 P:026D MACR +X1,Y0,A Y:(R6),X1
 P:026E MPY +X1,X0,B Y:(R6+N6),X1
 P:026F MACR +X1,Y0,B A,X:<$00
 P:0270 MOVE  B,X:<$01
 P:0271 RTS 
 P:0272 JCLR #$00,X:<$0F,$0276
 P:0274 MOVE  (R6)+N6
 P:0275 BCLR #$00,X:<$0F
 P:0276 MOVE  X:(R6),X0
 P:0277 MOVE  X0,X:<$00
 P:0278 MOVE  Y:(R6),Y0
 P:0279 MOVE  Y0,X:<$01
 P:027A RTS 
 P:027B MOVE  #>$000400,R6
 P:027D MOVE  #>$000200,N6
 P:027F MOVEC #>$0003FF,M6
 P:0281 MOVE  #>$000400,R2
 P:0283 MOVEC #>$0003FF,M2
 P:0285 MOVE  #>$0003E9,Y0
 P:0287 MOVE  Y0,X:<$0E
 P:0288 MOVE  #>$0003E8,Y0
 P:028A MOVE  Y0,Y:<$0E
 P:028B BCLR #$00,X:<$0F
 P:028C RTS 
 P:028D MOVE  X:<$00,X0
 P:028E MOVE  X0,X:(R1)
 P:028F MOVE  X:<$01,X0
 P:0290 MOVE  X0,Y:(R1)+
 P:0291 MOVE  X:<$10,B
 P:0292 MOVE  Y:<$10,Y0
 P:0293 SUB Y0,B #>$0007D2,Y1
 P:0295 JLT $0299
 P:0297 MOVE  (R5)+
 P:0298 JMP <$0293
 P:0299 ADD Y1,B #$01,X0
 P:029A MOVE  B,X:<$10
 P:029B MOVE  R1,B
 P:029C MOVE  R5,X1
 P:029D SUB X1,B #>$00003F,Y0
 P:029F JLE $02B4
 P:02A1 JSET #$00,X:<$11,$02A7
 P:02A3 CMP Y0,B 
 P:02A4 JGT $02B8
 P:02A6 BSET #$00,X:<$11
 P:02A7 MOVE  #>$800000,X1 B,Y0
 P:02A9 MPY +Y0,X0,B 
 P:02AA MOVE  B0,B1
 P:02AB ADD X1,B B1,X0
 P:02AC NEG B X:(R5),X1
 P:02AD MPY +X1,X0,A X:(R5+N5),X1
 P:02AE MOVE  B,Y0
 P:02AF MACR +X1,Y0,A Y:(R5),X1
 P:02B0 MPY +X1,X0,B Y:(R5+N5),X1
 P:02B1 MACR +X1,Y0,B A,X:<$00
 P:02B2 MOVE  B,X:<$01
 P:02B3 RTS 
 P:02B4 JCLR #$00,X:<$11,$02B8
 P:02B6 MOVE  (R5)+N5
 P:02B7 BCLR #$00,X:<$11
 P:02B8 MOVE  X:(R5),X0
 P:02B9 MOVE  X0,X:<$00
 P:02BA MOVE  Y:(R5),Y0
 P:02BB MOVE  Y0,X:<$01
 P:02BC RTS 
 P:02BD MOVE  #>$000800,R5
 P:02BF MOVE  #>$000200,N5
 P:02C1 MOVEC #>$0003FF,M5
 P:02C3 MOVE  #>$000800,R1
 P:02C5 MOVEC #>$0003FF,M1
 P:02C7 MOVE  #>$0003E9,Y0
 P:02C9 MOVE  Y0,X:<$10
 P:02CA MOVE  #>$0003E8,Y0
 P:02CC MOVE  Y0,Y:<$10
 P:02CD BCLR #$00,X:<$11
 P:02CE RTS 
 P:02CF MOVE  X0,X:<$24
 P:02D0 MOVE  X1,X:<$25
 P:02D1 JCLR #$00,X:<$26,$02DA
 P:02D3 MOVEP X:<<$FFEF,X1
 P:02D4 MOVE  X1,X:<$21
 P:02D5 BCLR #$00,X:<$26
 P:02D6 MOVE  X:<$24,X0
 P:02D7 MOVE  X:<$25,X1
 P:02D8 BSET #$00,X:<$28
 P:02D9 RTI 
 P:02DA MOVEP X:<<$FFEF,X0
 P:02DB MOVE  X0,X:<$20
 P:02DC BSET #$00,X:<$26
 P:02DD MOVE  X:<$24,X0
 P:02DE MOVE  X:<$25,X1
 P:02DF RTI 
 P:02E0 MOVE  X0,X:<$24
 P:02E1 MOVE  X1,X:<$25
 P:02E2 JCLR #$00,X:<$27,$02EA
 P:02E4 MOVE  X:<$23,X1
 P:02E5 MOVEP X1,X:<<$FFEF
 P:02E6 BCLR #$00,X:<$27
 P:02E7 MOVE  X:<$24,X0
 P:02E8 MOVE  X:<$25,X1
 P:02E9 RTI 
 P:02EA MOVE  X:<$22,X0
 P:02EB MOVEP X0,X:<<$FFEF
 P:02EC BSET #$00,X:<$27
 P:02ED MOVE  X:<$24,X0
 P:02EE MOVE  X:<$25,X1
 P:02EF RTI 
