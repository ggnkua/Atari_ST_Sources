/*
// file generated by: F:\HL970519\MAKESCRN.C
*/

#include "hland.h"
extern const byte balk[2080UL] = {
0,0,2,255,2,255,2,255,0,0,255,255,255,255,255,255,
0,0,255,255,255,255,255,255,0,0,253,0,253,0,253,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,122,255,122,0,122,0,0,0,255,255,0,0,0,0,
0,0,255,255,0,0,0,0,0,0,253,120,1,120,1,120,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,250,0,248,0,248,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,1,124,0,124,0,124,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
2,0,250,0,8,0,8,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,1,0,1,124,0,68,0,68,
0,0,0,2,0,2,0,2,0,0,255,255,255,255,255,255,
0,0,255,255,255,255,255,255,0,0,255,255,255,255,255,255,
0,0,255,255,255,255,255,255,0,0,255,255,255,255,255,255,
0,0,255,255,255,255,255,255,0,0,255,255,255,255,255,255,
0,0,255,255,255,255,255,255,0,0,255,255,255,255,255,255,
0,0,255,255,255,255,255,255,0,0,255,255,255,255,255,255,
0,0,255,255,255,255,255,255,0,0,255,255,255,255,255,255,
0,0,255,255,255,255,255,255,0,0,255,64,255,64,255,64,
2,0,248,0,8,0,10,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,1,0,0,124,0,68,1,68,
0,0,0,122,0,122,0,122,0,0,255,255,0,0,0,0,
0,0,255,255,0,0,0,0,0,0,255,255,0,0,0,0,
0,0,255,255,0,0,0,0,0,0,255,255,0,0,0,0,
0,0,255,255,0,0,0,0,0,0,255,255,0,0,0,0,
0,0,255,255,0,0,0,0,0,0,255,255,0,0,0,0,
0,0,255,255,0,0,0,0,0,0,255,255,0,0,0,0,
0,0,255,255,0,0,0,0,0,0,255,255,0,0,0,0,
0,0,255,255,0,0,0,0,0,0,255,94,0,94,0,94,
242,0,248,0,8,0,8,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,1,56,0,124,0,68,0,68,
0,0,0,250,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,95,0,0,0,0,
242,0,8,0,8,0,152,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,1,56,0,68,0,68,0,108,
0,250,0,2,0,0,0,136,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,95,0,64,0,0,0,17,
242,0,248,0,8,0,8,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,1,56,0,124,0,68,0,68,
0,250,0,248,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,95,0,31,0,0,0,0,
2,0,248,0,8,0,10,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,1,0,0,124,0,68,1,68,
0,2,0,250,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,64,0,95,0,0,0,0,
2,0,250,0,8,0,8,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,1,0,1,124,0,68,0,68,
0,0,0,122,0,120,0,120,0,0,255,255,0,0,0,0,
0,0,255,255,0,0,0,0,0,0,255,255,0,0,0,0,
0,0,255,255,0,0,0,0,0,0,255,255,0,0,0,0,
0,0,255,255,0,0,0,0,0,0,255,255,0,0,0,0,
0,0,255,255,0,0,0,0,0,0,255,255,0,0,0,0,
0,0,255,255,0,0,0,0,0,0,255,255,0,0,0,0,
0,0,255,255,0,0,0,0,0,0,255,255,0,0,0,0,
0,0,255,255,0,0,0,0,0,0,255,94,0,30,0,30,
0,0,250,0,248,0,248,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,1,124,0,124,0,124,
0,0,0,2,0,2,0,2,0,0,255,255,255,255,255,255,
0,0,255,255,255,255,255,255,0,0,255,255,255,255,255,255,
0,0,255,255,255,255,255,255,0,0,255,255,255,255,255,255,
0,0,255,255,255,255,255,255,0,0,255,255,255,255,255,255,
0,0,255,255,255,255,255,255,0,0,255,255,255,255,255,255,
0,0,255,255,255,255,255,255,0,0,255,255,255,255,255,255,
0,0,255,255,255,255,255,255,0,0,255,255,255,255,255,255,
0,0,255,255,255,255,255,255,0,0,255,64,255,64,255,64,
0,0,122,255,122,0,122,0,0,0,255,255,0,0,0,0,
0,0,255,255,0,0,0,0,0,0,253,120,1,120,1,120,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,2,255,2,255,2,255,0,0,255,255,255,255,255,255,
0,0,255,255,255,255,255,255,0,0,253,0,253,0,253,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
};
extern const byte wolk[2240UL] = {
0,0,15,240,48,15,63,255,0,0,0,0,231,255,231,255,
0,0,0,0,128,127,128,127,0,0,0,0,255,255,255,255,
0,0,0,0,128,127,128,127,0,0,0,0,255,255,255,255,
0,0,0,0,248,7,248,7,0,0,0,0,255,254,255,254,
0,0,0,15,1,240,1,255,0,0,224,0,31,159,255,159,
0,0,0,0,254,1,254,1,0,0,0,0,255,255,255,255,
0,0,0,0,254,1,254,1,0,0,0,0,255,255,255,255,
0,0,0,0,255,224,255,224,0,0,0,0,31,255,31,255,
0,0,0,0,248,7,248,7,0,64,63,191,192,0,255,255,
0,0,195,240,60,15,255,255,3,224,252,16,0,14,255,254,
7,240,8,15,112,0,127,255,0,0,195,252,60,3,255,255,
0,0,0,15,224,240,224,255,0,0,254,252,1,3,255,255,
0,0,0,15,224,240,224,255,0,0,254,111,1,144,255,255,
0,0,192,0,62,15,254,15,1,192,254,32,0,31,255,255,
0,15,0,240,227,0,227,255,240,0,15,15,0,240,255,255,
0,0,240,0,15,131,255,131,0,0,63,251,192,4,255,255,
0,0,240,0,15,131,255,131,0,0,63,249,192,6,255,255,
0,0,191,0,64,248,255,248,0,7,3,248,60,0,63,255,
0,0,128,3,127,140,255,143,63,255,192,0,0,0,255,191,
249,251,6,4,0,0,255,252,255,240,0,12,0,3,124,31,
15,255,48,0,192,0,248,15,247,224,8,31,0,0,255,255,
0,15,0,112,253,128,253,255,255,224,0,31,0,0,255,255,
0,15,0,112,253,128,253,255,255,254,0,1,0,0,255,255,
0,0,240,7,15,216,255,223,255,240,0,15,0,0,254,63,
1,255,130,0,124,0,255,240,255,223,0,32,0,0,15,255,
128,0,124,1,3,246,255,247,63,255,192,0,0,0,255,255,
128,0,124,1,3,246,255,247,63,255,192,0,0,0,255,255,
248,0,7,192,0,63,255,255,3,255,28,0,96,0,127,248,
192,7,62,8,1,240,255,255,255,255,0,0,0,0,192,0,
255,255,0,0,0,0,16,0,255,252,0,2,0,1,0,15,
63,255,64,0,128,0,240,0,251,255,4,0,0,0,28,3,
128,31,120,32,7,192,255,248,255,255,0,0,0,0,0,3,
128,31,120,32,7,192,255,248,255,255,0,0,0,0,0,0,
248,1,7,130,0,124,63,255,255,255,0,0,0,0,128,15,
131,255,116,0,8,0,255,0,255,239,0,16,0,0,0,112,
254,0,1,224,0,31,15,255,127,255,128,0,0,0,224,0,
255,0,0,224,0,31,15,255,127,255,128,0,0,0,192,0,
255,224,0,30,0,1,0,255,7,255,8,0,240,0,254,0,
254,15,1,208,0,32,63,252,255,255,0,0,0,0,0,0,
255,255,0,0,0,0,32,0,255,254,0,1,0,0,0,3,
127,255,128,0,0,0,192,0,253,255,2,0,0,0,14,0,
248,127,7,128,0,0,127,240,255,255,0,0,0,0,0,0,
248,127,7,128,0,0,127,240,255,255,0,0,0,0,0,0,
255,135,0,120,0,0,7,255,255,255,0,0,0,0,0,0,
249,255,6,0,0,0,6,0,255,247,0,8,0,0,0,56,
255,225,0,30,0,0,1,255,255,255,0,0,0,0,192,0,
255,128,0,127,0,0,1,255,255,255,0,0,0,0,0,0,
255,254,0,1,0,0,0,31,31,255,224,0,0,0,252,0,
255,231,0,24,0,0,0,24,255,255,0,0,0,0,0,0,
255,255,0,0,0,0,0,0,255,255,0,0,0,0,0,1,
255,255,0,0,0,0,128,0,255,255,0,0,0,0,6,0,
255,255,0,0,0,0,7,128,255,255,0,0,0,0,0,0,
255,255,0,0,0,0,7,128,255,255,0,0,0,0,0,0,
255,255,0,0,0,0,0,120,255,255,0,0,0,0,0,0,
255,255,0,0,0,0,0,0,255,255,0,0,0,0,0,24,
255,255,0,0,0,0,0,30,255,255,0,0,0,0,0,0,
255,255,0,0,0,0,0,192,255,255,0,0,0,0,0,0,
255,255,0,0,0,0,0,1,255,255,0,0,0,0,224,0,
255,255,0,0,0,0,0,0,255,255,0,0,0,0,0,0,
255,255,0,0,0,0,0,0,255,255,0,0,0,0,0,1,
255,255,0,0,0,0,128,0,255,255,0,0,0,0,0,0,
255,255,0,0,0,0,0,0,255,255,0,0,0,0,0,0,
255,255,0,0,0,0,0,0,255,255,0,0,0,0,0,0,
255,255,0,0,0,0,0,0,255,255,0,0,0,0,0,0,
255,255,0,0,0,0,0,0,255,255,0,0,0,0,0,0,
255,255,0,0,0,0,0,0,255,255,0,0,0,0,0,0,
255,255,0,0,0,0,0,0,255,255,0,0,0,0,0,0,
255,255,0,0,0,0,0,0,255,255,0,0,0,0,0,0,
255,255,0,0,0,0,0,0,255,255,0,0,0,0,0,0,
255,255,0,0,0,0,0,0,255,255,0,0,0,0,0,3,
255,255,0,0,0,0,192,0,255,255,0,0,0,0,0,0,
255,255,0,0,0,0,0,0,255,255,0,0,0,0,0,0,
255,255,0,0,0,0,0,0,255,255,0,0,0,0,0,0,
255,255,0,0,0,0,0,0,255,255,0,0,0,0,0,0,
255,255,0,0,0,0,0,0,255,255,0,0,0,0,0,0,
255,255,0,0,0,0,0,0,255,255,0,0,0,0,0,0,
255,255,0,0,0,0,0,0,255,255,0,0,0,0,0,0,
255,255,0,0,0,0,0,0,255,255,0,0,0,0,0,0,
255,255,0,0,0,0,0,0,255,255,0,0,0,0,0,0,
255,255,0,0,0,0,0,0,255,255,0,0,0,0,0,3,
255,255,0,0,0,0,192,0,255,255,0,0,0,0,0,0,
255,255,0,0,0,0,0,0,255,255,0,0,0,0,0,0,
255,255,0,0,0,0,0,0,255,255,0,0,0,0,0,0,
255,255,0,0,0,0,0,0,255,255,0,0,0,0,0,0,
255,255,0,0,0,0,60,0,255,255,0,0,0,0,0,0,
255,255,0,0,0,0,0,0,255,255,0,0,0,0,0,0,
255,255,0,0,0,0,0,0,255,255,0,0,0,0,0,0,
255,255,0,0,0,0,0,0,255,255,0,0,0,0,0,0,
255,255,0,0,0,0,0,240,255,255,0,0,0,0,0,0,
255,255,0,0,0,0,0,0,255,255,0,0,0,0,0,3,
255,255,0,0,0,0,192,0,255,255,0,0,0,0,0,0,
255,63,0,192,0,0,0,192,255,255,0,0,0,0,0,0,
255,63,0,192,0,0,0,192,255,255,0,0,0,0,0,0,
255,243,0,12,0,0,0,12,255,255,0,0,0,0,0,3,
195,255,60,0,0,0,255,128,255,255,0,0,0,0,0,0,
255,252,0,3,0,0,0,3,255,255,0,0,0,0,0,0,
255,252,0,3,0,0,0,3,255,255,0,0,0,0,0,0,
255,255,0,0,0,0,0,0,207,255,48,0,0,0,48,0,
255,15,0,240,0,0,15,254,255,255,0,0,0,0,0,14,
255,255,0,0,0,0,252,63,255,252,0,3,0,0,0,7,
63,255,192,0,0,0,224,0,255,255,0,0,0,0,63,1,
240,127,14,128,1,0,255,224,255,255,0,0,0,0,0,1,
240,127,14,128,1,0,255,224,255,255,0,0,0,0,0,0,
255,7,0,232,0,16,31,254,255,252,0,3,0,0,56,31,
0,255,193,0,62,0,255,192,255,255,0,0,0,0,2,252,
255,193,0,58,0,4,7,255,255,255,0,0,0,0,128,0,
255,193,0,58,0,4,7,255,255,255,0,0,0,0,128,0,
255,252,0,3,0,0,0,127,31,255,160,0,64,0,248,0,
240,3,15,4,0,248,127,255,255,241,0,14,0,0,0,127,
7,193,248,62,0,0,255,255,255,248,0,4,0,3,255,255,
31,255,32,0,192,0,255,255,224,254,31,1,0,0,255,199,
0,63,240,64,15,128,255,254,255,254,0,1,0,0,1,199,
0,63,240,64,15,128,255,254,255,255,0,0,0,0,1,156,
224,3,31,4,0,248,127,255,255,0,0,248,0,7,255,255,
0,127,3,128,236,0,239,255,253,131,2,124,0,0,255,255,
248,0,7,193,0,62,31,255,255,255,0,0,0,0,248,7,
248,0,7,193,0,62,31,255,255,255,0,0,0,0,248,6,
255,128,0,124,0,3,113,255,15,252,16,3,224,0,255,191,
0,1,224,14,31,240,255,255,255,128,0,65,0,62,255,255,
0,0,7,193,248,62,255,255,0,0,255,248,0,6,255,254,
0,0,31,255,96,0,127,255,0,56,224,196,31,3,255,255,
0,1,0,30,252,96,252,127,254,56,1,196,0,3,255,255,
0,1,0,30,252,96,252,127,254,99,1,156,0,0,255,255,
128,0,64,1,63,198,255,199,0,0,255,224,0,31,255,255,
0,0,0,127,7,128,7,255,0,0,241,131,14,124,255,255,
224,0,16,0,15,241,255,241,7,248,120,7,128,0,255,255,
224,0,16,0,15,241,255,241,7,249,120,6,128,0,255,255,
142,0,113,0,0,255,255,255,0,64,7,159,24,32,31,255,
0,0,128,1,124,30,252,31,0,0,255,128,0,115,255,243,
0,0,128,0,127,255,255,255,0,0,0,0,255,252,255,252,
0,0,0,0,63,255,63,255,0,0,0,0,248,255,248,255,
0,0,0,1,192,62,192,63,0,0,252,0,3,255,255,255,
0,0,0,1,192,62,192,63,0,0,252,64,3,191,255,255,
0,0,0,0,252,3,252,3,0,0,0,0,255,254,255,254,
0,0,0,0,3,255,3,255,0,0,0,0,255,227,255,227,
0,0,0,0,255,0,255,0,0,0,7,240,248,15,255,255,
0,0,0,0,255,0,255,0,0,0,7,241,248,14,255,255,
0,0,0,0,255,240,255,240,0,0,0,64,15,191,15,255,
0,0,0,0,224,7,224,7,0,0,0,0,255,224,255,224,
0,0,0,0,31,0,31,0,0,0,0,0,1,240,1,240,
};
