;
; file generated by: F:\HL001128\DATA\MAKE_BLK.C
;/


export mask_same
DATA
EVEN
mask_same: 

dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,1,2,0,3,4,5,6,7,8,0,9,0,
dc.b 0,0,0,0,0,0,10,11,12,13,14,15,16,3,17,18,
dc.b 19,20,21,22,23,24,25,26,27,28,3,0,0,0,0,0,
dc.b 0,0,29,30,31,32,0,0,3,0,0,3,0,0,0,0,
dc.b 0,0,0,0,0,0,33,34,35,36,37,38,39,40,41,42,
dc.b 0,0,3,0,19,20,21,22,23,24,35,36,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,

export masks_0
DATA
EVEN
masks_0: 

dc.b 0,0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,
dc.b 0,0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,
dc.b 0,0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,
dc.b 0,0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,
dc.b 0,0,0,240,0,0,0,228,0,0,0,248,0,0,0,251,
dc.b 0,0,0,243,0,0,0,247,0,0,0,231,0,0,0,239,
dc.b 0,0,0,207,0,0,0,223,0,0,0,159,0,0,0,191,
dc.b 0,0,160,63,0,0,240,127,0,0,248,255,0,0,254,255,
dc.b 0,0,15,0,0,0,39,0,0,0,31,0,0,0,223,0,
dc.b 0,0,207,0,0,0,239,0,0,0,231,0,0,0,247,0,
dc.b 0,0,243,0,0,0,251,0,0,0,249,0,0,0,253,0,
dc.b 0,0,252,5,0,0,254,15,0,0,255,31,0,0,255,127,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,126,71,0,0,56,67,0,0,16,163,0,0,1,17,
dc.b 0,0,130,17,0,0,198,17,0,0,252,56,0,0,252,56,
dc.b 0,0,248,120,0,0,248,120,0,0,240,252,0,0,240,252,
dc.b 0,0,241,252,0,0,241,253,0,0,243,253,0,0,247,255,
dc.b 0,0,250,31,0,0,247,15,0,0,247,191,0,0,231,159,
dc.b 0,0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,
dc.b 0,0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,
dc.b 0,0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,
dc.b 0,0,255,194,0,0,252,68,0,0,244,40,0,0,244,16,
dc.b 0,0,210,16,0,0,201,51,0,0,100,220,0,0,135,163,
dc.b 0,0,200,193,0,0,240,65,0,0,240,65,0,0,240,66,
dc.b 0,0,248,130,0,0,255,130,0,0,255,131,0,0,255,199,
dc.b 0,0,127,255,0,0,127,255,0,0,111,255,0,0,103,255,
dc.b 0,0,143,255,0,0,27,255,0,0,99,255,0,0,195,255,
dc.b 0,0,7,255,0,0,239,255,0,0,27,255,0,0,15,255,
dc.b 0,0,15,255,0,0,15,255,0,0,31,255,0,0,255,255,
dc.b 0,0,255,193,0,0,255,193,0,0,255,193,0,0,255,193,
dc.b 0,0,255,193,0,0,255,193,0,0,255,193,0,0,255,193,
dc.b 0,0,255,193,0,0,255,193,0,0,255,193,0,0,255,193,
dc.b 0,0,255,193,0,0,255,193,0,0,255,193,0,0,255,193,
dc.b 0,0,0,1,0,0,128,3,0,0,192,7,0,0,192,15,
dc.b 0,0,224,15,0,0,224,31,0,0,240,31,0,0,240,31,
dc.b 0,0,248,31,0,0,248,63,0,0,248,63,0,0,252,127,
dc.b 0,0,252,127,0,0,252,127,0,0,254,255,0,0,254,255,
dc.b 0,0,192,7,0,0,192,15,0,0,224,15,0,0,224,31,
dc.b 0,0,240,31,0,0,240,31,0,0,248,31,0,0,248,63,
dc.b 0,0,248,63,0,0,252,127,0,0,252,127,0,0,252,127,
dc.b 0,0,254,255,0,0,254,255,0,0,255,255,0,0,255,255,
dc.b 0,0,224,15,0,0,224,31,0,0,240,31,0,0,240,31,
dc.b 0,0,248,31,0,0,248,63,0,0,248,63,0,0,252,127,
dc.b 0,0,252,127,0,0,252,127,0,0,254,255,0,0,254,255,
dc.b 0,0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,
dc.b 0,0,240,31,0,0,240,31,0,0,248,31,0,0,248,63,
dc.b 0,0,248,63,0,0,252,127,0,0,252,127,0,0,252,127,
dc.b 0,0,254,255,0,0,254,255,0,0,255,255,0,0,255,255,
dc.b 0,0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,
dc.b 0,0,248,31,0,0,248,63,0,0,248,63,0,0,252,127,
dc.b 0,0,252,127,0,0,252,127,0,0,254,255,0,0,254,255,
dc.b 0,0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,
dc.b 0,0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,
dc.b 0,0,248,63,0,0,252,127,0,0,252,127,0,0,252,127,
dc.b 0,0,254,255,0,0,254,255,0,0,255,255,0,0,255,255,
dc.b 0,0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,
dc.b 0,0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,
dc.b 0,0,252,127,0,0,252,127,0,0,254,255,0,0,254,255,
dc.b 0,0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,
dc.b 0,0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,
dc.b 0,0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,
dc.b 0,0,254,255,0,0,254,255,0,0,255,255,0,0,255,255,
dc.b 0,0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,
dc.b 0,0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,
dc.b 0,0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,
dc.b 0,0,240,7,0,0,240,7,0,0,248,7,0,0,248,15,
dc.b 0,0,248,15,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,248,15,0,0,248,15,
dc.b 0,0,248,15,0,0,248,15,0,0,248,15,0,0,248,15,
dc.b 0,0,248,15,0,0,248,15,0,0,248,15,0,0,248,15,
dc.b 0,0,248,15,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,248,15,0,0,248,15,
dc.b 0,0,248,15,0,0,248,15,0,0,248,15,0,0,248,15,
dc.b 0,0,240,112,0,0,224,48,0,0,192,0,0,0,192,0,
dc.b 0,0,224,0,0,0,240,0,0,0,136,0,0,0,0,0,
dc.b 0,0,0,0,0,0,128,0,0,0,192,0,0,0,240,0,
dc.b 0,0,254,0,0,0,240,1,0,0,252,7,0,0,255,255,
dc.b 0,0,3,207,0,0,3,3,0,0,0,1,0,0,0,1,
dc.b 0,0,0,3,0,0,0,7,0,0,0,1,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,1,0,0,0,15,
dc.b 0,0,0,127,0,0,128,7,0,0,192,15,0,0,224,63,
dc.b 0,0,254,127,0,0,254,127,0,0,254,63,0,0,254,127,
dc.b 0,0,254,127,0,0,254,127,0,0,254,127,0,0,254,127,
dc.b 0,0,252,127,0,0,254,127,0,0,254,127,0,0,252,127,
dc.b 0,0,248,127,0,0,192,255,0,0,129,255,0,0,3,255,
dc.b 0,0,255,159,0,0,255,159,0,0,255,159,0,0,255,15,
dc.b 0,0,255,35,0,0,254,33,0,0,254,96,0,0,254,96,
dc.b 0,0,254,113,0,0,252,127,0,0,248,127,0,0,252,63,
dc.b 0,0,252,63,0,0,254,63,0,0,252,127,0,0,254,127,
dc.b 0,0,255,159,0,0,255,159,0,0,255,159,0,0,255,15,
dc.b 0,0,255,35,0,0,254,33,0,0,252,96,0,0,254,96,
dc.b 0,0,254,113,0,0,252,127,0,0,248,127,0,0,192,63,
dc.b 0,0,129,63,0,0,131,31,0,0,7,159,0,0,255,143,
dc.b 0,0,240,63,0,0,248,127,0,0,252,255,0,0,252,255,
dc.b 0,0,252,255,0,0,248,63,0,0,228,7,0,0,250,1,
dc.b 0,0,254,51,0,0,252,127,0,0,248,127,0,0,192,63,
dc.b 0,0,129,63,0,0,131,31,0,0,7,143,0,0,255,159,
dc.b 0,0,0,0,0,0,0,0,0,0,1,0,0,0,3,192,
dc.b 0,0,31,224,0,0,63,224,0,0,63,224,0,0,31,224,
dc.b 0,0,127,224,0,0,31,240,0,0,31,240,0,0,31,248,
dc.b 0,0,12,120,0,0,0,48,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,1,0,0,0,3,64,
dc.b 0,0,7,192,0,0,7,224,0,0,3,224,0,0,3,192,
dc.b 0,0,7,224,0,0,15,224,0,0,31,192,0,0,6,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,15,0,0,0,31,192,
dc.b 0,0,63,128,0,0,63,0,0,0,30,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,192,
dc.b 0,0,1,240,0,0,1,248,0,0,1,248,0,0,0,240,
dc.b 0,0,227,36,0,0,192,0,0,0,0,0,0,0,0,0,
dc.b 0,0,128,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,128,0,0,0,0,0,0,0,0,0,0,0,128,0,
dc.b 0,0,160,0,0,0,192,0,0,0,240,48,0,0,249,96,
dc.b 0,0,17,151,0,0,0,3,0,0,0,7,0,0,0,3,
dc.b 0,0,0,3,0,0,0,3,0,0,0,7,0,0,0,7,
dc.b 0,0,0,3,0,0,0,7,0,0,0,3,0,0,0,3,
dc.b 0,0,0,15,0,0,0,15,0,0,0,223,0,0,140,127,
dc.b 0,0,224,0,0,0,192,0,0,0,128,0,0,0,128,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,128,0,
dc.b 0,0,128,0,0,0,192,0,0,0,240,0,0,0,254,1,
dc.b 0,0,0,15,0,0,0,7,0,0,0,1,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,
dc.b 0,0,0,1,0,0,48,3,0,0,120,7,0,0,254,31,
dc.b 0,0,248,63,0,0,252,63,0,0,254,31,0,0,254,31,
dc.b 0,0,254,31,0,0,252,31,0,0,248,63,0,0,252,63,
dc.b 0,0,248,95,0,0,248,127,0,0,248,255,0,0,240,127,
dc.b 0,0,240,127,0,0,248,127,0,0,248,127,0,0,248,127,
dc.b 0,0,255,255,0,0,252,255,0,0,252,255,0,0,248,127,
dc.b 0,0,248,127,0,0,248,63,0,0,252,31,0,0,252,63,
dc.b 0,0,250,31,0,0,254,31,0,0,255,31,0,0,254,15,
dc.b 0,0,254,15,0,0,254,31,0,0,254,31,0,0,252,63,
dc.b 0,0,248,63,0,0,224,63,0,0,192,31,0,0,198,63,
dc.b 0,0,198,63,0,0,254,31,0,0,254,31,0,0,254,63,
dc.b 0,0,132,17,0,0,0,0,0,0,0,0,0,0,128,0,
dc.b 0,0,0,0,0,0,0,0,0,0,192,1,0,0,252,31,
dc.b 0,0,240,0,0,0,248,0,0,0,252,0,0,0,255,1,
dc.b 0,0,255,15,0,0,254,15,0,0,252,31,0,0,254,31,
dc.b 0,0,252,47,0,0,252,63,0,0,252,127,0,0,248,15,
dc.b 0,0,248,7,0,0,252,7,0,0,252,15,0,0,252,63,
dc.b 0,0,192,0,0,0,128,0,0,0,0,0,0,0,128,0,
dc.b 0,0,128,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,128,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,128,0,0,0,192,0,0,0,255,248,0,0,255,252,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,1,255,0,0,3,255,
dc.b 0,0,31,255,0,0,15,255,0,0,15,255,0,0,31,255,
dc.b 0,0,15,255,0,0,15,255,0,0,15,255,0,0,15,255,
dc.b 0,0,63,255,0,0,15,255,0,0,15,255,0,0,15,255,
dc.b 0,0,31,255,0,0,63,255,0,0,255,255,0,0,255,255,
dc.b 0,0,255,192,0,0,255,128,0,0,255,128,0,0,255,240,
dc.b 0,0,255,224,0,0,255,248,0,0,255,248,0,0,251,248,
dc.b 0,0,235,248,0,0,235,248,0,0,192,0,0,0,128,0,
dc.b 0,0,0,0,0,0,192,0,0,0,0,0,0,0,0,0,
dc.b 0,0,1,255,0,0,0,63,0,0,0,15,0,0,1,15,
dc.b 0,0,0,199,0,0,1,255,0,0,1,255,0,0,1,239,
dc.b 0,0,1,230,0,0,1,230,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,
dc.b 0,0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,
dc.b 0,0,255,255,0,0,255,255,0,0,63,255,0,0,31,255,
dc.b 0,0,15,255,0,0,63,255,0,0,15,255,0,0,63,255,

export masks_1
DATA
EVEN
masks_1: 

dc.b 0,15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,
dc.b 0,15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,
dc.b 0,15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,
dc.b 0,15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,
dc.b 0,0,15,0,0,0,14,64,0,0,15,128,0,0,15,176,
dc.b 0,0,15,48,0,0,15,112,0,0,14,112,0,0,14,240,
dc.b 0,0,12,240,0,0,13,240,0,0,9,240,0,0,11,240,
dc.b 0,10,3,240,0,15,7,240,0,15,143,240,0,15,239,240,
dc.b 0,0,240,0,0,2,112,0,0,1,240,0,0,13,240,0,
dc.b 0,12,240,0,0,14,240,0,0,14,112,0,0,15,112,0,
dc.b 0,15,48,0,0,15,176,0,0,15,144,0,0,15,208,0,
dc.b 0,15,192,80,0,15,224,240,0,15,241,240,0,15,247,240,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,7,228,112,0,3,132,48,0,1,10,48,0,0,17,16,
dc.b 0,8,33,16,0,12,97,16,0,15,195,128,0,15,195,128,
dc.b 0,15,135,128,0,15,135,128,0,15,15,192,0,15,15,192,
dc.b 0,15,31,192,0,15,31,208,0,15,63,208,0,15,127,240,
dc.b 0,15,161,240,0,15,112,240,0,15,123,240,0,14,121,240,
dc.b 0,15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,
dc.b 0,15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,
dc.b 0,15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,
dc.b 0,15,252,32,0,15,196,64,0,15,66,128,0,15,65,0,
dc.b 0,13,33,0,0,12,147,48,0,6,77,192,0,8,122,48,
dc.b 0,12,140,16,0,15,4,16,0,15,4,16,0,15,4,32,
dc.b 0,15,136,32,0,15,248,32,0,15,248,48,0,15,252,112,
dc.b 0,7,255,240,0,7,255,240,0,6,255,240,0,6,127,240,
dc.b 0,8,255,240,0,1,191,240,0,6,63,240,0,12,63,240,
dc.b 0,0,127,240,0,14,255,240,0,1,191,240,0,0,255,240,
dc.b 0,0,255,240,0,0,255,240,0,1,255,240,0,15,255,240,
dc.b 0,15,252,16,0,15,252,16,0,15,252,16,0,15,252,16,
dc.b 0,15,252,16,0,15,252,16,0,15,252,16,0,15,252,16,
dc.b 0,15,252,16,0,15,252,16,0,15,252,16,0,15,252,16,
dc.b 0,15,252,16,0,15,252,16,0,15,252,16,0,15,252,16,
dc.b 0,0,0,16,0,8,0,48,0,12,0,112,0,12,0,240,
dc.b 0,14,0,240,0,14,1,240,0,15,1,240,0,15,1,240,
dc.b 0,15,129,240,0,15,131,240,0,15,131,240,0,15,199,240,
dc.b 0,15,199,240,0,15,199,240,0,15,239,240,0,15,239,240,
dc.b 0,12,0,112,0,12,0,240,0,14,0,240,0,14,1,240,
dc.b 0,15,1,240,0,15,1,240,0,15,129,240,0,15,131,240,
dc.b 0,15,131,240,0,15,199,240,0,15,199,240,0,15,199,240,
dc.b 0,15,239,240,0,15,239,240,0,15,255,240,0,15,255,240,
dc.b 0,14,0,240,0,14,1,240,0,15,1,240,0,15,1,240,
dc.b 0,15,129,240,0,15,131,240,0,15,131,240,0,15,199,240,
dc.b 0,15,199,240,0,15,199,240,0,15,239,240,0,15,239,240,
dc.b 0,15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,
dc.b 0,15,1,240,0,15,1,240,0,15,129,240,0,15,131,240,
dc.b 0,15,131,240,0,15,199,240,0,15,199,240,0,15,199,240,
dc.b 0,15,239,240,0,15,239,240,0,15,255,240,0,15,255,240,
dc.b 0,15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,
dc.b 0,15,129,240,0,15,131,240,0,15,131,240,0,15,199,240,
dc.b 0,15,199,240,0,15,199,240,0,15,239,240,0,15,239,240,
dc.b 0,15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,
dc.b 0,15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,
dc.b 0,15,131,240,0,15,199,240,0,15,199,240,0,15,199,240,
dc.b 0,15,239,240,0,15,239,240,0,15,255,240,0,15,255,240,
dc.b 0,15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,
dc.b 0,15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,
dc.b 0,15,199,240,0,15,199,240,0,15,239,240,0,15,239,240,
dc.b 0,15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,
dc.b 0,15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,
dc.b 0,15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,
dc.b 0,15,239,240,0,15,239,240,0,15,255,240,0,15,255,240,
dc.b 0,15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,
dc.b 0,15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,
dc.b 0,15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,
dc.b 0,15,0,112,0,15,0,112,0,15,128,112,0,15,128,240,
dc.b 0,15,128,240,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,15,128,240,0,15,128,240,
dc.b 0,15,128,240,0,15,128,240,0,15,128,240,0,15,128,240,
dc.b 0,15,128,240,0,15,128,240,0,15,128,240,0,15,128,240,
dc.b 0,15,128,240,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,15,128,240,0,15,128,240,
dc.b 0,15,128,240,0,15,128,240,0,15,128,240,0,15,128,240,
dc.b 0,15,7,0,0,14,3,0,0,12,0,0,0,12,0,0,
dc.b 0,14,0,0,0,15,0,0,0,8,128,0,0,0,0,0,
dc.b 0,0,0,0,0,8,0,0,0,12,0,0,0,15,0,0,
dc.b 0,15,224,0,0,15,0,16,0,15,192,112,0,15,255,240,
dc.b 0,0,60,240,0,0,48,48,0,0,0,16,0,0,0,16,
dc.b 0,0,0,48,0,0,0,112,0,0,0,16,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,16,0,0,0,240,
dc.b 0,0,7,240,0,8,0,112,0,12,0,240,0,14,3,240,
dc.b 0,15,231,240,0,15,231,240,0,15,227,240,0,15,231,240,
dc.b 0,15,231,240,0,15,231,240,0,15,231,240,0,15,231,240,
dc.b 0,15,199,240,0,15,231,240,0,15,231,240,0,15,199,240,
dc.b 0,15,135,240,0,12,15,240,0,8,31,240,0,0,63,240,
dc.b 0,15,249,240,0,15,249,240,0,15,249,240,0,15,240,240,
dc.b 0,15,242,48,0,15,226,16,0,15,230,0,0,15,230,0,
dc.b 0,15,231,16,0,15,199,240,0,15,135,240,0,15,195,240,
dc.b 0,15,195,240,0,15,227,240,0,15,199,240,0,15,231,240,
dc.b 0,15,249,240,0,15,249,240,0,15,249,240,0,15,240,240,
dc.b 0,15,242,48,0,15,226,16,0,15,198,0,0,15,230,0,
dc.b 0,15,231,16,0,15,199,240,0,15,135,240,0,12,3,240,
dc.b 0,8,19,240,0,8,49,240,0,0,121,240,0,15,248,240,
dc.b 0,15,3,240,0,15,135,240,0,15,207,240,0,15,207,240,
dc.b 0,15,207,240,0,15,131,240,0,14,64,112,0,15,160,16,
dc.b 0,15,227,48,0,15,199,240,0,15,135,240,0,12,3,240,
dc.b 0,8,19,240,0,8,49,240,0,0,120,240,0,15,249,240,
dc.b 0,0,0,0,0,0,0,0,0,0,16,0,0,0,60,0,
dc.b 0,1,254,0,0,3,254,0,0,3,254,0,0,1,254,0,
dc.b 0,7,254,0,0,1,255,0,0,1,255,0,0,1,255,128,
dc.b 0,0,199,128,0,0,3,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,16,0,0,0,52,0,
dc.b 0,0,124,0,0,0,126,0,0,0,62,0,0,0,60,0,
dc.b 0,0,126,0,0,0,254,0,0,1,252,0,0,0,96,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,240,0,0,1,252,0,
dc.b 0,3,248,0,0,3,240,0,0,1,224,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,12,0,
dc.b 0,0,31,0,0,0,31,128,0,0,31,128,0,0,15,0,
dc.b 0,14,50,64,0,12,0,0,0,0,0,0,0,0,0,0,
dc.b 0,8,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,8,0,0,0,0,0,0,0,0,0,0,0,8,0,0,
dc.b 0,10,0,0,0,12,0,0,0,15,3,0,0,15,150,0,
dc.b 0,1,25,112,0,0,0,48,0,0,0,112,0,0,0,48,
dc.b 0,0,0,48,0,0,0,48,0,0,0,112,0,0,0,112,
dc.b 0,0,0,48,0,0,0,112,0,0,0,48,0,0,0,48,
dc.b 0,0,0,240,0,0,0,240,0,0,13,240,0,8,199,240,
dc.b 0,14,0,0,0,12,0,0,0,8,0,0,0,8,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,8,0,0,
dc.b 0,8,0,0,0,12,0,0,0,15,0,0,0,15,224,16,
dc.b 0,0,0,240,0,0,0,112,0,0,0,16,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,16,
dc.b 0,0,0,16,0,3,0,48,0,7,128,112,0,15,225,240,
dc.b 0,15,131,240,0,15,195,240,0,15,225,240,0,15,225,240,
dc.b 0,15,225,240,0,15,193,240,0,15,131,240,0,15,195,240,
dc.b 0,15,133,240,0,15,135,240,0,15,143,240,0,15,7,240,
dc.b 0,15,7,240,0,15,135,240,0,15,135,240,0,15,135,240,
dc.b 0,15,255,240,0,15,207,240,0,15,207,240,0,15,135,240,
dc.b 0,15,135,240,0,15,131,240,0,15,193,240,0,15,195,240,
dc.b 0,15,161,240,0,15,225,240,0,15,241,240,0,15,224,240,
dc.b 0,15,224,240,0,15,225,240,0,15,225,240,0,15,195,240,
dc.b 0,15,131,240,0,14,3,240,0,12,1,240,0,12,99,240,
dc.b 0,12,99,240,0,15,225,240,0,15,225,240,0,15,227,240,
dc.b 0,8,65,16,0,0,0,0,0,0,0,0,0,8,0,0,
dc.b 0,0,0,0,0,0,0,0,0,12,0,16,0,15,193,240,
dc.b 0,15,0,0,0,15,128,0,0,15,192,0,0,15,240,16,
dc.b 0,15,240,240,0,15,224,240,0,15,193,240,0,15,225,240,
dc.b 0,15,194,240,0,15,195,240,0,15,199,240,0,15,128,240,
dc.b 0,15,128,112,0,15,192,112,0,15,192,240,0,15,195,240,
dc.b 0,12,0,0,0,8,0,0,0,0,0,0,0,8,0,0,
dc.b 0,8,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,8,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,8,0,0,0,12,0,0,0,15,255,128,0,15,255,192,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,31,240,0,0,63,240,
dc.b 0,1,255,240,0,0,255,240,0,0,255,240,0,1,255,240,
dc.b 0,0,255,240,0,0,255,240,0,0,255,240,0,0,255,240,
dc.b 0,3,255,240,0,0,255,240,0,0,255,240,0,0,255,240,
dc.b 0,1,255,240,0,3,255,240,0,15,255,240,0,15,255,240,
dc.b 0,15,252,0,0,15,248,0,0,15,248,0,0,15,255,0,
dc.b 0,15,254,0,0,15,255,128,0,15,255,128,0,15,191,128,
dc.b 0,14,191,128,0,14,191,128,0,12,0,0,0,8,0,0,
dc.b 0,0,0,0,0,12,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,31,240,0,0,3,240,0,0,0,240,0,0,16,240,
dc.b 0,0,12,112,0,0,31,240,0,0,31,240,0,0,30,240,
dc.b 0,0,30,96,0,0,30,96,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,
dc.b 0,15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,
dc.b 0,15,255,240,0,15,255,240,0,3,255,240,0,1,255,240,
dc.b 0,0,255,240,0,3,255,240,0,0,255,240,0,3,255,240,

export masks_2
DATA
EVEN
masks_2: 

dc.b 0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,0,
dc.b 0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,0,
dc.b 0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,0,
dc.b 0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,0,
dc.b 0,0,240,0,0,0,228,0,0,0,248,0,0,0,251,0,
dc.b 0,0,243,0,0,0,247,0,0,0,231,0,0,0,239,0,
dc.b 0,0,207,0,0,0,223,0,0,0,159,0,0,0,191,0,
dc.b 0,160,63,0,0,240,127,0,0,248,255,0,0,254,255,0,
dc.b 0,15,0,0,0,39,0,0,0,31,0,0,0,223,0,0,
dc.b 0,207,0,0,0,239,0,0,0,231,0,0,0,247,0,0,
dc.b 0,243,0,0,0,251,0,0,0,249,0,0,0,253,0,0,
dc.b 0,252,5,0,0,254,15,0,0,255,31,0,0,255,127,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,126,71,0,0,56,67,0,0,16,163,0,0,1,17,0,
dc.b 0,130,17,0,0,198,17,0,0,252,56,0,0,252,56,0,
dc.b 0,248,120,0,0,248,120,0,0,240,252,0,0,240,252,0,
dc.b 0,241,252,0,0,241,253,0,0,243,253,0,0,247,255,0,
dc.b 0,250,31,0,0,247,15,0,0,247,191,0,0,231,159,0,
dc.b 0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,0,
dc.b 0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,0,
dc.b 0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,0,
dc.b 0,255,194,0,0,252,68,0,0,244,40,0,0,244,16,0,
dc.b 0,210,16,0,0,201,51,0,0,100,220,0,0,135,163,0,
dc.b 0,200,193,0,0,240,65,0,0,240,65,0,0,240,66,0,
dc.b 0,248,130,0,0,255,130,0,0,255,131,0,0,255,199,0,
dc.b 0,127,255,0,0,127,255,0,0,111,255,0,0,103,255,0,
dc.b 0,143,255,0,0,27,255,0,0,99,255,0,0,195,255,0,
dc.b 0,7,255,0,0,239,255,0,0,27,255,0,0,15,255,0,
dc.b 0,15,255,0,0,15,255,0,0,31,255,0,0,255,255,0,
dc.b 0,255,193,0,0,255,193,0,0,255,193,0,0,255,193,0,
dc.b 0,255,193,0,0,255,193,0,0,255,193,0,0,255,193,0,
dc.b 0,255,193,0,0,255,193,0,0,255,193,0,0,255,193,0,
dc.b 0,255,193,0,0,255,193,0,0,255,193,0,0,255,193,0,
dc.b 0,0,1,0,0,128,3,0,0,192,7,0,0,192,15,0,
dc.b 0,224,15,0,0,224,31,0,0,240,31,0,0,240,31,0,
dc.b 0,248,31,0,0,248,63,0,0,248,63,0,0,252,127,0,
dc.b 0,252,127,0,0,252,127,0,0,254,255,0,0,254,255,0,
dc.b 0,192,7,0,0,192,15,0,0,224,15,0,0,224,31,0,
dc.b 0,240,31,0,0,240,31,0,0,248,31,0,0,248,63,0,
dc.b 0,248,63,0,0,252,127,0,0,252,127,0,0,252,127,0,
dc.b 0,254,255,0,0,254,255,0,0,255,255,0,0,255,255,0,
dc.b 0,224,15,0,0,224,31,0,0,240,31,0,0,240,31,0,
dc.b 0,248,31,0,0,248,63,0,0,248,63,0,0,252,127,0,
dc.b 0,252,127,0,0,252,127,0,0,254,255,0,0,254,255,0,
dc.b 0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,0,
dc.b 0,240,31,0,0,240,31,0,0,248,31,0,0,248,63,0,
dc.b 0,248,63,0,0,252,127,0,0,252,127,0,0,252,127,0,
dc.b 0,254,255,0,0,254,255,0,0,255,255,0,0,255,255,0,
dc.b 0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,0,
dc.b 0,248,31,0,0,248,63,0,0,248,63,0,0,252,127,0,
dc.b 0,252,127,0,0,252,127,0,0,254,255,0,0,254,255,0,
dc.b 0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,0,
dc.b 0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,0,
dc.b 0,248,63,0,0,252,127,0,0,252,127,0,0,252,127,0,
dc.b 0,254,255,0,0,254,255,0,0,255,255,0,0,255,255,0,
dc.b 0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,0,
dc.b 0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,0,
dc.b 0,252,127,0,0,252,127,0,0,254,255,0,0,254,255,0,
dc.b 0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,0,
dc.b 0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,0,
dc.b 0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,0,
dc.b 0,254,255,0,0,254,255,0,0,255,255,0,0,255,255,0,
dc.b 0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,0,
dc.b 0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,0,
dc.b 0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,0,
dc.b 0,240,7,0,0,240,7,0,0,248,7,0,0,248,15,0,
dc.b 0,248,15,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,248,15,0,0,248,15,0,
dc.b 0,248,15,0,0,248,15,0,0,248,15,0,0,248,15,0,
dc.b 0,248,15,0,0,248,15,0,0,248,15,0,0,248,15,0,
dc.b 0,248,15,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,248,15,0,0,248,15,0,
dc.b 0,248,15,0,0,248,15,0,0,248,15,0,0,248,15,0,
dc.b 0,240,112,0,0,224,48,0,0,192,0,0,0,192,0,0,
dc.b 0,224,0,0,0,240,0,0,0,136,0,0,0,0,0,0,
dc.b 0,0,0,0,0,128,0,0,0,192,0,0,0,240,0,0,
dc.b 0,254,0,0,0,240,1,0,0,252,7,0,0,255,255,0,
dc.b 0,3,207,0,0,3,3,0,0,0,1,0,0,0,1,0,
dc.b 0,0,3,0,0,0,7,0,0,0,1,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,1,0,0,0,15,0,
dc.b 0,0,127,0,0,128,7,0,0,192,15,0,0,224,63,0,
dc.b 0,254,127,0,0,254,127,0,0,254,63,0,0,254,127,0,
dc.b 0,254,127,0,0,254,127,0,0,254,127,0,0,254,127,0,
dc.b 0,252,127,0,0,254,127,0,0,254,127,0,0,252,127,0,
dc.b 0,248,127,0,0,192,255,0,0,129,255,0,0,3,255,0,
dc.b 0,255,159,0,0,255,159,0,0,255,159,0,0,255,15,0,
dc.b 0,255,35,0,0,254,33,0,0,254,96,0,0,254,96,0,
dc.b 0,254,113,0,0,252,127,0,0,248,127,0,0,252,63,0,
dc.b 0,252,63,0,0,254,63,0,0,252,127,0,0,254,127,0,
dc.b 0,255,159,0,0,255,159,0,0,255,159,0,0,255,15,0,
dc.b 0,255,35,0,0,254,33,0,0,252,96,0,0,254,96,0,
dc.b 0,254,113,0,0,252,127,0,0,248,127,0,0,192,63,0,
dc.b 0,129,63,0,0,131,31,0,0,7,159,0,0,255,143,0,
dc.b 0,240,63,0,0,248,127,0,0,252,255,0,0,252,255,0,
dc.b 0,252,255,0,0,248,63,0,0,228,7,0,0,250,1,0,
dc.b 0,254,51,0,0,252,127,0,0,248,127,0,0,192,63,0,
dc.b 0,129,63,0,0,131,31,0,0,7,143,0,0,255,159,0,
dc.b 0,0,0,0,0,0,0,0,0,1,0,0,0,3,192,0,
dc.b 0,31,224,0,0,63,224,0,0,63,224,0,0,31,224,0,
dc.b 0,127,224,0,0,31,240,0,0,31,240,0,0,31,248,0,
dc.b 0,12,120,0,0,0,48,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,0,0,0,3,64,0,
dc.b 0,7,192,0,0,7,224,0,0,3,224,0,0,3,192,0,
dc.b 0,7,224,0,0,15,224,0,0,31,192,0,0,6,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,15,0,0,0,31,192,0,
dc.b 0,63,128,0,0,63,0,0,0,30,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,192,0,
dc.b 0,1,240,0,0,1,248,0,0,1,248,0,0,0,240,0,
dc.b 0,227,36,0,0,192,0,0,0,0,0,0,0,0,0,0,
dc.b 0,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,128,0,0,0,0,0,0,0,0,0,0,0,128,0,0,
dc.b 0,160,0,0,0,192,0,0,0,240,48,0,0,249,96,0,
dc.b 0,17,151,0,0,0,3,0,0,0,7,0,0,0,3,0,
dc.b 0,0,3,0,0,0,3,0,0,0,7,0,0,0,7,0,
dc.b 0,0,3,0,0,0,7,0,0,0,3,0,0,0,3,0,
dc.b 0,0,15,0,0,0,15,0,0,0,223,0,0,140,127,0,
dc.b 0,224,0,0,0,192,0,0,0,128,0,0,0,128,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,128,0,0,
dc.b 0,128,0,0,0,192,0,0,0,240,0,0,0,254,1,0,
dc.b 0,0,15,0,0,0,7,0,0,0,1,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,0,
dc.b 0,0,1,0,0,48,3,0,0,120,7,0,0,254,31,0,
dc.b 0,248,63,0,0,252,63,0,0,254,31,0,0,254,31,0,
dc.b 0,254,31,0,0,252,31,0,0,248,63,0,0,252,63,0,
dc.b 0,248,95,0,0,248,127,0,0,248,255,0,0,240,127,0,
dc.b 0,240,127,0,0,248,127,0,0,248,127,0,0,248,127,0,
dc.b 0,255,255,0,0,252,255,0,0,252,255,0,0,248,127,0,
dc.b 0,248,127,0,0,248,63,0,0,252,31,0,0,252,63,0,
dc.b 0,250,31,0,0,254,31,0,0,255,31,0,0,254,15,0,
dc.b 0,254,15,0,0,254,31,0,0,254,31,0,0,252,63,0,
dc.b 0,248,63,0,0,224,63,0,0,192,31,0,0,198,63,0,
dc.b 0,198,63,0,0,254,31,0,0,254,31,0,0,254,63,0,
dc.b 0,132,17,0,0,0,0,0,0,0,0,0,0,128,0,0,
dc.b 0,0,0,0,0,0,0,0,0,192,1,0,0,252,31,0,
dc.b 0,240,0,0,0,248,0,0,0,252,0,0,0,255,1,0,
dc.b 0,255,15,0,0,254,15,0,0,252,31,0,0,254,31,0,
dc.b 0,252,47,0,0,252,63,0,0,252,127,0,0,248,15,0,
dc.b 0,248,7,0,0,252,7,0,0,252,15,0,0,252,63,0,
dc.b 0,192,0,0,0,128,0,0,0,0,0,0,0,128,0,0,
dc.b 0,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,128,0,0,0,192,0,0,0,255,248,0,0,255,252,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,255,0,0,3,255,0,
dc.b 0,31,255,0,0,15,255,0,0,15,255,0,0,31,255,0,
dc.b 0,15,255,0,0,15,255,0,0,15,255,0,0,15,255,0,
dc.b 0,63,255,0,0,15,255,0,0,15,255,0,0,15,255,0,
dc.b 0,31,255,0,0,63,255,0,0,255,255,0,0,255,255,0,
dc.b 0,255,192,0,0,255,128,0,0,255,128,0,0,255,240,0,
dc.b 0,255,224,0,0,255,248,0,0,255,248,0,0,251,248,0,
dc.b 0,235,248,0,0,235,248,0,0,192,0,0,0,128,0,0,
dc.b 0,0,0,0,0,192,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,255,0,0,0,63,0,0,0,15,0,0,1,15,0,
dc.b 0,0,199,0,0,1,255,0,0,1,255,0,0,1,239,0,
dc.b 0,1,230,0,0,1,230,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,0,
dc.b 0,255,255,0,0,255,255,0,0,255,255,0,0,255,255,0,
dc.b 0,255,255,0,0,255,255,0,0,63,255,0,0,31,255,0,
dc.b 0,15,255,0,0,63,255,0,0,15,255,0,0,63,255,0,

export masks_3
DATA
EVEN
masks_3: 

dc.b 15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,0,
dc.b 15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,0,
dc.b 15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,0,
dc.b 15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,0,
dc.b 0,15,0,0,0,14,64,0,0,15,128,0,0,15,176,0,
dc.b 0,15,48,0,0,15,112,0,0,14,112,0,0,14,240,0,
dc.b 0,12,240,0,0,13,240,0,0,9,240,0,0,11,240,0,
dc.b 10,3,240,0,15,7,240,0,15,143,240,0,15,239,240,0,
dc.b 0,240,0,0,2,112,0,0,1,240,0,0,13,240,0,0,
dc.b 12,240,0,0,14,240,0,0,14,112,0,0,15,112,0,0,
dc.b 15,48,0,0,15,176,0,0,15,144,0,0,15,208,0,0,
dc.b 15,192,80,0,15,224,240,0,15,241,240,0,15,247,240,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 7,228,112,0,3,132,48,0,1,10,48,0,0,17,16,0,
dc.b 8,33,16,0,12,97,16,0,15,195,128,0,15,195,128,0,
dc.b 15,135,128,0,15,135,128,0,15,15,192,0,15,15,192,0,
dc.b 15,31,192,0,15,31,208,0,15,63,208,0,15,127,240,0,
dc.b 15,161,240,0,15,112,240,0,15,123,240,0,14,121,240,0,
dc.b 15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,0,
dc.b 15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,0,
dc.b 15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,0,
dc.b 15,252,32,0,15,196,64,0,15,66,128,0,15,65,0,0,
dc.b 13,33,0,0,12,147,48,0,6,77,192,0,8,122,48,0,
dc.b 12,140,16,0,15,4,16,0,15,4,16,0,15,4,32,0,
dc.b 15,136,32,0,15,248,32,0,15,248,48,0,15,252,112,0,
dc.b 7,255,240,0,7,255,240,0,6,255,240,0,6,127,240,0,
dc.b 8,255,240,0,1,191,240,0,6,63,240,0,12,63,240,0,
dc.b 0,127,240,0,14,255,240,0,1,191,240,0,0,255,240,0,
dc.b 0,255,240,0,0,255,240,0,1,255,240,0,15,255,240,0,
dc.b 15,252,16,0,15,252,16,0,15,252,16,0,15,252,16,0,
dc.b 15,252,16,0,15,252,16,0,15,252,16,0,15,252,16,0,
dc.b 15,252,16,0,15,252,16,0,15,252,16,0,15,252,16,0,
dc.b 15,252,16,0,15,252,16,0,15,252,16,0,15,252,16,0,
dc.b 0,0,16,0,8,0,48,0,12,0,112,0,12,0,240,0,
dc.b 14,0,240,0,14,1,240,0,15,1,240,0,15,1,240,0,
dc.b 15,129,240,0,15,131,240,0,15,131,240,0,15,199,240,0,
dc.b 15,199,240,0,15,199,240,0,15,239,240,0,15,239,240,0,
dc.b 12,0,112,0,12,0,240,0,14,0,240,0,14,1,240,0,
dc.b 15,1,240,0,15,1,240,0,15,129,240,0,15,131,240,0,
dc.b 15,131,240,0,15,199,240,0,15,199,240,0,15,199,240,0,
dc.b 15,239,240,0,15,239,240,0,15,255,240,0,15,255,240,0,
dc.b 14,0,240,0,14,1,240,0,15,1,240,0,15,1,240,0,
dc.b 15,129,240,0,15,131,240,0,15,131,240,0,15,199,240,0,
dc.b 15,199,240,0,15,199,240,0,15,239,240,0,15,239,240,0,
dc.b 15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,0,
dc.b 15,1,240,0,15,1,240,0,15,129,240,0,15,131,240,0,
dc.b 15,131,240,0,15,199,240,0,15,199,240,0,15,199,240,0,
dc.b 15,239,240,0,15,239,240,0,15,255,240,0,15,255,240,0,
dc.b 15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,0,
dc.b 15,129,240,0,15,131,240,0,15,131,240,0,15,199,240,0,
dc.b 15,199,240,0,15,199,240,0,15,239,240,0,15,239,240,0,
dc.b 15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,0,
dc.b 15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,0,
dc.b 15,131,240,0,15,199,240,0,15,199,240,0,15,199,240,0,
dc.b 15,239,240,0,15,239,240,0,15,255,240,0,15,255,240,0,
dc.b 15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,0,
dc.b 15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,0,
dc.b 15,199,240,0,15,199,240,0,15,239,240,0,15,239,240,0,
dc.b 15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,0,
dc.b 15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,0,
dc.b 15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,0,
dc.b 15,239,240,0,15,239,240,0,15,255,240,0,15,255,240,0,
dc.b 15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,0,
dc.b 15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,0,
dc.b 15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,0,
dc.b 15,0,112,0,15,0,112,0,15,128,112,0,15,128,240,0,
dc.b 15,128,240,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,15,128,240,0,15,128,240,0,
dc.b 15,128,240,0,15,128,240,0,15,128,240,0,15,128,240,0,
dc.b 15,128,240,0,15,128,240,0,15,128,240,0,15,128,240,0,
dc.b 15,128,240,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,15,128,240,0,15,128,240,0,
dc.b 15,128,240,0,15,128,240,0,15,128,240,0,15,128,240,0,
dc.b 15,7,0,0,14,3,0,0,12,0,0,0,12,0,0,0,
dc.b 14,0,0,0,15,0,0,0,8,128,0,0,0,0,0,0,
dc.b 0,0,0,0,8,0,0,0,12,0,0,0,15,0,0,0,
dc.b 15,224,0,0,15,0,16,0,15,192,112,0,15,255,240,0,
dc.b 0,60,240,0,0,48,48,0,0,0,16,0,0,0,16,0,
dc.b 0,0,48,0,0,0,112,0,0,0,16,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,16,0,0,0,240,0,
dc.b 0,7,240,0,8,0,112,0,12,0,240,0,14,3,240,0,
dc.b 15,231,240,0,15,231,240,0,15,227,240,0,15,231,240,0,
dc.b 15,231,240,0,15,231,240,0,15,231,240,0,15,231,240,0,
dc.b 15,199,240,0,15,231,240,0,15,231,240,0,15,199,240,0,
dc.b 15,135,240,0,12,15,240,0,8,31,240,0,0,63,240,0,
dc.b 15,249,240,0,15,249,240,0,15,249,240,0,15,240,240,0,
dc.b 15,242,48,0,15,226,16,0,15,230,0,0,15,230,0,0,
dc.b 15,231,16,0,15,199,240,0,15,135,240,0,15,195,240,0,
dc.b 15,195,240,0,15,227,240,0,15,199,240,0,15,231,240,0,
dc.b 15,249,240,0,15,249,240,0,15,249,240,0,15,240,240,0,
dc.b 15,242,48,0,15,226,16,0,15,198,0,0,15,230,0,0,
dc.b 15,231,16,0,15,199,240,0,15,135,240,0,12,3,240,0,
dc.b 8,19,240,0,8,49,240,0,0,121,240,0,15,248,240,0,
dc.b 15,3,240,0,15,135,240,0,15,207,240,0,15,207,240,0,
dc.b 15,207,240,0,15,131,240,0,14,64,112,0,15,160,16,0,
dc.b 15,227,48,0,15,199,240,0,15,135,240,0,12,3,240,0,
dc.b 8,19,240,0,8,49,240,0,0,120,240,0,15,249,240,0,
dc.b 0,0,0,0,0,0,0,0,0,16,0,0,0,60,0,0,
dc.b 1,254,0,0,3,254,0,0,3,254,0,0,1,254,0,0,
dc.b 7,254,0,0,1,255,0,0,1,255,0,0,1,255,128,0,
dc.b 0,199,128,0,0,3,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,16,0,0,0,52,0,0,
dc.b 0,124,0,0,0,126,0,0,0,62,0,0,0,60,0,0,
dc.b 0,126,0,0,0,254,0,0,1,252,0,0,0,96,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,240,0,0,1,252,0,0,
dc.b 3,248,0,0,3,240,0,0,1,224,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,12,0,0,
dc.b 0,31,0,0,0,31,128,0,0,31,128,0,0,15,0,0,
dc.b 14,50,64,0,12,0,0,0,0,0,0,0,0,0,0,0,
dc.b 8,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 8,0,0,0,0,0,0,0,0,0,0,0,8,0,0,0,
dc.b 10,0,0,0,12,0,0,0,15,3,0,0,15,150,0,0,
dc.b 1,25,112,0,0,0,48,0,0,0,112,0,0,0,48,0,
dc.b 0,0,48,0,0,0,48,0,0,0,112,0,0,0,112,0,
dc.b 0,0,48,0,0,0,112,0,0,0,48,0,0,0,48,0,
dc.b 0,0,240,0,0,0,240,0,0,13,240,0,8,199,240,0,
dc.b 14,0,0,0,12,0,0,0,8,0,0,0,8,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,8,0,0,0,
dc.b 8,0,0,0,12,0,0,0,15,0,0,0,15,224,16,0,
dc.b 0,0,240,0,0,0,112,0,0,0,16,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,16,0,
dc.b 0,0,16,0,3,0,48,0,7,128,112,0,15,225,240,0,
dc.b 15,131,240,0,15,195,240,0,15,225,240,0,15,225,240,0,
dc.b 15,225,240,0,15,193,240,0,15,131,240,0,15,195,240,0,
dc.b 15,133,240,0,15,135,240,0,15,143,240,0,15,7,240,0,
dc.b 15,7,240,0,15,135,240,0,15,135,240,0,15,135,240,0,
dc.b 15,255,240,0,15,207,240,0,15,207,240,0,15,135,240,0,
dc.b 15,135,240,0,15,131,240,0,15,193,240,0,15,195,240,0,
dc.b 15,161,240,0,15,225,240,0,15,241,240,0,15,224,240,0,
dc.b 15,224,240,0,15,225,240,0,15,225,240,0,15,195,240,0,
dc.b 15,131,240,0,14,3,240,0,12,1,240,0,12,99,240,0,
dc.b 12,99,240,0,15,225,240,0,15,225,240,0,15,227,240,0,
dc.b 8,65,16,0,0,0,0,0,0,0,0,0,8,0,0,0,
dc.b 0,0,0,0,0,0,0,0,12,0,16,0,15,193,240,0,
dc.b 15,0,0,0,15,128,0,0,15,192,0,0,15,240,16,0,
dc.b 15,240,240,0,15,224,240,0,15,193,240,0,15,225,240,0,
dc.b 15,194,240,0,15,195,240,0,15,199,240,0,15,128,240,0,
dc.b 15,128,112,0,15,192,112,0,15,192,240,0,15,195,240,0,
dc.b 12,0,0,0,8,0,0,0,0,0,0,0,8,0,0,0,
dc.b 8,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 8,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 8,0,0,0,12,0,0,0,15,255,128,0,15,255,192,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,31,240,0,0,63,240,0,
dc.b 1,255,240,0,0,255,240,0,0,255,240,0,1,255,240,0,
dc.b 0,255,240,0,0,255,240,0,0,255,240,0,0,255,240,0,
dc.b 3,255,240,0,0,255,240,0,0,255,240,0,0,255,240,0,
dc.b 1,255,240,0,3,255,240,0,15,255,240,0,15,255,240,0,
dc.b 15,252,0,0,15,248,0,0,15,248,0,0,15,255,0,0,
dc.b 15,254,0,0,15,255,128,0,15,255,128,0,15,191,128,0,
dc.b 14,191,128,0,14,191,128,0,12,0,0,0,8,0,0,0,
dc.b 0,0,0,0,12,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,31,240,0,0,3,240,0,0,0,240,0,0,16,240,0,
dc.b 0,12,112,0,0,31,240,0,0,31,240,0,0,30,240,0,
dc.b 0,30,96,0,0,30,96,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,0,
dc.b 15,255,240,0,15,255,240,0,15,255,240,0,15,255,240,0,
dc.b 15,255,240,0,15,255,240,0,3,255,240,0,1,255,240,0,
dc.b 0,255,240,0,3,255,240,0,0,255,240,0,3,255,240,0,

export blocks
DATA
EVEN
blocks: 

dc.b 0,0,255,255,255,255,255,255,17,17,255,255,238,238,238,238,
dc.b 17,17,255,255,204,204,204,204,17,17,255,255,136,136,136,136,
dc.b 51,51,255,255,136,136,136,136,255,255,255,255,0,0,0,0,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 243,150,12,105,255,255,12,105,51,145,204,111,255,254,204,110,
dc.b 53,153,202,119,253,204,200,68,53,153,202,119,189,136,136,0,
dc.b 55,51,218,255,173,136,136,136,255,255,158,255,97,0,0,0,
dc.b 255,255,0,0,255,255,158,255,255,255,0,0,255,255,156,255,
dc.b 255,255,0,0,255,255,188,255,255,255,0,0,255,255,188,255,
dc.b 255,255,0,0,255,255,253,255,255,255,0,0,255,255,253,255,
dc.b 255,255,0,0,255,255,253,255,255,255,0,0,255,255,253,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,0,0,0,0,255,255,255,255,0,0,
dc.b 255,255,255,255,255,255,0,0,63,254,255,255,127,255,0,0,
dc.b 7,156,255,255,127,254,0,0,3,4,255,255,7,142,0,0,
dc.b 0,0,255,255,66,4,64,0,0,8,255,255,0,0,0,0,
dc.b 0,0,255,255,0,0,0,0,0,0,255,255,18,26,18,26,
dc.b 8,0,255,255,0,0,0,0,0,0,255,255,0,0,0,0,
dc.b 0,64,255,255,66,0,66,0,0,0,255,255,0,128,0,128,
dc.b 32,5,255,255,8,0,8,0,0,0,255,255,2,138,2,138,
dc.b 255,255,0,0,255,255,0,0,0,0,255,255,255,255,0,0,
dc.b 255,255,255,255,255,255,0,0,249,226,255,255,255,250,0,0,
dc.b 96,192,255,255,113,224,0,0,0,0,255,255,32,66,0,2,
dc.b 0,16,255,255,4,0,4,0,16,0,255,255,0,0,0,0,
dc.b 0,0,255,255,0,0,0,0,0,0,255,255,88,72,88,72,
dc.b 0,16,255,255,0,0,0,0,0,0,255,255,0,0,0,0,
dc.b 2,0,255,255,0,66,0,66,0,0,255,255,1,0,1,0,
dc.b 160,4,255,255,0,16,0,16,0,0,255,255,81,64,81,64,
dc.b 224,127,255,255,0,0,255,255,240,7,255,255,0,0,255,255,
dc.b 240,35,255,255,0,0,255,255,191,145,191,255,64,0,255,255,
dc.b 185,201,191,255,64,0,255,255,188,113,191,255,64,0,255,255,
dc.b 159,53,159,255,96,0,255,255,159,24,159,255,96,0,255,255,
dc.b 159,252,159,255,96,0,255,255,143,252,143,255,112,0,255,255,
dc.b 174,254,174,255,81,0,255,255,182,124,182,127,73,128,255,255,
dc.b 147,252,147,255,108,0,255,255,152,254,152,255,103,0,255,255,
dc.b 206,30,206,31,49,224,255,255,255,255,255,255,0,0,255,255,
dc.b 0,0,255,255,0,0,0,0,0,0,255,255,128,0,128,0,
dc.b 0,2,255,255,32,0,32,0,4,0,255,255,0,0,0,0,
dc.b 0,32,255,255,192,0,192,0,0,0,255,255,20,16,20,16,
dc.b 0,2,255,255,0,0,0,0,0,0,255,255,97,0,97,0,
dc.b 0,0,255,255,0,1,0,1,0,0,255,255,0,0,0,0,
dc.b 8,0,255,255,1,9,1,9,0,0,255,255,4,1,4,1,
dc.b 128,16,255,255,0,64,0,64,0,0,255,255,69,0,69,0,
dc.b 8,8,255,255,0,194,0,194,0,0,255,255,4,0,4,0,
dc.b 255,255,0,0,255,255,0,0,128,0,127,255,255,255,0,0,
dc.b 127,255,255,255,255,255,0,0,249,227,255,255,255,251,0,0,
dc.b 96,192,255,255,241,224,0,0,64,128,255,255,224,194,0,2,
dc.b 0,16,255,255,196,128,4,0,144,0,127,255,192,0,0,0,
dc.b 0,0,255,255,0,0,0,0,0,0,255,255,88,72,88,72,
dc.b 0,16,255,255,0,0,0,0,0,0,255,255,0,0,0,0,
dc.b 2,0,255,255,0,66,0,66,0,0,255,255,1,0,1,0,
dc.b 160,4,255,255,0,16,0,16,0,0,255,255,81,64,81,64,
dc.b 255,255,0,0,255,255,0,0,0,1,255,254,255,255,0,0,
dc.b 255,254,255,255,255,255,0,0,199,159,255,255,223,255,0,0,
dc.b 3,6,255,255,7,143,0,0,1,2,255,255,67,7,64,0,
dc.b 8,0,255,255,1,35,0,32,0,9,255,254,0,3,0,0,
dc.b 0,0,255,255,0,0,0,0,0,0,255,255,18,26,18,26,
dc.b 8,0,255,255,0,0,0,0,0,0,255,255,0,0,0,0,
dc.b 0,64,255,255,66,0,66,0,0,0,255,255,0,128,0,128,
dc.b 32,5,255,255,8,0,8,0,0,0,255,255,2,138,2,138,
dc.b 153,215,103,40,152,215,230,232,27,220,231,35,24,220,231,227,
dc.b 63,159,230,99,25,156,231,227,127,61,230,225,25,30,231,227,
dc.b 111,255,197,227,58,28,215,227,255,255,223,229,32,26,223,229,
dc.b 239,255,207,229,48,26,223,229,255,255,223,229,32,26,223,229,
dc.b 119,255,87,247,168,8,223,247,59,187,27,179,228,76,223,247,
dc.b 161,221,1,213,254,42,223,247,176,8,0,0,255,255,207,247,
dc.b 244,8,0,0,255,255,207,247,255,255,0,0,255,255,215,247,
dc.b 255,255,0,0,255,255,247,247,255,255,0,0,255,255,255,247,
dc.b 255,155,0,100,255,155,0,127,184,81,103,238,152,17,103,255,
dc.b 253,236,107,254,148,1,107,255,253,188,115,188,140,67,115,255,
dc.b 239,222,103,222,152,33,119,255,217,252,209,252,46,3,247,255,
dc.b 255,254,255,254,0,1,255,255,255,124,255,124,0,131,255,255,
dc.b 255,62,255,62,0,193,255,255,186,188,186,60,69,195,255,255,
dc.b 17,124,16,124,239,131,255,255,1,185,0,56,255,199,255,255,
dc.b 64,195,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 4,1,255,254,32,1,32,0,0,2,255,253,32,3,32,0,
dc.b 0,37,255,251,0,135,0,128,64,11,255,247,4,15,4,0,
dc.b 2,22,255,239,32,31,32,0,0,44,255,223,2,62,2,0,
dc.b 0,92,255,191,0,126,0,0,128,188,255,127,16,254,16,0,
dc.b 1,96,254,255,1,254,0,0,18,192,253,255,67,252,64,8,
dc.b 5,208,251,255,7,224,0,0,11,0,247,255,15,224,0,0,
dc.b 23,0,239,255,31,194,0,66,47,0,223,255,63,128,0,0,
dc.b 90,4,191,255,127,144,0,16,176,0,127,255,251,64,1,64,
dc.b 255,255,0,0,255,255,127,255,127,255,128,0,255,255,63,255,
dc.b 191,255,192,0,255,255,31,255,223,255,224,0,255,255,15,255,
dc.b 111,255,240,0,255,255,7,255,55,255,248,0,127,255,3,255,
dc.b 59,255,252,0,127,255,1,255,61,255,254,0,127,255,0,255,
dc.b 6,255,255,0,127,255,0,127,3,127,255,128,63,255,16,63,
dc.b 11,191,255,192,7,255,0,31,0,223,255,224,7,255,0,15,
dc.b 0,239,255,240,67,255,66,7,0,247,255,248,1,255,0,3,
dc.b 32,91,255,252,9,255,8,1,0,13,255,254,2,223,2,128,
dc.b 255,255,0,0,255,255,255,254,255,254,0,1,255,255,255,252,
dc.b 255,253,0,3,255,255,255,248,255,251,0,7,255,255,255,240,
dc.b 255,246,0,15,255,255,255,224,255,236,0,31,255,254,255,192,
dc.b 255,220,0,63,255,254,255,128,255,188,0,127,255,254,255,0,
dc.b 255,96,0,255,255,254,254,0,254,192,1,255,255,252,252,8,
dc.b 253,208,3,255,255,224,248,0,251,0,7,255,255,224,240,0,
dc.b 247,0,15,255,255,194,224,66,239,0,31,255,255,128,192,0,
dc.b 218,4,63,255,255,144,128,16,176,0,127,255,251,64,1,64,
dc.b 128,0,127,255,128,0,0,0,72,0,191,255,196,68,4,68,
dc.b 160,128,223,255,228,0,4,0,208,16,239,255,240,32,0,32,
dc.b 104,0,247,255,249,1,1,1,52,0,251,255,124,0,0,0,
dc.b 58,32,253,255,126,0,0,0,61,1,254,255,127,8,0,8,
dc.b 6,128,255,127,127,128,0,0,3,64,255,191,63,192,16,0,
dc.b 11,160,255,223,7,226,0,2,0,210,255,239,7,240,0,0,
dc.b 0,232,255,247,67,248,66,0,0,244,255,251,1,252,0,0,
dc.b 32,90,255,253,9,254,8,0,0,13,255,254,2,223,2,128,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,5,224,248,31,255,255,
dc.b 255,255,2,64,253,191,255,255,255,255,4,96,249,159,255,255,
dc.b 255,255,5,224,248,31,255,255,253,191,0,0,255,255,255,255,
dc.b 253,191,0,0,255,255,255,255,253,191,0,0,255,255,255,255,
dc.b 247,239,4,32,251,223,255,255,223,251,16,8,237,247,253,255,
dc.b 191,253,32,4,217,251,249,255,191,253,0,0,251,255,251,255,
dc.b 191,253,0,0,255,255,255,255,255,253,0,0,251,255,251,255,
dc.b 223,251,0,0,255,255,255,255,231,231,0,0,255,255,255,255,
dc.b 0,0,255,255,0,0,0,0,0,0,255,255,128,0,128,0,
dc.b 0,2,255,255,32,0,32,0,4,0,255,255,0,0,0,0,
dc.b 0,32,255,255,192,0,192,0,0,0,255,255,20,16,20,16,
dc.b 0,2,255,255,0,0,0,0,0,0,255,255,97,0,97,0,
dc.b 0,0,255,255,0,1,0,1,0,0,255,255,0,0,0,0,
dc.b 8,0,255,255,1,9,1,9,0,0,255,255,4,1,4,1,
dc.b 128,16,255,255,0,64,0,64,0,0,255,255,69,0,69,0,
dc.b 8,8,255,255,0,194,0,194,0,0,255,255,4,0,4,0,
dc.b 5,0,254,127,16,132,17,132,3,10,252,63,64,192,67,192,
dc.b 39,0,248,31,0,224,7,224,15,0,240,15,128,242,143,242,
dc.b 31,0,224,7,0,248,31,248,63,0,192,3,0,252,63,252,
dc.b 127,0,128,1,0,254,127,254,255,0,0,0,0,255,255,255,
dc.b 0,0,0,255,255,0,255,255,0,0,128,255,127,0,127,254,
dc.b 0,0,192,255,63,0,63,252,0,0,224,255,31,0,31,248,
dc.b 0,0,240,255,15,0,15,240,128,2,248,255,39,0,39,224,
dc.b 0,0,252,255,3,4,3,196,8,0,254,255,1,0,1,128,
dc.b 25,23,231,232,24,23,102,40,27,28,231,227,24,28,231,35,
dc.b 62,31,231,227,24,28,230,99,126,61,231,225,24,30,230,227,
dc.b 109,255,197,227,58,28,215,227,255,255,223,229,32,26,223,229,
dc.b 239,255,207,229,48,26,223,229,255,255,223,229,32,26,223,229,
dc.b 119,255,87,247,168,8,223,247,59,187,27,179,228,76,223,247,
dc.b 33,221,129,213,126,42,95,247,48,8,128,0,127,255,79,247,
dc.b 48,8,196,0,59,255,11,247,40,136,215,247,40,8,0,0,
dc.b 72,9,247,247,8,8,0,0,0,8,255,247,17,8,17,0,
dc.b 255,128,0,127,255,128,0,100,184,64,103,255,152,0,103,238,
dc.b 253,236,107,254,148,1,107,255,253,188,115,188,140,67,115,255,
dc.b 239,222,103,222,152,33,119,255,217,252,209,252,46,3,247,255,
dc.b 255,254,255,254,0,1,255,255,255,124,255,124,0,131,255,255,
dc.b 255,62,255,62,0,193,255,255,186,60,186,60,69,195,255,255,
dc.b 16,124,17,124,238,131,254,255,0,56,1,185,254,70,254,126,
dc.b 0,0,64,195,191,60,191,60,0,0,255,255,128,0,128,0,
dc.b 1,16,255,255,0,68,0,68,0,0,255,255,4,0,4,0,
dc.b 254,255,1,0,255,255,255,255,248,255,7,0,255,255,255,255,
dc.b 240,127,15,0,247,255,247,255,184,191,95,128,227,127,227,255,
dc.b 24,255,255,64,195,191,195,255,24,223,255,64,195,191,195,255,
dc.b 24,255,255,32,195,223,195,255,24,239,255,32,195,223,195,255,
dc.b 24,255,255,16,195,239,195,255,24,247,255,16,195,239,195,255,
dc.b 24,255,255,8,195,247,195,255,24,251,255,8,195,247,195,255,
dc.b 24,255,255,4,195,251,195,255,24,253,255,4,195,251,195,254,
dc.b 24,255,255,2,195,253,195,230,24,254,255,2,195,253,195,243,
dc.b 255,127,0,128,255,255,255,255,255,31,0,224,255,255,255,255,
dc.b 254,15,0,240,255,239,255,239,253,29,1,250,254,199,255,199,
dc.b 255,24,2,255,253,195,255,195,251,24,2,255,253,195,255,195,
dc.b 255,24,4,255,251,195,255,195,247,24,4,255,251,195,255,195,
dc.b 255,24,8,255,247,195,255,195,239,24,8,255,247,195,255,195,
dc.b 255,24,16,255,239,195,255,195,223,24,16,255,239,195,255,195,
dc.b 255,24,32,255,223,195,255,195,191,24,32,255,223,195,127,195,
dc.b 255,24,64,255,191,195,103,195,127,24,64,255,191,195,207,195,
dc.b 0,5,255,255,147,64,147,66,0,0,255,255,129,232,129,232,
dc.b 12,3,255,255,192,176,192,176,28,7,255,254,192,224,192,224,
dc.b 8,2,255,255,224,248,224,249,128,1,127,255,241,248,241,248,
dc.b 224,3,31,255,255,240,255,240,224,34,31,223,255,248,255,249,
dc.b 240,119,15,143,255,248,255,248,255,250,0,7,255,252,255,252,
dc.b 255,252,0,3,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,247,255,251,253,4,2,255,255,243,253,
dc.b 249,253,6,2,255,255,241,253,253,253,2,2,255,255,241,252,
dc.b 252,253,3,2,255,255,240,252,254,253,1,2,255,255,240,252,
dc.b 254,121,1,134,255,255,248,120,254,123,1,132,255,255,248,120,
dc.b 255,59,0,196,255,255,252,56,255,59,0,196,255,255,252,56,
dc.b 199,147,56,108,255,255,198,17,131,215,124,40,255,255,130,17,
dc.b 57,247,198,8,255,255,1,17,124,239,131,16,255,255,16,163,
dc.b 255,255,0,0,255,255,56,67,255,255,0,0,255,255,126,71,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 231,159,8,64,239,223,247,191,255,255,0,0,255,255,247,191,
dc.b 255,207,0,32,255,239,247,95,255,255,0,0,255,255,250,95,
dc.b 255,199,0,0,255,255,255,199,255,147,0,0,255,239,255,147,
dc.b 255,170,0,16,255,199,255,186,248,146,0,0,255,239,248,146,
dc.b 242,66,0,0,253,255,242,66,245,73,2,0,248,247,247,73,
dc.b 242,85,0,8,253,227,242,93,216,201,32,0,255,247,200,201,
dc.b 183,227,72,0,255,255,135,163,239,255,16,0,255,255,100,220,
dc.b 255,255,2,0,255,255,201,51,255,59,0,196,255,255,210,16,
dc.b 246,186,9,199,254,255,244,16,253,109,3,147,255,255,244,56,
dc.b 253,198,2,57,255,255,252,124,255,195,0,60,255,255,255,254,
dc.b 255,255,0,0,255,255,255,255,31,255,0,0,255,255,31,255,
dc.b 79,255,0,0,191,255,79,255,175,255,64,0,31,255,239,255,
dc.b 79,255,0,0,191,255,79,255,31,255,0,0,255,255,27,255,
dc.b 255,255,0,0,255,255,239,255,223,255,48,0,255,255,7,255,
dc.b 239,255,24,0,255,255,195,255,255,255,4,0,255,255,99,255,
dc.b 223,255,32,0,255,255,27,255,223,255,32,0,255,255,143,255,
dc.b 239,255,16,0,255,255,103,255,255,255,0,0,255,255,111,255,
dc.b 255,255,0,0,255,255,127,255,255,255,0,0,255,255,127,255,
dc.b 255,193,0,62,255,239,255,239,255,201,0,62,255,247,255,247,
dc.b 255,201,0,62,255,247,255,247,255,201,0,62,255,227,255,227,
dc.b 255,201,0,62,255,227,255,227,255,201,0,62,255,227,255,227,
dc.b 255,201,0,62,255,247,255,247,255,201,0,62,255,227,255,227,
dc.b 255,201,0,62,255,243,255,243,255,201,0,62,255,231,255,231,
dc.b 255,201,0,62,255,227,255,227,255,201,0,62,255,243,255,243,
dc.b 255,201,0,62,255,231,255,231,255,201,0,62,255,231,255,231,
dc.b 255,201,0,62,255,243,255,243,255,201,0,62,255,247,255,247,
dc.b 96,0,255,255,240,0,0,0,224,0,255,255,240,2,0,2,
dc.b 128,0,255,255,240,8,0,8,0,64,255,255,128,1,0,1,
dc.b 8,0,255,255,0,6,0,6,0,0,255,255,16,80,16,80,
dc.b 128,0,255,255,0,0,0,0,0,0,255,255,1,12,1,12,
dc.b 0,0,255,255,0,0,0,0,0,0,255,255,0,0,0,0,
dc.b 0,32,255,255,33,0,33,0,0,0,255,255,0,64,0,64,
dc.b 16,2,255,255,4,0,4,0,0,0,255,255,1,68,1,68,
dc.b 32,32,255,255,134,0,134,0,0,0,255,255,0,64,0,64,
dc.b 254,255,0,0,255,255,255,255,255,255,1,0,254,255,255,255,
dc.b 253,255,1,128,254,127,255,255,252,255,1,128,254,127,255,255,
dc.b 252,255,3,128,252,127,255,255,248,191,3,128,252,127,255,255,
dc.b 248,191,3,128,252,127,255,255,250,223,1,192,252,63,255,255,
dc.b 246,95,5,192,248,63,255,255,243,95,4,192,248,63,255,255,
dc.b 235,223,12,64,240,63,253,255,235,239,12,96,240,31,253,255,
dc.b 215,239,24,32,224,31,252,255,215,247,24,16,224,15,248,127,
dc.b 175,243,48,0,192,15,248,63,95,249,96,0,128,7,240,31,
dc.b 128,0,255,255,12,65,12,65,0,28,255,255,2,128,2,128,
dc.b 224,54,255,255,6,1,6,9,176,60,127,255,3,129,67,129,
dc.b 112,25,255,254,7,131,135,131,224,3,255,252,3,131,3,131,
dc.b 192,3,255,252,7,199,7,199,71,3,248,252,15,255,143,255,
dc.b 143,143,240,112,31,255,31,255,31,255,224,0,63,255,63,255,
dc.b 63,255,192,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 240,63,0,0,247,191,240,63,224,31,0,0,239,223,224,31,
dc.b 228,159,4,128,235,95,224,31,235,95,0,0,224,31,227,31,
dc.b 223,111,31,224,192,143,192,143,238,223,15,192,225,31,225,31,
dc.b 247,191,7,128,240,63,240,63,195,7,3,0,196,135,192,7,
dc.b 128,3,51,24,191,251,176,27,0,1,99,4,127,253,96,5,
dc.b 0,1,67,0,127,253,64,1,0,1,3,4,127,253,0,5,
dc.b 0,1,67,0,127,253,64,1,0,1,3,132,127,253,0,5,
dc.b 0,1,3,132,127,253,0,5,0,1,67,128,127,253,64,1,
dc.b 3,129,64,4,127,253,67,133,3,129,0,0,127,253,3,129,
dc.b 99,141,96,12,31,241,3,129,102,237,96,140,30,113,6,225,
dc.b 14,227,8,128,6,99,14,227,238,239,8,128,230,111,238,239,
dc.b 238,239,4,128,234,111,238,239,238,239,8,128,230,111,238,239,
dc.b 238,239,4,192,234,47,238,239,238,239,8,128,230,111,238,239,
dc.b 238,239,8,192,230,47,238,239,238,239,8,64,230,175,238,239,
dc.b 238,239,8,64,231,175,239,239,238,239,8,64,231,175,239,239,
dc.b 222,247,0,0,195,135,195,135,128,3,0,0,190,251,190,251,
dc.b 0,0,240,31,15,224,15,224,7,194,167,203,88,52,95,244,
dc.b 136,32,207,231,48,25,63,249,19,144,220,119,32,8,63,248,
dc.b 23,208,152,51,96,12,126,252,23,208,24,49,224,14,252,126,
dc.b 23,208,152,51,96,12,126,252,19,145,220,119,32,8,63,248,
dc.b 8,32,207,231,48,24,63,248,7,192,167,203,88,52,95,244,
dc.b 0,0,240,31,15,226,15,226,64,0,236,111,19,144,19,144,
dc.b 0,0,254,255,65,0,65,0,0,4,255,255,4,0,4,0,
dc.b 66,0,255,255,128,64,128,64,0,0,255,255,16,2,16,2,
dc.b 1,128,255,255,0,0,1,128,3,0,253,63,0,192,1,192,
dc.b 6,0,250,31,1,224,3,224,4,4,249,159,3,96,3,96,
dc.b 36,64,253,223,2,160,6,224,7,128,254,159,16,116,22,244,
dc.b 3,128,255,191,0,64,3,192,1,128,255,255,0,97,1,225,
dc.b 1,128,255,255,0,0,1,128,3,0,253,63,0,192,1,192,
dc.b 6,8,250,31,9,225,11,225,4,0,249,159,2,100,2,100,
dc.b 20,192,253,223,66,32,70,96,7,128,254,159,0,101,6,229,
dc.b 11,136,255,191,192,64,195,192,1,128,255,255,0,4,1,132,
dc.b 0,0,255,199,0,56,0,0,8,16,255,131,64,108,64,16,
dc.b 0,40,255,146,16,69,16,56,0,16,248,130,7,109,0,16,
dc.b 130,64,240,2,45,253,34,64,5,73,242,0,8,247,7,73,
dc.b 2,85,240,8,13,227,2,93,24,201,224,0,63,247,8,201,
dc.b 55,227,200,0,127,255,7,163,143,255,112,0,159,255,4,220,
dc.b 63,255,194,0,63,255,9,51,47,59,208,196,47,255,2,16,
dc.b 130,186,253,199,10,255,0,16,9,109,247,147,11,255,0,56,
dc.b 9,134,254,121,67,191,64,60,0,1,255,254,0,61,0,60,
dc.b 0,0,255,255,0,0,0,0,4,0,31,255,224,0,0,0,
dc.b 64,32,15,255,176,1,64,1,160,0,79,255,18,64,226,64,
dc.b 64,0,15,255,176,8,64,8,4,0,27,255,228,0,0,0,
dc.b 240,8,15,255,241,0,225,0,216,0,55,255,248,0,0,0,
dc.b 236,0,27,255,252,18,192,18,252,128,7,255,252,0,96,0,
dc.b 196,0,59,255,228,0,0,0,208,8,47,255,240,0,128,0,
dc.b 138,0,119,255,152,48,0,48,144,0,111,255,144,2,0,2,
dc.b 128,16,127,255,129,0,1,0,128,0,127,255,128,0,0,0,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 254,255,0,0,255,255,255,255,255,255,1,0,254,255,255,255,
dc.b 253,255,1,128,254,127,255,255,252,255,1,128,254,127,255,255,
dc.b 252,255,3,128,252,127,255,255,248,191,3,128,252,127,255,255,
dc.b 248,191,3,128,252,127,255,255,250,223,1,192,252,63,255,255,
dc.b 246,95,5,192,248,63,255,255,243,95,4,192,248,63,255,255,
dc.b 235,223,12,64,240,63,253,255,235,239,12,96,240,31,253,255,
dc.b 215,239,24,32,224,31,252,255,215,247,24,16,224,15,248,127,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 254,255,0,0,255,255,255,255,255,255,1,0,254,255,255,255,
dc.b 253,255,1,128,254,127,255,255,252,255,1,128,254,127,255,255,
dc.b 252,255,3,128,252,127,255,255,248,191,3,128,252,127,255,255,
dc.b 248,191,3,128,252,127,255,255,250,223,1,192,252,63,255,255,
dc.b 246,95,5,192,248,63,255,255,243,95,4,192,248,63,255,255,
dc.b 235,223,12,64,240,63,253,255,235,239,12,96,240,31,253,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 254,255,0,0,255,255,255,255,255,255,1,0,254,255,255,255,
dc.b 253,255,1,128,254,127,255,255,252,255,1,128,254,127,255,255,
dc.b 252,255,3,128,252,127,255,255,248,191,3,128,252,127,255,255,
dc.b 248,191,3,128,252,127,255,255,250,223,1,192,252,63,255,255,
dc.b 246,95,5,192,248,63,255,255,243,95,4,192,248,63,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 254,255,0,0,255,255,255,255,255,255,1,0,254,255,255,255,
dc.b 253,255,1,128,254,127,255,255,252,255,1,128,254,127,255,255,
dc.b 252,255,3,128,252,127,255,255,248,191,3,128,252,127,255,255,
dc.b 248,191,3,128,252,127,255,255,250,223,1,192,252,63,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 254,255,0,0,255,255,255,255,255,255,1,0,254,255,255,255,
dc.b 253,255,1,128,254,127,255,255,252,255,1,128,254,127,255,255,
dc.b 252,255,3,128,252,127,255,255,248,191,3,128,252,127,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 254,255,0,0,255,255,255,255,255,255,1,0,254,255,255,255,
dc.b 253,255,1,128,254,127,255,255,252,255,1,128,254,127,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 254,255,0,0,255,255,255,255,255,255,1,0,254,255,255,255,
dc.b 0,0,255,255,255,255,255,255,0,0,255,255,128,1,128,1,
dc.b 0,0,255,255,128,1,128,1,127,196,255,255,128,1,128,1,
dc.b 0,4,255,255,255,131,255,131,0,8,255,255,147,5,147,5,
dc.b 0,16,255,255,146,9,146,9,0,32,255,255,148,25,148,25,
dc.b 0,64,255,255,152,41,152,41,0,128,255,255,144,73,144,73,
dc.b 65,0,255,255,160,201,160,201,2,0,255,255,193,255,193,255,
dc.b 4,0,255,255,128,1,128,1,8,0,255,255,128,1,128,1,
dc.b 31,254,255,255,128,1,128,1,0,0,255,255,255,255,255,255,
dc.b 249,15,7,240,254,31,254,31,251,143,7,240,252,63,252,63,
dc.b 249,15,7,240,254,31,254,31,251,143,7,240,252,63,252,63,
dc.b 249,15,7,240,254,31,254,31,251,143,7,240,252,63,252,63,
dc.b 0,0,255,255,255,255,255,255,255,255,255,255,0,0,0,0,
dc.b 255,255,255,255,0,0,0,0,0,0,255,255,0,0,0,0,
dc.b 0,0,255,255,255,255,255,255,248,15,7,240,254,31,254,31,
dc.b 251,175,7,208,252,63,252,31,255,239,3,176,252,95,248,23,
dc.b 251,255,5,192,254,63,244,7,255,255,0,0,255,255,240,7,
dc.b 249,15,7,240,254,31,254,31,251,143,7,240,252,63,252,63,
dc.b 249,15,7,240,254,31,254,31,251,143,7,240,252,63,252,63,
dc.b 249,15,7,240,254,31,254,31,251,143,7,240,252,63,252,63,
dc.b 0,0,255,255,255,255,255,255,255,255,255,255,0,0,0,0,
dc.b 255,255,255,255,0,0,0,0,0,0,255,255,0,0,0,0,
dc.b 0,0,255,255,255,255,255,255,248,15,7,240,254,31,254,31,
dc.b 251,143,7,240,252,63,252,63,249,143,7,240,254,31,254,31,
dc.b 251,207,7,240,252,63,252,63,249,15,7,240,254,255,254,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,252,7,
dc.b 248,7,7,248,255,255,240,1,255,0,0,224,255,224,254,31,
dc.b 248,12,7,128,255,128,240,115,240,24,15,0,255,0,192,231,
dc.b 193,16,62,0,255,0,128,239,161,0,94,128,255,128,0,127,
dc.b 220,128,35,32,255,160,0,95,252,96,3,138,255,234,136,21,
dc.b 248,0,7,255,255,255,240,0,240,8,15,247,255,255,224,0,
dc.b 224,16,31,239,255,255,192,0,244,112,11,143,255,255,192,0,
dc.b 250,240,5,15,255,255,224,48,255,244,0,11,255,255,240,112,
dc.b 255,255,0,0,255,255,224,63,224,63,31,192,255,255,192,15,
dc.b 192,127,63,128,255,255,128,7,1,255,6,0,7,255,248,127,
dc.b 1,255,0,0,1,255,254,15,0,95,0,32,0,127,255,129,
dc.b 0,65,0,62,0,127,255,128,0,129,1,126,1,255,254,0,
dc.b 1,3,10,252,11,255,244,0,0,31,175,224,175,255,80,1,
dc.b 8,15,247,240,255,255,0,7,12,7,243,248,255,255,0,3,
dc.b 4,3,251,252,255,255,0,1,7,43,248,212,255,255,0,1,
dc.b 3,207,252,48,255,255,3,3,7,255,248,0,255,255,3,207,
dc.b 163,255,92,0,255,255,3,255,213,255,42,0,255,255,129,255,
dc.b 255,255,0,0,255,255,192,255,255,255,0,0,255,255,248,127,
dc.b 255,255,0,0,255,255,252,127,255,255,0,0,255,255,254,127,
dc.b 255,255,0,0,255,255,254,127,255,255,0,0,255,255,252,127,
dc.b 255,255,0,0,255,255,254,127,255,255,0,0,255,255,254,127,
dc.b 255,255,0,0,255,255,254,127,255,255,0,0,255,255,254,127,
dc.b 255,255,0,0,255,255,254,127,255,255,0,0,255,255,254,63,
dc.b 255,255,0,0,255,255,254,127,255,255,0,0,255,255,254,127,
dc.b 255,255,0,0,255,255,254,127,255,255,0,0,255,255,252,127,
dc.b 255,255,0,0,255,255,254,63,255,255,0,0,255,255,252,63,
dc.b 255,255,0,0,255,255,252,63,255,255,0,0,255,255,248,127,
dc.b 255,255,0,0,255,255,252,127,255,255,0,0,255,255,254,113,
dc.b 255,249,0,6,255,255,254,96,255,243,0,12,255,255,254,96,
dc.b 255,247,0,8,255,255,254,33,255,239,0,16,255,255,255,35,
dc.b 255,255,0,0,255,255,255,15,255,255,0,0,255,255,255,159,
dc.b 255,255,0,0,255,255,255,159,255,255,0,0,255,255,255,159,
dc.b 255,255,0,0,255,255,255,143,255,255,0,0,255,255,7,159,
dc.b 207,255,48,0,255,255,131,31,231,255,24,0,255,255,129,63,
dc.b 255,255,0,0,255,255,192,63,255,255,0,0,255,255,248,127,
dc.b 255,255,0,0,255,255,252,127,255,255,0,0,255,255,254,113,
dc.b 255,249,0,6,255,255,254,96,255,243,0,12,255,255,252,96,
dc.b 255,247,0,8,255,255,254,33,255,239,0,16,255,255,255,35,
dc.b 255,255,0,0,255,255,255,15,255,255,0,0,255,255,255,159,
dc.b 255,255,0,0,255,255,255,159,255,255,0,0,255,255,255,159,
dc.b 255,255,0,0,255,255,255,159,255,255,0,0,255,255,7,143,
dc.b 207,255,48,0,255,255,131,31,231,255,24,0,255,255,129,63,
dc.b 243,255,12,0,255,255,192,63,255,255,0,0,255,255,248,127,
dc.b 255,255,0,0,255,255,252,127,255,255,0,0,255,255,254,51,
dc.b 255,255,0,0,255,255,250,1,255,255,0,0,255,255,228,7,
dc.b 255,255,0,0,255,255,248,63,255,255,0,0,255,255,252,255,
dc.b 255,255,0,0,255,255,252,255,255,255,0,0,255,255,252,255,
dc.b 255,255,0,0,255,255,248,127,255,255,0,0,255,255,240,63,
dc.b 0,0,255,255,0,0,0,0,0,0,255,255,128,0,128,0,
dc.b 0,2,255,255,32,48,32,48,0,0,255,255,12,104,12,104,
dc.b 0,0,255,255,223,248,223,248,0,0,255,255,23,240,23,240,
dc.b 0,2,255,255,31,112,31,112,0,0,255,255,127,224,127,224,
dc.b 0,0,255,255,29,225,29,225,0,0,255,255,63,224,63,224,
dc.b 0,0,255,255,47,105,47,105,0,0,255,255,31,225,31,225,
dc.b 128,16,255,255,3,192,3,192,0,0,255,255,69,0,69,0,
dc.b 8,8,255,255,0,194,0,194,0,0,255,255,4,0,4,0,
dc.b 0,0,255,255,0,0,0,0,0,0,255,255,128,0,128,0,
dc.b 0,2,255,255,32,0,32,0,4,0,255,255,0,0,0,0,
dc.b 0,32,255,255,198,0,198,0,0,0,255,255,31,208,31,208,
dc.b 1,2,255,255,14,224,14,224,0,0,255,255,103,224,103,224,
dc.b 0,0,255,255,3,193,3,193,0,128,255,255,3,96,3,96,
dc.b 8,0,255,255,7,233,7,233,1,0,255,255,6,193,6,193,
dc.b 128,16,255,255,3,64,3,64,0,0,255,255,69,0,69,0,
dc.b 8,8,255,255,0,194,0,194,0,0,255,255,4,0,4,0,
dc.b 0,0,255,255,0,0,0,0,0,0,255,255,128,0,128,0,
dc.b 0,2,255,255,32,128,32,128,4,0,255,255,0,0,0,0,
dc.b 0,0,255,255,192,0,192,0,0,0,255,255,20,0,20,0,
dc.b 0,2,255,255,0,0,0,0,0,0,255,255,97,0,97,0,
dc.b 0,0,255,255,0,1,0,1,0,0,255,255,30,0,30,0,
dc.b 0,0,255,255,55,9,55,9,0,0,255,255,61,129,61,129,
dc.b 128,16,255,255,31,192,31,192,0,0,255,255,79,0,79,0,
dc.b 8,8,255,255,0,194,0,194,0,0,255,255,4,0,4,0,
dc.b 0,0,255,255,0,240,0,240,0,0,255,255,129,120,129,120,
dc.b 0,2,255,255,33,232,33,232,4,0,255,255,1,240,1,240,
dc.b 0,0,255,255,192,192,192,192,0,0,255,255,20,0,20,0,
dc.b 0,2,255,255,0,0,0,0,0,0,255,255,97,0,97,0,
dc.b 0,0,255,255,0,1,0,1,0,0,255,255,0,0,0,0,
dc.b 0,0,255,255,0,9,0,9,4,0,255,255,0,1,0,1,
dc.b 129,16,255,255,0,0,0,0,0,0,255,255,64,0,64,0,
dc.b 8,8,255,255,0,194,0,194,0,0,255,255,4,0,4,0,
dc.b 0,0,255,255,0,0,0,0,0,0,255,255,128,0,128,0,
dc.b 0,2,255,255,32,0,32,0,4,0,255,255,0,0,0,0,
dc.b 0,32,255,255,192,0,192,0,0,0,255,255,20,16,20,16,
dc.b 0,2,255,255,0,0,0,0,0,0,255,255,97,0,97,0,
dc.b 0,0,255,255,0,1,0,1,0,0,255,255,0,0,0,0,
dc.b 8,0,255,255,1,9,1,9,0,0,255,255,4,1,4,1,
dc.b 128,16,255,255,0,64,0,64,0,0,255,255,69,0,69,0,
dc.b 8,8,255,255,0,194,0,194,0,0,255,255,4,0,4,0,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 248,127,0,0,255,191,248,63,248,255,0,0,231,31,224,31,
dc.b 240,103,0,0,207,159,192,7,225,11,0,0,158,247,128,3,
dc.b 3,157,0,0,252,99,0,1,23,217,0,0,232,39,0,1,
dc.b 51,129,0,0,204,127,0,1,128,3,0,0,255,255,128,3,
dc.b 240,31,0,0,255,255,240,31,249,63,2,128,252,127,255,255,
dc.b 249,63,2,128,252,127,255,255,227,143,4,64,248,63,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,191,248,63,255,255,0,0,231,31,224,31,
dc.b 255,255,0,0,207,159,192,7,255,255,0,0,158,247,128,3,
dc.b 255,255,0,0,252,99,0,1,255,255,0,0,232,39,0,1,
dc.b 255,255,0,0,204,127,0,1,255,255,0,0,255,255,128,3,
dc.b 255,255,0,0,255,255,240,31,249,63,2,128,252,127,255,255,
dc.b 249,63,2,128,252,127,255,255,227,143,4,64,248,63,255,255,
dc.b 255,127,0,0,254,255,255,255,255,63,0,0,252,255,255,255,
dc.b 255,31,0,0,248,255,255,255,255,15,0,0,240,255,255,255,
dc.b 255,7,0,0,224,255,255,255,255,3,0,0,192,255,255,255,
dc.b 255,1,0,0,128,255,255,255,255,0,0,0,0,255,255,255,
dc.b 0,0,0,255,255,0,255,255,128,1,0,254,255,1,255,255,
dc.b 192,3,0,252,255,3,255,255,224,7,0,248,255,7,255,255,
dc.b 240,15,0,240,255,15,255,255,248,31,0,224,255,31,255,255,
dc.b 252,63,0,192,255,63,255,255,254,127,0,128,255,127,255,255,
dc.b 255,255,1,0,255,255,254,127,255,255,3,0,255,255,252,63,
dc.b 255,255,7,0,255,255,248,31,255,255,15,0,255,255,240,15,
dc.b 255,255,31,0,255,255,224,7,255,255,63,0,255,255,192,3,
dc.b 255,255,127,0,255,255,128,1,255,255,255,0,255,255,0,0,
dc.b 255,0,0,255,255,255,0,0,255,1,0,254,255,255,128,1,
dc.b 255,3,0,252,255,255,192,3,255,7,0,248,255,255,224,7,
dc.b 255,15,0,240,255,255,240,15,255,31,0,224,255,255,248,31,
dc.b 255,63,0,192,255,255,252,63,255,127,0,128,255,255,254,127,
dc.b 255,255,3,0,252,255,255,255,254,127,2,0,249,255,251,255,
dc.b 252,63,4,0,243,255,247,255,251,63,0,0,247,255,247,255,
dc.b 251,191,8,128,247,127,255,255,255,63,13,0,240,255,253,255,
dc.b 255,127,7,0,248,255,255,255,255,255,3,0,252,255,255,255,
dc.b 255,255,3,0,252,255,255,255,254,127,2,0,249,255,251,255,
dc.b 252,63,4,0,243,255,247,255,251,63,0,0,247,255,247,255,
dc.b 251,191,8,128,247,127,255,255,255,63,13,0,240,255,253,255,
dc.b 255,127,7,0,248,255,255,255,255,255,3,0,252,255,255,255,
dc.b 240,31,0,0,255,255,255,255,167,203,7,192,248,63,255,255,
dc.b 200,39,15,224,240,31,255,255,211,151,28,112,224,15,255,255,
dc.b 151,211,24,48,224,15,254,255,23,209,24,48,224,15,252,127,
dc.b 151,211,24,48,224,15,254,255,211,151,28,112,224,15,255,255,
dc.b 200,39,15,224,240,31,255,255,167,203,7,192,248,63,255,255,
dc.b 240,31,0,0,255,255,255,255,236,111,0,0,255,255,255,255,
dc.b 254,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,244,0,11,255,255,249,96,255,177,0,79,255,255,240,48,
dc.b 244,202,11,63,255,255,192,0,241,99,14,191,255,255,160,0,
dc.b 196,40,59,223,255,255,128,0,235,9,31,247,255,255,0,0,
dc.b 214,162,63,127,255,255,0,0,165,41,95,223,255,255,128,0,
dc.b 196,67,59,191,255,255,0,0,174,181,89,95,255,255,0,0,
dc.b 212,100,47,187,255,255,0,0,226,213,29,47,255,255,128,0,
dc.b 233,106,22,149,255,255,0,0,244,245,11,10,255,255,0,0,
dc.b 255,254,0,1,255,255,192,0,255,255,0,0,255,255,227,36,
dc.b 175,255,80,0,255,255,140,127,65,255,254,0,255,255,0,223,
dc.b 150,127,253,128,255,255,0,15,200,191,255,64,255,255,0,15,
dc.b 164,63,255,192,255,255,0,3,116,207,251,176,255,255,0,3,
dc.b 39,23,252,232,255,255,0,7,74,71,253,184,255,255,0,3,
dc.b 164,47,251,240,255,255,0,7,73,103,255,248,255,255,0,7,
dc.b 130,87,253,248,255,255,0,3,44,171,215,244,255,255,0,3,
dc.b 154,71,229,248,255,255,0,3,109,47,146,208,255,255,0,7,
dc.b 222,159,33,96,255,255,0,3,255,255,0,0,255,255,17,151,
dc.b 254,1,0,0,255,255,255,255,240,240,0,240,255,15,255,255,
dc.b 199,252,7,252,248,3,255,255,141,94,15,254,240,1,255,255,
dc.b 154,7,31,255,224,0,255,255,52,15,63,255,192,0,255,255,
dc.b 32,5,63,255,192,0,255,255,112,0,127,254,128,0,255,255,
dc.b 96,1,127,254,128,1,255,254,112,1,127,250,128,1,255,254,
dc.b 120,2,127,253,128,2,255,252,48,31,63,254,192,1,255,254,
dc.b 180,14,63,254,192,1,255,255,156,46,31,222,224,33,255,223,
dc.b 206,127,5,191,250,64,245,159,231,255,2,115,253,140,250,115,
dc.b 254,31,0,0,255,255,255,255,127,199,7,192,248,63,255,255,
dc.b 63,227,15,224,240,31,255,255,14,113,15,240,240,15,255,255,
dc.b 28,49,31,240,224,15,255,255,24,240,31,240,192,15,255,255,
dc.b 187,248,159,248,96,7,223,255,177,184,149,248,96,7,223,255,
dc.b 235,56,133,248,122,7,145,255,162,56,133,248,58,7,217,255,
dc.b 160,48,1,176,250,15,95,255,181,240,2,112,253,143,72,127,
dc.b 255,224,0,224,255,31,0,255,248,41,4,0,251,255,3,215,
dc.b 253,87,134,40,121,255,132,175,254,95,141,160,114,127,140,47,
dc.b 4,16,0,0,255,255,255,255,127,255,123,239,132,16,255,255,
dc.b 68,16,123,239,132,16,255,255,95,255,96,0,132,16,255,255,
dc.b 95,255,96,0,132,16,244,16,255,255,0,0,255,255,255,255,
dc.b 95,255,96,0,135,255,247,255,94,1,96,1,134,0,246,1,
dc.b 94,0,96,0,134,32,246,32,94,0,96,0,134,0,246,0,
dc.b 94,0,96,0,134,0,246,0,94,0,96,0,134,0,246,0,
dc.b 94,0,96,0,134,0,246,0,95,8,97,0,134,0,247,8,
dc.b 254,0,0,0,254,0,254,0,94,0,96,0,134,0,246,0,
dc.b 0,32,0,0,255,255,255,255,255,255,255,223,0,32,255,255,
dc.b 0,32,255,223,0,32,255,255,255,255,0,0,0,32,255,255,
dc.b 255,255,0,0,0,32,0,32,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,0,1,0,0,0,1,0,1,
dc.b 0,1,0,0,0,1,0,1,0,1,0,0,8,33,8,33,
dc.b 0,1,0,0,0,1,0,1,0,1,0,0,0,1,0,1,
dc.b 4,17,0,0,0,1,4,17,0,1,0,0,0,1,0,1,
dc.b 0,1,0,0,64,1,64,1,0,1,0,0,0,1,0,1,
dc.b 131,255,0,0,255,255,255,255,251,255,120,0,135,255,255,255,
dc.b 139,255,120,0,135,255,255,255,235,255,24,0,135,255,255,255,
dc.b 235,255,24,0,135,255,191,255,255,255,0,0,255,255,255,255,
dc.b 235,255,24,0,135,255,191,255,235,255,24,0,135,255,191,255,
dc.b 235,255,24,0,135,255,191,255,235,255,24,0,135,255,191,255,
dc.b 235,255,24,0,135,255,191,255,235,255,24,0,135,255,191,255,
dc.b 235,255,24,0,135,255,191,255,235,255,24,0,135,255,191,255,
dc.b 255,255,0,0,255,255,255,255,235,255,24,0,135,255,191,255,
dc.b 94,0,96,0,134,64,246,64,94,0,96,0,134,0,246,0,
dc.b 94,0,96,0,134,0,246,0,94,0,96,0,134,0,246,0,
dc.b 94,0,96,0,134,0,246,0,94,8,96,8,134,0,246,8,
dc.b 94,128,96,0,134,0,246,128,94,0,96,0,134,0,246,0,
dc.b 94,0,96,0,134,0,246,0,94,0,96,0,134,0,246,0,
dc.b 254,0,0,0,254,0,254,0,94,2,96,0,134,0,246,2,
dc.b 94,0,96,0,135,0,247,0,94,0,96,0,134,0,246,0,
dc.b 94,0,96,16,134,0,246,16,94,16,96,40,134,0,246,40,
dc.b 2,1,2,0,0,1,2,1,0,1,0,0,0,3,0,3,
dc.b 0,1,0,0,0,1,0,1,0,1,0,0,0,1,0,1,
dc.b 0,1,32,8,0,1,32,9,32,1,80,0,0,1,80,1,
dc.b 0,1,32,0,1,1,33,1,0,1,0,0,0,1,0,1,
dc.b 0,1,0,0,0,1,0,1,0,1,0,0,0,1,0,1,
dc.b 0,1,0,0,0,9,0,9,0,1,0,0,64,1,64,1,
dc.b 0,1,0,0,0,1,0,1,0,1,0,0,0,1,0,1,
dc.b 0,1,0,0,0,1,0,1,0,1,0,0,0,33,0,33,
dc.b 235,255,24,0,135,255,191,255,235,255,24,0,135,255,191,255,
dc.b 235,255,24,0,135,255,191,255,235,255,24,0,135,255,191,255,
dc.b 235,255,24,0,135,255,191,255,235,255,24,0,135,255,191,255,
dc.b 235,255,24,0,135,255,191,255,235,255,24,0,135,255,191,255,
dc.b 235,255,24,0,135,255,191,255,235,255,24,0,135,255,191,255,
dc.b 255,255,0,0,255,255,255,255,235,255,24,0,135,255,191,255,
dc.b 235,255,24,0,135,255,191,255,235,255,24,0,135,255,191,255,
dc.b 235,255,24,0,135,255,191,255,235,255,24,0,135,255,191,255,
dc.b 91,64,247,255,0,16,4,144,23,128,255,255,0,18,8,18,
dc.b 30,0,255,255,0,32,0,32,12,0,255,255,0,72,0,72,
dc.b 0,0,255,255,0,128,0,128,0,4,255,255,21,0,21,0,
dc.b 0,32,255,255,63,0,63,0,0,0,255,255,15,0,15,0,
dc.b 0,0,255,255,47,132,47,132,0,0,255,255,65,192,65,192,
dc.b 24,16,255,255,0,194,0,194,60,0,255,255,0,192,0,192,
dc.b 44,0,255,255,0,128,16,128,56,0,255,255,1,164,1,164,
dc.b 16,0,255,255,4,0,4,0,0,64,255,255,24,0,24,0,
dc.b 65,109,255,247,4,0,4,144,0,244,255,255,4,0,4,8,
dc.b 0,60,255,255,18,0,18,0,0,24,255,255,65,0,65,0,
dc.b 16,0,255,255,0,128,0,128,0,0,255,255,0,84,0,84,
dc.b 0,0,255,255,10,126,10,126,0,0,255,255,32,120,32,120,
dc.b 0,0,255,255,0,250,0,250,8,0,255,255,33,193,33,193,
dc.b 0,12,255,255,1,128,1,128,0,30,255,255,1,128,1,128,
dc.b 64,26,255,255,8,128,8,132,0,14,255,255,0,192,0,192,
dc.b 16,4,255,255,128,16,128,16,0,0,255,255,1,12,1,12,
dc.b 0,0,255,255,0,30,0,30,0,0,255,255,2,60,2,60,
dc.b 32,0,255,255,16,48,16,48,2,8,255,255,0,225,0,225,
dc.b 0,28,255,255,1,192,1,192,0,12,255,255,73,192,73,192,
dc.b 0,0,255,255,1,192,1,192,32,0,255,255,1,227,1,227,
dc.b 0,0,255,255,73,254,73,254,0,0,255,255,0,251,0,251,
dc.b 128,0,255,255,16,126,16,126,2,0,255,255,0,244,0,244,
dc.b 0,0,255,255,1,178,1,178,33,9,255,255,66,0,66,0,
dc.b 3,220,255,255,4,0,4,1,1,109,255,247,4,0,4,144,
dc.b 255,224,0,31,255,254,255,254,255,192,0,63,255,252,255,252,
dc.b 255,192,0,63,255,240,255,240,255,8,0,255,255,225,255,225,
dc.b 254,28,1,255,255,192,255,192,254,12,1,255,255,192,255,192,
dc.b 254,0,1,255,255,192,255,192,254,0,1,255,255,227,255,227,
dc.b 254,0,1,255,255,254,255,254,255,0,0,255,255,251,255,251,
dc.b 255,128,0,127,255,254,255,254,255,0,0,255,255,244,255,244,
dc.b 254,0,1,255,255,178,255,178,253,9,3,255,254,0,254,0,
dc.b 251,220,7,255,252,0,252,1,249,109,7,247,252,0,252,144,
dc.b 249,109,7,247,252,0,252,144,248,244,7,255,252,0,252,8,
dc.b 252,60,3,255,254,0,254,0,254,24,1,255,255,0,255,0,
dc.b 255,0,0,255,255,128,255,128,255,128,0,127,255,212,255,212,
dc.b 255,128,0,127,255,254,255,254,255,128,0,127,255,248,255,248,
dc.b 255,0,0,255,255,250,255,250,254,0,1,255,255,193,255,193,
dc.b 254,12,1,255,255,128,255,128,254,30,1,255,255,128,255,128,
dc.b 255,26,0,255,255,128,255,132,255,14,0,255,255,192,255,192,
dc.b 255,228,0,31,255,240,255,240,255,240,0,15,255,252,255,252,
dc.b 0,0,255,255,0,0,0,0,0,0,255,255,98,8,98,8,
dc.b 8,66,255,255,0,0,0,0,0,0,255,255,32,0,32,0,
dc.b 0,64,248,63,7,132,0,4,152,224,224,31,7,0,0,0,
dc.b 48,96,192,7,15,152,0,0,97,8,128,3,30,244,0,0,
dc.b 3,156,0,1,252,98,0,0,23,216,0,1,232,38,0,0,
dc.b 51,128,0,1,204,126,0,0,0,0,128,3,127,252,0,0,
dc.b 0,0,240,31,15,224,0,0,65,0,250,191,4,68,7,196,
dc.b 1,2,250,191,68,64,71,192,3,128,228,79,24,48,31,240,
dc.b 182,159,239,224,0,63,9,63,47,31,255,224,0,63,16,63,
dc.b 60,63,255,192,0,127,0,127,24,127,255,128,0,255,0,255,
dc.b 0,255,255,0,1,255,1,255,1,255,254,0,43,255,43,255,
dc.b 1,255,254,0,127,255,127,255,1,255,254,0,31,255,31,255,
dc.b 0,255,255,0,95,255,95,255,0,127,255,128,131,255,131,255,
dc.b 48,127,255,128,1,255,1,255,120,127,255,128,1,255,1,255,
dc.b 88,255,255,0,1,255,33,255,112,255,255,0,3,255,3,255,
dc.b 39,255,248,0,15,255,15,255,15,255,240,0,63,255,63,255,
dc.b 7,255,248,0,127,255,127,255,3,255,252,0,63,255,63,255,
dc.b 3,255,252,0,15,255,15,255,16,255,255,0,135,255,135,255,
dc.b 56,127,255,128,3,255,3,255,48,127,255,128,3,255,3,255,
dc.b 0,127,255,128,3,255,3,255,0,127,255,128,199,255,199,255,
dc.b 0,127,255,128,127,255,127,255,0,255,255,0,223,255,223,255,
dc.b 1,255,254,0,127,255,127,255,0,255,255,0,47,255,47,255,
dc.b 0,127,255,128,77,255,77,255,144,191,255,192,0,127,0,127,
dc.b 59,223,255,224,0,63,128,63,182,159,239,224,0,63,9,63,
dc.b 0,6,255,255,0,15,0,0,0,7,255,255,64,15,64,0,
dc.b 0,1,255,255,16,15,16,0,2,0,255,255,128,1,128,0,
dc.b 0,16,255,255,96,0,96,0,0,0,255,255,10,8,10,8,
dc.b 0,1,255,255,0,0,0,0,0,0,255,255,48,128,48,128,
dc.b 0,0,255,255,0,0,0,0,0,0,255,255,0,0,0,0,
dc.b 4,0,255,255,0,132,0,132,0,0,255,255,2,0,2,0,
dc.b 64,8,255,255,0,32,0,32,0,0,255,255,34,128,34,128,
dc.b 4,4,255,255,0,97,0,97,0,0,255,255,2,0,2,0,
dc.b 255,255,0,0,255,255,255,255,254,3,0,0,254,3,254,3,
dc.b 252,243,1,248,253,11,253,11,248,241,3,252,250,5,250,5,
dc.b 251,225,7,254,252,3,252,3,243,0,7,254,240,112,240,112,
dc.b 247,66,7,254,240,152,240,152,227,116,15,254,232,136,232,136,
dc.b 192,166,31,254,208,8,208,8,132,4,31,254,147,64,211,64,
dc.b 128,12,15,254,139,226,171,226,192,169,1,252,192,85,208,85,
dc.b 234,3,6,0,224,3,230,3,214,3,27,248,192,3,219,251,
dc.b 192,1,15,252,208,1,223,253,224,11,0,10,255,245,255,255,
dc.b 252,255,3,0,255,255,248,127,252,255,3,0,255,255,248,127,
dc.b 253,127,2,128,255,255,248,127,253,255,2,128,255,255,240,127,
dc.b 252,255,3,0,255,255,240,127,253,255,2,0,255,255,248,255,
dc.b 252,255,3,0,255,255,248,127,252,255,3,0,255,255,248,95,
dc.b 254,127,1,128,255,255,252,63,254,127,1,128,255,255,248,63,
dc.b 254,63,1,192,255,255,252,31,255,63,0,192,255,255,254,31,
dc.b 255,63,0,192,255,255,254,31,255,63,0,192,255,255,254,31,
dc.b 254,127,1,128,255,255,252,63,254,127,1,128,255,255,248,63,
dc.b 254,63,1,192,255,255,252,63,255,63,0,192,255,255,254,31,
dc.b 254,191,1,64,255,255,254,31,255,191,1,64,255,255,254,15,
dc.b 255,63,0,192,255,255,254,15,255,191,0,64,255,255,255,31,
dc.b 255,63,0,192,255,255,254,31,255,63,0,192,255,255,250,31,
dc.b 254,127,1,128,255,255,252,63,254,127,1,128,255,255,252,31,
dc.b 252,127,3,128,255,255,248,63,252,255,3,0,255,255,248,127,
dc.b 252,255,3,0,255,255,248,127,254,255,1,0,255,255,252,255,
dc.b 255,255,0,0,255,255,252,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,252,31,253,95,2,160,254,191,192,1,
dc.b 214,41,40,22,233,215,0,0,220,31,32,0,162,32,1,192,
dc.b 254,61,0,2,193,195,128,0,95,255,160,0,160,1,0,0,
dc.b 149,233,106,22,234,23,0,0,255,223,0,32,254,63,132,17,
dc.b 255,255,0,0,255,255,254,63,255,127,0,128,255,255,254,31,
dc.b 255,127,0,128,255,255,254,31,255,127,0,128,255,255,198,63,
dc.b 255,127,24,128,255,255,198,63,255,127,24,128,255,255,192,31,
dc.b 254,127,1,128,255,255,224,63,250,127,5,128,255,255,248,63,
dc.b 254,127,1,128,255,255,252,63,254,127,1,128,255,255,252,15,
dc.b 254,159,1,112,255,255,252,7,254,255,1,112,255,255,248,7,
dc.b 254,127,1,128,255,255,248,15,254,255,1,0,255,255,252,127,
dc.b 254,127,1,128,255,255,252,63,254,127,1,128,255,255,252,47,
dc.b 255,63,0,192,255,255,254,31,255,63,0,192,255,255,252,31,
dc.b 255,31,0,224,255,255,254,15,255,159,0,96,255,255,255,15,
dc.b 255,159,0,96,255,255,255,1,255,1,0,254,255,255,252,0,
dc.b 252,1,3,254,255,255,248,0,251,13,4,242,255,255,240,0,
dc.b 255,252,0,3,255,255,255,255,255,248,0,7,255,254,255,254,
dc.b 218,0,37,255,255,255,229,255,190,0,101,255,218,0,192,0,
dc.b 120,0,231,255,152,0,128,0,84,0,239,255,144,0,128,0,
dc.b 39,119,248,136,128,0,128,0,212,37,123,218,128,0,128,0,
dc.b 7,37,248,218,128,0,128,0,65,37,254,218,0,0,0,0,
dc.b 7,39,248,216,128,0,128,0,128,0,127,255,128,0,128,0,
dc.b 192,0,127,255,128,0,128,0,29,219,226,36,128,0,128,0,
dc.b 209,81,110,174,128,0,128,0,221,89,34,166,192,0,192,0,
dc.b 3,255,252,0,255,255,255,255,97,255,254,0,7,255,7,255,
dc.b 0,201,255,54,255,255,255,54,0,201,255,54,0,201,0,0,
dc.b 0,65,255,190,0,65,0,0,0,0,255,255,0,0,0,0,
dc.b 119,110,136,145,0,0,0,0,68,74,187,181,0,0,0,0,
dc.b 119,110,136,145,0,0,0,0,17,76,238,179,0,0,0,0,
dc.b 119,106,136,149,0,0,0,0,0,0,255,255,0,0,0,0,
dc.b 0,0,255,255,0,0,0,0,165,221,90,34,0,0,0,0,
dc.b 37,85,218,170,0,0,0,0,45,93,210,162,0,0,0,0,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 191,255,64,0,255,255,127,255,159,255,96,0,191,255,63,255,
dc.b 207,255,240,0,31,255,31,255,79,255,240,0,31,255,31,255,
dc.b 15,255,240,0,31,255,31,255,63,255,192,0,63,255,63,255,
dc.b 15,255,240,0,31,255,31,255,15,255,240,0,31,255,31,255,
dc.b 15,255,240,0,31,255,31,255,15,255,240,0,31,255,31,255,
dc.b 31,255,224,0,31,255,31,255,143,255,112,0,31,255,31,255,
dc.b 15,255,240,0,63,255,63,255,159,255,96,0,31,255,31,255,
dc.b 5,81,250,174,128,0,128,0,29,209,226,46,192,0,192,0,
dc.b 192,0,63,255,192,0,192,0,32,0,255,255,128,0,128,0,
dc.b 176,0,127,255,192,0,192,0,192,0,63,255,255,255,255,255,
dc.b 255,248,0,7,255,255,235,255,255,248,0,7,255,254,235,254,
dc.b 255,248,0,7,255,254,251,254,255,248,0,7,255,254,255,254,
dc.b 255,248,0,7,255,254,255,254,255,232,0,23,255,254,255,230,
dc.b 255,240,0,15,255,254,255,246,255,245,0,10,255,255,255,130,
dc.b 255,249,0,6,255,255,255,130,255,255,0,0,255,255,255,192,
dc.b 61,217,194,38,0,0,0,0,37,85,218,170,0,0,0,0,
dc.b 0,0,255,255,0,0,0,0,0,3,255,255,0,0,0,0,
dc.b 0,10,255,255,0,0,0,0,0,0,255,255,255,255,255,255,
dc.b 1,255,254,0,255,255,255,230,97,255,254,0,7,255,7,230,
dc.b 97,255,254,0,15,255,15,239,97,255,254,0,15,255,15,255,
dc.b 97,255,254,0,7,255,7,255,97,223,222,32,63,255,14,199,
dc.b 211,63,44,192,247,255,5,15,220,255,35,0,255,255,0,15,
dc.b 179,255,108,0,223,255,8,63,255,255,0,0,255,255,1,255,
dc.b 63,255,192,0,63,255,63,255,143,255,112,0,31,255,31,255,
dc.b 191,255,192,0,63,255,63,255,79,255,240,0,31,255,31,255,
dc.b 159,255,224,0,127,255,127,255,63,255,192,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,0,0,255,255,255,255,
dc.b 94,0,96,16,134,0,246,16,94,64,96,64,134,0,246,64,
dc.b 94,0,96,0,134,0,246,0,94,0,96,0,134,0,246,0,
dc.b 94,0,96,0,134,0,246,0,94,0,96,0,134,8,246,8,
dc.b 94,0,96,0,134,0,246,0,254,0,0,0,254,0,254,0,
dc.b 94,0,96,0,134,0,246,0,94,0,96,0,134,0,246,0,
dc.b 94,128,96,128,134,0,246,128,94,0,96,0,134,0,246,0,
dc.b 94,0,96,0,134,4,246,4,94,0,96,0,134,0,246,0,
dc.b 94,0,96,0,134,0,246,0,94,0,96,0,134,0,246,0,
dc.b 0,1,0,0,0,1,0,1,2,1,2,0,0,1,2,1,
dc.b 0,1,0,2,0,1,0,3,0,1,0,0,0,1,0,1,
dc.b 0,1,0,0,0,1,0,1,1,1,0,0,0,1,1,1,
dc.b 0,1,0,0,0,1,0,1,0,1,0,0,0,3,0,3,
dc.b 0,1,0,0,0,1,0,1,128,1,0,0,0,1,128,1,
dc.b 0,1,0,0,8,1,8,1,1,1,1,0,0,1,1,1,
dc.b 0,1,0,0,0,1,0,1,0,1,0,4,0,1,0,5,
dc.b 0,1,0,0,0,1,0,1,0,1,0,0,0,1,0,1,
dc.b 235,255,24,0,135,255,191,255,235,255,24,0,135,255,191,255,
dc.b 235,255,24,0,135,255,191,255,235,255,24,0,135,255,191,255,
dc.b 235,255,24,0,135,255,191,255,235,255,24,0,135,255,191,255,
dc.b 235,255,24,0,135,255,191,255,255,255,0,0,255,255,255,255,
dc.b 235,255,24,0,135,255,191,255,235,255,24,0,135,255,191,255,
dc.b 235,255,24,0,135,255,191,255,235,255,24,0,135,255,191,255,
dc.b 235,255,24,0,135,255,191,255,235,255,24,0,135,255,191,255,
dc.b 235,255,24,0,135,255,191,255,235,255,24,0,135,255,191,255,
dc.b 0,0,255,255,60,0,60,0,0,16,255,255,30,0,30,0,
dc.b 0,0,255,255,6,4,6,4,8,0,255,255,67,160,67,160,
dc.b 28,0,255,255,1,196,1,196,24,2,255,255,1,192,1,192,
dc.b 0,8,255,255,1,192,1,192,0,0,255,255,99,194,99,194,
dc.b 0,0,255,255,63,208,63,208,0,2,255,255,111,128,111,128,
dc.b 0,0,255,255,63,0,63,0,0,0,255,255,23,136,23,136,
dc.b 0,0,255,255,38,192,38,192,72,68,255,255,0,33,0,33,
dc.b 29,224,255,255,0,16,64,16,91,64,247,255,0,16,4,144,
dc.b 16,2,255,255,0,64,0,64,3,248,252,7,67,248,64,0,
dc.b 8,6,247,249,15,254,0,0,1,0,254,224,33,224,32,31,
dc.b 8,12,247,128,15,128,0,115,48,24,207,0,63,0,0,231,
dc.b 65,16,190,0,127,0,0,239,161,0,94,128,255,128,0,127,
dc.b 220,128,35,32,255,160,0,95,116,96,139,138,119,234,0,21,
dc.b 8,0,247,255,15,255,0,0,144,8,239,247,31,255,0,0,
dc.b 32,16,223,239,63,255,0,0,52,112,203,143,63,255,0,0,
dc.b 26,192,229,63,159,207,128,0,15,132,240,123,15,143,0,0,
dc.b 31,194,224,63,31,192,0,0,32,48,223,207,63,240,0,0,
dc.b 64,120,191,135,127,250,0,2,1,128,6,127,7,128,248,0,
dc.b 1,244,0,15,1,240,254,0,0,94,0,33,0,126,255,128,
dc.b 0,65,0,62,0,127,255,128,0,129,1,126,1,255,254,0,
dc.b 1,3,10,252,11,255,244,0,0,30,175,225,175,254,80,0,
dc.b 8,8,247,247,255,248,0,0,12,4,243,251,255,252,0,0,
dc.b 4,2,251,253,255,254,0,0,7,42,248,213,255,254,0,0,
dc.b 0,204,255,51,252,252,0,0,4,50,251,207,252,48,0,0,
dc.b 160,0,95,255,252,32,0,32,84,0,171,255,126,0,0,0,
dc.b 63,0,192,255,63,0,0,0,7,132,248,127,7,128,0,0,
dc.b 3,128,252,127,3,128,0,0,1,128,254,127,1,128,0,0,
dc.b 9,128,254,127,65,128,64,0,3,128,252,127,3,132,0,4,
dc.b 1,128,254,127,1,128,0,0,65,128,254,127,1,128,0,0,
dc.b 1,192,254,127,9,128,8,0,1,136,254,127,1,128,0,0,
dc.b 1,128,254,127,1,128,0,0,1,193,254,63,65,200,64,8,
dc.b 17,128,254,127,1,128,0,0,1,128,254,127,1,128,0,0,
dc.b 1,128,254,127,1,128,0,0,67,128,252,127,3,136,0,8,
dc.b 1,192,254,63,1,192,0,0,3,192,252,63,67,192,64,0,
dc.b 3,200,252,63,3,192,0,0,7,128,248,127,7,144,0,16,
dc.b 3,128,252,127,3,128,0,0,1,142,254,113,1,142,0,0,
dc.b 33,153,254,102,1,159,0,0,1,147,254,108,1,159,0,0,
dc.b 1,214,254,41,1,222,0,0,0,204,255,51,16,220,16,0,
dc.b 0,240,255,15,0,240,0,0,0,96,255,159,0,96,0,0,
dc.b 8,96,255,159,0,100,0,4,0,96,255,159,0,96,0,0,
dc.b 0,112,255,143,0,112,0,0,248,96,7,159,248,96,0,0,
dc.b 76,225,179,31,124,224,0,0,102,192,153,63,126,196,0,4,
dc.b 63,192,192,63,63,192,0,0,7,160,248,127,7,128,0,0,
dc.b 3,128,252,127,19,128,16,0,1,142,254,113,1,142,0,0,
dc.b 9,153,254,102,1,159,0,0,3,147,252,108,3,159,0,0,
dc.b 1,214,254,41,1,222,0,0,64,204,255,51,0,220,0,0,
dc.b 0,240,255,15,0,240,0,0,0,96,255,159,8,97,8,1,
dc.b 32,96,255,159,0,96,0,0,0,96,255,159,0,96,0,0,
dc.b 0,97,255,159,0,96,0,0,248,112,7,143,248,112,0,0,
dc.b 76,224,179,31,124,224,0,0,102,192,153,63,126,196,0,4,
dc.b 51,192,204,63,63,192,0,0,7,144,248,127,7,128,0,0,
dc.b 3,128,252,127,3,128,0,0,17,204,254,51,65,204,64,0,
dc.b 5,254,250,1,5,254,0,0,27,248,228,7,27,248,0,0,
dc.b 39,192,248,63,7,192,0,0,3,0,252,255,3,0,0,0,
dc.b 3,4,252,255,35,0,32,0,3,0,252,255,3,32,0,32,
dc.b 7,136,248,127,7,128,0,0,15,193,240,63,15,192,0,0,
dc.b 67,224,252,31,35,228,32,4,61,94,194,161,62,190,0,0,
dc.b 214,41,40,22,233,215,0,0,220,31,32,0,162,32,1,192,
dc.b 126,61,128,2,65,195,0,0,95,255,160,0,160,1,0,0,
dc.b 149,233,106,22,234,23,0,0,123,206,132,49,122,46,0,0,
dc.b 9,192,254,63,1,196,0,4,1,96,254,159,33,224,32,0,
dc.b 1,98,254,159,3,224,2,0,185,64,198,191,57,196,0,4,
dc.b 57,80,222,191,57,192,0,0,63,96,216,159,63,226,0,2,
dc.b 30,64,225,191,95,208,64,16,2,66,253,191,7,192,0,0,
dc.b 2,66,253,191,3,192,0,0,66,112,253,143,11,240,8,0,
dc.b 2,152,253,119,3,248,0,0,6,248,249,119,7,250,0,2,
dc.b 6,112,249,143,135,240,128,0,10,136,253,127,3,128,0,0,
dc.b 2,64,253,191,3,192,0,0,2,80,253,175,3,208,0,0,
dc.b 1,32,254,223,33,228,32,4,3,32,252,223,3,224,0,0,
dc.b 1,16,254,239,1,240,0,0,0,145,255,111,40,240,40,0,
dc.b 0,158,255,97,0,254,0,0,67,1,252,254,3,255,0,0,
dc.b 4,1,251,254,39,255,32,0,11,13,244,242,15,255,0,0,
dc.b 0,0,255,255,0,0,255,255,8,0,128,1,119,254,135,255,
dc.b 47,252,128,1,80,2,128,3,15,244,128,1,112,10,128,3,
dc.b 47,252,128,1,80,2,128,3,127,252,128,1,0,2,128,3,
dc.b 60,156,128,1,67,98,192,3,56,12,128,1,71,242,192,3,
dc.b 56,12,128,1,71,242,192,3,60,28,128,1,67,226,192,3,
dc.b 62,62,128,1,65,192,192,1,63,112,128,1,64,142,192,1,
dc.b 47,244,128,1,80,10,192,1,63,240,128,1,64,14,192,1,
dc.b 0,20,128,1,127,234,255,225,0,0,255,255,0,0,255,255,
dc.b 0,0,255,255,0,0,255,255,40,0,128,1,87,254,135,255,
dc.b 31,252,128,1,96,2,128,3,31,244,128,1,96,10,128,3,
dc.b 47,252,128,1,80,2,128,3,127,252,128,1,0,2,128,3,
dc.b 60,156,128,1,67,98,192,3,56,12,128,1,71,242,192,3,
dc.b 56,12,128,1,71,242,192,3,60,28,128,1,67,226,192,3,
dc.b 62,62,128,1,65,192,192,1,63,116,128,1,64,138,192,1,
dc.b 47,242,128,1,80,12,192,1,63,242,128,1,64,12,192,1,
dc.b 0,20,128,1,127,234,255,225,0,0,255,255,0,0,255,255,
dc.b 0,0,255,255,0,0,255,255,76,0,128,1,51,254,131,255,
dc.b 55,252,128,1,72,2,128,3,55,244,128,1,72,10,128,3,
dc.b 79,252,128,1,48,2,128,3,119,252,128,1,8,2,128,3,
dc.b 60,156,128,1,67,98,192,3,56,12,128,1,71,242,192,3,
dc.b 56,12,128,1,71,242,192,3,60,30,128,1,67,224,192,1,
dc.b 62,50,128,1,65,204,192,1,63,108,128,1,64,146,192,1,
dc.b 47,236,128,1,80,18,192,1,63,242,128,1,64,12,192,1,
dc.b 0,28,128,1,127,226,255,225,0,0,255,255,0,0,255,255,
dc.b 0,0,255,255,0,0,255,255,8,0,128,1,119,254,135,255,
dc.b 95,252,128,1,32,2,128,3,95,244,128,1,32,10,128,3,
dc.b 31,252,128,1,96,2,128,3,127,252,128,1,0,2,128,3,
dc.b 60,156,128,1,67,98,192,3,56,12,128,1,71,242,192,3,
dc.b 56,12,128,1,71,242,192,3,60,28,128,1,67,226,192,3,
dc.b 62,62,128,1,65,192,192,1,63,112,128,1,64,142,192,1,
dc.b 47,250,128,1,80,4,192,1,63,250,128,1,64,4,192,1,
dc.b 0,18,128,1,127,236,255,225,0,0,255,255,0,0,255,255,
dc.b 255,255,0,0,255,255,255,255,255,255,5,224,248,31,255,255,
dc.b 255,255,3,192,252,63,255,255,255,255,5,224,248,31,255,255,
dc.b 255,255,5,224,248,31,255,255,252,63,3,128,252,127,255,255,
dc.b 252,63,3,128,252,127,255,255,252,63,3,128,252,127,255,255,
dc.b 244,47,7,224,248,31,255,255,210,11,29,248,224,7,255,255,
dc.b 166,5,57,252,192,3,255,255,132,1,59,252,192,3,255,255,
dc.b 191,253,0,0,255,255,192,3,223,249,32,4,255,255,192,3,
dc.b 207,243,16,8,255,255,224,7,227,199,4,32,255,255,248,31,
dc.b 255,255,0,0,255,255,255,255,255,255,5,224,248,31,255,255,
dc.b 255,255,3,192,252,63,255,255,255,255,5,224,248,31,255,255,
dc.b 255,255,5,224,248,31,255,255,252,63,3,128,252,127,255,255,
dc.b 252,63,3,128,252,127,255,255,252,63,3,128,252,127,255,255,
dc.b 244,47,7,224,248,31,255,255,210,11,29,248,224,7,255,255,
dc.b 166,5,57,252,192,3,255,255,132,29,59,224,192,31,255,227,
dc.b 135,253,56,0,199,255,248,3,223,249,32,4,255,255,192,3,
dc.b 207,243,16,8,255,255,224,7,227,199,4,32,255,255,248,31,
dc.b 255,255,0,0,255,255,255,255,255,255,5,224,248,31,255,255,
dc.b 255,255,3,192,252,63,255,255,255,255,5,224,248,31,255,255,
dc.b 255,255,5,224,248,31,255,255,252,63,3,128,252,127,255,255,
dc.b 252,63,3,128,252,127,255,255,252,63,3,128,252,127,255,255,
dc.b 244,47,7,224,248,31,255,255,210,11,29,248,224,7,255,255,
dc.b 166,13,57,240,192,15,255,243,132,61,59,192,192,63,255,195,
dc.b 129,253,62,0,193,255,254,3,207,249,48,4,239,255,208,3,
dc.b 207,243,16,8,255,255,224,7,227,199,4,32,255,255,248,31,
dc.b 255,255,0,0,255,255,255,255,255,255,5,224,248,31,255,255,
dc.b 255,255,3,192,252,63,255,255,255,255,5,224,248,31,255,255,
dc.b 255,255,5,224,248,31,255,255,252,63,3,128,252,127,255,255,
dc.b 252,63,3,128,252,127,255,255,252,63,3,128,252,127,255,255,
dc.b 244,47,7,224,248,31,255,255,210,11,29,248,224,7,255,255,
dc.b 166,5,57,252,192,3,255,255,132,29,59,224,192,31,255,227,
dc.b 135,253,56,0,199,255,248,3,223,249,32,4,255,255,192,3,
dc.b 207,243,16,8,255,255,224,7,227,199,4,32,255,255,248,31,
dc.b 255,255,0,0,255,255,255,255,255,255,5,224,248,31,255,255,
dc.b 255,255,3,192,252,63,255,255,255,255,5,224,248,31,255,255,
dc.b 255,255,5,224,248,31,255,255,252,63,3,128,252,127,255,255,
dc.b 252,63,3,128,252,127,255,255,252,63,3,128,252,127,255,255,
dc.b 244,47,7,224,248,31,255,255,210,11,29,248,224,7,255,255,
dc.b 166,5,57,252,192,3,255,255,132,1,59,252,192,3,255,255,
dc.b 191,253,0,0,255,255,192,3,223,249,32,4,255,255,192,3,
dc.b 207,243,16,8,255,255,224,7,227,199,4,32,255,255,248,31,
dc.b 255,255,0,0,255,255,255,255,255,255,5,224,248,31,255,255,
dc.b 255,255,3,192,252,63,255,255,255,255,5,224,248,31,255,255,
dc.b 255,255,5,224,248,31,255,255,252,63,3,128,252,127,255,255,
dc.b 252,63,3,128,252,127,255,255,252,63,3,128,252,127,255,255,
dc.b 244,47,7,224,248,31,255,255,210,11,29,248,224,7,255,255,
dc.b 166,5,57,252,192,3,255,255,188,1,3,252,248,3,199,255,
dc.b 191,225,0,28,255,227,192,31,223,249,32,4,255,255,192,3,
dc.b 207,243,16,8,255,255,224,7,227,199,4,32,255,255,248,31,
dc.b 255,255,0,0,255,255,255,255,255,255,5,224,248,31,255,255,
dc.b 255,255,3,192,252,63,255,255,255,255,5,224,248,31,255,255,
dc.b 255,255,5,224,248,31,255,255,252,63,3,128,252,127,255,255,
dc.b 252,63,3,128,252,127,255,255,252,63,3,128,252,127,255,255,
dc.b 244,47,7,224,248,31,255,255,210,11,29,248,224,7,255,255,
dc.b 182,5,9,252,240,3,207,255,188,1,3,252,252,3,195,255,
dc.b 191,129,0,124,255,131,192,127,223,241,32,12,255,247,192,11,
dc.b 207,243,16,8,255,255,224,7,227,199,4,32,255,255,248,31,
dc.b 255,255,0,0,255,255,255,255,255,255,5,224,248,31,255,255,
dc.b 255,255,3,192,252,63,255,255,255,255,5,224,248,31,255,255,
dc.b 255,255,5,224,248,31,255,255,252,63,3,128,252,127,255,255,
dc.b 252,63,3,128,252,127,255,255,252,63,3,128,252,127,255,255,
dc.b 244,47,7,224,248,31,255,255,210,11,29,248,224,7,255,255,
dc.b 166,5,57,252,192,3,255,255,188,1,3,252,248,3,199,255,
dc.b 191,225,0,28,255,227,192,31,223,249,32,4,255,255,192,3,
dc.b 207,243,16,8,255,255,224,7,227,199,4,32,255,255,248,31,
dc.b 255,255,0,0,248,63,248,63,248,63,0,0,224,15,231,207,
dc.b 224,31,0,0,192,7,223,231,192,15,0,0,128,3,191,243,
dc.b 128,7,0,0,128,3,255,251,128,3,0,0,0,1,127,253,
dc.b 128,3,0,0,0,1,127,253,128,3,0,0,0,1,127,253,
dc.b 128,3,0,0,0,1,127,253,192,7,0,0,0,1,63,249,
dc.b 192,7,0,0,128,3,191,251,224,15,0,0,128,3,159,243,
dc.b 224,31,0,0,192,7,223,231,248,63,0,0,224,15,231,207,
dc.b 255,255,0,0,248,63,248,63,255,255,0,0,255,255,255,255,
dc.b 255,127,0,0,254,63,254,191,252,31,0,0,248,15,251,239,
dc.b 252,31,0,0,248,15,251,239,248,15,0,0,240,7,247,247,
dc.b 248,15,0,0,240,7,247,247,240,7,0,0,224,3,239,251,
dc.b 240,7,0,0,224,3,239,251,240,7,0,0,224,3,239,251,
dc.b 240,7,0,0,224,3,239,251,240,7,0,0,224,3,239,251,
dc.b 248,15,0,0,240,7,247,247,248,15,0,0,240,7,247,247,
dc.b 252,31,0,0,248,15,251,239,252,31,0,0,248,15,251,239,
dc.b 255,127,0,0,254,63,254,191,255,255,0,0,255,255,255,255,
dc.b 254,255,0,0,252,127,253,127,252,127,0,0,248,63,251,191,
dc.b 252,127,0,0,249,63,251,191,252,127,0,0,249,63,251,191,
dc.b 249,63,0,0,240,31,246,223,249,63,0,0,240,31,246,223,
dc.b 249,63,0,0,240,31,246,223,249,63,0,0,240,31,246,223,
dc.b 249,63,0,0,240,31,246,223,249,63,0,0,240,31,246,223,
dc.b 248,63,0,0,241,31,247,223,253,127,0,0,249,63,250,191,
dc.b 253,127,0,0,249,63,250,191,252,127,0,0,248,63,251,191,
dc.b 254,255,0,0,252,127,253,127,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,252,127,252,127,254,255,0,0,252,127,253,127,
dc.b 254,255,0,0,252,127,253,127,254,255,0,0,252,127,253,127,
dc.b 254,255,0,0,252,127,253,127,254,255,0,0,252,127,253,127,
dc.b 254,255,0,0,252,127,253,127,254,255,0,0,252,127,253,127,
dc.b 254,255,0,0,252,127,253,127,254,255,0,0,252,127,253,127,
dc.b 254,255,0,0,252,127,253,127,254,255,0,0,252,127,253,127,
dc.b 254,255,0,0,252,127,253,127,254,255,0,0,252,127,253,127,
dc.b 255,255,0,0,252,127,252,127,255,255,0,0,255,255,255,255,
dc.b 254,255,0,0,252,127,253,127,252,127,0,0,248,63,251,191,
dc.b 252,127,0,0,249,63,251,191,252,127,0,0,249,63,251,191,
dc.b 249,63,0,0,240,31,246,223,249,63,0,0,240,31,246,223,
dc.b 249,63,0,0,240,31,246,223,249,63,0,0,240,31,246,223,
dc.b 249,63,0,0,240,31,246,223,249,63,0,0,240,31,246,223,
dc.b 248,63,0,0,241,31,247,223,253,127,0,0,249,63,250,191,
dc.b 253,127,0,0,249,63,250,191,252,127,0,0,248,63,251,191,
dc.b 254,255,0,0,252,127,253,127,255,255,0,0,255,255,255,255,
dc.b 255,127,0,0,254,63,254,191,252,31,0,0,248,15,251,239,
dc.b 252,31,0,0,248,15,251,239,248,15,0,0,240,7,247,247,
dc.b 248,15,0,0,240,7,247,247,240,7,0,0,224,3,239,251,
dc.b 240,7,0,0,224,3,239,251,240,7,0,0,224,3,239,251,
dc.b 240,7,0,0,224,3,239,251,240,7,0,0,224,3,239,251,
dc.b 248,15,0,0,240,7,247,247,248,15,0,0,240,7,247,247,
dc.b 252,31,0,0,248,15,251,239,252,31,0,0,248,15,251,239,
dc.b 255,127,0,0,254,63,254,191,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,248,63,248,63,248,63,0,0,224,15,231,207,
dc.b 224,31,0,0,192,7,223,231,192,15,0,0,128,3,191,243,
dc.b 128,7,0,0,128,3,255,251,128,3,0,0,0,1,127,253,
dc.b 128,3,0,0,0,1,127,253,128,3,0,0,0,1,127,253,
dc.b 128,3,0,0,0,1,127,253,192,7,0,0,0,1,63,249,
dc.b 192,7,0,0,128,3,191,251,224,15,0,0,128,3,159,243,
dc.b 224,31,0,0,192,7,223,231,248,63,0,0,224,15,231,207,
dc.b 255,255,0,0,248,63,248,63,255,255,0,0,255,255,255,255,
dc.b 255,255,0,0,248,63,248,63,248,63,0,0,224,15,231,207,
dc.b 224,31,0,0,192,7,223,231,192,15,0,0,128,3,191,243,
dc.b 128,7,0,0,128,3,255,251,128,3,0,0,0,1,127,253,
dc.b 128,3,0,0,0,1,127,253,128,3,0,0,0,1,127,253,
dc.b 128,3,0,0,0,1,127,253,192,7,0,0,0,1,63,249,
dc.b 192,7,0,0,128,3,191,251,224,15,0,0,128,3,159,243,
dc.b 224,31,0,0,192,7,223,231,248,63,0,0,224,15,231,207,
dc.b 255,255,0,0,248,63,248,63,255,255,0,0,255,255,255,255,

EXPORT ani_table
ani_table:
dc.b 0, 1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15, 
dc.b 16, 17, 18, 19, 20, 21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 31, 
dc.b 32, 33, 34, 35, 36, 37, 38, 39, 40, 41, 42, 43, 44, 45, 46, 47, 
dc.b 48, 49, 50, 51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 61, 62, 63, 
dc.b 64, 65, 66, 67, 68, 69, 70, 71, 72, 73, 74, 75, 76, 77, 78, 79, 
dc.b 80, 81, 82, 83, 84, 85, 86, 87, 88, 89, 90, 91, 92, 93, 94, 95, 
dc.b 96, 97, 98, 99, 100, 101, 102, 103, 104, 105, 106, 107, 108, 109, 110, 111, 
dc.b 112, 113, 114, 115, 116, 117, 118, 119, 120, 121, 122, 123, 124, 125, 126, 127, 

export duo_block_table
DATA
EVEN
duo_block_table: 

dc.b 0,0,0,128,1,0,1,128,2,0,2,128,3,0,3,128,
dc.b 0,0,0,0,0,0,0,0,4,0,0,0,0,0,4,128,
dc.b 0,0,3,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 4,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,3,0,4,128,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 5,0,5,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,6,0,6,128,0,0,0,0,7,0,7,128,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,8,0,
dc.b 0,0,7,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 8,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,7,128,8,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 8,128,9,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,9,128,10,0,10,128,11,0,11,128,
dc.b 12,0,0,0,0,0,0,0,12,128,0,0,13,0,13,128,
dc.b 0,0,11,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 13,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,11,0,13,128,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,14,0,14,128,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,15,0,15,128,16,0,16,128,17,0,17,128,18,0,
dc.b 18,128,0,0,0,0,0,0,19,0,0,0,19,128,0,0,
dc.b 0,0,17,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,17,128,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,20,0,0,0,0,0,20,128,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,21,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,21,128,22,0,22,128,23,0,23,128,24,0,24,128,
dc.b 25,0,25,128,26,0,0,0,26,128,0,0,27,0,27,128,
dc.b 28,0,24,0,28,128,0,0,0,0,0,0,0,0,29,0,
dc.b 27,128,0,0,29,128,30,0,0,0,30,128,0,0,31,0,
dc.b 31,128,0,0,0,0,0,0,32,0,32,128,0,0,33,0,
dc.b 33,128,34,0,34,128,35,0,35,128,36,0,36,128,37,0,
dc.b 37,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,24,0,27,128,0,0,0,0,38,0,
dc.b 38,128,39,0,39,128,40,0,0,0,40,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,41,0,41,128,42,0,42,128,0,0,43,0,
dc.b 0,0,43,128,44,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,44,128,0,0,0,0,0,0,
dc.b 0,0,45,0,0,0,45,128,46,0,0,0,0,0,46,128,
dc.b 0,0,47,0,47,128,48,0,0,0,0,0,48,128,49,0,
dc.b 48,128,49,128,50,0,50,128,51,0,0,0,0,0,0,0,
dc.b 0,0,51,128,52,0,52,128,53,0,53,128,54,0,54,128,
dc.b 0,0,0,0,0,0,55,0,55,128,0,0,0,0,56,0,
dc.b 0,0,54,0,56,128,57,0,0,0,0,0,0,0,0,0,
dc.b 56,0,0,0,0,0,0,0,0,0,0,0,57,128,58,0,
dc.b 58,128,0,0,0,0,59,0,59,128,60,0,0,0,60,128,
dc.b 61,0,61,128,62,0,62,128,63,0,63,128,64,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,64,128,
dc.b 65,0,65,128,66,0,54,0,56,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,66,128,
dc.b 0,0,0,0,0,0,0,0,0,0,67,0,67,128,68,0,
dc.b 0,0,0,0,68,128,69,0,69,128,70,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,70,128,71,0,0,0,71,128,
dc.b 0,0,72,0,72,128,73,0,73,128,74,0,0,0,0,0,
dc.b 74,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,75,0,75,128,76,0,76,128,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,77,0,77,128,78,0,0,0,78,128,
dc.b 79,0,0,0,0,0,0,0,79,128,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,80,0,0,0,80,128,81,0,81,128,82,0,82,128,
dc.b 83,0,0,0,0,0,0,0,83,128,0,0,0,0,84,0,
dc.b 0,0,82,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 84,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,82,0,84,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,84,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,85,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,85,128,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,86,0,86,128,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,87,0,0,0,0,0,0,0,87,128,0,0,0,0,
dc.b 0,0,88,0,88,128,0,0,0,0,0,0,0,0,89,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 89,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,89,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,89,128,90,0,0,0,90,128,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,91,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,91,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,92,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,92,128,0,0,
dc.b 92,0,0,0,0,0,0,0,0,0,0,0,0,0,93,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,93,128,
dc.b 94,0,94,128,95,0,95,128,96,0,96,128,97,0,0,0,
dc.b 0,0,97,128,0,0,0,0,0,0,0,0,98,0,0,0,
dc.b 0,0,0,0,0,0,0,0,92,0,0,0,0,0,0,0,
dc.b 0,0,0,0,98,128,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,99,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 99,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,100,0,100,128,101,0,101,128,0,0,0,0,0,0,
dc.b 0,0,102,0,102,128,103,0,103,128,104,0,104,128,105,0,
dc.b 105,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,104,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,106,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,106,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,107,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,104,128,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,107,128,0,0,108,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,108,128,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,108,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,108,128,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,109,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,109,128,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,110,0,110,128,0,0,0,0,111,0,111,128,112,0,
dc.b 0,0,112,128,0,0,0,0,0,0,113,0,0,0,113,128,
dc.b 114,0,111,128,114,128,0,0,0,0,115,0,115,128,116,0,
dc.b 113,128,116,128,117,0,117,128,0,0,118,0,0,0,118,128,
dc.b 119,0,119,128,120,0,0,0,0,0,0,0,0,0,120,128,
dc.b 121,0,121,128,122,0,122,128,123,0,123,128,124,0,124,128,
dc.b 125,0,125,128,0,0,126,0,126,128,127,0,127,128,0,0,
dc.b 128,0,0,0,128,128,111,128,113,128,129,0,129,128,130,0,
dc.b 130,128,131,0,131,128,132,0,0,0,132,128,0,0,133,0,
dc.b 0,0,0,0,133,128,0,0,0,0,0,0,0,0,0,0,
dc.b 134,0,134,128,0,0,0,0,0,0,0,0,135,0,135,128,
dc.b 136,0,136,128,137,0,137,128,0,0,0,0,138,0,0,0,
dc.b 0,0,138,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,139,0,139,128,140,0,0,0,0,0,140,128,141,0,
dc.b 140,128,141,128,142,0,142,128,143,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,143,128,0,0,144,0,
dc.b 144,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 144,0,0,0,145,0,0,0,0,0,0,0,0,0,145,128,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,146,0,
dc.b 146,128,147,0,147,128,148,0,148,128,149,0,0,0,0,0,
dc.b 0,0,149,128,0,0,0,0,0,0,150,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,144,0,150,128,151,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,151,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,152,0,152,128,153,0,0,0,0,0,153,128,154,0,
dc.b 153,128,154,128,155,0,155,128,156,0,0,0,0,0,0,0,
dc.b 0,0,51,128,52,0,52,128,53,0,53,128,54,0,54,128,
dc.b 0,0,0,0,0,0,55,0,55,128,0,0,0,0,56,0,
dc.b 0,0,54,0,56,128,57,0,0,0,0,0,0,0,0,0,
dc.b 56,0,0,0,0,0,0,0,0,0,0,0,57,128,58,0,
dc.b 58,128,0,0,0,0,59,0,59,128,60,0,0,0,60,128,
dc.b 61,0,61,128,62,0,62,128,63,0,63,128,64,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,64,128,
dc.b 65,0,65,128,66,0,54,0,56,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,66,128,
dc.b 0,0,0,0,0,0,0,0,0,0,67,0,67,128,68,0,
dc.b 0,0,0,0,68,128,69,0,69,128,70,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,70,128,71,0,0,0,71,128,
dc.b 0,0,72,0,72,128,73,0,73,128,74,0,0,0,0,0,
dc.b 74,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,75,0,75,128,76,0,76,128,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,156,128,157,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,157,0,157,128,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,157,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,158,0,158,128,159,0,159,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,160,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,160,128,161,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,161,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,161,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,161,128,0,0,162,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 162,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 162,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,162,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,163,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,163,128,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 163,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,164,0,
dc.b 164,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,163,128,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,165,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,165,128,166,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,166,0,0,0,0,0,0,0,0,0,0,0,166,128,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 167,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,166,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,110,0,110,128,0,0,0,0,111,0,111,128,112,0,
dc.b 0,0,112,128,0,0,0,0,0,0,113,0,0,0,113,128,
dc.b 114,0,111,128,114,128,0,0,0,0,115,0,115,128,116,0,
dc.b 113,128,116,128,117,0,117,128,0,0,118,0,0,0,118,128,
dc.b 119,0,119,128,120,0,0,0,0,0,0,0,0,0,120,128,
dc.b 121,0,121,128,122,0,122,128,123,0,123,128,124,0,124,128,
dc.b 125,0,125,128,0,0,126,0,126,128,127,0,127,128,0,0,
dc.b 128,0,0,0,128,128,111,128,113,128,129,0,129,128,130,0,
dc.b 130,128,131,0,131,128,132,0,0,0,132,128,0,0,133,0,
dc.b 0,0,0,0,133,128,0,0,0,0,0,0,0,0,0,0,
dc.b 134,0,134,128,0,0,0,0,0,0,0,0,135,0,135,128,
dc.b 136,0,136,128,137,0,137,128,0,0,0,0,138,0,0,0,
dc.b 0,0,138,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,139,0,139,128,140,0,0,0,0,0,0,0,141,0,
dc.b 140,128,141,128,142,0,142,128,143,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,167,128,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 167,128,168,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,168,128,169,0,0,0,169,128,0,0,
dc.b 0,0,0,0,0,0,0,0,167,128,170,0,0,0,0,0,
dc.b 0,0,0,0,0,0,170,128,0,0,171,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,171,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,172,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,172,128,0,0,173,0,
dc.b 173,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 173,0,0,0,174,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,173,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 174,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,175,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,175,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,176,0,176,128,177,0,0,0,0,0,177,128,178,0,
dc.b 177,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,178,128,179,0,179,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,180,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 180,0,180,128,0,0,181,0,0,0,181,128,0,0,182,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,182,128,
dc.b 183,0,183,128,184,0,184,128,185,0,185,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,186,0,186,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,180,0,187,0,0,0,0,0,
dc.b 187,128,0,0,188,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,188,128,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,189,0,189,128,190,0,190,128,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,191,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 191,0,0,0,0,0,191,128,0,0,192,0,0,0,192,128,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,193,0,
dc.b 193,128,194,0,194,128,195,0,195,128,196,0,196,128,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,191,0,197,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,197,128,0,0,198,0,0,0,0,0,198,128,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,199,0,199,128,200,0,200,128,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,201,0,201,128,202,0,
dc.b 0,0,0,0,0,0,0,0,202,128,0,0,0,0,0,0,
dc.b 0,0,201,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,201,128,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,203,0,203,128,204,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,204,128,0,0,0,0,
dc.b 0,0,0,0,205,0,0,0,205,128,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,206,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,206,128,0,0,207,0,
dc.b 207,128,0,0,208,0,0,0,0,0,0,0,0,0,0,0,
dc.b 207,0,208,128,0,0,0,0,0,0,0,0,0,0,209,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,209,128,
dc.b 0,0,210,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,207,0,210,128,211,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 211,128,212,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,212,128,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,213,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,213,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,214,0,214,128,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,215,0,
dc.b 0,0,214,128,0,0,0,0,0,0,0,0,0,0,215,128,
dc.b 215,0,0,0,0,0,0,0,0,0,216,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,214,128,215,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 216,128,217,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,217,128,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 217,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,217,128,0,0,0,0,0,0,
dc.b 218,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,218,128,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 218,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,218,128,0,0,0,0,0,0,
dc.b 219,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,219,128,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,219,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,220,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,219,128,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,220,128,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,221,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,221,0,221,128,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,222,0,222,128,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,221,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,223,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,223,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,223,128,224,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,223,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,224,128,225,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,225,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,225,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,225,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,226,0,0,0,226,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,227,0,0,0,0,0,
dc.b 227,128,228,0,228,128,0,0,229,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,229,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,230,0,0,0,230,128,
dc.b 231,0,0,0,231,128,0,0,0,0,0,0,0,0,0,0,
dc.b 230,128,232,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,232,128,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,233,0,
dc.b 0,0,233,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,230,128,234,0,234,128,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 235,0,235,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,236,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,236,128,0,0,0,0,0,0,237,0,0,0,
dc.b 237,0,237,128,238,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,238,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,239,0,0,0,239,128,
dc.b 240,0,0,0,240,128,0,0,0,0,0,0,0,0,0,0,
dc.b 239,128,241,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 241,128,0,0,0,0,0,0,0,0,0,0,0,0,242,0,
dc.b 0,0,242,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,239,128,243,0,243,128,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 244,0,244,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,245,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,245,128,0,0,0,0,0,0,246,0,
dc.b 0,0,0,0,246,128,247,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,247,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,248,0,0,0,248,128,
dc.b 249,0,0,0,249,128,0,0,0,0,0,0,0,0,0,0,
dc.b 248,128,250,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,250,128,0,0,0,0,0,0,0,0,0,0,251,0,
dc.b 0,0,251,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,248,128,252,0,252,128,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 253,0,253,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,254,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,254,128,0,0,0,0,0,0,255,0,0,0,
dc.b 255,0,0,0,0,0,255,129,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,0,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,1,0,0,1,1,129,
dc.b 2,0,0,1,2,128,0,0,0,0,0,0,0,0,0,1,
dc.b 1,129,3,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,1,3,128,0,0,0,0,0,0,0,1,4,0,
dc.b 0,1,4,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,1,1,129,5,1,5,128,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,
dc.b 6,1,6,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,1,7,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,7,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,1,8,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,8,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,9,0,0,1,9,129,
dc.b 10,0,0,1,10,128,0,0,0,0,0,0,0,0,0,1,
dc.b 9,129,11,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,1,11,128,0,0,0,0,0,1,12,0,
dc.b 0,1,12,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,1,9,129,13,1,13,128,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,
dc.b 14,1,14,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,1,15,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,1,15,128,0,0,0,0,0,1,16,0,0,1,
dc.b 16,0,0,0,0,1,16,129,17,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,17,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,18,0,0,1,18,129,
dc.b 19,0,0,1,19,128,0,0,0,0,0,0,0,0,0,1,
dc.b 18,129,20,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,1,20,128,0,0,0,1,21,0,
dc.b 0,1,21,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,1,18,129,22,1,22,128,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,
dc.b 23,1,23,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,1,24,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,1,24,128,0,0,0,0,0,1,25,0,
dc.b 0,0,0,1,25,129,26,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,26,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,27,0,0,1,27,129,
dc.b 28,0,0,1,28,128,0,0,0,0,0,0,0,0,0,1,
dc.b 27,129,29,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,29,128,0,1,30,0,
dc.b 0,1,30,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,1,27,129,31,1,31,128,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,
dc.b 32,1,32,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,1,33,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,1,33,128,0,0,0,0,0,1,34,0,0,1,
dc.b 34,1,34,129,35,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,35,128,0,0,0,0,0,1,36,1,36,128,0,0,
dc.b 0,0,0,0,0,0,0,1,37,1,37,128,0,1,38,1,
dc.b 38,129,36,128,0,0,0,0,0,0,0,0,0,0,0,1,
dc.b 38,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,1,39,0,0,0,
dc.b 0,1,39,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,1,36,129,38,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,1,40,0,
dc.b 0,0,0,1,40,128,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,1,41,0,0,0,0,0,0,0,
dc.b 0,1,41,129,42,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,42,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,43,1,43,129,44,0,0,0,0,1,44,129,45,1,
dc.b 44,129,45,129,46,1,46,129,47,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,47,128,0,1,48,0,
dc.b 0,0,0,0,0,0,0,0,0,1,48,128,0,0,0,1,
dc.b 48,0,0,0,0,0,0,0,0,0,0,0,0,1,49,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,1,49,129,
dc.b 50,1,50,129,51,1,51,129,52,1,52,128,0,1,53,1,
dc.b 53,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,1,48,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,1,54,0,
dc.b 0,0,0,0,0,0,0,0,0,1,54,129,55,0,0,1,
dc.b 54,0,0,0,0,0,0,0,0,1,55,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,1,56,1,
dc.b 56,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,1,54,0,0,1,57,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,1,57,128,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,1,58,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,
dc.b 58,1,58,128,0,0,0,0,0,0,0,0,0,1,59,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,1,59,129,
dc.b 60,1,60,129,61,1,61,129,62,1,62,128,0,0,0,0,
dc.b 0,1,63,0,0,0,0,1,63,129,64,1,64,128,0,0,
dc.b 0,0,0,0,0,0,0,1,58,1,65,1,65,128,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,1,66,0,0,0,0,0,0,0,0,0,0,1,
dc.b 66,129,67,0,0,0,0,0,0,0,0,0,0,1,67,129,
dc.b 68,1,68,129,69,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,1,69,128,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,
dc.b 69,128,0,0,0,0,0,0,0,0,0,0,0,1,70,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,1,70,129,
dc.b 71,1,71,129,72,1,72,129,73,1,73,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,1,69,128,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,1,74,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,1,74,128,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,
dc.b 74,129,75,0,0,1,75,128,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,76,0,0,1,76,129,77,0,0,1,77,128,0,0,
dc.b 0,0,0,0,0,0,0,1,74,128,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,78,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,1,78,128,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,
dc.b 78,128,0,0,0,1,79,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,79,128,0,0,0,1,80,1,80,129,81,0,0,0,
dc.b 0,0,0,0,0,0,0,1,78,129,81,129,82,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,82,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,
dc.b 83,1,83,128,0,0,0,0,0,0,0,0,0,1,84,1,
dc.b 84,129,85,1,85,128,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,86,1,86,129,87,1,87,128,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,1,88,0,
dc.b 0,0,0,0,0,0,0,0,0,1,88,128,0,0,0,1,
dc.b 88,1,89,1,89,128,0,0,0,0,0,0,0,1,90,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,1,90,129,
dc.b 91,1,91,129,92,1,92,129,93,1,93,128,0,0,0,0,
dc.b 0,1,94,0,0,0,0,1,94,129,95,1,95,128,0,0,
dc.b 0,0,0,0,0,0,0,1,88,1,96,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,
dc.b 96,129,97,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,97,129,98,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,1,98,128,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,98,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,
dc.b 99,0,0,0,0,1,98,128,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,1,99,128,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,99,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,100,0,0,1,99,128,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,1,100,128,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,100,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,1,100,128,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,1,101,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,101,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,1,101,128,
dc.b 0,0,0,0,0,1,101,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,51,128,52,0,52,128,53,0,53,128,54,0,54,128,
dc.b 0,0,0,0,0,0,55,0,55,128,0,0,0,0,56,0,
dc.b 0,0,54,0,56,128,57,0,0,0,0,0,0,0,0,0,
dc.b 56,0,0,0,0,0,0,0,0,0,0,0,57,128,58,0,
dc.b 58,128,0,0,0,0,59,0,59,128,60,0,0,0,60,128,
dc.b 61,0,61,128,62,0,62,128,63,0,63,128,64,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,64,128,
dc.b 65,0,65,128,66,0,54,0,56,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,66,128,
dc.b 0,0,0,0,0,0,0,0,0,0,67,0,67,128,68,0,
dc.b 0,0,0,0,68,128,69,0,69,128,70,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,70,128,71,0,0,0,71,128,
dc.b 0,0,72,0,72,128,73,0,73,128,74,0,0,0,0,0,
dc.b 74,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,75,0,75,128,76,0,76,128,0,0,0,0,0,0,
dc.b 0,0,110,0,110,128,0,0,0,0,111,0,111,128,112,0,
dc.b 0,0,112,128,0,0,0,0,0,0,113,0,0,0,113,128,
dc.b 114,0,111,128,114,128,0,0,0,0,115,0,115,128,116,0,
dc.b 113,128,116,128,117,0,117,128,0,0,118,0,0,0,118,128,
dc.b 119,0,119,128,120,0,0,0,0,0,0,0,0,0,120,128,
dc.b 121,0,121,128,122,0,122,128,123,0,123,128,124,0,124,128,
dc.b 125,0,125,128,0,0,126,0,126,128,127,0,127,128,0,0,
dc.b 128,0,0,0,128,128,111,128,113,128,129,0,129,128,130,0,
dc.b 130,128,131,0,131,128,132,0,0,0,132,128,0,0,133,0,
dc.b 0,0,0,0,133,128,0,0,0,0,0,0,0,0,0,0,
dc.b 134,0,134,128,0,0,0,0,0,0,0,0,135,0,135,128,
dc.b 136,0,136,128,137,0,137,128,0,0,0,0,138,0,0,0,
dc.b 0,0,138,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,139,0,139,128,140,0,0,0,0,0,0,0,141,0,
dc.b 140,128,141,128,142,0,142,128,143,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,1,102,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,
dc.b 102,1,102,128,0,1,103,0,0,1,103,128,0,1,104,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,1,104,129,
dc.b 105,1,105,129,106,1,106,129,107,1,107,128,0,0,0,0,
dc.b 0,1,108,0,0,0,0,1,108,129,109,1,109,128,0,0,
dc.b 0,0,0,0,0,0,0,1,102,1,110,1,110,128,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,111,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,111,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,1,112,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,1,112,128,0,1,
dc.b 112,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,113,1,113,128,0,0,
dc.b 0,0,0,0,0,0,0,1,112,1,114,1,114,128,0,0,
dc.b 0,0,0,0,0,1,115,0,0,1,115,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,1,116,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,1,116,128,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,
dc.b 116,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,1,117,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,1,116,128,0,0,0,1,117,129,
dc.b 118,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,118,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,1,119,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,
dc.b 119,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,119,129,120,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,1,119,1,120,128,0,1,121,1,
dc.b 121,128,0,0,0,1,122,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,
dc.b 122,129,123,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,123,128,0,0,0,0,0,1,124,0,0,0,0,0,
dc.b 0,1,124,128,0,0,0,0,0,0,0,0,0,1,125,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,
dc.b 125,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,1,125,0,0,0,0,0,0,0,
dc.b 0,1,125,129,126,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,126,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,127,0,0,1,127,128,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,
dc.b 127,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,1,127,128,0,1,128,0,0,0,
dc.b 0,1,128,129,129,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,1,129,128,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,130,0,0,0,0,0,0,1,130,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,1,131,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,1,131,128,0,1,
dc.b 131,1,132,0,0,1,132,128,0,1,133,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,1,133,128,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,1,131,1,134,0,0,0,0,0,
dc.b 0,0,0,0,0,1,134,128,0,1,135,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,
dc.b 135,129,136,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,136,129,137,1,137,129,138,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,1,138,128,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,1,139,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,
dc.b 139,0,0,0,0,0,0,0,0,1,139,128,0,1,140,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,1,140,129,
dc.b 141,1,141,129,142,1,142,129,143,1,143,128,0,0,0,0,
dc.b 0,1,144,0,0,0,0,1,144,129,145,1,145,128,0,0,
dc.b 0,0,0,0,0,0,0,1,139,0,0,0,0,0,0,0,
dc.b 0,0,0,1,146,1,146,128,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,1,147,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,
dc.b 147,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,148,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,1,148,128,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,
dc.b 148,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,1,148,128,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,1,149,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,1,149,128,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,1,150,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,
dc.b 150,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,1,150,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,1,150,128,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,150,129,151,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,1,150,128,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,151,129,152,1,152,128,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,152,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,1,152,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,1,153,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,1,153,129,154,1,154,129,155,1,155,128,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,155,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,1,155,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,1,156,0,0,1,156,129,157,1,157,128,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,157,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,1,157,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,1,158,0,0,0,0,1,158,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,159,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,1,159,128,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,1,160,1,160,129,161,1,161,129,
dc.b 162,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,161,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,1,161,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,162,128,0,0,0,0,
dc.b 0,0,0,0,0,1,163,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,163,129,164,0,0,0,
dc.b 0,0,0,0,0,1,164,129,165,0,0,0,0,0,0,0,
dc.b 0,1,164,1,165,128,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,166,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,1,164,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,1,166,128,0,0,0,1,167,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,167,128,0,0,0,0,
dc.b 0,1,168,1,168,129,169,1,169,128,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,170,0,0,0,0,0,
dc.b 0,1,170,128,0,0,0,0,0,0,0,0,0,1,171,1,
dc.b 171,128,0,0,0,0,0,0,0,0,0,0,0,1,172,1,
dc.b 171,0,0,0,0,0,0,0,0,1,172,128,0,1,173,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,1,173,129,
dc.b 174,1,174,129,175,1,175,129,176,1,176,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,1,171,1,177,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,177,129,178,1,178,128,0,0,0,1,179,1,179,129,
dc.b 179,1,180,1,180,129,181,1,181,128,0,0,0,0,0,0,
dc.b 0,1,182,1,182,128,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,1,183,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,
dc.b 183,0,0,0,0,0,0,0,0,1,183,128,0,1,184,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,1,184,129,
dc.b 185,1,185,129,186,1,186,129,187,1,187,128,0,0,0,1,
dc.b 188,1,188,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,1,183,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,1,189,0,0,1,189,128,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,1,190,1,
dc.b 190,128,0,0,0,0,0,0,0,0,0,0,0,0,0,1,
dc.b 190,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,1,190,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,191,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,191,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,192,1,192,129,193,0,0,0,0,1,193,129,194,1,
dc.b 193,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,194,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,195,0,0,1,195,128,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,1,196,1,
dc.b 195,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,196,128,0,0,0,0,0,1,197,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,1,195,128,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,
dc.b 197,129,198,0,0,0,0,0,0,0,0,0,0,1,198,129,
dc.b 199,1,199,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,200,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,1,200,128,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,
dc.b 200,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,201,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,1,200,128,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,1,201,128,
dc.b 0,1,202,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,202,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,203,0,0,1,203,128,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,
dc.b 203,129,204,1,204,128,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,205,0,0,0,0,1,205,129,206,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,1,203,129,206,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,207,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,207,128,0,0,0,0,0,0,0,0,0,1,208,0,
dc.b 0,1,208,129,209,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,209,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,1,210,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,
dc.b 210,1,210,129,211,1,211,128,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,212,1,212,128,0,0,
dc.b 0,0,0,0,0,0,0,1,210,1,213,0,0,1,213,128,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,214,1,214,128,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,1,215,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,215,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,1,216,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,
dc.b 216,0,0,0,0,0,0,0,0,1,216,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,1,216,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,1,217,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,217,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,
dc.b 218,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,1,218,128,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,
dc.b 218,129,219,0,0,0,0,0,0,1,219,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,1,218,128,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,220,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,1,220,128,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,1,221,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,1,221,128,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,
dc.b 221,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,1,221,128,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,1,222,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,222,1,222,128,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,1,222,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,1,223,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,1,223,128,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,224,1,224,128,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,1,225,0,
dc.b 0,1,224,128,0,0,0,0,0,0,0,0,0,0,0,1,
dc.b 225,0,0,0,0,0,0,0,0,0,0,1,225,128,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,1,224,129,225,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,1,226,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,1,226,128,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,227,0,0,0,0,0,
dc.b 0,1,227,129,228,1,228,129,229,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,229,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,
dc.b 230,1,230,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,1,231,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,231,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,1,231,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,1,231,128,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,
dc.b 232,1,232,128,0,0,0,1,233,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,1,233,128,0,0,
dc.b 0,0,0,0,0,0,0,1,234,0,0,0,0,1,234,128,
dc.b 0,1,233,128,0,0,0,0,0,0,0,0,0,0,0,1,
dc.b 234,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,235,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,1,233,129,234,128,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,1,235,129,236,1,236,129,237,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,237,128,0,0,0,0,0,1,238,0,0,0,0,1,
dc.b 238,129,239,1,239,129,240,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,1,240,128,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,240,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,1,241,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,241,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,1,240,128,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,1,242,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,242,128,0,1,243,1,
dc.b 243,129,244,1,244,129,245,1,245,128,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,246,1,246,128,0,0,
dc.b 0,0,0,0,0,0,0,1,247,0,0,0,0,0,0,0,
dc.b 0,1,246,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,247,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,1,246,128,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,1,248,0,
dc.b 0,0,0,1,248,128,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,249,0,0,0,0,0,
dc.b 0,1,249,129,250,1,250,129,251,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,1,251,128,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,251,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,1,252,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,1,252,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,1,251,128,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,1,253,0,0,0,0,1,253,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,1,254,1,254,129,255,1,255,128,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,2,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,2,0,128,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,2,0,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,2,0,128,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,2,1,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,2,1,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,2,1,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,2,1,128,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,2,2,0,0,2,2,130,
dc.b 3,0,0,0,0,0,0,0,0,0,0,0,0,0,0,2,
dc.b 2,128,0,2,3,128,0,0,0,0,0,0,0,2,4,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,2,4,128,0,0,0,0,0,0,0,0,0,0,
dc.b 0,2,5,0,0,0,0,0,0,2,5,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,2,2,130,6,2,6,128,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,2,7,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,2,7,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,2,8,0,0,0,0,2,8,128,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,2,9,0,0,2,9,130,
dc.b 10,0,0,0,0,0,0,0,0,0,0,0,0,0,0,2,
dc.b 9,128,0,2,10,128,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,2,11,0,
dc.b 0,2,11,128,0,2,12,0,0,2,12,128,0,0,0,0,
dc.b 0,2,13,0,0,0,0,0,0,2,13,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,2,9,130,14,2,14,128,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,2,15,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,2,15,128,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,2,16,0,0,2,16,128,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,2,17,0,0,2,17,130,
dc.b 18,0,0,0,0,0,0,0,0,0,0,0,0,0,0,2,
dc.b 17,128,0,2,18,128,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,2,
dc.b 19,0,0,0,0,0,0,2,19,128,0,0,0,0,0,0,
dc.b 0,2,20,0,0,0,0,0,0,2,20,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,2,17,130,21,2,21,128,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,2,22,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,2,22,128,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,2,23,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,2,23,128,0,2,24,2,
dc.b 24,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,2,25,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,2,25,128,
dc.b 0,2,26,0,0,2,26,128,0,2,27,0,0,0,0,0,
dc.b 0,2,27,128,0,0,0,0,0,2,28,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,2,28,130,29,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,2,29,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,2,30,0,0,0,
dc.b 0,2,30,128,0,2,31,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,2,31,128,0,2,32,2,
dc.b 32,128,0,0,0,0,0,0,0,0,0,0,0,0,0,2,
dc.b 32,0,0,2,33,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,2,
dc.b 33,128,0,0,0,0,0,2,34,0,0,0,0,0,0,0,
dc.b 0,2,34,128,0,0,0,0,0,2,35,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,2,32,2,35,130,36,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,2,36,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,2,37,0,
dc.b 0,0,0,2,37,128,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,2,23,128,0,2,24,2,
dc.b 24,128,0,0,0,0,0,0,0,0,0,0,0,0,0,2,
dc.b 24,0,0,2,25,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,2,25,128,
dc.b 0,2,26,0,0,2,26,128,0,2,27,0,0,0,0,0,
dc.b 0,2,27,128,0,0,0,0,0,2,28,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,2,24,2,28,130,29,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,2,29,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,2,
dc.b 30,2,30,128,0,2,31,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,2,38,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,2,38,128,0,2,39,2,
dc.b 39,128,0,2,40,0,0,0,0,0,0,0,0,0,0,2,
dc.b 39,0,0,0,0,0,0,0,0,2,40,128,0,2,41,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,2,41,128,
dc.b 0,0,0,0,0,0,0,0,0,2,42,2,42,128,0,0,
dc.b 0,2,43,0,0,0,0,0,0,0,0,2,43,128,0,0,
dc.b 0,0,0,0,0,0,0,2,39,0,0,0,0,0,0,0,
dc.b 0,2,44,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,2,
dc.b 44,130,45,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,2,45,128,0,0,0,0,0,0,0,2,46,0,0,2,
dc.b 46,2,46,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,2,47,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,2,47,128,0,2,48,2,
dc.b 48,128,0,2,49,0,0,0,0,0,0,0,0,0,0,2,
dc.b 48,0,0,0,0,0,0,0,0,2,49,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,2,50,2,
dc.b 50,128,0,0,0,0,0,2,51,2,51,130,52,0,0,0,
dc.b 0,2,52,128,0,0,0,0,0,0,0,2,53,0,0,0,
dc.b 0,0,0,0,0,0,0,2,48,0,0,0,0,0,0,0,
dc.b 0,2,53,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,2,
dc.b 54,2,54,128,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,2,55,0,0,0,0,0,0,0,0,2,55,128,
dc.b 0,0,0,2,56,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,2,56,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,2,57,0,0,2,57,130,
dc.b 58,0,0,2,58,128,0,0,0,0,0,0,0,0,0,2,
dc.b 57,128,0,0,0,0,0,0,0,2,59,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,2,
dc.b 59,130,60,0,0,2,60,130,61,0,0,2,61,128,0,0,
dc.b 0,2,62,0,0,0,0,0,0,0,0,2,62,128,0,0,
dc.b 0,0,0,0,0,0,0,2,57,128,0,0,0,0,0,0,
dc.b 0,2,63,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,2,
dc.b 63,130,64,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,2,64,128,0,0,0,2,65,0,0,2,
dc.b 65,0,0,0,0,2,65,128,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,2,66,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,2,66,128,0,2,67,2,
dc.b 67,128,0,2,68,0,0,0,0,0,0,0,0,0,0,2,
dc.b 67,0,0,0,0,0,0,0,0,2,68,128,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,2,69,2,69,130,70,0,0,0,0,2,70,128,0,0,
dc.b 0,2,71,0,0,0,0,0,0,0,0,2,71,128,0,0,
dc.b 0,0,0,0,0,0,0,2,67,0,0,0,0,0,0,0,
dc.b 0,2,72,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,2,
dc.b 72,130,73,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,2,73,130,74,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,2,74,128,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
dc.b 0,0,
export ani_duo_blocks
TEXT
; D0 = game animatie counter x4
; A3 = duo_block table
; A5 = return adres
fixes:
dc.l fixa, fixb, fixc, fixd, fixe, fixf, fixg, fixh
dc.l fixi, fixj, fixk, fixl, fixm, fixn, fixo, fixp
ani_duo_blocks:
     move.l fixes(pc,d0.w),a4
     move.l (a4)+,1084(a3)
     move.l (a4)+,1248(a3)
     move.l (a4)+,1264(a3)
     move.l (a4)+,1340(a3)
     move.l (a4)+,1520(a3)
     move.l (a4)+,2876(a3)
     move.l (a4)+,3056(a3)
     move.l (a4)+,3644(a3)
     move.l (a4)+,3808(a3)
     move.l (a4)+,3824(a3)
     move.l (a4)+,3900(a3)
     move.l (a4)+,4064(a3)
     move.l (a4)+,4080(a3)
     move.l (a4)+,4156(a3)
     move.l (a4)+,4336(a3)
     move.l (a4)+,5948(a3)
     move.l (a4)+,6112(a3)
     move.l (a4)+,6128(a3)
     move.l (a4)+,6624(a3)
     move.l (a4)+,6972(a3)
     move.l (a4)+,7152(a3)
     move.l (a4)+,7228(a3)
     move.l (a4)+,7408(a3)
     move.l (a4)+,7688(a3)
     move.l (a4)+,7704(a3)
     move.l (a4)+,7708(a3)
     move.l (a4)+,7712(a3)
     move.w (a4)+,7716(a3)
     move.l (a4)+,7726(a3)
     move.w (a4)+,7730(a3)
     move.l (a4)+,7740(a3)
     move.l (a4)+,7772(a3)
     move.l (a4)+,7776(a3)
     move.l (a4)+,7798(a3)
     move.l (a4)+,7802(a3)
     move.l (a4)+,7838(a3)
     move.w (a4)+,7842(a3)
     move.l (a4)+,7858(a3)
     move.l (a4)+,7904(a3)
     move.l (a4)+,7920(a3)
     move.l (a4)+,9968(a3)
     move.l (a4)+,10720(a3)
     move.l (a4)+,11504(a3)
     move.l (a4)+,11744(a3)
     move.l (a4)+,11760(a3)
     move.l (a4)+,11836(a3)
     move.l (a4)+,12604(a3)
     move.l (a4)+,12860(a3)
     move.l (a4)+,13552(a3)
     move.l (a4)+,13628(a3)
     move.l (a4)+,14908(a3)
     move.l (a4)+,15088(a3)
     move.l (a4)+,15164(a3)
     move.l (a4)+,15328(a3)
     move.l (a4)+,15344(a3)
     move.l (a4)+,15420(a3)
     move.l (a4)+,17392(a3)
     move.l (a4)+,17724(a3)
     move.l (a4)+,21052(a3)
     move.l (a4)+,21216(a3)
     move.l (a4)+,21232(a3)
     move.l (a4)+,21308(a3)
     move.l (a4)+,21984(a3)
     move.l (a4)+,28696(a3)
     move.l (a4)+,28700(a3)
     move.w (a4)+,28704(a3)
     move.l (a4)+,28718(a3)
     move.l (a4)+,28722(a3)
     move.l (a4)+,28732(a3)
     move.l (a4)+,28754(a3)
     move.l (a4)+,28768(a3)
     move.l (a4)+,28776(a3)
     move.l (a4)+,28790(a3)
     move.l (a4)+,28794(a3)
     move.l (a4)+,28832(a3)
     move.l (a4)+,28896(a3)
     move.l (a4)+,28912(a3)
     move.l (a4)+,28918(a3)
     move.l (a4)+,30192(a3)
     move.l (a4)+,30704(a3)
     move.l (a4)+,30728(a3)
     move.l (a4)+,30744(a3)
     move.l (a4)+,30748(a3)
     move.l (a4)+,30752(a3)
     move.w (a4)+,30756(a3)
     move.l (a4)+,30766(a3)
     move.l (a4)+,30776(a3)
     move.l (a4)+,30780(a3)
     move.l (a4)+,30796(a3)
     move.l (a4)+,30808(a3)
     move.w (a4)+,30812(a3)
     move.l (a4)+,30816(a3)
     move.l (a4)+,30826(a3)
     move.l (a4)+,30838(a3)
     move.l (a4)+,30848(a3)
     move.l (a4)+,30878(a3)
     move.w (a4)+,30882(a3)
     move.l (a4)+,30944(a3)
     move.l (a4)+,30954(a3)
     move.l (a4)+,30958(a3)
     move.w (a4)+,30962(a3)
     move.l (a4)+,31712(a3)
     jmp (a5)

export fixa
DATA
EVEN
fixa: 

dc.b 0,0,31,0,0,0,47,0,48,128,49,128,57,128,58,0,
dc.b 0,0,75,0,0,0,93,0,0,0,100,0,0,0,118,128,
dc.b 0,0,139,0,140,128,141,128,0,0,145,128,0,0,152,0,
dc.b 153,128,154,128,57,128,58,0,0,0,75,0,0,0,118,128,
dc.b 0,0,139,0,140,128,141,128,0,0,176,0,0,0,182,0,
dc.b 0,0,189,0,0,0,192,128,0,0,199,0,0,0,206,0,
dc.b 0,0,206,128,0,0,207,0,207,128,0,0,208,0,0,0,
dc.b 207,0,208,128,0,0,209,0,0,0,209,128,0,0,210,0,
dc.b 0,0,207,0,210,128,211,0,0,0,211,128,212,0,0,0,
dc.b 212,128,0,0,213,0,0,0,213,128,237,0,237,128,0,1,
dc.b 7,128,34,1,34,129,0,1,43,1,44,129,45,129,0,1,
dc.b 49,0,0,1,59,0,0,1,70,0,0,1,86,1,0,1,
dc.b 90,0,57,128,58,0,0,0,75,0,0,0,118,128,0,0,
dc.b 139,0,140,128,141,128,0,1,104,0,0,1,136,129,0,1,
dc.b 140,0,0,1,173,0,0,1,177,129,179,1,180,1,0,1,
dc.b 184,0,0,1,192,1,0,2,2,0,0,2,2,130,3,0,
dc.b 0,2,2,128,0,2,3,128,0,2,4,0,0,2,4,128,
dc.b 0,2,5,0,0,2,5,128,0,2,2,130,6,2,6,128,
dc.b 0,2,7,0,0,2,7,128,0,2,8,0,0,2,8,128,
dc.b 0,2,30,128,30,2,30,128,0,2,38,0,0,2,38,128,
dc.b 0,2,39,2,39,128,0,2,40,0,0,2,39,0,0,2,
dc.b 40,128,0,2,41,0,0,2,41,128,0,2,42,2,42,128,
dc.b 0,2,43,0,0,2,43,128,0,2,39,0,0,2,44,0,
dc.b 0,2,44,130,45,0,0,2,45,128,0,2,46,0,0,2,
dc.b 46,2,46,128,0,2,73,130,

export fixb
DATA
EVEN
fixb: 

dc.b 0,0,33,0,0,0,47,128,48,128,50,0,57,128,60,128,
dc.b 0,0,75,128,0,0,93,128,0,0,100,128,0,0,120,128,
dc.b 0,0,139,128,140,128,142,0,0,0,146,0,0,0,152,128,
dc.b 153,128,155,0,57,128,60,128,0,0,75,128,0,0,120,128,
dc.b 0,0,139,128,140,128,142,0,0,0,176,128,0,0,182,128,
dc.b 0,0,189,128,0,0,193,0,0,0,199,128,0,0,229,128,
dc.b 0,0,230,0,0,0,230,128,231,0,0,0,231,128,0,0,
dc.b 230,128,232,0,0,0,232,128,0,0,233,0,0,0,233,128,
dc.b 0,0,230,128,234,0,234,128,0,0,235,0,235,128,0,0,
dc.b 236,0,0,0,236,128,237,0,238,0,237,0,238,0,0,0,
dc.b 0,0,34,1,35,1,0,1,43,129,44,129,46,1,0,1,
dc.b 49,128,0,1,59,128,0,1,70,128,0,1,86,129,0,1,
dc.b 90,128,57,128,60,128,0,0,75,128,0,0,120,128,0,0,
dc.b 139,128,140,128,142,0,0,1,104,128,0,1,137,1,0,1,
dc.b 140,128,0,1,173,128,0,1,178,1,179,1,180,129,0,1,
dc.b 184,128,0,1,192,129,0,2,9,0,0,2,9,130,10,0,
dc.b 0,2,9,128,0,2,10,128,0,2,11,0,11,128,0,2,
dc.b 0,2,13,0,0,2,13,128,0,2,9,130,14,2,14,128,
dc.b 0,2,15,0,0,2,15,130,0,2,16,2,0,2,16,128,
dc.b 0,0,0,0,30,0,0,0,0,2,47,0,0,2,47,128,
dc.b 0,2,48,2,48,128,0,2,49,0,0,2,48,0,0,2,
dc.b 49,128,0,2,50,0,0,2,50,2,51,2,51,130,52,0,
dc.b 0,2,52,128,0,2,53,0,0,2,48,0,0,2,53,128,
dc.b 0,2,54,2,54,128,0,2,55,2,0,0,0,2,55,128,
dc.b 0,2,56,2,0,2,74,2,

export fixc
DATA
EVEN
fixc: 

dc.b 0,0,33,128,0,0,48,0,48,128,50,128,57,128,61,0,
dc.b 0,0,76,0,0,0,94,0,0,0,101,0,0,0,121,0,
dc.b 0,0,140,0,140,128,142,128,0,0,146,128,0,0,153,0,
dc.b 153,128,155,128,57,128,61,0,0,0,76,0,0,0,121,0,
dc.b 0,0,140,0,140,128,142,128,0,0,177,0,0,0,183,0,
dc.b 0,0,190,0,0,0,193,128,0,0,200,0,0,0,238,128,
dc.b 0,0,239,0,0,0,239,128,240,0,0,0,240,128,0,0,
dc.b 239,128,241,0,0,0,241,128,0,0,242,0,0,0,242,128,
dc.b 0,0,239,128,243,0,243,128,0,0,244,0,244,128,0,0,
dc.b 245,0,0,0,245,128,0,0,247,0,237,0,0,0,0,0,
dc.b 0,0,34,0,0,1,0,1,44,1,44,129,46,129,0,1,
dc.b 50,0,0,1,60,0,0,1,71,0,0,1,87,1,0,1,
dc.b 91,0,57,128,61,0,0,0,76,0,0,0,121,0,0,0,
dc.b 140,0,140,128,142,128,0,1,105,0,0,1,137,129,0,1,
dc.b 141,0,0,1,174,0,0,1,178,129,179,1,181,1,0,1,
dc.b 185,0,0,1,193,1,0,2,17,0,0,2,17,130,18,0,
dc.b 0,2,17,128,0,2,18,128,0,2,19,0,0,0,0,0,
dc.b 0,2,20,0,0,2,20,128,0,2,17,130,21,2,21,128,
dc.b 0,2,22,0,0,2,22,128,0,2,23,0,23,0,0,0,
dc.b 0,2,31,0,30,2,31,0,0,2,56,128,0,2,57,0,
dc.b 0,2,57,130,58,0,0,2,58,128,0,2,57,128,0,2,
dc.b 59,0,0,2,59,128,0,0,0,2,61,0,0,2,61,128,
dc.b 0,2,62,0,0,2,62,128,0,2,57,128,0,2,63,0,
dc.b 0,2,63,130,64,0,0,2,64,128,0,2,65,0,0,2,
dc.b 65,2,65,128,0,0,0,2,

export fixd
DATA
EVEN
fixd: 

dc.b 0,0,34,0,0,0,47,128,48,128,51,0,57,128,61,128,
dc.b 0,0,76,128,0,0,94,128,0,0,101,128,0,0,121,128,
dc.b 0,0,139,128,140,128,143,0,0,0,147,0,0,0,152,128,
dc.b 153,128,156,0,57,128,61,128,0,0,76,128,0,0,121,128,
dc.b 0,0,139,128,140,128,143,0,0,0,176,128,0,0,183,128,
dc.b 0,0,190,128,0,0,194,0,0,0,200,128,0,0,247,128,
dc.b 0,0,248,0,0,0,248,128,249,0,0,0,249,128,0,0,
dc.b 248,128,250,0,0,0,250,128,0,0,251,0,0,0,251,128,
dc.b 0,0,248,128,252,0,252,128,0,0,253,0,253,128,0,0,
dc.b 254,0,0,0,254,128,255,1,0,0,237,0,0,0,0,0,
dc.b 0,0,34,0,0,1,0,1,43,129,44,129,47,1,0,1,
dc.b 50,128,0,1,60,128,0,1,71,128,0,1,87,129,0,1,
dc.b 91,128,57,128,61,128,0,0,76,128,0,0,121,128,0,0,
dc.b 139,128,140,128,143,0,0,1,105,128,0,1,138,1,0,1,
dc.b 141,128,0,1,174,128,0,1,178,1,179,1,181,129,0,1,
dc.b 185,128,0,1,192,129,0,2,9,0,0,2,9,130,10,0,
dc.b 0,2,9,128,0,2,10,128,0,2,11,128,11,128,0,2,
dc.b 0,2,13,0,0,2,13,128,0,2,9,130,14,2,14,128,
dc.b 0,2,15,0,0,2,15,130,0,2,16,130,0,2,16,128,
dc.b 0,0,0,0,30,0,0,0,0,2,66,0,0,2,66,128,
dc.b 0,2,67,2,67,128,0,2,68,0,0,2,67,0,0,2,
dc.b 68,128,0,2,69,0,0,0,0,0,0,0,0,2,70,128,
dc.b 0,2,71,0,0,2,71,128,0,2,67,0,0,2,72,0,
dc.b 0,2,72,130,73,0,0,2,74,2,0,0,0,0,0,0,
dc.b 0,2,74,128,0,2,74,2,

export fixe
DATA
EVEN
fixe: 

dc.b 0,0,34,128,0,0,47,0,48,128,51,0,57,128,62,0,
dc.b 0,0,76,128,0,0,95,0,0,0,101,128,0,0,122,0,
dc.b 0,0,139,0,140,128,143,0,0,0,147,128,0,0,152,0,
dc.b 153,128,156,0,57,128,62,0,0,0,76,128,0,0,122,0,
dc.b 0,0,139,0,140,128,143,0,0,0,176,0,0,0,184,0,
dc.b 0,0,190,128,0,0,194,128,0,0,200,128,0,1,0,128,
dc.b 0,1,1,0,0,1,1,129,2,0,0,1,2,128,0,1,
dc.b 1,129,3,0,0,1,3,128,0,1,4,0,0,1,4,128,
dc.b 0,1,1,129,5,1,5,128,0,1,6,1,6,128,0,1,
dc.b 7,0,0,1,7,128,0,1,8,0,237,0,0,0,0,1,
dc.b 7,128,34,0,0,1,0,1,43,1,44,129,47,1,0,1,
dc.b 51,0,0,1,61,0,0,1,72,0,0,1,87,129,0,1,
dc.b 92,0,57,128,62,0,0,0,76,128,0,0,122,0,0,0,
dc.b 139,0,140,128,143,0,0,1,106,0,0,1,138,1,0,1,
dc.b 142,0,0,1,175,0,0,1,177,129,179,1,181,129,0,1,
dc.b 186,0,0,1,192,1,0,2,2,0,0,2,2,130,3,0,
dc.b 0,2,2,128,0,2,3,128,0,2,4,128,0,2,4,128,
dc.b 0,2,5,0,0,2,5,128,0,2,2,130,6,2,6,128,
dc.b 0,2,7,0,0,2,7,128,0,2,8,128,0,2,8,128,
dc.b 0,0,0,0,30,0,0,0,0,2,66,0,0,2,66,128,
dc.b 0,2,67,2,67,128,0,2,68,0,0,2,67,0,0,2,
dc.b 68,128,0,2,69,128,0,0,0,0,0,0,0,2,70,128,
dc.b 0,2,71,0,0,2,71,128,0,2,67,0,0,2,72,0,
dc.b 0,2,72,130,73,0,0,2,73,130,0,0,0,0,0,0,
dc.b 0,2,74,128,0,2,73,130,

export fixf
DATA
EVEN
fixf: 

dc.b 0,0,35,0,0,0,48,128,48,128,50,128,57,128,62,128,
dc.b 0,0,76,0,0,0,95,128,0,0,101,0,0,0,122,128,
dc.b 0,0,140,128,140,128,142,128,0,0,148,0,0,0,153,128,
dc.b 153,128,155,128,57,128,62,128,0,0,76,0,0,0,122,128,
dc.b 0,0,140,128,140,128,142,128,0,0,177,128,0,0,184,128,
dc.b 0,0,190,0,0,0,195,0,0,0,200,0,0,1,8,128,
dc.b 0,1,9,0,0,1,9,129,10,0,0,1,10,128,0,1,
dc.b 9,129,11,0,0,1,11,128,0,1,12,0,0,1,12,128,
dc.b 0,1,9,129,13,1,13,128,0,1,14,1,14,128,0,1,
dc.b 15,0,0,1,16,1,16,1,16,128,237,0,0,0,0,0,
dc.b 0,0,34,0,0,1,0,1,44,129,44,129,46,129,0,1,
dc.b 51,128,0,1,61,128,0,1,72,128,0,1,87,1,0,1,
dc.b 92,128,57,128,62,128,0,0,76,0,0,0,122,128,0,0,
dc.b 140,128,140,128,142,128,0,1,106,128,0,1,137,129,0,1,
dc.b 142,128,0,1,175,128,0,1,179,1,179,1,181,1,0,1,
dc.b 186,128,0,1,193,129,0,2,23,128,0,2,24,2,24,128,
dc.b 0,2,24,0,0,2,25,0,0,2,26,128,26,0,0,2,
dc.b 0,2,27,128,0,2,28,0,0,2,24,2,28,130,29,0,
dc.b 0,2,29,128,0,2,30,0,30,2,31,0,31,0,0,0,
dc.b 0,2,31,0,30,2,31,0,0,2,56,128,0,2,57,0,
dc.b 0,2,57,130,58,0,0,2,58,128,0,2,57,128,0,2,
dc.b 59,0,0,2,60,128,0,0,0,2,61,0,0,2,61,128,
dc.b 0,2,62,0,0,2,62,128,0,2,57,128,0,2,63,0,
dc.b 0,2,63,130,64,0,0,2,65,0,0,2,65,0,0,2,
dc.b 65,2,65,128,0,0,0,2,

export fixg
DATA
EVEN
fixg: 

dc.b 0,0,35,128,0,0,49,0,48,128,50,0,57,128,63,0,
dc.b 0,0,75,128,0,0,96,0,0,0,100,128,0,0,123,0,
dc.b 0,0,141,0,140,128,142,0,0,0,148,128,0,0,154,0,
dc.b 153,128,155,0,57,128,63,0,0,0,75,128,0,0,123,0,
dc.b 0,0,141,0,140,128,142,0,0,0,178,0,0,0,185,0,
dc.b 0,0,189,128,0,0,195,128,0,0,199,128,0,1,17,128,
dc.b 0,1,18,0,0,1,18,129,19,0,0,1,19,128,0,1,
dc.b 18,129,20,0,0,1,20,128,0,1,21,0,0,1,21,128,
dc.b 0,1,18,129,22,1,22,128,0,1,23,1,23,128,0,1,
dc.b 24,0,0,1,25,0,0,1,25,129,237,0,238,0,0,0,
dc.b 0,0,34,1,35,1,0,1,45,1,44,129,46,1,0,1,
dc.b 52,0,0,1,62,0,0,1,73,0,0,1,86,129,0,1,
dc.b 93,0,57,128,63,0,0,0,75,128,0,0,123,0,0,0,
dc.b 141,0,140,128,142,0,0,1,107,0,0,1,137,1,0,1,
dc.b 143,0,0,1,176,0,0,1,179,129,179,1,180,129,0,1,
dc.b 187,0,0,1,194,1,0,2,31,128,0,2,32,2,32,128,
dc.b 0,2,32,0,0,2,33,0,0,2,34,0,0,0,0,0,
dc.b 0,2,34,128,0,2,35,0,0,2,32,2,35,130,36,0,
dc.b 0,2,36,128,0,2,37,0,0,2,37,130,0,0,0,0,
dc.b 0,0,0,0,30,0,0,0,0,2,47,0,0,2,47,128,
dc.b 0,2,48,2,48,128,0,2,49,0,0,2,48,0,0,2,
dc.b 49,128,0,2,51,0,0,2,50,2,51,2,51,130,52,0,
dc.b 0,2,52,128,0,2,53,0,0,2,48,0,0,2,53,128,
dc.b 0,2,54,2,54,128,0,2,55,130,0,0,0,2,55,128,
dc.b 0,2,56,2,0,0,0,2,

export fixh
DATA
EVEN
fixh: 

dc.b 0,0,36,0,0,0,48,128,48,128,49,128,57,128,63,128,
dc.b 0,0,75,0,0,0,96,128,0,0,100,0,0,0,123,128,
dc.b 0,0,140,128,140,128,141,128,0,0,149,0,0,0,153,128,
dc.b 153,128,154,128,57,128,63,128,0,0,75,0,0,0,123,128,
dc.b 0,0,140,128,140,128,141,128,0,0,177,128,0,0,185,128,
dc.b 0,0,189,0,0,0,196,0,0,0,199,0,0,1,26,128,
dc.b 0,1,27,0,0,1,27,129,28,0,0,1,28,128,0,1,
dc.b 27,129,29,0,0,1,29,128,0,1,30,0,0,1,30,128,
dc.b 0,1,27,129,31,1,31,128,0,1,32,1,32,128,0,1,
dc.b 33,0,0,1,34,1,34,1,34,129,237,0,237,128,0,0,
dc.b 0,0,34,1,34,129,0,1,44,129,44,129,45,129,0,1,
dc.b 52,128,0,1,62,128,0,1,73,128,0,1,86,1,0,1,
dc.b 93,128,57,128,63,128,0,0,75,0,0,0,123,128,0,0,
dc.b 140,128,140,128,141,128,0,1,107,128,0,1,136,129,0,1,
dc.b 143,128,0,1,176,128,0,1,179,1,179,1,180,1,0,1,
dc.b 187,128,0,1,193,129,0,2,23,128,0,2,24,2,24,128,
dc.b 0,2,24,0,0,2,25,0,0,2,27,0,26,0,0,2,
dc.b 0,2,27,128,0,2,28,0,0,2,24,2,28,130,29,0,
dc.b 0,2,29,128,0,2,30,0,30,2,30,128,31,0,0,0,
dc.b 0,2,30,128,30,2,30,128,0,2,38,0,0,2,38,128,
dc.b 0,2,39,2,39,128,0,2,40,0,0,2,39,0,0,2,
dc.b 40,128,0,2,42,0,0,2,41,128,0,2,42,2,42,128,
dc.b 0,2,43,0,0,2,43,128,0,2,39,0,0,2,44,0,
dc.b 0,2,44,130,45,0,0,2,46,0,0,2,46,0,0,2,
dc.b 46,2,46,128,0,0,0,2,

export fixi
DATA
EVEN
fixi: 

dc.b 0,0,27,128,0,0,47,0,48,128,49,128,57,128,56,0,
dc.b 0,0,75,0,0,0,92,0,0,0,100,0,0,0,113,128,
dc.b 0,0,139,0,140,128,141,128,0,0,144,0,0,0,152,0,
dc.b 153,128,154,128,57,128,56,0,0,0,75,0,0,0,113,128,
dc.b 0,0,139,0,140,128,141,128,0,0,176,0,0,0,180,0,
dc.b 0,0,189,0,0,0,191,0,0,0,199,0,0,0,111,0,
dc.b 0,0,113,0,0,0,113,128,114,0,111,128,114,128,116,0,
dc.b 113,128,116,128,0,0,113,128,124,0,124,128,125,0,125,128,
dc.b 111,128,113,128,129,0,129,128,0,0,134,0,134,128,136,128,
dc.b 137,0,0,0,139,0,140,128,141,128,237,0,237,128,0,1,
dc.b 7,128,34,1,34,129,0,1,43,1,44,129,45,129,0,1,
dc.b 48,0,0,1,58,0,0,1,69,128,0,1,86,1,0,1,
dc.b 88,0,57,128,56,0,0,0,75,0,0,0,113,128,0,0,
dc.b 139,0,140,128,141,128,0,1,102,0,0,1,136,129,0,1,
dc.b 139,0,0,1,171,0,0,1,177,129,179,1,180,1,0,1,
dc.b 183,0,0,1,192,1,0,2,2,0,0,2,2,130,3,0,
dc.b 0,2,2,128,0,2,3,128,0,2,2,128,0,2,4,128,
dc.b 0,2,5,0,0,2,5,128,0,2,2,130,6,2,6,128,
dc.b 0,2,7,0,0,2,7,128,0,2,8,0,0,2,8,128,
dc.b 0,2,30,128,30,2,30,128,0,2,38,0,0,2,38,128,
dc.b 0,2,39,2,39,128,0,2,40,0,0,2,39,0,0,2,
dc.b 40,128,0,2,39,0,0,2,41,128,0,2,42,2,42,128,
dc.b 0,2,43,0,0,2,43,128,0,2,39,0,0,2,44,0,
dc.b 0,2,44,130,45,0,0,2,45,128,0,2,46,0,0,2,
dc.b 46,2,46,128,0,2,73,130,

export fixj
DATA
EVEN
fixj: 

dc.b 0,0,36,0,0,0,47,128,48,128,50,0,57,128,63,128,
dc.b 0,0,75,128,0,0,96,128,0,0,100,128,0,0,123,128,
dc.b 0,0,139,128,140,128,142,0,0,0,149,0,0,0,152,128,
dc.b 153,128,155,0,57,128,63,128,0,0,75,128,0,0,123,128,
dc.b 0,0,139,128,140,128,142,0,0,0,176,128,0,0,185,128,
dc.b 0,0,189,128,0,0,196,0,0,0,199,128,0,1,26,128,
dc.b 0,1,27,0,0,1,27,129,28,0,0,1,28,128,0,1,
dc.b 27,129,29,0,0,1,29,128,0,1,30,0,0,1,30,128,
dc.b 0,1,27,129,31,1,31,128,0,1,32,1,32,128,0,1,
dc.b 33,0,0,1,33,129,34,1,35,1,237,0,238,0,0,0,
dc.b 0,0,34,1,35,1,0,1,43,129,44,129,46,1,0,1,
dc.b 52,128,0,1,62,128,0,1,73,128,0,1,86,129,0,1,
dc.b 93,128,57,128,63,128,0,0,75,128,0,0,123,128,0,0,
dc.b 139,128,140,128,142,0,0,1,107,128,0,1,137,1,0,1,
dc.b 143,128,0,1,176,128,0,1,178,1,179,1,180,129,0,1,
dc.b 187,128,0,1,192,129,0,2,9,0,0,2,9,130,10,0,
dc.b 0,2,9,128,0,2,10,128,0,2,12,128,11,128,0,2,
dc.b 0,2,13,0,0,2,13,128,0,2,9,130,14,2,14,128,
dc.b 0,2,15,0,0,2,15,130,0,2,16,2,0,2,16,128,
dc.b 0,0,0,0,30,0,0,0,0,2,47,0,0,2,47,128,
dc.b 0,2,48,2,48,128,0,2,49,0,0,2,48,0,0,2,
dc.b 49,128,0,2,51,128,0,2,50,2,51,2,51,130,52,0,
dc.b 0,2,52,128,0,2,53,0,0,2,48,0,0,2,53,128,
dc.b 0,2,54,2,54,128,0,2,55,2,0,0,0,2,55,128,
dc.b 0,2,56,2,0,2,74,2,

export fixk
DATA
EVEN
fixk: 

dc.b 0,0,35,128,0,0,48,0,48,128,50,128,57,128,63,0,
dc.b 0,0,76,0,0,0,96,0,0,0,101,0,0,0,123,0,
dc.b 0,0,140,0,140,128,142,128,0,0,148,128,0,0,153,0,
dc.b 153,128,155,128,57,128,63,0,0,0,76,0,0,0,123,0,
dc.b 0,0,140,0,140,128,142,128,0,0,177,0,0,0,185,0,
dc.b 0,0,190,0,0,0,195,128,0,0,200,0,0,1,17,128,
dc.b 0,1,18,0,0,1,18,129,19,0,0,1,19,128,0,1,
dc.b 18,129,20,0,0,1,20,128,0,1,21,0,0,1,21,128,
dc.b 0,1,18,129,22,1,22,128,0,1,23,1,23,128,0,1,
dc.b 24,0,0,1,24,128,0,1,26,1,237,0,0,0,0,0,
dc.b 0,0,34,0,0,1,0,1,44,1,44,129,46,129,0,1,
dc.b 52,0,0,1,62,0,0,1,73,0,0,1,87,1,0,1,
dc.b 93,0,57,128,63,0,0,0,76,0,0,0,123,0,0,0,
dc.b 140,0,140,128,142,128,0,1,107,0,0,1,137,129,0,1,
dc.b 143,0,0,1,176,0,0,1,178,129,179,1,181,1,0,1,
dc.b 187,0,0,1,193,1,0,2,17,0,0,2,17,130,18,0,
dc.b 0,2,17,128,0,2,18,128,0,2,19,128,0,0,0,0,
dc.b 0,2,20,0,0,2,20,128,0,2,17,130,21,2,21,128,
dc.b 0,2,22,0,0,2,22,128,0,2,23,0,23,0,0,0,
dc.b 0,2,31,0,30,2,31,0,0,2,56,128,0,2,57,0,
dc.b 0,2,57,130,58,0,0,2,58,128,0,2,57,128,0,2,
dc.b 59,0,0,2,61,0,0,0,0,2,61,0,0,2,61,128,
dc.b 0,2,62,0,0,2,62,128,0,2,57,128,0,2,63,0,
dc.b 0,2,63,130,64,0,0,2,64,128,0,2,65,0,0,2,
dc.b 65,2,65,128,0,0,0,2,

export fixl
DATA
EVEN
fixl: 

dc.b 0,0,35,0,0,0,47,128,48,128,51,0,57,128,62,128,
dc.b 0,0,76,128,0,0,95,128,0,0,101,128,0,0,122,128,
dc.b 0,0,139,128,140,128,143,0,0,0,148,0,0,0,152,128,
dc.b 153,128,156,0,57,128,62,128,0,0,76,128,0,0,122,128,
dc.b 0,0,139,128,140,128,143,0,0,0,176,128,0,0,184,128,
dc.b 0,0,190,128,0,0,195,0,0,0,200,128,0,1,8,128,
dc.b 0,1,9,0,0,1,9,129,10,0,0,1,10,128,0,1,
dc.b 9,129,11,0,0,1,11,128,0,1,12,0,0,1,12,128,
dc.b 0,1,9,129,13,1,13,128,0,1,14,1,14,128,0,1,
dc.b 15,0,0,1,15,129,16,1,17,0,237,0,0,0,0,0,
dc.b 0,0,34,0,0,1,0,1,43,129,44,129,47,1,0,1,
dc.b 51,128,0,1,61,128,0,1,72,128,0,1,87,129,0,1,
dc.b 92,128,57,128,62,128,0,0,76,128,0,0,122,128,0,0,
dc.b 139,128,140,128,143,0,0,1,106,128,0,1,138,1,0,1,
dc.b 142,128,0,1,175,128,0,1,178,1,179,1,181,129,0,1,
dc.b 186,128,0,1,192,129,0,2,9,0,0,2,9,130,10,0,
dc.b 0,2,9,128,0,2,10,128,0,2,12,0,11,128,0,2,
dc.b 0,2,13,0,0,2,13,128,0,2,9,130,14,2,14,128,
dc.b 0,2,15,0,0,2,15,130,0,2,16,130,0,2,16,128,
dc.b 0,0,0,0,30,0,0,0,0,2,66,0,0,2,66,128,
dc.b 0,2,67,2,67,128,0,2,68,0,0,2,67,0,0,2,
dc.b 68,128,0,2,70,0,0,0,0,0,0,0,0,2,70,128,
dc.b 0,2,71,0,0,2,71,128,0,2,67,0,0,2,72,0,
dc.b 0,2,72,130,73,0,0,2,74,2,0,0,0,0,0,0,
dc.b 0,2,74,128,0,2,74,2,

export fixm
DATA
EVEN
fixm: 

dc.b 0,0,34,128,0,0,47,0,48,128,51,0,57,128,62,0,
dc.b 0,0,76,128,0,0,95,0,0,0,101,128,0,0,122,0,
dc.b 0,0,139,0,140,128,143,0,0,0,147,128,0,0,152,0,
dc.b 153,128,156,0,57,128,62,0,0,0,76,128,0,0,122,0,
dc.b 0,0,139,0,140,128,143,0,0,0,176,0,0,0,184,0,
dc.b 0,0,190,128,0,0,194,128,0,0,200,128,0,1,0,128,
dc.b 0,1,1,0,0,1,1,129,2,0,0,1,2,128,0,1,
dc.b 1,129,3,0,0,1,3,128,0,1,4,0,0,1,4,128,
dc.b 0,1,1,129,5,1,5,128,0,1,6,1,6,128,0,1,
dc.b 7,0,0,1,7,128,0,1,8,0,237,0,0,0,0,1,
dc.b 7,128,34,0,0,1,0,1,43,1,44,129,47,1,0,1,
dc.b 51,0,0,1,61,0,0,1,72,0,0,1,87,129,0,1,
dc.b 92,0,57,128,62,0,0,0,76,128,0,0,122,0,0,0,
dc.b 139,0,140,128,143,0,0,1,106,0,0,1,138,1,0,1,
dc.b 142,0,0,1,175,0,0,1,177,129,179,1,181,129,0,1,
dc.b 186,0,0,1,192,1,0,2,2,0,0,2,2,130,3,0,
dc.b 0,2,2,128,0,2,3,128,0,2,4,128,0,2,4,128,
dc.b 0,2,5,0,0,2,5,128,0,2,2,130,6,2,6,128,
dc.b 0,2,7,0,0,2,7,128,0,2,8,128,0,2,8,128,
dc.b 0,0,0,0,30,0,0,0,0,2,66,0,0,2,66,128,
dc.b 0,2,67,2,67,128,0,2,68,0,0,2,67,0,0,2,
dc.b 68,128,0,2,69,128,0,0,0,0,0,0,0,2,70,128,
dc.b 0,2,71,0,0,2,71,128,0,2,67,0,0,2,72,0,
dc.b 0,2,72,130,73,0,0,2,73,130,0,0,0,0,0,0,
dc.b 0,2,74,128,0,2,73,130,

export fixn
DATA
EVEN
fixn: 

dc.b 0,0,34,0,0,0,48,128,48,128,50,128,57,128,61,128,
dc.b 0,0,76,0,0,0,94,128,0,0,101,0,0,0,121,128,
dc.b 0,0,140,128,140,128,142,128,0,0,147,0,0,0,153,128,
dc.b 153,128,155,128,57,128,61,128,0,0,76,0,0,0,121,128,
dc.b 0,0,140,128,140,128,142,128,0,0,177,128,0,0,183,128,
dc.b 0,0,190,0,0,0,194,0,0,0,200,0,0,0,247,128,
dc.b 0,0,248,0,0,0,248,128,249,0,0,0,249,128,0,0,
dc.b 248,128,250,0,0,0,250,128,0,0,251,0,0,0,251,128,
dc.b 0,0,248,128,252,0,252,128,0,0,253,0,253,128,0,0,
dc.b 254,0,0,0,255,0,255,0,255,128,237,0,0,0,0,0,
dc.b 0,0,34,0,0,1,0,1,44,129,44,129,46,129,0,1,
dc.b 50,128,0,1,60,128,0,1,71,128,0,1,87,1,0,1,
dc.b 91,128,57,128,61,128,0,0,76,0,0,0,121,128,0,0,
dc.b 140,128,140,128,142,128,0,1,105,128,0,1,137,129,0,1,
dc.b 141,128,0,1,174,128,0,1,179,1,179,1,181,1,0,1,
dc.b 185,128,0,1,193,129,0,2,23,128,0,2,24,2,24,128,
dc.b 0,2,24,0,0,2,25,0,0,2,26,0,26,0,0,2,
dc.b 0,2,27,128,0,2,28,0,0,2,24,2,28,130,29,0,
dc.b 0,2,29,128,0,2,30,0,30,2,31,0,31,0,0,0,
dc.b 0,2,31,0,30,2,31,0,0,2,56,128,0,2,57,0,
dc.b 0,2,57,130,58,0,0,2,58,128,0,2,57,128,0,2,
dc.b 59,0,0,2,60,0,0,0,0,2,61,0,0,2,61,128,
dc.b 0,2,62,0,0,2,62,128,0,2,57,128,0,2,63,0,
dc.b 0,2,63,130,64,0,0,2,65,0,0,2,65,0,0,2,
dc.b 65,2,65,128,0,0,0,2,

export fixo
DATA
EVEN
fixo: 

dc.b 0,0,33,128,0,0,49,0,48,128,50,0,57,128,61,0,
dc.b 0,0,75,128,0,0,94,0,0,0,100,128,0,0,121,0,
dc.b 0,0,141,0,140,128,142,0,0,0,146,128,0,0,154,0,
dc.b 153,128,155,0,57,128,61,0,0,0,75,128,0,0,121,0,
dc.b 0,0,141,0,140,128,142,0,0,0,178,0,0,0,183,0,
dc.b 0,0,189,128,0,0,193,128,0,0,199,128,0,0,238,128,
dc.b 0,0,239,0,0,0,239,128,240,0,0,0,240,128,0,0,
dc.b 239,128,241,0,0,0,241,128,0,0,242,0,0,0,242,128,
dc.b 0,0,239,128,243,0,243,128,0,0,244,0,244,128,0,0,
dc.b 245,0,0,0,246,0,0,0,246,128,237,0,238,0,0,0,
dc.b 0,0,34,1,35,1,0,1,45,1,44,129,46,1,0,1,
dc.b 50,0,0,1,60,0,0,1,71,0,0,1,86,129,0,1,
dc.b 91,0,57,128,61,0,0,0,75,128,0,0,121,0,0,0,
dc.b 141,0,140,128,142,0,0,1,105,0,0,1,137,1,0,1,
dc.b 141,0,0,1,174,0,0,1,179,129,179,1,180,129,0,1,
dc.b 185,0,0,1,194,1,0,2,31,128,0,2,32,2,32,128,
dc.b 0,2,32,0,0,2,33,0,0,2,33,128,0,0,0,0,
dc.b 0,2,34,128,0,2,35,0,0,2,32,2,35,130,36,0,
dc.b 0,2,36,128,0,2,37,0,0,2,37,130,0,0,0,0,
dc.b 0,0,0,0,30,0,0,0,0,2,47,0,0,2,47,128,
dc.b 0,2,48,2,48,128,0,2,49,0,0,2,48,0,0,2,
dc.b 49,128,0,2,50,128,0,2,50,2,51,2,51,130,52,0,
dc.b 0,2,52,128,0,2,53,0,0,2,48,0,0,2,53,128,
dc.b 0,2,54,2,54,128,0,2,55,130,0,0,0,2,55,128,
dc.b 0,2,56,2,0,0,0,2,

export fixp
DATA
EVEN
fixp: 

dc.b 0,0,33,0,0,0,48,128,48,128,49,128,57,128,60,128,
dc.b 0,0,75,0,0,0,93,128,0,0,100,0,0,0,120,128,
dc.b 0,0,140,128,140,128,141,128,0,0,146,0,0,0,153,128,
dc.b 153,128,154,128,57,128,60,128,0,0,75,0,0,0,120,128,
dc.b 0,0,140,128,140,128,141,128,0,0,177,128,0,0,182,128,
dc.b 0,0,189,0,0,0,193,0,0,0,199,0,0,0,229,128,
dc.b 0,0,230,0,0,0,230,128,231,0,0,0,231,128,0,0,
dc.b 230,128,232,0,0,0,232,128,0,0,233,0,0,0,233,128,
dc.b 0,0,230,128,234,0,234,128,0,0,235,0,235,128,0,0,
dc.b 236,0,0,0,237,0,237,0,237,128,237,0,237,128,0,0,
dc.b 0,0,34,1,34,129,0,1,44,129,44,129,45,129,0,1,
dc.b 49,128,0,1,59,128,0,1,70,128,0,1,86,1,0,1,
dc.b 90,128,57,128,60,128,0,0,75,0,0,0,120,128,0,0,
dc.b 140,128,140,128,141,128,0,1,104,128,0,1,136,129,0,1,
dc.b 140,128,0,1,173,128,0,1,179,1,179,1,180,1,0,1,
dc.b 184,128,0,1,193,129,0,2,23,128,0,2,24,2,24,128,
dc.b 0,2,24,0,0,2,25,0,0,2,25,128,26,0,0,2,
dc.b 0,2,27,128,0,2,28,0,0,2,24,2,28,130,29,0,
dc.b 0,2,29,128,0,2,30,0,30,2,30,128,31,0,0,0,
dc.b 0,2,30,128,30,2,30,128,0,2,38,0,0,2,38,128,
dc.b 0,2,39,2,39,128,0,2,40,0,0,2,39,0,0,2,
dc.b 40,128,0,2,41,128,0,2,41,128,0,2,42,2,42,128,
dc.b 0,2,43,0,0,2,43,128,0,2,39,0,0,2,44,0,
dc.b 0,2,44,130,45,0,0,2,46,0,0,2,46,0,0,2,
dc.b 46,2,46,128,0,0,0,2,
