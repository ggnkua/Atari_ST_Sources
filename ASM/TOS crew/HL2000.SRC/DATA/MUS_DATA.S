;
; file generated by: F:\HL001128\DATA\MUSICS.C
;

DATA
EXPORT ploing, ploing_end
ploing: 
dc.b 70,5,81,1,67,5,11,250,13,0,13,84,0,0,168,0,171,0,171,0,11,248,14,14,14,84,0,0,167,0,170,0,
dc.b 173,0,11,248,14,14,14,84,0,0,166,0,169,0,175,0,11,248,14,14,14,84,0,0,165,0,168,0,177,0,11,248,
dc.b 14,14,14,84,0,0,164,0,167,0,173,0,11,248,14,14,14,84,0,0,163,0,166,0,169,0,11,248,14,14,14,84,
dc.b 0,0,162,0,165,0,165,0,11,248,14,14,14,84,0,0,161,0,164,0,161,0,11,248,13,13,13,84,0,0,160,0,
dc.b 163,0,163,0,11,248,13,13,13,84,0,0,159,0,162,0,165,0,11,248,13,13,13,84,0,0,158,0,161,0,167,0,
dc.b 11,248,13,13,13,84,0,0,157,0,160,0,169,0,11,248,12,12,13,84,0,0,156,0,159,0,165,0,11,248,12,12,
dc.b 13,84,0,0,155,0,158,0,161,0,11,248,12,12,13,84,0,0,154,0,157,0,157,0,11,248,12,12,13,84,0,0,
dc.b 153,0,156,0,153,0,11,248,11,11,12,84,0,0,152,0,155,0,155,0,11,248,11,11,12,84,0,0,151,0,154,0,
dc.b 157,0,11,248,11,11,12,84,0,0,150,0,153,0,159,0,11,248,11,11,12,84,0,0,149,0,152,0,161,0,11,248,
dc.b 10,10,12,84,0,0,148,0,151,0,157,0,11,248,10,10,12,84,0,0,147,0,150,0,153,0,11,248,10,10,12,84,
dc.b 0,0,146,0,149,0,149,0,11,248,10,10,12,84,0,0,145,0,148,0,145,0,11,248,9,9,11,84,0,0,144,0,
dc.b 147,0,147,0,11,248,9,9,11,84,0,0,143,0,146,0,149,0,11,248,9,9,11,84,0,0,142,0,145,0,151,0,
dc.b 11,248,9,9,11,84,0,0,141,0,144,0,153,0,11,248,8,8,11,84,0,0,140,0,143,0,149,0,11,248,8,8,
dc.b 11,84,0,0,139,0,142,0,145,0,11,248,8,8,11,84,0,0,138,0,141,0,141,0,11,248,8,8,11,84,0,0,
dc.b 137,0,140,0,137,0,11,248,7,7,10,84,0,0,136,0,139,0,139,0,11,248,7,7,10,84,0,0,135,0,138,0,
dc.b 141,0,11,248,7,7,10,84,0,0,134,0,137,0,143,0,11,248,7,7,10,84,0,0,133,0,136,0,145,0,11,248,
dc.b 6,6,10,84,0,0,132,0,135,0,141,0,11,248,6,6,10,84,0,0,131,0,134,0,137,0,11,248,6,6,10,84,
dc.b 0,0,130,0,133,0,133,0,11,248,6,6,10,84,0,0,129,0,132,0,129,0,11,248,5,5,9,84,0,0,128,0,
dc.b 131,0,131,0,11,248,5,5,9,84,0,0,127,0,130,0,133,0,11,248,5,5,9,84,0,0,126,0,129,0,135,0,
dc.b 11,248,5,5,9,84,0,0,125,0,128,0,137,0,11,248,4,4,9,84,0,0,124,0,127,0,133,0,11,248,4,4,
dc.b 9,84,0,0,123,0,126,0,129,0,11,248,4,4,9,84,0,0,122,0,125,0,125,0,11,248,4,4,9,84,0,0,
dc.b 121,0,124,0,121,0,11,248,3,3,8,84,0,0,121,0,124,0,121,0,11,248,3,3,8,84,0,0,121,0,124,0,
dc.b 121,0,11,248,0,0,0,84,0,0,
ploing_end: 
EXPORT rinkel, rinkel_end
rinkel: 
dc.b 70,5,81,1,67,5,11,250,13,0,13,84,0,0,89,0,0,0,0,0,11,250,15,0,0,84,0,0,89,0,0,0,
dc.b 0,0,11,250,11,0,0,84,0,0,119,0,0,0,0,0,11,250,15,0,0,84,0,0,119,0,0,0,0,0,11,250,
dc.b 11,0,0,84,0,0,75,0,0,0,0,0,11,250,15,0,0,84,0,0,75,0,89,0,0,0,11,248,11,13,0,84,
dc.b 0,0,79,0,89,0,0,0,11,248,15,9,0,84,0,0,79,0,119,0,0,0,11,248,11,13,0,84,0,0,79,0,
dc.b 119,0,0,0,11,248,11,9,0,84,0,0,79,0,75,0,0,0,11,248,0,13,0,84,0,0,79,0,75,0,89,0,
dc.b 11,248,0,9,11,84,0,0,79,0,79,0,89,0,11,248,0,13,7,84,0,0,79,0,79,0,119,0,11,248,0,9,
dc.b 11,84,0,0,79,0,79,0,119,0,11,248,0,9,7,84,0,0,79,0,79,0,75,0,11,248,0,0,11,84,0,0,
dc.b 79,0,79,0,75,0,11,248,0,0,7,84,0,0,79,0,79,0,79,0,11,248,0,0,11,84,0,0,79,0,79,0,
dc.b 79,0,11,248,0,0,7,84,0,0,79,0,79,0,79,0,11,248,0,0,7,84,0,0,79,0,79,0,79,0,11,248,
dc.b 0,0,0,84,0,0,
rinkel_end: 
EXPORT ploef, ploef_end
ploef: 
dc.b 70,5,81,1,67,5,11,250,13,0,13,84,0,0,44,1,0,0,0,0,11,242,15,0,0,84,0,0,124,1,0,0,
dc.b 0,0,11,250,15,0,0,84,0,0,174,1,0,0,0,0,11,250,15,0,0,84,0,0,224,1,0,0,0,0,11,250,
dc.b 14,0,0,84,0,0,18,2,0,0,0,0,11,250,14,0,0,84,0,0,68,2,0,0,0,0,11,250,13,0,0,84,
dc.b 0,0,118,2,0,0,0,0,11,250,13,0,0,84,0,0,168,2,0,0,0,0,11,250,12,0,0,84,0,0,218,2,
dc.b 0,0,0,0,11,250,12,0,0,84,0,0,12,3,0,0,0,0,11,250,11,0,0,84,0,0,62,3,0,0,0,0,
dc.b 11,250,11,0,0,84,0,0,112,3,0,0,0,0,11,250,10,0,0,84,0,0,162,3,0,0,0,0,11,250,10,0,
dc.b 0,84,0,0,212,3,0,0,0,0,11,250,9,0,0,84,0,0,6,4,0,0,0,0,11,250,9,0,0,84,0,0,
dc.b 56,4,0,0,0,0,11,250,8,0,0,84,0,0,106,4,0,0,0,0,11,250,8,0,0,84,0,0,156,4,0,0,
dc.b 0,0,11,250,7,0,0,84,0,0,206,4,0,0,0,0,11,250,7,0,0,84,0,0,0,5,0,0,0,0,11,250,
dc.b 6,0,0,84,0,0,0,5,0,0,0,0,11,250,6,0,0,84,0,0,0,5,0,0,0,0,11,250,0,0,0,84,
dc.b 0,0,
ploef_end: 
EXPORT pjoew, pjoew_end
pjoew: 
dc.b 70,5,81,1,67,5,11,250,13,0,13,84,0,0,110,0,113,0,0,0,11,248,13,13,0,84,0,0,126,0,129,0,
dc.b 0,0,11,248,13,13,0,84,0,0,142,0,145,0,0,0,11,248,13,13,0,84,0,0,158,0,161,0,0,0,11,248,
dc.b 13,13,0,84,0,0,174,0,177,0,0,0,11,248,13,13,0,84,0,0,190,0,193,0,0,0,11,248,13,13,0,84,
dc.b 0,0,206,0,209,0,0,0,11,248,13,13,0,84,0,0,222,0,225,0,0,0,11,248,13,13,0,84,0,0,238,0,
dc.b 241,0,0,0,11,248,13,13,0,84,0,0,254,0,1,1,0,0,11,248,13,13,0,84,0,0,14,1,17,1,0,0,
dc.b 11,248,13,13,0,84,0,0,30,1,33,1,0,0,11,248,13,13,0,84,0,0,46,1,49,1,0,0,11,248,13,13,
dc.b 0,84,0,0,62,1,65,1,0,0,11,248,13,13,0,84,0,0,78,1,81,1,0,0,11,248,13,13,0,84,0,0,
dc.b 94,1,97,1,0,0,11,248,13,13,0,84,0,0,110,1,113,1,0,0,11,248,13,13,0,84,0,0,126,1,129,1,
dc.b 0,0,11,248,13,13,0,84,0,0,142,1,145,1,0,0,11,248,13,13,0,84,0,0,158,1,161,1,0,0,11,248,
dc.b 13,13,0,84,0,0,158,1,161,1,0,0,11,248,13,13,0,84,0,0,158,1,161,1,0,0,11,248,0,0,0,84,
dc.b 0,0,
pjoew_end: 
EXPORT card_pac, card_pac_end
card_pac: 
dc.b 2,95,99,113,162,198,163,255,27,169,114,180,225,118,5,103,12,8,48,169,86,245,42,240,216,159,194,6,5,102,204,5,
dc.b 192,120,105,128,41,11,208,99,214,197,18,221,244,214,23,0,95,99,21,192,87,55,236,24,87,230,14,35,248,1,16,205,
dc.b 57,47,125,252,191,10,251,121,106,187,211,71,167,231,70,143,85,232,247,253,170,237,90,52,63,47,159,243,46,179,42,23,
dc.b 39,248,189,39,201,233,254,151,189,95,188,250,191,90,180,195,47,159,215,247,150,133,107,126,84,46,117,73,145,122,126,144,
dc.b 249,59,242,226,95,170,247,170,248,158,25,111,248,93,107,161,249,80,185,23,62,69,223,5,225,242,112,134,112,202,193,79,
dc.b 97,61,204,38,104,94,229,73,145,119,193,115,10,123,34,167,176,83,216,38,115,63,42,23,34,247,33,98,159,51,242,226,
dc.b 91,69,61,164,247,80,153,161,116,170,76,139,190,11,168,83,219,21,61,162,158,209,51,169,249,80,185,23,74,22,41,245,
dc.b 63,46,37,231,125,255,23,223,154,159,240,167,202,41,242,147,222,209,51,66,246,42,76,139,190,11,218,41,242,197,79,148,
dc.b 83,229,19,61,175,202,133,200,189,136,88,167,237,20,249,115,212,255,61,79,253,242,242,47,191,145,115,124,203,211,66,235,
dc.b 92,249,23,124,23,204,190,252,75,106,185,21,63,200,168,62,111,202,133,210,170,208,178,167,249,149,63,200,83,218,41,237,
dc.b 19,56,84,26,23,90,233,66,197,61,245,63,18,220,41,238,39,190,162,102,133,244,85,121,23,124,23,212,83,221,21,61,
dc.b 194,158,225,51,234,252,168,93,107,232,133,138,127,81,79,118,117,63,243,83,251,197,63,121,61,208,38,104,92,234,173,11,
dc.b 53,63,230,106,127,203,198,167,249,223,127,197,247,176,83,216,79,115,9,154,23,185,85,161,103,123,248,41,236,138,158,193,
dc.b 79,96,153,195,189,26,23,90,247,33,98,159,48,167,179,61,79,243,212,255,223,47,3,83,254,6,157,124,77,72,208,186,
dc.b 23,62,69,223,5,241,53,63,225,30,247,252,5,63,128,153,241,126,84,46,117,80,133,138,127,17,79,225,225,79,112,167,
dc.b 184,158,250,137,154,23,209,84,33,102,209,240,83,221,21,61,194,158,225,51,134,206,104,93,11,232,133,138,123,246,143,137,
dc.b 119,10,125,196,247,220,76,208,191,101,81,145,119,193,125,197,62,232,169,247,10,125,194,103,221,249,80,186,23,236,133,138,
dc.b 127,113,79,187,58,159,249,169,252,245,63,207,83,255,253,79,180,83,218,79,117,9,154,23,74,168,66,206,79,240,83,219,
dc.b 21,61,162,158,209,51,135,38,52,46,133,210,133,138,125,66,158,223,23,223,105,125,246,151,55,216,189,52,46,197,207,145,
dc.b 119,193,125,139,239,182,60,159,237,20,251,68,207,179,242,161,115,170,196,44,83,251,10,125,190,20,255,85,193,79,195,46,
dc.b 30,130,184,38,104,92,139,179,34,240,244,35,246,61,28,56,169,240,244,35,225,151,4,206,30,130,180,46,197,201,145,120,
dc.b 41,250,241,134,79,3,173,167,132,62,19,220,197,65,161,123,149,98,22,120,67,251,99,12,145,171,10,159,97,80,112,240,
dc.b 121,161,118,47,118,69,224,167,204,84,251,51,190,255,155,239,112,167,184,158,250,137,154,23,209,86,33,103,18,248,41,238,
dc.b 138,158,225,79,112,153,195,136,154,23,98,250,33,98,159,212,83,241,226,95,105,196,190,19,221,66,102,133,210,171,16,179,
dc.b 137,124,20,246,197,79,104,167,180,76,225,196,77,11,177,116,161,98,158,254,37,241,46,81,79,148,158,246,137,154,23,177,
dc.b 86,33,103,240,103,193,79,150,42,124,162,159,40,153,195,248,44,208,187,23,179,34,239,130,192,
card_pac_end: 
EXPORT veeg, veeg_end
veeg: 
dc.b 70,5,81,1,67,5,11,250,13,0,13,84,0,0,209,15,0,0,0,0,0,243,12,0,0,84,0,0,209,15,0,0,
dc.b 0,0,0,243,13,0,0,84,0,0,209,15,0,0,0,0,0,243,14,0,0,84,0,0,209,15,0,0,0,0,0,243,
dc.b 15,0,0,84,0,0,209,15,0,0,0,0,1,243,15,0,0,84,0,0,209,15,0,0,0,0,2,243,15,0,0,84,
dc.b 0,0,209,15,0,0,0,0,3,243,15,0,0,84,0,0,209,15,0,0,0,0,4,243,15,0,0,84,0,0,209,15,
dc.b 0,0,0,0,5,243,15,0,0,84,0,0,209,15,0,0,0,0,6,243,14,0,0,84,0,0,209,15,0,0,0,0,
dc.b 7,243,14,0,0,84,0,0,209,15,0,0,0,0,8,243,13,0,0,84,0,0,209,15,0,0,0,0,9,243,13,0,
dc.b 0,84,0,0,209,15,0,0,0,0,10,243,12,0,0,84,0,0,209,15,0,0,0,0,11,243,12,0,0,84,0,0,
dc.b 209,15,0,0,0,0,12,243,11,0,0,84,0,0,209,15,0,0,0,0,13,243,11,0,0,84,0,0,209,15,0,0,
dc.b 0,0,14,243,10,0,0,84,0,0,209,15,0,0,0,0,15,243,10,0,0,84,0,0,209,15,0,0,0,0,16,243,
dc.b 9,0,0,84,0,0,209,15,0,0,0,0,17,243,9,0,0,84,0,0,209,15,0,0,0,0,18,243,8,0,0,84,
dc.b 0,0,209,15,0,0,0,0,19,243,8,0,0,84,0,0,209,15,0,0,0,0,20,243,7,0,0,84,0,0,209,15,
dc.b 0,0,0,0,21,243,7,0,0,84,0,0,209,15,0,0,0,0,22,243,6,0,0,84,0,0,209,15,0,0,0,0,
dc.b 23,243,6,0,0,84,0,0,209,15,0,0,0,0,24,243,5,0,0,84,0,0,209,15,0,0,0,0,25,243,5,0,
dc.b 0,84,0,0,209,15,0,0,0,0,26,243,4,0,0,84,0,0,209,15,0,0,0,0,27,243,4,0,0,84,0,0,
dc.b 209,15,0,0,0,0,28,243,3,0,0,84,0,0,209,15,0,0,0,0,29,243,3,0,0,84,0,0,209,15,0,0,
dc.b 0,0,30,243,2,0,0,84,0,0,209,15,0,0,0,0,31,243,2,0,0,84,0,0,209,15,0,0,0,0,31,243,
dc.b 1,0,0,84,0,0,209,15,0,0,0,0,31,243,1,0,0,84,0,0,209,15,0,0,0,0,31,243,0,0,0,84,
dc.b 0,0,
veeg_end: 
EXPORT gameover_pac, gameover_pac_end
gameover_pac: 
dc.b 5,94,115,120,224,7,86,212,127,239,122,217,44,158,247,191,255,47,51,188,185,85,155,101,203,150,89,176,132,46,217,136,
dc.b 218,178,27,12,134,149,102,1,78,101,151,50,26,12,109,180,99,36,163,44,214,219,71,210,73,90,113,78,30,12,75,1,
dc.b 159,110,92,170,237,137,239,34,123,244,6,2,139,24,205,99,19,56,223,0,51,12,150,248,39,153,111,139,25,230,81,224,
dc.b 0,229,58,73,117,199,38,229,173,142,164,63,142,190,188,178,124,211,127,57,113,250,229,147,250,203,212,201,46,218,94,222,
dc.b 89,122,41,151,169,235,151,209,38,218,93,204,178,244,73,251,242,203,142,78,254,89,125,42,191,85,60,188,105,171,219,201,
dc.b 41,236,79,98,123,19,216,158,192,246,7,176,61,129,236,15,96,123,65,237,7,180,30,208,123,65,237,7,179,158,206,123,
dc.b 57,236,231,179,158,206,123,49,236,199,179,30,204,123,49,236,199,182,207,109,158,219,61,182,123,146,95,74,175,157,135,94,
dc.b 118,29,121,233,95,158,87,18,11,228,97,103,238,97,215,238,85,249,24,173,231,99,39,202,199,47,222,195,175,149,135,90,
dc.b 158,196,246,39,177,61,137,236,15,96,123,3,218,170,246,220,189,97,112,201,218,183,236,206,158,137,105,229,246,146,254,204,
dc.b 178,224,166,92,150,19,126,77,164,189,172,178,224,147,247,101,151,12,159,110,89,113,42,249,169,229,227,77,94,214,73,79,
dc.b 98,123,19,216,158,196,246,7,176,61,129,236,15,96,123,3,218,15,104,61,160,246,131,218,15,104,61,156,246,115,217,207,
dc.b 103,61,166,80,94,74,80,235,211,47,218,151,53,95,105,46,210,90,239,223,141,126,252,75,247,226,95,191,26,246,249,23,
dc.b 239,202,171,209,135,84,185,248,154,194,230,195,173,243,219,234,188,15,154,225,125,71,19,237,188,212,203,159,19,254,252,58,
dc.b 196,246,39,177,61,129,236,15,96,123,159,19,245,133,231,147,240,155,217,157,61,18,211,203,249,210,249,178,203,228,166,90,
dc.b 181,49,243,165,200,22,173,79,237,79,94,167,251,25,101,242,170,254,250,121,122,181,63,243,228,148,246,39,177,61,137,236,
dc.b 79,96,123,3,216,30,192,246,7,176,61,160,246,131,218,15,104,61,160,246,131,217,207,103,61,156,246,115,217,207,106,232,
dc.b 23,181,61,125,51,251,9,85,107,247,198,191,124,107,247,232,95,191,161,126,254,133,251,244,47,111,26,253,253,42,190,147,
dc.b 222,147,222,147,218,165,207,196,214,23,242,33,252,79,127,21,95,228,249,175,75,234,63,155,237,178,203,94,29,127,54,29,
dc.b 106,123,19,216,158,196,246,39,176,61,129,236,15,96,123,3,220,146,232,235,193,211,215,159,253,250,243,254,169,123,121,117,
dc.b 35,209,45,60,191,101,47,99,44,191,77,50,228,176,159,211,47,101,47,111,44,191,76,187,153,101,250,165,239,229,151,245,
dc.b 42,255,93,60,188,105,171,236,228,148,246,39,177,61,137,236,79,96,123,3,216,30,192,246,174,95,177,150,94,188,181,236,
dc.b 231,162,90,121,127,58,90,244,11,235,75,94,106,122,178,215,156,94,172,181,231,135,173,45,121,253,235,203,94,131,63,90,
dc.b 175,246,203,94,116,254,185,107,207,127,93,160,95,89,47,85,196,245,65,106,123,3,216,30,192,246,7,176,61,211,158,253,
dc.b 61,247,250,123,239,244,247,223,233,239,191,255,221,247,248,93,244,117,61,215,247,85,255,219,247,249,126,7,190,233,118,190,
dc.b 31,132,30,111,192,247,136,247,137,87,198,249,175,35,234,60,175,182,248,216,117,229,97,215,145,135,94,55,125,31,19,190,
dc.b 255,137,87,198,195,175,35,14,188,172,58,248,210,242,184,158,64,91,205,240,244,75,79,47,182,150,189,86,238,180,249,184,
dc.b 212,86,227,83,27,173,83,111,53,105,225,85,248,154,145,240,181,63,188,213,110,234,91,142,38,224,45,214,248,119,155,239,
dc.b 240,170,252,77,72,248,90,159,222,106,183,117,190,253,198,251,247,27,239,221,111,135,121,190,255,10,175,196,222,103,133,189,
dc.b 173,230,250,55,82,220,113,55,1,110,183,195,188,223,127,133,87,226,111,191,194,223,126,243,125,251,173,247,238,55,223,184,
dc.b 223,126,235,124,59,205,247,248,85,117,61,180,123,104,246,209,237,163,219,71,182,143,117,143,117,143,117,143,117,143,117,143,
dc.b 117,143,108,158,217,61,178,123,100,246,201,237,147,219,7,182,15,108,30,216,61,176,123,96,247,84,247,84,247,84,247,84,
dc.b 247,84,247,84,247,80,247,80,247,80,247,80,247,80,247,80,246,83,217,79,101,61,148,246,83,217,79,100,61,144,246,67,
dc.b 217,15,100,61,144,246,67,217,15,100,210,247,75,223,248,247,113,190,30,137,105,229,246,210,215,190,255,117,190,255,113,190,
dc.b 255,113,190,255,117,190,30,227,125,254,242,175,236,111,51,222,111,107,184,223,71,186,151,184,226,123,128,189,214,248,123,141,
dc.b 247,251,202,191,177,190,255,121,190,254,227,125,253,245,132,239,172,151,125,104,59,244,161,170,94,255,194,175,121,102,123,171,
dc.b 79,221,91,94,242,93,247,19,192,11,225,119,20,240,59,145,119,213,123,203,51,221,90,126,234,218,247,179,88,74,201,120,
dc.b 22,131,225,90,239,2,222,119,213,122,58,149,82,231,226,107,11,155,169,86,227,14,183,21,119,86,103,121,105,252,43,107,
dc.b 241,83,46,126,167,255,127,82,172,79,98,123,19,216,30,192,246,7,185,250,159,235,11,201,39,5,159,102,116,244,75,79,
dc.b 47,224,75,223,203,47,29,50,213,218,35,224,75,193,102,190,209,251,214,107,237,31,254,25,101,229,85,248,233,229,234,237,
dc.b 31,240,100,148,246,39,177,61,137,236,79,96,123,3,216,30,192,246,7,176,61,160,246,131,218,15,104,61,160,246,131,217,
dc.b 207,103,61,156,246,115,217,207,103,61,152,246,99,217,143,102,61,152,246,99,219,103,182,207,109,158,219,61,182,123,146,93,
dc.b 246,29,119,255,145,54,164,127,25,92,72,46,243,11,59,172,58,238,170,247,152,173,223,99,39,129,142,95,11,14,188,12,
dc.b 58,212,246,39,177,61,137,236,79,96,123,3,216,30,192,246,7,186,123,239,255,255,125,255,59,161,7,157,208,187,154,175,
dc.b 10,253,240,175,223,15,248,253,200,112,230,66,191,124,43,247,211,251,207,255,175,222,127,79,247,31,254,255,184,252,158,26,
dc.b 158,190,69,249,229,113,52,133,236,205,95,247,31,216,203,47,170,153,106,254,227,251,47,12,223,32,90,191,182,93,201,171,
dc.b 254,224,123,233,107,171,169,236,199,179,30,204,123,49,236,199,179,30,219,61,182,123,108,246,217,237,179,220,146,250,169,240,
dc.b 139,109,107,250,234,210,227,75,209,84,175,15,182,169,124,217,37,120,130,250,207,17,7,90,151,191,134,89,125,82,90,158,
dc.b 186,189,140,178,227,85,212,246,201,237,147,219,39,182,79,108,158,217,61,176,123,96,246,193,237,131,219,7,182,51,107,123,
dc.b 175,162,93,26,243,224,103,190,251,61,247,217,239,192,206,158,109,121,241,42,249,153,169,196,206,46,22,120,112,37,190,226,
dc.b 111,130,224,103,79,11,61,248,149,124,204,247,226,103,191,11,61,248,27,239,223,111,191,125,190,254,6,248,120,91,239,226,
dc.b 85,243,55,153,196,222,215,11,125,28,9,111,184,155,224,184,31,188,30,23,239,63,137,87,204,253,231,241,63,121,252,47,
dc.b 222,127,3,247,159,190,253,231,239,191,121,252,15,222,15,11,247,159,196,171,209,179,42,92,252,77,97,115,108,203,232,97,
dc.b 215,208,171,232,98,183,27,25,62,150,57,125,84,203,159,104,255,126,204,177,61,137,236,79,96,123,3,216,30,231,218,62,
dc.b 176,189,47,44,207,251,75,242,242,85,254,94,70,206,127,39,86,171,93,121,42,255,31,35,103,165,228,108,227,246,203,231,
dc.b 74,11,237,67,176,150,191,35,103,27,201,17,198,242,75,113,188,187,254,156,210,252,124,149,124,121,144,210,245,86,229,255,
dc.b 161,63,55,195,225,126,223,147,130,236,203,93,188,236,203,95,150,159,238,171,174,236,118,94,53,190,203,198,183,250,30,53,
dc.b 191,206,241,173,254,119,141,111,244,60,105,189,151,141,111,250,37,211,229,167,233,242,211,244,245,231,233,235,207,211,215,159,
dc.b 254,122,243,192,
gameover_pac_end: 
EXPORT welldone_pac, welldone_pac_end
welldone_pac: 
dc.b 1,92,91,122,238,177,159,247,255,119,119,110,219,118,221,234,138,10,26,130,130,250,104,136,248,18,68,76,166,83,213,53,
dc.b 69,69,69,4,4,72,83,80,105,26,134,161,168,40,40,40,40,41,38,34,138,145,152,130,134,145,71,255,189,219,220,253,
dc.b 189,164,36,77,17,73,73,73,242,251,148,48,6,181,53,151,113,162,235,68,55,146,132,145,21,151,110,198,165,129,98,40,
dc.b 191,150,137,81,253,94,103,44,186,106,148,252,45,134,44,74,147,175,246,163,38,139,100,214,182,154,185,23,213,63,75,202,
dc.b 229,131,88,175,175,35,149,241,43,50,68,152,94,119,45,5,235,71,34,250,139,22,212,139,72,214,62,134,165,199,53,176,
dc.b 213,175,34,210,141,68,159,189,238,75,33,86,186,40,142,189,52,83,125,121,130,219,71,66,250,28,75,94,148,91,106,250,
dc.b 133,182,165,18,120,23,177,171,150,141,71,153,212,112,174,129,174,147,204,232,121,230,185,205,94,246,42,242,125,30,193,39,
dc.b 237,34,212,53,117,246,45,210,203,71,1,170,100,93,176,180,209,174,251,63,163,186,89,72,214,106,245,5,166,165,18,125,
dc.b 161,115,17,112,47,17,112,204,103,81,82,241,200,190,12,245,175,161,220,53,223,106,233,192,197,86,77,72,4,152,95,22,
dc.b 100,173,118,207,219,84,213,41,98,214,106,234,154,197,16,245,133,170,213,195,39,83,241,126,111,99,93,163,230,245,164,93,
dc.b 146,184,90,173,90,205,201,171,138,79,112,188,69,126,233,121,5,87,174,91,217,111,101,189,150,246,91,217,111,126,111,110,
dc.b 18,215,52,167,236,23,113,253,13,234,20,40,124,43,50,97,134,19,85,73,221,145,85,123,228,107,62,124,243,93,226,243,
dc.b 63,161,189,58,116,225,235,155,54,104,215,130,8,4,156,201,147,5,123,239,190,21,231,158,25,46,186,232,133,113,199,5,
dc.b 10,16,129,122,106,61,100,68,53,205,68,153,168,175,11,139,39,12,40,161,23,166,191,247,160,
welldone_pac_end: 
EXPORT sample_pac, sample_pac_end
sample_pac: 
dc.b 16,40,123,187,238,138,56,220,35,51,12,51,48,0,0,0,3,67,67,64,221,215,187,187,187,186,219,111,91,230,222,182,
dc.b 219,109,247,62,233,221,47,73,209,78,83,165,150,217,84,169,79,128,146,171,228,182,165,82,190,26,148,81,95,5,86,85,
dc.b 85,150,245,169,114,182,43,213,117,147,185,243,125,205,182,219,109,238,176,208,208,208,0,0,0,12,195,0,204,51,51,48,
dc.b 207,223,240,233,35,111,118,238,205,164,234,235,43,155,40,234,184,138,97,110,91,22,65,4,185,95,6,98,84,55,30,91,
dc.b 153,84,197,134,250,172,213,69,115,6,78,6,180,102,197,140,187,102,89,137,89,53,86,205,152,177,209,102,216,147,34,243,
dc.b 55,253,158,190,190,190,196,56,177,153,160,146,89,14,183,122,255,31,207,225,153,223,239,112,250,60,94,111,55,213,255,31,
dc.b 227,250,63,183,251,63,191,252,63,207,227,255,127,249,240,121,188,30,25,150,203,219,223,238,254,15,195,241,127,63,222,247,
dc.b 255,39,242,124,95,209,249,127,47,227,254,63,135,248,190,31,131,181,237,252,31,15,242,254,79,197,248,63,15,195,217,140,
dc.b 213,91,115,252,62,42,20,39,205,224,243,120,229,208,176,106,77,222,63,134,229,150,51,179,45,147,34,41,172,58,135,91,
dc.b 165,74,205,211,215,37,124,22,43,121,190,79,207,253,127,213,253,63,221,249,255,79,234,255,95,244,248,254,79,151,233,240,
dc.b 206,53,120,90,178,164,107,242,245,180,245,53,118,121,253,78,166,255,95,161,179,181,185,189,211,230,115,59,159,127,220,231,
dc.b 239,123,26,240,221,16,154,104,227,55,26,234,96,189,145,101,20,33,155,135,12,218,54,40,145,147,69,44,195,12,178,120,
dc.b 172,213,161,58,218,74,36,141,251,21,232,240,125,95,63,207,223,250,252,94,111,71,147,215,86,201,217,83,89,155,119,46,
dc.b 225,105,73,147,202,229,107,110,243,122,222,239,179,214,223,246,58,93,30,119,51,111,159,191,189,179,175,175,181,177,29,243,
dc.b 199,239,219,12,168,195,35,136,243,241,227,201,149,11,244,169,83,155,58,165,243,176,168,178,73,170,150,11,54,172,211,167,
dc.b 106,197,57,252,94,159,15,160,46,190,255,213,223,250,60,211,40,76,244,77,163,100,236,105,140,99,65,201,110,221,214,132,
dc.b 153,90,253,14,191,87,127,167,205,216,214,218,230,111,116,55,118,54,53,245,180,244,163,104,104,65,48,150,133,152,80,227,
dc.b 46,51,49,178,164,54,108,119,66,37,96,236,39,160,162,185,113,27,114,181,91,23,77,185,86,141,26,156,156,116,171,222,
dc.b 189,110,172,201,115,234,217,181,119,10,75,179,116,233,179,200,15,30,233,4,83,159,211,236,116,247,186,61,45,237,222,94,
dc.b 214,182,206,222,163,247,78,91,51,100,205,171,216,145,29,50,100,97,68,7,219,54,205,154,148,170,7,214,157,199,70,166,
dc.b 0,175,144,54,205,74,83,230,250,229,242,84,227,245,120,190,143,217,243,247,188,30,78,42,212,102,76,157,75,146,133,163,
dc.b 209,84,134,128,91,187,122,245,228,73,90,187,92,238,150,255,91,177,217,237,118,187,91,253,30,143,79,127,159,177,38,36,
dc.b 7,102,16,201,163,231,173,92,60,116,225,161,76,199,81,69,243,37,151,38,27,124,147,232,213,179,119,18,24,242,97,193,
dc.b 122,213,106,52,42,89,171,62,108,191,79,215,244,119,190,158,255,147,131,213,233,245,241,77,155,58,125,59,54,175,100,79,
dc.b 49,45,92,57,123,11,71,83,111,123,171,216,235,246,123,126,215,185,221,238,119,61,158,239,111,127,123,119,102,84,88,15,
dc.b 95,232,104,198,145,169,39,70,38,134,132,39,238,11,102,66,136,29,90,133,59,54,239,94,185,114,253,251,85,57,40,210,
dc.b 159,199,63,147,143,135,207,229,241,247,190,111,218,22,47,159,209,46,141,106,51,121,44,0,81,128,227,141,55,34,105,44,
dc.b 91,119,112,162,233,106,109,115,119,186,93,175,119,222,247,62,215,189,246,189,158,207,87,165,206,217,229,106,202,147,36,63,
dc.b 191,47,155,183,171,171,167,163,1,201,107,229,195,110,151,15,170,117,30,74,28,124,94,185,124,92,82,248,120,56,61,115,
dc.b 233,212,167,70,132,249,220,92,83,167,208,161,74,197,219,231,98,195,122,253,251,215,206,63,9,184,48,96,191,133,44,203,
dc.b 140,75,70,206,226,233,235,109,110,242,250,27,253,158,223,111,183,218,9,39,83,173,215,235,117,58,125,94,199,103,177,215,
dc.b 223,222,215,143,160,236,148,176,84,226,244,249,60,158,174,41,178,248,61,94,127,47,163,131,215,48,7,126,74,84,192,233,
dc.b 175,106,221,220,24,79,63,18,32,159,7,32,101,0,69,191,122,221,171,85,169,211,171,108,211,207,65,44,160,26,60,129,
dc.b 14,38,140,104,242,101,106,236,108,108,238,115,186,30,199,79,169,213,236,247,125,207,108,3,158,126,204,119,166,102,62,237,
dc.b 110,73,252,149,43,89,185,114,197,58,33,94,212,173,90,165,74,181,171,128,45,115,6,52,147,83,50,235,142,64,224,203,
dc.b 18,67,17,160,39,88,171,74,135,37,123,192,125,7,247,32,166,142,29,61,124,245,203,118,205,219,135,227,7,71,79,84,
dc.b 18,223,47,157,207,230,242,247,53,244,227,192,108,78,100,79,54,253,227,144,81,97,84,235,42,170,138,172,162,7,157,130,
dc.b 245,219,151,111,94,55,22,35,240,159,139,30,51,196,14,218,170,22,228,249,188,83,128,187,188,122,131,150,221,211,232,48,
dc.b 162,70,145,31,71,70,36,24,16,96,232,71,147,167,171,175,179,183,185,185,183,179,173,169,42,60,23,6,16,166,67,175,
dc.b 92,1,164,236,57,17,69,4,50,100,65,12,120,176,92,181,94,157,42,149,236,220,8,185,199,227,69,37,2,112,178,185,
dc.b 67,255,100,60,38,8,101,21,184,200,182,174,159,194,137,22,38,131,231,78,92,53,49,160,76,33,67,131,6,30,132,72,
dc.b 218,82,0,243,209,128,224,178,21,67,22,44,97,237,193,242,7,186,65,53,151,95,50,103,220,177,82,141,26,85,44,221,
dc.b 191,128,19,40,89,40,168,185,4,146,58,234,164,28,81,113,201,44,182,108,217,150,217,219,232,90,49,162,67,124,24,121,
dc.b 32,10,210,76,110,237,235,199,78,93,58,121,10,36,56,79,221,24,66,217,113,29,128,211,194,191,198,32,55,34,41,44,
dc.b 186,201,160,112,141,27,119,111,158,138,106,42,162,96,33,7,187,114,237,211,99,10,100,64,124,102,91,70,166,20,72,121,
dc.b 54,116,245,251,231,110,12,100,186,185,81,202,154,163,20,208,194,203,49,171,103,1,138,23,206,219,22,72,202,165,149,4,
dc.b 18,81,101,83,69,4,69,196,50,99,195,124,12,250,181,106,85,177,115,6,32,13,208,202,166,97,192,19,106,208,178,89,
dc.b 16,65,3,142,200,162,204,48,182,98,241,104,7,27,102,140,199,95,50,202,133,18,209,195,183,110,222,61,129,12,2,184,
dc.b 161,110,185,110,213,163,66,194,239,48,176,203,8,112,44,28,185,80,63,5,208,177,45,88,181,114,240,42,27,215,240,29,
dc.b 140,40,101,84,80,40,108,169,177,196,146,2,219,236,40,51,4,116,60,70,33,145,37,52,110,237,227,232,26,17,99,105,
dc.b 105,71,210,210,1,6,12,7,239,224,64,124,241,219,183,78,2,139,108,221,161,68,178,24,47,16,61,17,200,126,17,37,
dc.b 75,96,24,94,189,120,9,75,226,242,9,128,37,123,225,248,221,187,124,208,68,103,227,4,2,26,95,24,130,76,106,225,
dc.b 219,232,16,67,90,178,37,106,106,242,181,185,90,128,249,100,72,145,165,30,60,120,194,38,94,187,114,221,161,101,50,5,
dc.b 248,142,65,3,216,193,83,155,118,213,122,226,99,246,108,216,175,90,189,122,213,171,135,227,102,205,122,161,192,253,44,5,
dc.b 213,114,224,57,220,105,174,18,55,14,157,188,4,195,31,79,83,149,174,44,233,235,6,209,246,182,246,131,242,229,106,73,
dc.b 141,22,32,90,175,131,35,109,75,40,160,69,128,58,136,55,68,77,168,43,43,118,107,84,167,78,165,46,64,195,44,249,
dc.b 252,115,166,241,76,151,50,108,233,211,167,210,169,90,213,227,177,162,7,80,21,238,94,61,122,254,20,80,200,32,55,240,
dc.b 144,236,237,131,33,220,230,114,247,54,246,53,36,71,5,187,12,3,183,193,154,87,45,154,135,12,102,58,200,159,126,229,
dc.b 161,86,246,44,6,12,233,210,161,67,146,133,26,84,185,39,49,140,158,25,147,103,209,167,86,230,28,89,18,92,21,139,
dc.b 81,113,179,119,47,31,65,208,139,163,22,44,104,250,82,2,87,171,175,174,25,25,143,18,20,40,16,33,66,0,193,235,
dc.b 248,47,222,130,113,124,237,185,100,46,154,2,123,135,158,109,235,128,75,49,44,175,90,165,25,211,102,112,240,112,250,230,
dc.b 113,207,9,141,107,119,240,98,72,8,240,195,24,152,225,77,66,72,253,251,240,112,90,17,52,99,200,146,7,196,23,239,
dc.b 28,184,114,229,203,172,254,34,78,154,0,130,222,55,49,144,147,50,226,240,84,55,136,18,227,133,43,177,83,144,52,148,
dc.b 1,79,24,72,42,134,0,239,225,200,14,73,101,243,200,139,5,116,246,8,159,0,142,144,58,227,199,138,21,219,144,74,
dc.b 65,114,10,231,112,41,59,118,166,24,204,129,216,197,152,158,130,170,170,154,121,80,196,112,36,219,150,108,1,42,34,72,
dc.b 36,84,234,132,132,211,143,196,39,112,154,185,179,46,59,49,18,97,34,145,42,84,157,40,241,163,71,141,23,66,24,172,
dc.b 97,72,154,52,9,19,112,143,150,72,54,21,215,92,49,46,12,21,52,196,191,243,1,251,147,16,100,202,224,6,21,169,
dc.b 210,2,78,141,58,214,111,26,44,89,131,181,7,131,152,50,146,14,68,91,121,135,22,60,144,86,113,227,104,196,133,6,
dc.b 0,2,65,189,70,34,172,138,49,168,157,113,97,96,135,24,113,194,226,225,238,199,18,97,65,132,197,110,200,43,250,180,
dc.b 193,38,133,132,120,87,201,10,132,15,161,5,1,133,240,195,115,214,13,168,65,28,5,78,17,230,162,123,227,132,24,4,
dc.b 118,141,66,205,23,238,200,112,144,46,195,187,7,132,50,234,166,24,109,198,4,118,11,226,114,54,132,197,2,194,199,144,
dc.b 88,156,10,19,63,2,197,48,49,66,249,251,21,219,241,42,7,142,221,9,185,179,100,42,0,56,3,251,28,93,81,16,
dc.b 185,64,36,10,133,118,56,1,162,73,136,44,7,40,112,184,126,52,18,75,43,22,8,164,33,232,130,68,73,109,91,186,
dc.b 123,2,20,49,88,130,197,92,56,15,66,72,219,61,108,198,56,199,23,74,216,67,178,227,60,48,134,105,167,98,22,123,
dc.b 131,152,243,249,6,102,240,26,44,29,226,12,28,229,73,141,100,178,36,29,97,36,7,25,51,102,83,86,236,41,103,175,
dc.b 159,133,151,14,28,40,15,157,185,112,8,252,52,0,72,73,24,144,230,10,197,48,218,32,129,81,34,182,35,89,228,72,
dc.b 35,159,11,200,9,31,134,121,131,75,236,72,133,151,162,202,44,32,162,204,0,35,92,234,113,184,159,112,98,105,192,141,
dc.b 242,130,66,20,64,226,178,64,49,22,15,65,86,11,59,152,133,170,224,251,196,199,219,30,63,191,88,97,50,23,95,6,
dc.b 124,180,4,116,90,71,9,24,104,196,81,199,207,159,63,22,90,159,135,30,186,9,32,127,134,56,88,175,17,243,139,107,
dc.b 35,144,7,115,77,52,79,133,129,252,89,91,65,1,56,86,54,74,168,105,40,84,195,32,57,76,21,118,88,128,178,74,
dc.b 98,200,108,12,21,132,124,13,193,141,139,1,4,56,122,176,142,174,194,30,20,157,101,18,8,102,44,224,218,25,51,133,
dc.b 72,101,99,69,249,3,71,160,115,16,72,175,241,108,4,8,33,53,209,6,70,125,156,45,138,224,65,248,43,15,222,167,
dc.b 6,11,219,48,121,176,25,46,27,87,22,235,178,135,210,25,248,31,146,66,212,174,84,82,87,48,169,66,25,0,70,32,
dc.b 105,192,72,51,175,240,12,196,127,177,198,76,80,68,178,206,64,9,181,138,195,21,138,195,119,2,69,76,228,150,48,62,
dc.b 176,128,74,45,240,35,151,42,34,109,162,114,2,93,68,8,24,22,88,92,56,13,109,55,22,183,91,103,71,249,248,5,
dc.b 25,76,216,77,217,229,2,224,226,246,172,153,48,25,177,132,22,50,0,45,117,135,72,117,240,86,65,175,140,7,48,221,
dc.b 24,98,163,14,195,12,120,7,0,28,79,94,135,144,152,80,42,156,242,230,191,185,38,253,140,89,128,133,150,127,225,251,
dc.b 164,32,195,3,19,119,69,174,16,222,101,246,54,192,22,147,11,53,6,2,246,44,118,205,243,241,192,71,28,49,105,7,
dc.b 216,191,171,26,127,105,156,156,98,88,201,134,146,33,52,143,225,156,96,73,130,175,2,195,206,149,197,211,96,40,250,96,
dc.b 149,4,22,18,73,127,194,70,40,187,108,233,68,71,89,130,241,102,197,134,197,140,199,147,33,34,50,130,96,44,126,10,
dc.b 69,144,24,120,164,97,97,130,194,56,246,53,78,121,226,98,234,9,191,11,44,66,35,219,183,207,24,48,89,180,10,224,
dc.b 85,211,92,242,211,24,39,25,231,39,89,177,224,195,171,100,9,81,49,116,73,158,198,19,175,132,135,236,125,232,49,210,
dc.b 196,9,109,140,79,138,149,45,166,112,81,138,228,161,64,10,96,12,99,165,185,141,21,52,206,20,103,144,103,64,226,10,
dc.b 150,80,17,250,1,139,12,225,69,224,145,225,96,132,4,170,152,186,82,115,9,163,176,149,139,21,118,211,59,23,99,161,
dc.b 143,57,167,246,14,194,100,25,200,210,133,234,76,49,135,40,11,140,44,113,152,197,146,32,21,129,234,45,23,11,166,252,
dc.b 209,62,116,65,40,103,206,64,12,31,98,159,97,187,231,32,216,3,200,206,191,135,96,130,97,210,7,164,13,140,53,49,
dc.b 168,58,214,173,25,152,80,0,98,101,169,45,152,50,2,113,167,157,115,9,182,207,64,219,233,37,137,48,213,34,33,60,
dc.b 77,81,201,76,119,165,152,229,203,226,76,114,137,37,102,49,101,154,146,73,77,180,91,52,136,81,141,199,108,4,155,199,
dc.b 8,181,112,166,85,7,72,146,137,145,30,60,168,240,49,182,101,132,139,150,178,164,83,86,67,149,15,65,169,23,230,240,
dc.b 249,103,205,253,159,179,201,51,16,203,148,73,184,198,120,101,252,149,148,140,187,221,13,15,107,127,161,22,241,211,199,129,
dc.b 104,110,79,37,171,143,70,167,75,255,59,243,231,155,71,9,228,74,109,11,123,87,115,223,251,157,199,25,34,105,245,253,
dc.b 190,183,45,104,191,111,175,182,182,27,222,62,26,164,225,177,114,112,211,191,250,132,180,201,59,215,224,163,52,100,169,243,
dc.b 91,203,239,216,231,110,244,113,94,113,250,254,79,250,255,47,215,227,30,236,15,230,247,255,55,191,237,254,111,183,204,196,
dc.b 158,174,231,223,238,109,57,65,110,79,60,186,62,79,251,228,190,213,63,161,94,183,82,70,140,3,58,126,255,179,237,72,
dc.b 89,69,236,219,75,199,244,219,37,58,182,101,164,55,147,213,224,239,85,77,236,40,230,46,229,158,140,146,198,41,124,137,
dc.b 122,104,100,250,230,209,240,127,239,199,231,241,204,163,245,208,164,107,50,11,125,164,232,177,204,149,2,30,206,214,255,177,
dc.b 207,145,181,210,112,228,181,93,33,82,248,227,83,169,226,243,187,37,188,141,63,187,239,117,247,33,69,24,124,195,110,236,
dc.b 199,149,209,247,55,228,140,228,105,213,188,94,155,216,8,88,146,153,192,81,180,109,24,233,54,220,142,234,127,13,127,155,
dc.b 244,254,143,146,93,84,157,24,152,216,173,100,188,130,84,144,121,13,236,13,168,45,72,228,157,78,218,198,65,116,145,78,
dc.b 91,59,74,165,74,30,158,26,249,89,232,105,66,140,244,13,44,204,219,16,94,183,67,216,222,120,152,203,94,196,80,247,
dc.b 169,82,187,199,222,224,227,176,246,68,94,159,226,252,127,23,119,93,249,191,55,201,245,112,250,103,78,166,187,162,56,59,
dc.b 211,40,77,250,184,200,114,102,87,18,95,55,85,231,99,122,3,192,239,210,142,82,7,113,120,124,179,103,223,78,202,113,
dc.b 140,202,92,78,95,91,155,181,218,235,242,245,162,69,50,191,12,187,117,165,208,34,70,128,116,179,235,53,61,0,98,68,
dc.b 56,135,208,230,188,113,167,160,178,117,44,39,47,199,233,173,150,135,139,132,228,110,30,59,199,174,91,41,118,103,131,195,
dc.b 46,198,104,114,118,55,251,122,236,199,44,149,50,101,41,154,106,144,61,175,55,135,193,227,244,78,86,71,87,185,189,187,
dc.b 181,12,145,156,57,123,34,84,103,141,87,187,137,85,178,219,78,1,102,213,175,134,199,174,202,208,35,201,236,125,239,187,
dc.b 217,142,207,20,207,151,245,127,183,203,73,0,206,72,102,29,188,56,209,157,140,49,244,39,85,199,136,211,171,154,168,236,
dc.b 222,69,110,29,140,207,200,25,252,39,37,167,138,253,106,212,235,158,118,92,103,152,98,133,73,222,233,115,37,63,131,8,
dc.b 145,226,243,182,180,93,175,138,143,163,197,225,171,126,226,175,116,246,186,29,127,107,163,202,142,49,248,56,60,188,60,62,
dc.b 111,55,151,255,251,222,73,102,187,230,109,106,71,49,90,146,237,230,129,35,149,169,6,11,162,137,80,233,147,46,97,64,
dc.b 229,158,54,93,84,46,91,204,213,163,249,16,3,111,88,125,61,234,25,180,181,100,238,104,180,41,65,158,73,229,74,213,
dc.b 128,82,87,242,38,116,217,117,239,45,23,169,238,247,119,34,192,82,221,89,246,175,167,154,217,232,218,163,62,226,132,42,
dc.b 147,199,23,121,40,89,67,51,87,177,100,202,221,231,238,237,190,185,90,228,191,23,150,178,235,163,102,197,218,151,14,94,
dc.b 0,104,246,46,147,101,210,85,172,39,172,222,61,29,101,71,32,114,71,35,33,185,19,36,166,171,174,240,183,58,221,79,
dc.b 185,220,215,141,25,209,246,105,210,173,66,92,186,22,44,85,194,89,107,164,122,185,39,204,225,162,120,229,53,0,86,6,
dc.b 150,164,71,14,27,53,91,14,52,87,25,43,20,234,114,93,69,118,73,100,69,60,71,16,222,54,231,71,169,185,185,168,
dc.b 29,30,13,115,102,106,205,106,94,186,18,248,231,213,57,103,110,225,243,123,159,7,187,191,187,33,210,136,163,114,213,137,
dc.b 126,95,23,237,250,120,171,3,219,45,192,110,173,202,249,6,109,14,27,162,203,124,224,148,66,223,187,82,181,139,171,183,
dc.b 120,102,58,214,19,106,204,100,80,91,29,9,118,47,228,117,1,252,24,18,118,249,187,146,34,57,131,172,233,92,87,43,
dc.b 79,167,70,109,42,184,201,45,238,207,87,218,238,243,229,7,100,67,98,154,43,122,119,163,130,103,23,166,108,238,59,21,
dc.b 112,12,89,40,140,226,38,180,120,242,101,74,122,90,202,228,179,94,140,207,52,244,134,78,229,212,17,104,241,201,134,58,
dc.b 102,166,76,138,32,49,139,229,73,172,56,250,177,33,68,141,169,21,235,97,210,65,36,48,91,190,8,229,12,134,65,149,
dc.b 25,243,199,48,30,22,66,202,164,145,230,170,137,183,173,89,165,201,74,217,231,38,66,164,189,1,190,60,169,81,94,60,
dc.b 104,54,75,149,234,220,191,106,184,118,11,217,52,212,70,28,183,45,204,14,167,232,47,219,24,29,205,112,66,135,77,98,
dc.b 89,46,57,109,219,181,33,53,150,41,251,215,143,228,108,199,110,161,166,158,146,65,168,85,150,202,30,103,170,50,106,228,
dc.b 194,170,71,92,5,40,114,43,150,234,28,125,22,197,179,85,145,109,221,52,110,201,51,104,81,227,226,161,199,78,193,201,
dc.b 34,57,70,56,121,26,78,174,214,198,222,196,168,141,198,69,51,171,220,53,37,215,202,122,104,102,6,85,171,183,187,169,
dc.b 32,64,33,243,11,128,228,155,174,11,252,0,0,0,0,0,64,64,16,64,69,21,72,196,138,177,172,177,146,205,44,116,
dc.b 179,215,109,189,187,221,237,167,109,219,219,119,94,190,221,182,237,219,183,197,187,181,246,248,183,187,183,111,131,110,189,187,
dc.b 183,107,125,189,237,125,175,180,150,75,108,146,86,70,73,100,150,200,229,90,170,10,138,136,160,0,0,8,2,0,0,0,
dc.b 7,239,237,207,239,190,240,238,182,198,204,64,96,197,106,148,36,66,125,14,79,45,126,21,173,137,34,152,68,160,249,21,
dc.b 231,208,228,145,46,133,193,83,61,144,31,251,37,143,0,127,165,72,114,188,216,242,163,192,133,14,79,37,0,62,138,164,
dc.b 32,78,7,149,131,145,142,201,122,81,80,13,122,196,0,93,77,135,22,28,91,73,111,26,95,224,53,103,121,118,165,57,
dc.b 226,228,88,169,67,142,11,215,219,174,95,70,153,100,176,177,28,185,67,21,173,24,180,65,212,103,204,84,133,22,43,233,
dc.b 21,203,26,54,98,221,174,65,226,106,22,43,210,168,0,231,50,68,169,148,136,62,178,241,130,229,215,98,216,19,170,64,
dc.b 151,211,159,45,114,132,190,78,58,37,79,167,76,136,250,19,166,5,208,107,21,167,66,114,213,8,252,80,228,63,132,60,
dc.b 109,74,111,37,41,49,107,20,40,121,26,85,73,207,154,41,78,169,114,45,22,47,114,180,216,209,160,62,147,80,75,36,
dc.b 154,30,108,212,167,108,210,43,176,72,130,215,45,75,141,72,169,132,151,105,81,33,21,114,85,174,108,242,21,140,110,209,
dc.b 31,46,98,220,170,195,131,169,86,132,137,210,33,238,239,205,168,81,18,116,101,102,67,131,187,185,2,109,145,58,3,69,
dc.b 235,81,155,42,157,194,135,84,174,80,110,212,231,251,27,59,220,82,236,16,42,5,45,70,20,114,16,37,103,135,138,221,
dc.b 106,116,229,37,79,38,194,147,39,144,160,54,94,167,33,7,145,41,106,223,1,171,21,72,43,114,83,40,94,197,154,115,
dc.b 169,74,135,10,60,186,102,143,30,66,69,146,165,170,75,155,31,142,124,152,146,167,81,173,63,146,181,122,150,80,171,68,
dc.b 108,161,98,148,103,3,122,209,171,70,76,121,49,99,209,32,218,4,10,22,171,66,162,245,104,42,178,132,133,237,91,177,
dc.b 86,156,201,51,172,20,54,161,143,41,91,84,34,70,173,114,180,5,234,139,196,31,142,31,82,184,230,20,107,23,45,98,
dc.b 181,145,113,249,3,12,115,228,193,131,6,60,154,103,142,148,177,90,208,172,40,131,98,130,155,18,162,69,147,58,124,234,
dc.b 52,237,30,62,108,242,133,236,23,170,84,51,8,157,50,3,36,88,31,139,86,169,147,232,17,156,54,144,15,201,88,200,
dc.b 209,242,150,237,216,185,98,149,8,144,164,69,143,48,99,212,89,104,110,213,128,36,138,84,232,140,52,15,22,78,228,29,
dc.b 167,78,225,115,134,237,212,156,8,37,72,161,195,198,207,25,38,182,2,197,207,28,60,157,74,181,8,14,142,42,84,64,
dc.b 120,241,91,68,88,21,3,85,165,109,40,184,113,56,25,24,25,233,180,199,136,34,192,174,178,197,43,22,166,206,157,84,
dc.b 161,22,5,82,220,144,165,85,60,94,201,243,99,199,130,188,58,34,207,73,175,246,183,32,79,227,145,88,205,210,68,106,
dc.b 212,222,0,185,128,233,45,74,181,105,228,98,175,11,86,138,27,74,149,17,123,105,209,148,58,64,134,172,233,59,190,191,
dc.b 71,143,233,244,240,239,240,78,41,106,104,42,170,165,170,85,177,100,173,49,67,104,41,205,154,51,100,124,178,85,166,205,
dc.b 163,82,160,225,123,5,80,85,130,235,209,255,191,249,250,127,211,244,121,190,205,71,124,15,158,190,148,92,1,35,13,190,
dc.b 87,99,164,223,23,29,195,140,43,254,135,83,39,43,175,252,159,151,222,254,143,237,255,15,235,254,111,223,236,126,47,109,
dc.b 178,75,115,30,236,103,246,188,31,79,119,183,241,246,188,29,190,239,155,83,109,239,19,248,210,165,188,222,131,189,190,241,
dc.b 222,231,12,55,243,140,30,91,128,220,39,67,153,139,140,188,237,153,179,99,238,253,190,47,87,147,193,229,240,249,118,54,
dc.b 157,197,162,85,26,100,247,173,218,93,175,96,205,189,250,204,30,135,59,152,227,163,251,223,143,179,217,252,159,217,253,255,
dc.b 221,253,93,158,166,102,26,82,181,230,187,245,120,190,95,139,253,127,55,231,255,159,139,253,255,227,229,240,233,185,219,127,
dc.b 14,20,178,102,253,82,217,196,168,80,40,92,219,159,155,155,214,254,47,195,213,235,99,178,102,164,209,22,164,57,210,208,
dc.b 239,231,253,29,222,246,135,159,82,12,7,147,108,16,161,122,230,184,12,219,115,49,113,114,243,57,221,62,191,181,214,236,
dc.b 123,191,139,249,253,255,229,252,125,112,112,134,169,15,212,224,119,169,220,249,127,95,195,240,252,63,159,252,191,207,243,124,
dc.b 31,31,111,187,161,235,215,221,121,187,189,6,52,89,116,40,92,52,105,18,133,192,242,236,219,97,129,119,177,94,197,105,
dc.b 226,42,73,137,28,4,205,235,249,17,248,184,96,68,160,88,242,182,43,154,98,97,183,112,14,187,251,93,108,239,220,254,
dc.b 14,207,240,254,239,187,238,117,122,56,238,48,239,87,35,47,70,43,221,125,79,179,197,245,119,187,189,206,223,201,241,254,
dc.b 190,231,123,201,163,170,231,125,255,24,190,126,173,178,195,51,235,47,176,27,55,195,190,106,209,139,59,176,9,163,133,110,
dc.b 88,4,210,6,206,153,58,165,42,128,111,66,5,8,68,92,214,45,188,104,213,157,246,14,23,59,158,61,51,139,130,205,
dc.b 106,116,71,72,175,66,47,6,238,182,158,158,143,171,201,226,208,207,240,124,255,63,213,159,228,243,233,57,117,183,184,6,
dc.b 188,250,20,78,57,181,11,162,80,178,244,17,229,138,213,87,87,108,24,44,76,128,233,145,107,89,66,12,31,52,100,234,
dc.b 5,11,23,50,192,109,133,137,205,197,3,203,196,196,196,194,190,195,203,246,122,93,76,220,134,237,111,2,86,206,145,82,
dc.b 140,152,14,245,61,127,95,213,243,247,59,189,174,215,209,222,240,121,61,30,189,125,183,97,15,207,129,34,164,241,200,139,
dc.b 42,169,7,81,35,3,78,74,129,26,145,156,133,234,211,167,64,94,213,48,130,250,54,11,157,66,182,247,3,39,43,39,
dc.b 157,141,149,149,143,143,145,236,244,186,25,46,49,91,184,198,195,193,102,193,74,36,71,207,21,173,90,100,55,186,250,62,
dc.b 141,15,7,205,255,127,245,251,62,111,159,191,159,245,234,111,240,112,1,75,195,129,6,77,33,43,218,228,137,62,148,249,
dc.b 114,166,79,180,101,42,235,198,55,138,211,33,54,69,57,224,13,118,140,30,68,154,243,11,35,216,205,234,251,125,111,111,
dc.b 218,205,246,115,122,89,190,207,71,167,151,143,147,138,213,106,51,66,28,183,11,158,60,86,172,233,92,90,223,111,151,195,
dc.b 219,249,62,94,231,123,189,223,208,242,249,244,246,53,246,54,130,59,65,7,132,144,198,125,196,203,102,201,143,42,141,131,
dc.b 1,39,87,161,114,138,9,52,85,154,148,171,23,72,173,147,92,60,124,172,172,207,99,47,31,153,141,206,199,203,205,246,
dc.b 250,93,12,220,150,236,213,40,64,100,185,163,199,211,93,170,60,82,188,200,27,90,126,157,15,30,127,143,205,229,245,105,
dc.b 233,234,106,236,236,185,214,213,117,181,179,173,178,242,28,206,73,188,145,225,65,129,196,246,12,170,166,18,48,195,199,112,
dc.b 223,5,114,34,196,194,188,169,5,144,94,97,97,96,96,227,100,98,225,55,230,97,182,107,129,132,61,23,135,133,124,177,
dc.b 33,224,173,132,105,2,61,153,180,100,168,249,73,208,54,190,237,77,125,183,91,91,207,5,4,60,47,223,188,224,226,8,
dc.b 35,225,123,196,245,227,183,78,118,117,245,117,183,55,224,113,213,50,145,82,246,163,204,75,82,9,23,84,6,139,54,133,
dc.b 2,43,165,107,90,226,14,191,200,199,198,195,109,132,197,49,225,118,33,113,102,241,212,74,20,45,29,228,193,133,218,99,
dc.b 165,43,205,131,193,192,50,13,190,12,25,193,3,142,149,130,70,221,90,100,142,56,175,93,108,57,216,217,114,48,183,192,
dc.b 250,52,186,165,207,38,88,194,242,233,34,3,54,9,66,220,250,0,197,71,19,94,95,97,115,114,178,249,249,60,209,132,
dc.b 198,97,42,105,134,47,208,154,44,96,90,128,169,109,235,75,246,139,82,26,179,198,252,43,11,115,120,38,41,236,8,145,
dc.b 99,205,2,245,176,46,84,169,58,76,30,7,143,1,110,55,183,184,68,123,168,90,58,153,66,155,164,103,204,217,23,16,
dc.b 146,192,195,70,135,6,187,90,211,15,154,227,35,159,145,142,227,23,1,112,27,122,33,17,18,110,20,40,80,193,196,0,
dc.b 73,165,107,114,71,225,6,201,223,11,36,125,14,44,144,4,26,22,9,185,44,193,91,149,101,12,224,196,135,26,68,137,
dc.b 51,64,1,170,16,92,193,179,132,163,186,200,106,232,13,45,155,133,142,166,5,87,105,132,221,190,47,55,25,199,55,9,
dc.b 138,229,96,109,194,161,208,155,240,25,130,83,1,110,181,42,18,226,130,207,111,187,220,222,123,197,26,136,235,210,11,137,
dc.b 192,147,127,237,105,220,100,160,94,80,187,32,98,244,53,64,200,187,196,224,253,106,228,128,86,141,64,173,131,10,65,183,
dc.b 26,140,187,131,163,54,106,197,88,57,177,146,79,54,64,62,129,91,118,174,91,176,46,173,153,42,32,95,95,0,236,119,
dc.b 176,33,242,3,96,15,34,30,36,199,71,75,217,165,201,46,44,40,188,166,217,36,169,32,96,69,135,195,4,131,134,205,
dc.b 32,24,251,69,78,168,90,197,165,248,98,135,48,97,33,154,197,66,135,113,123,161,194,228,18,10,219,131,218,118,196,192,
dc.b 170,79,149,35,142,64,203,60,73,19,39,138,196,73,29,88,159,249,66,214,66,110,101,113,198,133,12,21,106,79,28,208,
dc.b 30,0,60,177,127,173,106,83,128,26,103,78,165,92,161,211,200,194,177,149,6,140,46,92,198,249,160,188,69,120,132,161,
dc.b 37,90,48,72,16,199,85,28,45,110,229,170,179,166,18,10,89,213,73,82,218,4,39,65,188,75,148,36,204,36,88,171,
dc.b 74,140,200,208,120,184,131,180,69,51,148,129,192,0,196,132,243,159,134,15,197,149,66,185,99,136,129,60,17,128,240,36,
dc.b 72,165,139,92,6,151,205,25,48,91,118,153,18,49,3,116,9,84,43,8,219,78,140,233,106,192,20,65,62,181,136,12,
dc.b 43,31,104,201,80,17,224,166,139,66,160,89,145,226,193,123,186,239,123,127,121,219,200,17,69,17,224,38,146,162,241,59,
dc.b 220,221,220,222,131,199,66,208,138,241,62,217,58,117,18,101,108,25,223,223,181,109,129,124,198,236,78,186,233,56,74,154,
dc.b 214,44,135,198,2,155,227,28,164,102,48,108,67,157,72,59,33,46,104,19,242,43,112,86,147,46,59,224,141,45,199,78,
dc.b 93,11,13,31,4,208,133,218,240,188,119,182,239,124,32,110,44,185,180,185,112,168,21,232,121,42,155,171,160,146,85,10,
dc.b 83,142,186,88,181,105,40,231,95,120,181,98,229,203,86,171,82,17,236,49,148,160,23,105,55,222,51,64,70,212,7,10,
dc.b 215,157,34,40,192,60,1,22,210,84,2,32,131,188,236,102,115,131,136,122,206,60,120,208,66,86,96,199,151,54,141,146,
dc.b 166,71,32,88,181,80,169,80,103,65,74,165,173,48,89,51,196,194,106,197,117,216,58,184,133,10,198,161,66,141,24,42,
dc.b 68,128,185,7,144,161,74,169,98,149,203,19,165,64,110,128,124,88,178,42,60,216,207,223,200,149,32,148,11,61,217,214,
dc.b 214,222,124,243,109,236,104,91,250,250,186,186,58,91,27,144,57,43,86,46,169,139,70,184,142,26,221,160,42,124,250,91,
dc.b 229,204,26,179,107,130,52,21,43,210,94,41,46,145,66,133,105,206,16,132,213,75,28,124,79,163,203,141,104,249,131,138,
dc.b 25,50,191,194,30,64,169,61,219,152,112,36,198,143,78,109,75,150,79,23,169,112,194,101,75,149,21,54,160,225,21,37,
dc.b 240,106,232,232,125,175,53,124,142,157,191,143,195,52,205,229,233,211,2,109,91,187,144,249,37,112,199,42,148,40,5,130,
dc.b 246,217,62,222,119,224,247,253,255,195,217,254,62,174,99,139,245,202,142,212,164,80,234,19,165,10,154,54,145,74,98,245,
dc.b 226,235,186,213,243,248,190,143,211,240,252,153,254,151,49,129,41,5,56,101,109,92,186,82,52,16,40,210,166,43,78,164,
dc.b 184,83,39,214,18,210,42,185,160,244,10,148,232,74,215,7,244,167,1,248,132,1,165,233,11,168,94,216,78,218,249,179,
dc.b 103,25,56,183,235,210,151,173,57,243,183,207,56,32,61,135,62,112,130,35,247,58,190,191,39,217,167,246,250,116,62,157,
dc.b 7,49,128,170,101,92,24,151,90,181,134,30,47,63,175,157,210,231,228,251,24,204,86,46,103,126,160,242,190,102,99,140,
dc.b 70,140,154,168,70,156,83,163,86,141,41,176,225,11,168,120,118,158,195,147,66,185,67,71,77,139,125,84,166,72,128,189,
dc.b 57,244,37,200,124,242,28,39,162,71,94,167,91,58,206,118,53,181,221,190,226,223,219,116,253,254,211,189,231,245,211,180,
dc.b 105,128,225,198,86,111,79,59,170,40,98,236,126,14,191,185,238,246,51,179,187,30,231,79,159,141,129,123,125,122,164,240,
dc.b 96,16,203,117,171,20,30,105,121,188,126,125,61,190,8,147,6,116,225,72,133,183,193,22,36,104,242,39,1,165,75,141,
dc.b 62,108,55,155,195,68,70,254,20,7,142,117,246,119,161,200,136,255,131,132,104,69,165,218,60,199,155,153,148,221,179,110,
dc.b 99,124,76,70,140,47,185,153,29,31,101,198,55,177,151,205,195,190,100,202,245,131,38,41,206,145,62,109,42,18,31,189,
dc.b 119,173,171,173,255,218,143,56,95,201,159,70,104,110,187,231,123,220,59,227,65,195,42,76,72,115,37,60,120,249,236,126,
dc.b 73,18,108,161,68,94,213,195,38,142,165,82,50,146,177,98,198,55,237,253,140,238,199,187,215,205,232,251,93,28,188,156,
dc.b 108,38,216,56,156,204,28,60,172,150,237,154,180,102,37,70,189,133,226,148,1,109,34,206,119,219,122,251,58,158,95,14,
dc.b 134,135,139,211,171,173,165,163,246,122,125,30,79,71,167,235,245,233,236,139,246,224,191,225,121,177,167,173,175,173,173,180,
dc.b 254,92,249,179,39,85,179,94,197,122,35,56,133,78,41,89,123,141,155,211,233,117,191,111,59,175,156,41,135,26,52,140,
dc.b 188,188,220,238,174,111,67,31,13,179,69,169,210,42,189,106,201,114,99,100,86,151,3,111,87,238,117,171,234,214,220,12,
dc.b 133,217,213,213,210,211,218,121,184,237,252,17,8,72,147,104,79,22,179,188,221,115,174,231,108,83,197,76,87,73,112,139,
dc.b 67,71,146,45,181,75,116,205,187,135,24,249,25,28,236,124,207,104,79,243,171,212,203,201,203,233,245,186,185,185,88,216,
dc.b 248,215,235,194,151,238,174,215,175,84,136,197,153,176,120,94,187,117,179,165,230,243,232,250,0,230,187,125,206,239,209,223,
dc.b 241,250,125,90,58,159,118,206,235,248,99,65,250,33,15,21,239,4,8,145,37,87,48,73,203,16,146,150,245,43,5,246,
dc.b 236,2,242,216,176,85,116,181,125,238,8,141,179,118,248,217,157,94,199,99,173,156,63,217,185,153,153,88,119,216,110,49,
dc.b 177,24,167,57,110,120,180,58,14,239,221,163,230,207,250,126,110,215,107,229,248,254,47,213,251,59,189,255,23,144,114,87,
dc.b 60,48,229,114,82,168,58,236,28,178,209,67,129,165,247,98,36,233,209,36,78,75,51,205,18,128,81,50,145,64,130,1,
dc.b 0,1,204,216,182,195,111,143,151,151,147,143,145,207,231,227,227,99,100,101,229,228,98,243,48,152,38,60,116,10,226,84,
dc.b 55,174,116,189,62,111,30,127,135,195,159,226,241,120,180,60,153,249,254,47,54,142,174,187,157,215,155,207,95,198,151,201,
dc.b 78,209,147,233,7,185,87,173,37,192,65,57,136,78,24,0,97,7,164,10,179,68,145,17,241,107,26,133,139,239,67,166,
dc.b 197,151,237,155,9,219,184,200,203,204,201,197,196,191,96,168,104,38,11,220,167,40,99,239,84,82,93,167,165,169,179,182,
dc.b 231,101,214,206,203,161,86,6,235,222,46,23,225,134,115,105,217,32,202,21,4,173,100,153,4,146,100,163,69,200,184,72,
dc.b 49,2,201,140,32,18,9,7,55,38,146,48,164,229,42,185,91,160,207,3,7,16,85,159,130,201,98,116,38,133,106,53,
dc.b 128,91,95,240,239,10,77,119,197,38,33,181,240,224,62,39,228,40,194,128,49,160,250,175,112,151,212,137,239,146,235,195,
dc.b 102,9,152,24,71,141,154,193,161,86,202,152,37,1,39,121,79,44,75,169,16,11,212,131,166,134,136,137,176,1,66,225,
dc.b 27,116,135,71,215,45,100,85,63,13,243,232,2,4,225,171,48,248,119,222,110,237,186,114,51,131,191,195,16,2,82,168,
dc.b 29,65,58,18,209,162,198,39,248,29,108,57,57,4,183,32,158,220,12,48,39,68,56,92,183,41,204,70,144,140,114,69,
dc.b 42,215,10,99,196,212,0,16,204,19,66,192,10,68,168,195,72,224,5,253,108,86,29,55,142,49,45,87,126,63,232,81,
dc.b 196,239,5,3,199,146,38,72,78,19,137,160,144,59,40,217,114,92,178,40,30,46,43,159,58,41,28,34,207,44,197,197,
dc.b 218,54,45,21,54,75,219,20,19,73,216,60,200,57,209,160,172,26,244,37,4,187,77,157,74,193,5,46,87,164,15,40,
dc.b 18,67,46,108,206,62,57,67,71,86,52,101,162,196,203,197,138,132,198,212,127,254,132,160,240,237,82,82,202,108,117,49,
dc.b 123,86,45,218,171,76,31,54,144,204,236,190,74,85,108,92,44,96,224,211,2,21,37,189,60,168,98,15,178,176,26,171,
dc.b 76,13,228,155,193,3,156,105,147,250,20,9,70,39,32,237,128,32,51,168,79,141,16,119,42,12,197,38,230,9,162,76,
dc.b 142,85,112,5,152,14,59,94,217,43,104,184,22,173,104,168,208,224,33,19,78,30,63,19,193,25,74,70,52,45,160,81,
dc.b 67,42,7,11,137,206,147,67,24,72,88,12,160,208,16,72,10,178,156,43,228,251,220,245,112,95,177,247,184,144,161,60,
dc.b 112,150,155,18,204,42,131,71,123,86,176,185,150,124,233,211,168,86,182,65,129,66,146,34,104,33,64,132,240,242,242,112,
dc.b 172,254,85,103,6,42,156,55,202,252,162,81,180,45,81,175,66,111,28,137,3,75,11,78,185,60,206,183,42,227,249,87,
dc.b 202,74,80,230,203,147,34,72,148,140,250,85,108,220,182,61,0,74,161,69,52,245,174,10,56,212,135,177,50,189,98,201,
dc.b 152,254,47,89,181,191,104,205,135,46,128,180,150,53,29,70,152,105,39,210,29,50,90,221,25,81,226,66,125,197,197,196,
dc.b 41,247,28,55,140,149,144,73,144,61,90,52,219,220,184,223,117,173,175,178,40,131,18,205,26,36,80,160,138,1,201,220,
dc.b 184,194,56,141,66,213,247,130,140,155,230,163,75,73,139,140,45,236,195,105,120,172,120,169,24,117,184,251,87,172,152,174,
dc.b 84,42,227,38,225,171,53,7,124,134,188,13,26,29,90,3,193,150,44,12,180,87,167,58,60,46,23,90,218,90,218,254,
dc.b 189,109,161,12,104,130,62,128,46,145,33,242,82,151,82,180,170,97,69,231,80,26,76,173,34,139,197,247,87,108,151,180,
dc.b 193,21,210,45,86,181,90,197,42,25,95,39,80,177,106,36,9,16,171,40,97,162,50,23,93,218,55,90,117,174,45,249,
dc.b 81,166,194,146,68,168,84,144,25,48,142,169,85,168,173,211,153,193,164,235,235,137,63,110,179,215,86,138,30,50,156,206,
dc.b 180,185,91,15,180,116,180,123,190,63,62,241,101,40,169,207,58,173,26,222,109,233,252,188,190,167,244,245,51,61,206,199,
dc.b 228,236,175,149,97,93,211,84,4,27,226,155,49,249,9,82,209,159,10,219,85,107,88,74,217,253,90,152,184,165,104,219,
dc.b 134,233,233,100,207,119,225,107,198,196,232,83,115,102,212,94,255,218,195,242,251,204,113,153,95,244,138,114,107,193,147,21,
dc.b 107,199,78,191,199,193,77,178,231,178,149,56,172,82,254,181,218,137,182,198,145,239,21,2,236,89,70,88,95,44,155,11,
dc.b 228,132,224,218,41,93,207,135,73,255,150,155,173,22,199,113,113,226,107,209,206,236,251,222,209,92,166,76,156,23,83,171,
dc.b 254,222,95,209,240,124,27,22,72,63,7,98,137,187,235,244,213,36,144,115,18,250,85,186,191,117,11,236,2,196,33,133,
dc.b 219,243,196,226,144,90,236,245,133,40,83,43,89,213,103,117,205,197,98,153,61,81,131,104,78,15,15,123,155,77,187,9,
dc.b 253,249,36,146,73,126,73,36,146,73,52,211,109,182,219,27,96,193,140,108,0,128,18,66,82,74,73,161,174,146,205,116,
dc.b 182,221,182,189,182,237,221,123,123,186,251,219,227,111,117,221,239,124,63,123,119,111,118,247,95,118,214,219,111,172,146,219,
dc.b 36,150,107,36,146,144,146,18,4,32,72,1,33,0,6,0,0,216,198,219,109,54,155,73,36,146,73,36,146,95,127,191,
dc.b 217,59,222,135,15,125,247,116,178,70,148,123,143,125,136,243,78,91,24,54,241,107,61,216,236,119,145,216,157,159,59,62,
dc.b 174,124,149,251,178,243,52,237,246,159,99,127,252,123,42,87,240,35,92,91,220,201,169,217,227,115,190,14,167,43,167,73,
dc.b 230,11,91,167,218,110,235,201,153,98,174,123,106,221,254,246,123,53,238,29,245,58,220,254,103,59,157,164,180,76,191,147,
dc.b 165,244,74,123,30,247,115,186,136,218,126,159,111,46,212,230,85,117,174,54,91,24,45,86,177,120,222,138,211,66,242,243,
dc.b 107,86,144,9,241,86,139,251,237,207,151,179,118,218,211,38,235,59,113,94,164,153,89,125,218,149,86,118,245,189,150,206,
dc.b 145,71,61,152,17,227,183,88,50,93,105,147,244,243,117,51,251,125,249,206,98,199,141,90,124,124,13,166,251,115,145,120,
dc.b 190,111,115,67,74,141,25,75,193,97,229,230,31,7,135,187,222,98,182,32,42,228,114,59,189,156,202,96,116,173,174,34,
dc.b 51,97,221,90,108,62,115,23,97,133,176,137,17,110,183,95,48,134,34,109,9,90,50,103,210,117,5,157,150,76,64,121,
dc.b 78,204,21,165,201,235,115,190,127,164,153,206,141,103,151,23,86,208,99,236,111,93,47,63,191,220,232,241,249,186,50,245,
dc.b 156,224,91,193,139,26,255,123,229,120,187,173,140,103,38,153,26,156,254,87,67,149,243,119,59,93,202,38,138,203,6,38,
dc.b 49,127,184,223,110,254,183,15,133,143,10,205,10,90,29,110,191,79,167,220,233,253,18,4,188,209,31,61,114,225,236,44,
dc.b 11,120,175,236,214,145,170,249,241,41,254,162,208,26,210,156,229,180,245,169,200,233,252,31,63,115,73,164,77,134,54,247,
dc.b 198,223,239,200,37,240,33,176,230,118,132,234,212,115,251,249,93,46,143,51,153,212,206,151,58,172,218,148,59,205,112,118,
dc.b 23,209,163,222,226,225,62,181,159,149,162,66,205,151,147,220,151,57,222,199,2,221,251,219,188,76,60,92,38,22,108,182,
dc.b 142,92,178,96,214,173,44,78,152,41,53,109,10,19,123,51,122,157,141,93,89,26,51,91,198,188,196,222,97,198,192,192,
dc.b 140,245,180,142,174,149,86,110,222,58,173,167,159,173,86,102,142,103,99,74,100,173,26,14,93,220,227,238,182,119,209,219,
dc.b 218,179,69,74,44,243,187,51,0,107,173,89,1,100,135,110,245,212,123,151,142,86,205,236,76,104,226,28,87,54,165,75,
dc.b 176,217,181,122,180,41,218,157,154,109,155,85,213,149,160,186,109,23,27,101,119,135,123,114,253,147,14,22,175,90,144,182,
dc.b 19,185,153,54,126,112,103,237,46,255,79,186,215,97,135,145,143,133,29,186,224,142,185,93,78,166,151,127,163,222,149,72,
dc.b 8,156,88,9,89,173,230,70,208,73,90,254,193,45,192,154,82,211,167,26,89,114,217,63,130,253,205,154,243,187,218,11,
dc.b 3,128,161,36,96,169,209,218,79,178,253,149,71,13,217,48,12,121,87,55,165,221,176,196,253,42,118,167,233,154,21,188,
dc.b 33,112,142,214,117,86,208,222,206,157,70,86,166,86,138,225,71,77,151,55,179,102,230,11,242,133,109,171,168,147,187,0,
dc.b 207,83,145,34,195,179,104,104,142,167,205,173,62,109,77,12,218,244,179,179,167,59,188,188,116,205,157,102,140,92,17,73,
dc.b 223,94,132,57,202,151,62,94,159,115,55,91,189,147,162,179,54,209,136,53,153,86,111,121,131,119,5,103,45,105,216,171,
dc.b 98,205,13,60,189,30,215,211,149,45,136,144,29,193,11,226,98,21,240,20,123,8,59,29,75,83,100,202,173,103,59,169,
dc.b 223,167,94,156,220,233,116,245,170,179,139,178,194,142,196,40,43,217,110,72,55,70,125,77,46,246,111,126,94,177,22,172,
dc.b 169,146,117,43,155,38,2,157,220,63,129,117,29,134,246,43,88,214,147,61,119,173,170,77,68,18,21,31,69,139,117,119,
dc.b 128,37,20,183,140,221,146,213,42,207,151,38,74,45,157,180,184,47,115,54,0,8,13,183,8,64,136,180,233,135,251,210,
dc.b 178,244,24,89,243,212,158,128,33,90,188,242,0,240,250,67,89,165,196,19,174,160,194,32,19,109,98,157,117,153,48,237,
dc.b 157,73,90,98,165,20,223,144,152,205,179,224,82,182,30,61,14,245,94,160,87,249,155,3,111,181,169,209,69,154,90,154,
dc.b 148,80,60,131,232,57,114,196,8,119,54,208,161,186,39,90,8,103,145,163,163,169,42,68,153,116,151,104,233,136,86,246,
dc.b 247,247,247,119,54,241,159,136,199,207,44,150,147,184,230,72,82,119,118,239,193,196,137,138,136,111,32,57,177,52,220,135,
dc.b 75,74,92,240,238,59,69,89,104,158,193,187,2,82,198,64,201,107,216,88,255,244,74,240,108,25,52,137,122,165,166,85,
dc.b 64,5,27,189,124,237,71,239,56,112,31,10,177,191,58,226,183,217,66,187,233,129,33,171,182,68,197,102,236,0,72,132,
dc.b 15,236,171,79,151,56,130,18,176,23,163,14,152,77,155,215,108,204,67,36,64,101,70,194,36,199,1,224,114,86,46,152,
dc.b 21,155,55,55,166,167,40,156,253,61,229,187,183,174,27,194,132,136,122,129,68,94,134,11,159,163,52,246,93,45,89,180,
dc.b 105,166,250,45,2,194,196,64,77,153,89,100,218,185,1,85,58,21,235,150,166,22,42,189,109,89,85,103,201,155,100,93,
dc.b 24,245,19,194,7,237,50,176,48,128,105,106,187,37,172,208,149,92,30,168,65,130,244,44,14,56,27,147,215,206,153,164,
dc.b 2,180,64,11,117,180,181,12,220,106,207,163,101,195,150,238,161,64,5,51,87,237,87,166,151,18,202,200,9,155,130,87,
dc.b 198,77,72,188,151,175,101,187,75,43,175,100,13,190,205,123,44,215,172,67,192,136,207,53,199,227,63,58,195,135,75,148,
dc.b 9,236,46,29,180,89,112,30,129,11,53,73,179,132,217,83,40,209,174,107,62,76,56,229,176,168,58,112,153,225,21,199,
dc.b 185,114,204,192,41,156,121,116,171,207,32,161,161,105,153,250,246,22,108,233,149,166,78,130,20,196,18,236,61,108,205,122,
dc.b 160,50,66,71,149,148,138,190,34,6,236,70,52,95,141,122,149,232,138,225,0,88,53,117,38,216,1,249,100,217,244,39,
dc.b 239,156,38,14,42,149,32,169,18,185,227,45,107,209,167,59,86,109,57,192,120,172,130,41,207,168,213,157,114,222,44,216,
dc.b 3,84,118,249,243,230,166,57,231,50,100,4,178,39,178,124,240,75,106,49,233,106,89,171,178,43,112,55,29,93,25,0,
dc.b 105,245,146,21,39,35,1,18,31,91,2,248,113,39,157,138,160,61,37,12,201,20,193,85,18,73,149,189,138,212,165,79,
dc.b 177,93,17,199,88,92,240,58,172,139,17,116,48,232,175,105,162,202,67,209,0,143,180,195,228,7,173,12,65,191,134,41,
dc.b 239,23,17,34,53,93,105,180,103,217,34,210,1,28,106,201,19,206,205,174,209,89,5,89,177,21,164,185,225,124,148,232,
dc.b 82,180,93,29,16,75,186,228,8,173,198,82,54,87,4,129,105,94,117,66,45,153,213,217,34,150,170,100,83,160,63,78,
dc.b 204,190,150,84,237,173,105,168,190,138,133,36,194,201,232,174,28,59,130,248,182,84,220,148,91,27,84,134,173,193,106,32,
dc.b 75,147,229,203,65,59,68,212,19,168,87,69,20,171,32,59,207,0,216,9,34,218,87,93,187,52,93,19,106,169,130,37,
dc.b 194,124,217,146,27,70,189,189,182,35,33,79,218,212,35,194,214,212,19,95,174,66,98,137,211,103,82,100,103,98,189,138,
dc.b 84,209,35,217,148,67,252,209,170,96,216,240,176,193,51,214,11,142,89,52,78,125,108,245,177,224,77,89,32,150,33,241,
dc.b 83,232,23,72,213,122,225,60,14,152,135,24,218,213,195,75,52,106,80,52,1,239,104,233,233,23,221,1,250,231,129,53,
dc.b 100,217,210,45,210,180,108,140,99,237,105,211,196,95,192,144,204,236,17,81,22,80,178,9,159,68,81,234,221,236,56,204,
dc.b 25,131,36,209,127,0,142,25,170,38,107,4,151,177,80,43,165,52,11,106,99,238,146,70,65,172,8,107,32,142,249,118,
dc.b 172,211,17,194,56,162,61,210,158,93,89,195,100,22,148,186,39,115,175,70,88,190,101,99,239,137,218,104,83,12,92,123,
dc.b 14,1,139,23,240,32,19,70,163,66,166,72,150,88,16,61,24,89,176,228,51,213,20,196,36,156,2,214,173,45,25,84,
dc.b 102,24,63,54,196,168,83,67,36,35,221,220,57,75,131,48,116,179,119,142,215,52,7,46,20,78,164,64,215,84,147,185,
dc.b 98,133,126,254,36,33,73,115,247,100,185,141,173,9,221,236,215,36,102,172,179,151,112,237,224,60,116,213,48,92,103,218,
dc.b 100,185,114,69,134,146,9,54,230,137,52,237,22,80,72,162,137,48,67,42,69,217,8,189,133,153,41,187,66,90,116,24,
dc.b 242,149,18,231,217,53,106,23,230,244,37,244,51,174,11,214,233,39,194,74,0,178,90,69,144,90,0,71,225,35,186,94,
dc.b 34,225,228,164,104,65,121,218,122,58,104,197,38,141,83,15,140,147,81,21,147,3,164,146,245,217,53,114,111,16,77,70,
dc.b 102,36,92,193,69,75,224,207,197,93,236,18,92,168,33,149,172,36,141,238,157,55,45,149,6,21,170,177,45,107,14,211,
dc.b 50,9,42,195,52,79,247,94,134,182,142,124,145,60,140,148,97,207,96,181,64,112,192,249,245,145,161,194,237,129,91,196,
dc.b 42,195,6,16,105,121,98,99,113,61,35,82,233,146,108,214,32,132,11,59,126,253,36,107,49,20,186,225,17,137,152,151,
dc.b 108,62,97,22,134,182,50,165,101,23,228,149,0,207,192,244,84,96,114,74,114,109,114,171,22,176,103,122,213,133,41,38,
dc.b 93,153,121,21,85,46,125,112,41,36,215,184,41,149,23,237,184,54,251,122,43,221,77,177,156,154,32,19,224,162,90,18,
dc.b 116,184,15,157,53,45,185,6,13,177,82,126,180,157,29,13,41,50,181,53,81,54,45,67,30,66,241,83,74,43,73,146,
dc.b 69,149,102,135,166,26,188,138,131,39,23,96,37,248,104,109,192,236,24,125,250,89,100,40,209,18,114,194,207,21,135,187,
dc.b 77,93,19,123,192,114,221,24,77,159,23,44,246,76,129,122,128,42,68,144,5,106,171,53,110,109,160,141,161,214,178,139,
dc.b 36,235,135,172,2,213,146,155,203,161,62,154,45,52,48,14,201,186,79,231,6,24,194,20,55,22,28,52,86,46,245,219,
dc.b 242,36,242,108,198,166,212,175,161,65,48,210,222,213,123,85,40,209,155,169,163,163,163,172,147,54,74,14,170,160,154,134,
dc.b 89,39,115,47,242,100,163,73,148,192,16,166,221,21,58,78,154,141,160,236,169,90,104,171,25,155,86,29,193,34,89,192,
dc.b 191,70,16,177,83,110,20,106,82,213,176,123,203,165,0,104,233,21,161,22,172,101,70,81,100,64,124,104,161,92,30,32,
dc.b 150,136,85,80,154,230,34,122,241,85,193,134,99,85,226,123,185,104,190,249,107,54,147,44,109,220,46,187,96,251,152,247,
dc.b 23,251,11,224,192,98,252,143,66,39,246,96,46,16,215,49,177,31,91,66,124,116,27,102,164,225,13,126,110,126,134,118,
dc.b 118,156,218,21,10,100,189,50,254,103,79,170,89,41,54,157,20,83,20,138,152,233,167,166,139,29,147,75,117,150,44,165,
dc.b 128,5,65,79,200,183,44,89,71,26,226,44,19,85,134,198,143,96,52,16,95,64,122,109,28,48,236,92,153,140,18,78,
dc.b 150,180,144,133,176,140,41,101,61,69,38,174,38,202,213,61,68,208,158,161,163,53,51,69,209,67,98,149,42,56,100,99,
dc.b 157,22,200,88,100,213,135,240,237,144,7,240,7,225,107,179,228,87,36,0,182,99,52,178,99,25,164,244,144,6,54,198,
dc.b 167,129,14,194,157,213,46,232,213,212,211,21,83,165,238,214,166,107,4,138,27,167,38,53,146,127,89,245,75,127,64,197,
dc.b 2,70,153,162,194,66,193,24,3,150,25,211,91,198,131,10,34,46,148,2,92,0,6,122,110,180,158,198,241,25,174,187,
dc.b 110,206,185,183,122,101,216,143,104,83,203,169,32,243,201,230,186,225,150,41,161,236,229,41,58,77,138,165,205,76,87,12,
dc.b 181,12,213,24,199,84,95,13,81,121,228,27,123,155,180,158,26,36,23,241,45,237,227,4,0,219,67,141,115,111,14,3,
dc.b 242,163,17,185,174,166,92,5,139,202,8,3,208,145,164,6,28,42,74,214,20,146,163,13,20,105,11,60,167,39,138,75,
dc.b 77,130,141,143,66,126,170,86,80,62,6,144,161,45,175,192,146,45,162,219,169,134,84,49,137,232,9,0,6,4,72,136,
dc.b 13,233,232,65,73,40,80,73,113,230,222,210,134,187,35,58,80,18,57,133,143,76,26,156,35,40,163,212,166,74,66,178,
dc.b 102,8,82,232,144,219,132,255,212,76,244,178,108,133,119,54,27,0,1,85,69,1,131,21,246,197,64,232,211,36,72,174,
dc.b 77,23,86,193,39,68,120,209,75,128,211,59,225,171,218,71,161,201,74,142,104,133,80,106,102,0,216,54,182,1,30,69,
dc.b 138,32,14,98,166,9,231,215,178,205,10,63,96,199,249,131,212,244,88,145,34,149,18,52,13,133,1,23,226,65,16,129,
dc.b 38,241,175,20,180,176,211,145,192,189,174,205,73,211,21,81,166,236,34,189,89,232,85,89,28,177,83,34,27,221,52,98,
dc.b 135,62,122,122,72,14,217,34,26,7,172,67,24,94,201,75,197,69,247,177,8,29,79,137,162,105,80,176,241,87,210,34,
dc.b 245,61,176,217,225,3,33,40,116,106,100,107,163,173,50,137,140,73,230,133,161,97,212,205,87,230,17,219,1,98,204,69,
dc.b 102,9,153,128,193,5,52,215,40,99,18,176,31,195,131,10,40,213,9,208,172,16,216,234,40,11,235,196,91,24,250,8,
dc.b 154,101,21,185,145,149,147,26,86,11,147,212,2,46,209,207,1,199,19,251,79,160,22,220,98,152,171,13,48,4,170,134,
dc.b 23,202,212,57,58,106,155,121,17,210,17,165,60,118,5,74,248,40,222,20,72,15,30,57,43,52,106,116,149,161,255,207,
dc.b 17,104,210,44,77,102,213,161,179,196,244,183,48,61,82,248,139,11,26,209,141,53,181,81,207,109,53,48,220,77,20,15,
dc.b 87,21,246,78,75,138,172,166,53,38,45,13,108,136,126,80,48,210,37,181,97,37,10,166,26,147,155,30,61,43,205,118,
dc.b 166,69,145,166,132,148,82,42,179,206,11,129,75,109,40,129,22,161,165,49,42,74,105,233,88,142,124,168,165,169,126,218,
dc.b 23,240,168,62,83,115,215,165,16,124,76,176,58,65,92,156,187,72,252,82,172,61,53,246,184,166,198,129,9,2,105,74,
dc.b 81,40,69,94,122,105,25,82,162,127,106,41,111,2,124,164,120,44,192,191,20,179,148,173,147,106,70,229,148,176,150,236,
dc.b 98,97,219,157,113,24,136,151,139,133,24,167,159,237,134,202,100,244,139,243,42,83,170,161,74,143,43,22,81,26,88,210,
dc.b 166,154,71,210,42,42,196,183,106,15,18,194,71,127,224,92,157,41,22,90,216,70,217,195,51,116,99,81,10,9,81,163,
dc.b 93,228,134,180,248,44,160,76,106,59,85,112,217,14,69,14,43,169,87,95,210,144,225,117,54,165,22,172,235,179,75,75,
dc.b 37,64,223,106,212,255,245,166,155,25,50,113,224,177,4,110,56,241,195,101,50,200,102,213,76,228,76,154,61,126,175,184,
dc.b 153,23,73,48,234,80,4,9,170,96,209,90,125,217,178,94,230,187,44,27,36,27,200,203,189,48,154,46,147,60,24,129,
dc.b 121,4,181,22,186,166,46,28,154,117,17,251,61,114,41,113,33,210,108,111,92,131,179,171,13,71,168,184,83,10,22,104,
dc.b 243,138,152,44,145,114,9,38,93,67,91,114,171,36,205,53,0,87,158,159,45,31,136,122,162,152,67,167,166,166,164,70,
dc.b 174,68,138,166,247,68,145,76,16,110,32,222,230,114,27,39,245,41,196,167,65,130,76,241,180,87,162,152,145,167,73,47,
dc.b 126,140,244,184,84,197,73,90,22,255,98,186,67,54,191,129,163,218,110,11,80,252,154,67,113,129,144,67,84,213,164,243,
dc.b 132,93,242,139,190,145,146,216,192,52,84,120,229,75,170,145,120,19,146,24,229,84,33,243,137,149,196,104,123,89,47,189,
dc.b 8,95,176,167,6,39,161,170,1,213,52,218,69,214,106,178,138,200,192,157,75,185,213,230,77,203,50,51,208,233,75,211,
dc.b 53,216,169,163,1,164,99,116,205,95,167,100,178,68,162,211,199,181,220,143,166,23,210,205,108,120,24,234,127,255,226,174,
dc.b 226,122,15,86,155,127,22,248,194,156,142,163,14,20,34,129,154,126,118,191,245,154,106,68,217,186,177,108,172,86,153,191,
dc.b 158,161,213,168,23,8,158,100,186,97,45,100,139,201,51,52,65,210,135,253,150,82,127,178,206,89,38,93,81,121,139,10,
dc.b 101,160,170,49,162,202,251,43,167,237,30,203,105,19,110,158,210,149,169,182,30,187,100,107,10,193,114,100,21,35,121,168,
dc.b 151,215,97,80,2,218,74,201,117,123,235,77,118,158,232,215,157,25,208,154,64,169,141,193,31,51,99,237,42,237,17,161,
dc.b 2,32,88,176,166,173,218,244,2,176,90,85,9,233,197,187,120,25,159,38,113,60,31,128,140,216,19,101,68,98,52,94,
dc.b 122,89,210,21,172,194,180,233,66,63,146,225,79,224,132,56,130,121,76,229,109,36,72,150,84,59,213,85,94,122,174,46,
dc.b 181,93,124,175,149,82,15,101,174,206,73,17,20,18,100,34,125,66,25,118,95,83,56,52,176,228,194,139,8,224,145,76,
dc.b 103,72,128,81,135,219,84,109,55,101,7,244,170,150,6,158,68,136,87,181,221,51,31,225,86,68,153,18,76,189,107,183,
dc.b 230,79,174,92,114,177,68,148,209,186,122,175,61,114,217,213,122,10,99,56,153,129,54,64,49,108,149,229,164,209,195,192,
dc.b 224,160,244,149,88,34,189,45,85,186,84,127,83,94,74,150,16,22,196,199,59,83,40,173,21,119,106,169,215,79,137,139,
dc.b 5,107,150,166,63,170,185,83,35,140,213,26,242,97,228,177,125,123,17,174,171,20,52,43,215,245,164,6,209,1,85,70,
dc.b 51,10,185,139,62,6,51,8,140,61,89,9,70,50,126,7,44,100,99,10,218,65,226,89,58,158,33,248,50,30,171,41,
dc.b 77,57,245,232,85,18,9,68,243,133,108,5,101,69,12,209,83,62,82,238,126,166,244,8,210,1,76,228,188,13,14,79,
dc.b 64,215,107,3,174,209,73,90,226,36,89,141,53,217,58,171,210,117,246,3,70,146,170,203,126,190,195,117,148,239,241,50,
dc.b 66,173,186,79,149,211,35,44,254,166,157,133,70,171,48,70,134,38,84,188,5,64,171,104,100,178,223,3,56,239,6,116,
dc.b 19,57,31,83,92,228,193,218,98,209,54,22,171,245,98,188,207,33,7,17,28,99,54,201,160,158,190,16,89,179,110,148,
dc.b 163,116,203,67,35,233,136,2,156,144,51,161,164,228,140,238,220,43,26,8,143,30,202,168,90,136,226,4,95,148,58,93,
dc.b 160,144,90,83,147,81,97,109,234,71,243,62,157,42,22,89,83,168,99,130,153,83,179,121,102,146,207,94,44,230,172,215,
dc.b 208,155,51,114,230,136,169,218,229,194,207,35,10,74,219,193,193,187,128,242,28,124,11,230,207,46,22,158,202,182,165,9,
dc.b 250,178,102,106,145,240,234,84,106,202,38,69,195,84,224,79,40,200,210,155,159,157,171,151,223,16,73,213,36,111,184,189,
dc.b 192,219,224,178,180,225,105,114,38,76,168,232,200,163,252,76,79,15,236,255,79,223,243,127,187,252,127,175,202,199,91,74,
dc.b 180,254,79,181,239,250,159,159,210,255,127,252,255,167,249,255,151,227,245,191,135,189,201,229,242,62,78,103,197,237,251,31,
dc.b 179,242,126,63,246,245,184,158,199,238,227,117,51,218,94,99,121,127,135,241,127,207,254,191,139,240,254,15,237,254,127,51,
dc.b 200,200,185,187,216,8,162,162,3,16,91,93,108,246,184,187,157,198,54,37,187,118,72,176,214,153,186,49,12,179,119,247,
dc.b 152,121,30,39,3,125,191,223,236,238,223,218,211,237,117,62,47,111,137,252,61,207,248,253,126,135,165,232,122,126,223,187,
dc.b 201,233,100,244,126,142,103,201,240,251,158,231,23,145,203,227,241,185,92,254,150,92,214,247,27,60,141,239,147,246,255,229,
dc.b 254,31,219,231,253,175,59,235,239,177,239,163,220,163,246,215,77,92,66,186,188,216,237,54,216,216,88,87,162,30,231,238,
dc.b 173,78,155,89,4,212,112,139,122,49,118,219,140,97,74,51,203,18,51,58,253,30,143,203,236,254,207,79,211,244,63,63,
dc.b 234,245,125,127,91,215,246,127,135,27,145,240,251,188,78,55,39,143,237,122,254,239,35,230,235,119,179,100,213,121,127,183,
dc.b 224,253,191,232,254,143,191,247,124,207,55,238,249,222,63,137,145,179,17,64,220,134,133,221,93,156,13,166,54,211,27,111,
dc.b 184,218,224,95,92,64,114,209,236,66,36,72,129,110,16,227,96,98,237,177,118,216,98,93,198,179,116,59,63,63,43,223,
dc.b 226,123,62,183,169,234,250,158,143,163,234,126,254,39,197,204,230,242,184,252,111,139,145,199,227,113,184,255,47,67,175,151,
dc.b 165,50,139,40,55,88,219,221,255,143,228,249,158,127,217,243,60,238,31,7,195,200,197,197,15,49,192,195,195,192,194,216,
dc.b 226,227,238,119,222,22,70,54,38,5,196,5,98,61,147,102,235,169,189,77,116,156,98,180,237,62,239,103,175,206,248,125,
dc.b 191,91,245,255,247,210,244,191,55,229,252,222,135,167,235,123,124,111,147,151,202,230,115,249,220,174,63,35,151,211,237,135,
dc.b 165,106,75,157,77,103,97,196,22,215,152,123,109,214,255,127,226,240,255,147,133,252,126,111,149,245,252,174,31,151,195,243,
dc.b 127,144,254,255,47,221,254,175,185,246,188,255,56,87,229,187,218,227,98,6,9,71,136,241,203,11,210,153,35,77,26,205,
dc.b 232,101,228,245,58,124,239,151,147,198,226,251,30,159,165,250,191,63,228,255,111,209,251,127,112,168,59,225,229,114,61,225,
dc.b 71,111,207,209,201,238,103,17,140,73,32,108,175,89,102,32,71,216,8,121,114,60,47,23,196,240,247,155,125,192,132,227,
dc.b 115,183,200,219,248,91,239,23,131,194,242,254,199,146,138,104,188,95,15,127,189,222,111,50,48,239,239,110,226,61,56,65,
dc.b 161,129,124,233,58,29,191,167,233,233,244,57,188,159,131,138,44,95,253,126,135,163,251,127,111,163,251,63,119,179,197,247,
dc.b 189,254,71,43,155,244,244,251,25,89,121,196,132,211,72,98,103,208,14,140,121,14,231,0,225,73,55,126,47,141,194,250,
dc.b 254,63,7,198,241,184,30,39,136,112,91,156,15,31,133,229,112,188,143,39,135,229,121,28,13,255,139,245,183,217,27,76,
dc.b 43,219,97,69,21,164,138,76,154,215,79,189,214,235,119,59,61,94,143,51,227,227,113,125,175,91,212,244,253,31,209,249,
dc.b 63,223,243,122,62,175,177,197,42,46,127,63,233,201,236,245,122,93,140,176,214,57,1,221,236,221,193,185,195,197,198,20,
dc.b 152,151,45,229,249,94,71,7,197,241,68,76,98,172,109,198,62,215,109,186,222,239,55,57,3,239,253,174,208,158,202,19,
dc.b 8,22,138,38,74,128,51,49,110,177,47,229,25,178,59,217,41,194,104,113,248,158,175,234,252,159,143,253,127,249,250,125,
dc.b 63,95,247,122,190,183,175,251,253,207,123,225,248,185,60,207,163,167,218,207,213,158,50,70,182,193,199,223,112,120,94,79,
dc.b 11,248,188,239,183,247,60,255,179,195,242,60,61,241,194,209,238,118,219,43,219,204,13,150,215,27,105,133,119,109,9,243,
dc.b 150,236,235,78,148,126,105,27,67,215,208,163,34,98,135,224,27,14,220,45,72,66,125,215,234,244,57,124,127,123,217,255,
dc.b 143,107,139,240,242,62,62,63,23,218,246,61,143,99,219,247,125,255,131,141,241,243,250,249,178,235,181,119,14,235,11,107,
dc.b 185,223,240,56,28,14,15,145,245,248,94,71,3,125,187,14,0,218,236,240,110,173,149,193,76,70,132,195,52,94,239,60,
dc.b 121,9,54,179,87,145,35,220,11,27,111,140,109,196,35,139,120,6,1,98,140,179,131,197,56,116,126,111,39,147,203,249,
dc.b 185,188,206,87,197,239,241,125,222,39,185,238,123,156,79,131,227,231,228,247,230,172,229,244,81,79,182,62,231,121,189,240,
dc.b 133,63,91,193,95,78,223,109,141,180,216,136,246,162,235,203,90,249,193,81,82,39,15,39,118,178,221,248,178,34,246,255,
dc.b 3,0,126,243,25,243,133,49,104,149,167,159,223,17,188,228,244,121,156,158,79,39,227,48,159,243,252,252,238,111,55,230,
dc.b 249,190,110,119,67,169,149,163,56,194,132,67,131,153,193,217,156,31,192,166,79,31,107,180,217,226,108,132,245,184,120,155,
dc.b 60,43,251,203,144,235,184,80,29,182,60,162,80,130,169,56,64,182,78,145,212,42,40,58,53,84,106,170,136,18,199,47,
dc.b 180,63,179,234,245,122,189,62,143,67,161,209,234,116,190,126,127,51,229,229,114,121,95,47,63,169,149,34,139,71,246,247,
dc.b 251,44,92,141,208,178,175,121,225,110,247,91,157,206,231,113,145,139,137,177,56,14,189,142,22,5,245,218,112,79,238,134,
dc.b 49,66,13,164,113,70,31,204,167,155,14,18,12,193,17,84,253,99,129,73,206,56,1,94,216,169,200,72,150,165,24,74,
dc.b 87,220,136,129,242,123,121,178,104,90,112,254,44,123,203,237,134,196,78,94,36,247,15,236,190,15,243,216,96,7,248,225,
dc.b 139,127,239,110,134,32,80,224,48,206,189,20,158,40,127,231,165,172,34,54,180,64,70,155,207,45,174,168,76,224,134,187,
dc.b 226,127,131,129,184,16,6,10,25,197,80,29,94,159,76,225,179,14,24,107,66,85,86,111,35,93,136,191,113,81,97,230,
dc.b 46,215,27,109,141,141,181,218,22,80,159,68,224,106,112,175,238,98,36,168,43,140,239,232,169,234,212,185,132,127,234,158,
dc.b 122,213,89,179,0,73,116,142,6,183,60,224,80,179,66,151,81,204,105,225,57,93,206,198,79,83,165,213,236,118,59,121,
dc.b 89,154,58,179,106,34,156,112,85,194,120,196,82,69,118,136,219,118,155,93,182,219,113,183,78,8,55,23,102,40,97,185,
dc.b 134,237,178,213,81,212,233,7,162,10,102,57,73,118,146,178,58,68,76,150,77,252,210,103,243,230,166,150,134,110,97,165,
dc.b 215,95,39,37,22,93,253,61,46,158,79,103,43,74,93,20,225,126,90,53,77,225,146,108,128,24,155,115,131,65,194,196,
dc.b 218,228,109,182,187,93,153,113,215,169,137,183,186,252,37,34,236,220,60,24,187,199,1,63,130,244,87,62,18,250,15,254,
dc.b 33,114,68,35,234,121,68,33,55,22,55,10,100,17,102,159,105,56,116,179,136,197,78,19,212,156,5,56,81,50,6,230,
dc.b 142,159,141,77,79,74,196,217,167,205,142,192,82,105,108,138,97,144,80,71,228,246,246,231,2,193,120,112,95,88,56,23,
dc.b 231,3,148,7,228,76,94,146,141,217,3,202,2,98,16,142,118,69,179,31,55,203,203,19,88,242,126,94,119,75,172,85,
dc.b 61,190,182,73,193,66,245,187,70,175,135,15,78,18,174,73,228,254,45,197,221,233,240,202,234,129,129,61,12,8,65,211,
dc.b 232,183,66,75,99,25,199,20,192,137,197,47,211,129,213,189,60,12,240,32,14,80,63,241,173,189,35,113,240,7,221,14,
dc.b 247,116,91,61,214,235,167,166,245,250,157,30,135,209,207,231,243,250,29,94,214,108,153,160,14,36,166,104,151,198,229,56,
dc.b 63,104,130,63,68,225,46,200,34,43,172,84,96,65,99,118,209,70,240,146,230,245,63,0,252,36,76,36,45,20,72,69,
dc.b 8,165,168,200,93,126,188,214,157,158,250,217,189,149,234,118,170,88,201,239,80,235,116,166,230,115,228,72,231,119,101,245,
dc.b 242,172,73,205,104,210,131,184,203,186,190,122,226,246,11,43,104,204,152,135,98,163,122,122,150,43,235,50,126,187,23,79,
dc.b 93,92,68,111,6,43,135,215,15,24,12,82,137,17,187,15,218,183,132,195,103,236,50,116,195,55,16,24,110,249,219,86,
dc.b 24,35,140,153,40,3,166,118,176,214,99,47,191,35,67,56,77,163,50,165,75,64,231,36,190,36,170,110,196,189,97,15,
dc.b 205,156,144,184,87,170,130,205,33,142,212,42,32,178,200,19,243,80,75,131,129,214,141,117,110,4,222,210,200,141,252,13,
dc.b 168,18,98,153,131,198,138,144,149,56,108,6,96,236,243,116,228,72,56,172,44,220,221,0,120,100,53,149,171,177,182,36,
dc.b 116,225,20,225,196,138,4,179,21,48,112,167,145,166,42,148,53,139,37,72,90,161,180,87,81,119,233,194,0,168,92,196,
dc.b 136,237,3,196,72,177,149,57,98,0,4,21,44,110,63,220,69,242,7,18,55,60,156,64,74,33,10,50,184,95,92,17,
dc.b 178,116,81,36,154,184,8,66,65,134,77,192,31,224,2,94,147,209,130,133,217,72,218,43,129,191,35,226,128,36,9,138,
dc.b 224,53,237,18,84,211,84,75,84,145,113,141,77,119,177,82,192,133,131,118,132,126,97,218,11,32,124,208,5,14,152,27,
dc.b 19,104,177,74,182,37,236,104,12,56,103,94,146,104,104,156,28,226,129,244,108,154,89,153,110,24,212,102,32,123,250,128,
dc.b 211,84,173,35,225,96,139,112,135,114,224,206,20,218,72,27,208,25,81,27,200,155,212,204,253,20,246,82,44,219,9,6,
dc.b 117,181,197,233,197,36,153,221,16,41,219,219,66,10,180,38,80,106,17,2,156,20,148,7,204,56,106,178,9,77,70,134,
dc.b 169,137,174,238,102,134,126,110,130,113,21,116,195,127,210,104,97,68,98,47,188,160,19,138,159,137,59,87,71,55,43,41,
dc.b 56,89,105,148,236,178,52,74,135,115,125,125,131,180,200,221,239,119,155,140,109,166,29,250,106,212,43,26,26,200,2,238,
dc.b 48,192,46,203,80,174,144,42,0,246,41,122,179,38,105,201,68,210,154,122,115,39,206,27,37,77,155,171,168,112,128,58,
dc.b 178,138,198,125,65,141,105,169,24,91,22,134,110,95,116,79,25,34,93,18,226,94,67,25,128,236,182,152,228,16,248,248,
dc.b 135,15,5,117,108,253,87,4,13,64,42,125,189,23,239,67,116,200,61,250,209,110,64,195,147,11,134,211,53,205,207,24,
dc.b 16,154,127,231,28,34,184,112,9,255,114,232,33,201,196,150,133,196,232,229,245,250,61,65,130,246,105,105,181,237,57,133,
dc.b 30,251,11,15,19,107,143,183,219,227,226,236,176,205,115,175,99,137,165,1,64,132,183,144,211,134,108,128,29,46,147,255,
dc.b 213,78,9,98,86,162,7,189,159,155,156,94,82,112,28,82,167,39,8,5,48,19,234,154,73,56,156,26,205,10,41,196,
dc.b 156,232,131,225,3,39,159,174,134,94,162,122,248,230,132,184,55,233,177,178,84,48,1,22,17,116,129,161,44,50,174,53,
dc.b 218,112,97,77,154,184,119,189,105,122,199,12,135,154,107,145,173,53,65,130,167,18,247,81,56,45,75,54,141,102,196,213,
dc.b 169,199,77,39,25,254,110,94,169,148,217,185,77,105,85,195,174,42,1,136,241,239,54,24,55,182,200,46,188,22,1,238,
dc.b 93,152,176,77,48,99,66,118,224,67,150,22,120,88,174,142,121,176,157,58,179,11,37,6,159,48,144,29,12,221,236,69,
dc.b 44,220,24,132,233,119,14,31,171,183,156,113,227,173,29,153,174,56,81,164,80,27,175,194,153,130,186,10,57,46,97,61,
dc.b 65,215,160,39,12,14,140,18,238,98,193,126,60,198,155,40,205,158,108,131,105,250,73,157,37,172,78,145,161,163,155,151,
dc.b 219,236,229,200,155,82,210,103,4,117,194,33,120,213,207,203,236,117,187,121,133,164,203,13,139,69,39,136,61,59,216,113,
dc.b 238,239,239,135,204,198,168,80,7,243,104,0,235,14,213,196,197,158,177,18,6,191,16,119,53,5,197,156,169,138,67,133,
dc.b 172,156,72,166,169,164,44,128,104,122,72,225,117,184,210,110,152,117,82,200,78,196,225,160,232,41,145,135,89,213,150,3,
dc.b 132,17,198,197,140,154,226,62,39,165,102,166,82,232,160,105,218,10,66,15,159,10,19,224,174,246,28,178,38,208,10,174,
dc.b 145,151,222,207,9,75,32,51,61,244,46,45,2,95,49,127,93,46,162,76,194,255,181,51,244,205,162,181,180,229,140,194,
dc.b 79,70,97,74,111,25,59,130,83,239,161,198,138,14,202,21,4,50,37,64,104,151,43,232,17,97,67,184,186,72,111,2,
dc.b 208,13,58,4,30,0,234,102,11,40,20,102,172,128,142,194,205,205,41,218,24,12,161,39,67,71,56,227,139,11,233,211,
dc.b 146,90,130,78,214,128,109,34,17,214,168,56,24,95,82,30,8,92,139,214,31,69,141,108,252,37,46,20,68,226,115,6,
dc.b 207,70,176,193,21,73,19,99,214,23,66,171,199,113,250,218,35,218,73,35,205,107,76,24,48,16,12,204,209,236,244,178,
dc.b 72,32,115,180,165,78,82,143,154,115,166,147,92,44,224,82,103,10,218,60,120,46,90,26,44,17,218,9,15,224,199,35,
dc.b 47,32,11,116,16,74,111,183,22,11,9,164,82,212,167,86,65,48,214,78,35,105,165,81,103,6,134,96,221,139,80,70,
dc.b 14,204,225,191,91,216,151,156,54,206,148,14,233,92,4,45,32,68,52,212,214,47,200,224,158,160,91,222,145,241,135,139,
dc.b 38,180,5,219,62,126,158,146,233,13,169,20,112,70,132,68,16,249,208,89,197,20,102,134,201,0,253,106,135,27,203,50,
dc.b 63,166,141,225,218,2,69,9,82,243,59,134,183,218,58,114,235,16,236,36,240,20,181,115,137,126,72,72,22,107,2,243,
dc.b 99,135,123,25,227,102,204,235,8,155,3,198,204,47,219,193,105,84,42,120,66,154,53,60,193,193,188,56,244,241,33,192,
dc.b 72,235,112,186,148,59,186,79,123,171,244,116,242,180,195,249,223,70,188,190,192,138,182,174,103,111,177,219,203,207,153,96,
dc.b 106,114,101,149,194,211,59,221,142,206,100,137,135,28,74,254,222,243,2,59,228,96,29,46,76,171,12,65,185,194,196,219,
dc.b 110,49,111,94,10,176,20,18,155,88,4,28,40,234,232,66,152,45,16,44,188,9,114,166,174,87,68,224,120,51,228,77,
dc.b 174,71,108,58,122,101,90,86,111,116,91,47,48,46,93,112,6,21,168,105,118,187,97,232,118,91,64,184,25,209,95,92,
dc.b 192,109,92,132,95,78,101,115,11,87,4,13,187,27,151,237,80,31,68,221,224,51,149,241,31,109,148,208,45,119,5,248,
dc.b 150,78,210,150,174,87,92,226,233,251,227,175,97,145,153,117,46,25,81,33,186,87,21,218,129,88,212,146,69,230,44,244,
dc.b 156,187,203,124,65,169,134,37,244,80,4,97,217,104,135,29,237,184,250,210,242,218,27,129,218,193,178,121,123,12,1,202,
dc.b 159,167,65,67,114,180,104,57,200,66,135,139,200,210,25,58,235,12,202,8,162,27,46,60,1,16,93,206,212,164,177,19,
dc.b 85,89,231,34,185,151,159,218,202,163,62,197,192,226,171,19,113,135,108,246,194,235,80,111,86,123,198,176,95,182,185,120,
dc.b 238,217,228,23,53,96,188,161,90,179,247,235,67,16,120,187,137,43,54,142,92,250,50,218,49,2,171,200,86,109,5,10,
dc.b 233,173,35,77,154,216,119,184,252,11,173,205,205,207,10,229,102,211,207,91,249,253,223,155,141,251,249,60,127,79,216,253,
dc.b 60,77,60,173,69,154,196,190,199,224,248,219,173,190,207,2,46,47,151,182,165,49,252,102,86,31,222,108,95,197,130,188,
dc.b 255,135,157,221,230,74,94,101,23,222,54,250,219,83,221,234,244,120,157,134,77,249,253,87,150,26,96,156,148,223,3,237,
dc.b 249,176,253,190,147,126,223,27,217,255,79,252,124,178,36,95,110,222,95,253,143,233,251,223,217,225,91,127,119,225,251,222,
dc.b 126,210,53,14,95,253,191,203,255,127,250,252,188,202,87,45,176,241,237,252,127,27,31,127,192,250,219,60,38,24,243,188,
dc.b 41,236,93,180,127,139,184,222,221,78,203,235,115,127,111,163,254,191,247,201,184,192,143,115,186,217,223,221,187,105,168,61,
dc.b 167,186,169,203,253,31,231,203,108,183,183,206,116,217,199,83,223,238,245,126,79,114,68,223,166,94,171,61,140,76,255,209,
dc.b 232,243,230,187,210,129,195,251,222,117,181,188,57,93,47,115,232,234,100,231,116,38,196,138,254,140,135,27,136,110,241,241,
dc.b 119,24,55,113,239,255,139,11,113,253,127,119,252,127,7,7,119,225,111,51,191,79,175,202,231,252,95,38,132,77,155,71,
dc.b 24,56,59,223,173,184,198,241,184,91,39,183,222,102,234,151,87,45,157,12,188,222,215,127,63,179,206,254,29,46,246,132,
dc.b 93,255,224,251,251,108,77,183,134,239,225,226,252,217,185,221,110,231,118,88,249,11,187,94,119,86,157,204,27,26,61,170,
dc.b 150,211,178,178,243,117,90,180,230,245,187,190,247,193,238,244,78,9,59,196,252,95,223,227,237,31,57,91,87,191,222,151,
dc.b 85,106,153,63,15,187,241,124,249,150,33,198,141,225,127,55,220,225,225,196,192,188,112,37,202,93,245,77,94,255,23,211,
dc.b 252,191,159,147,216,204,101,181,251,95,225,255,79,179,190,197,187,139,106,122,61,0,237,117,196,1,223,112,184,123,201,54,
dc.b 228,12,0,4,0,0,64,0,0,0,4,17,85,85,85,98,200,217,35,36,146,73,36,233,157,110,235,46,189,110,215,93,
dc.b 123,186,219,218,251,221,187,235,223,7,123,190,41,221,117,247,187,181,186,221,125,44,219,109,101,214,222,182,91,36,146,105,
dc.b 35,36,178,72,200,170,170,170,170,168,8,40,0,130,0,31,224,0,128,126,254,97,248,15,223,125,247,189,172,105,45,47,
dc.b 23,121,213,74,178,227,154,78,178,189,203,100,134,7,182,73,91,216,49,74,130,142,166,91,249,35,126,246,204,15,4,19,
dc.b 133,142,141,122,101,207,167,3,98,36,250,103,23,175,74,57,215,25,146,168,13,106,213,132,213,101,230,238,60,241,6,116,
dc.b 218,115,145,34,174,183,110,205,5,35,213,204,79,160,152,235,51,185,221,203,216,144,90,182,186,218,189,57,195,165,246,246,
dc.b 116,241,53,74,52,129,35,22,6,161,108,110,109,103,72,93,113,107,99,116,202,161,15,49,61,103,191,96,114,56,249,175,
dc.b 15,27,68,163,41,91,41,74,26,97,34,8,67,151,46,90,225,138,83,197,107,102,99,249,181,234,162,76,185,90,1,149,
dc.b 105,131,138,152,46,51,34,11,167,187,123,166,169,27,64,117,49,185,102,19,161,33,23,91,178,158,73,163,20,186,49,171,
dc.b 144,247,102,160,69,252,157,123,85,139,26,178,100,186,140,61,92,205,136,134,15,23,62,98,52,72,207,99,0,172,152,15,
dc.b 201,84,162,72,172,177,180,197,228,12,106,227,71,136,88,245,96,11,36,251,33,254,162,50,240,188,190,44,135,155,146,142,
dc.b 49,108,185,133,105,116,136,42,12,106,38,33,67,80,232,30,51,99,85,244,121,37,151,48,92,140,51,20,219,219,44,165,
dc.b 69,158,249,85,61,140,237,44,253,7,144,195,234,163,169,143,25,6,168,214,34,60,158,197,187,117,134,169,198,123,170,250,
dc.b 28,66,230,209,218,183,96,174,157,36,236,84,41,102,184,204,232,240,7,183,197,165,6,181,17,166,79,48,114,164,56,50,
dc.b 232,163,78,3,175,102,189,40,100,37,183,30,36,9,179,34,210,68,157,66,52,106,151,167,11,33,36,78,4,34,201,28,
dc.b 116,209,44,113,16,109,186,130,164,104,245,66,39,176,147,228,234,36,229,135,102,21,105,3,53,34,80,60,136,20,172,12,
dc.b 133,58,113,11,107,6,6,230,147,61,72,187,114,99,63,132,81,113,246,160,32,144,180,227,34,13,42,148,253,210,163,237,
dc.b 62,42,153,145,131,117,100,87,187,14,223,199,44,18,111,163,78,168,58,68,173,76,130,124,82,107,128,254,32,226,8,44,
dc.b 85,104,185,123,70,128,42,202,165,81,221,146,5,22,149,32,217,19,125,173,94,110,112,206,40,112,60,104,204,193,139,65,
dc.b 83,119,55,12,157,155,26,64,253,170,65,89,83,45,67,74,129,170,187,165,165,193,213,213,133,22,44,146,201,209,158,76,
dc.b 37,170,147,43,69,80,135,217,82,167,35,102,96,150,81,170,153,147,86,106,80,205,220,17,8,179,106,162,84,205,187,3,
dc.b 133,20,17,187,77,54,71,19,71,39,81,48,98,148,138,8,19,172,104,186,152,4,163,63,61,221,4,35,73,179,243,37,
dc.b 85,45,50,121,181,32,64,35,17,222,186,217,117,161,2,137,192,202,172,213,25,131,135,205,89,1,218,5,114,244,135,209,
dc.b 160,167,68,218,214,34,6,214,76,40,147,35,63,152,125,149,125,157,213,144,83,42,118,60,57,123,161,81,53,34,65,165,
dc.b 71,139,77,16,198,97,41,97,246,252,17,207,24,27,166,140,40,82,130,5,128,148,237,34,35,130,12,144,40,208,32,217,
dc.b 38,204,149,12,44,15,138,25,207,210,58,144,241,195,161,9,147,139,22,161,90,36,80,211,179,91,108,59,186,70,152,138,
dc.b 13,213,177,7,24,130,223,200,230,48,118,16,73,56,195,198,39,200,217,121,22,120,230,253,74,116,65,83,180,202,72,18,
dc.b 15,255,165,36,124,225,2,81,128,150,12,200,194,222,104,7,55,116,200,47,118,100,173,230,24,233,92,89,217,57,94,122,
dc.b 124,120,48,35,73,54,177,123,4,71,41,199,153,186,109,26,202,225,133,29,9,251,143,138,14,76,83,47,84,160,252,184,
dc.b 26,56,206,226,203,67,92,37,111,212,82,132,245,233,84,206,48,100,185,21,57,154,184,250,80,39,23,173,94,165,58,19,
dc.b 19,221,103,9,41,137,103,211,36,28,238,72,118,246,137,181,55,92,59,166,234,105,60,199,199,208,131,57,13,165,205,155,
dc.b 69,40,38,70,150,85,67,202,216,171,82,63,127,196,147,58,85,4,194,66,170,180,180,93,125,55,114,167,153,102,185,66,
dc.b 99,50,94,191,135,22,100,179,9,146,140,106,137,233,141,16,155,228,26,61,86,91,253,93,29,125,55,165,81,3,193,33,
dc.b 26,252,160,80,149,107,10,211,229,232,4,57,241,130,121,244,137,212,42,90,156,50,75,10,114,4,170,144,62,204,124,150,
dc.b 79,228,9,232,247,66,41,250,36,77,152,15,112,58,62,60,145,28,136,73,229,142,160,199,134,244,169,136,66,227,195,107,
dc.b 234,146,183,36,110,12,247,167,74,31,221,42,93,3,135,148,7,86,66,22,166,117,74,84,141,158,222,79,140,8,254,10,
dc.b 18,66,82,144,129,177,9,228,105,151,45,74,150,178,156,248,187,66,1,126,154,53,106,23,39,60,108,20,141,64,110,40,
dc.b 88,132,150,207,160,100,132,171,25,14,77,162,196,140,85,64,247,0,68,194,70,126,245,219,232,245,67,34,244,168,0,233,
dc.b 51,40,24,64,177,163,37,72,79,22,26,190,207,170,1,39,166,8,145,145,52,125,172,48,91,178,103,90,98,80,118,53,
dc.b 10,170,53,76,4,214,53,2,162,141,56,129,9,100,55,176,176,53,204,142,240,194,147,65,39,133,22,54,220,195,72,130,
dc.b 36,20,117,35,140,145,246,138,10,128,3,245,9,192,253,57,51,204,214,86,86,178,94,61,122,56,0,66,24,212,37,80,
dc.b 13,108,50,88,118,236,156,124,85,70,40,66,72,81,148,234,86,42,72,128,200,80,197,18,12,121,113,100,151,5,162,164,
dc.b 84,152,27,234,2,235,157,21,252,96,171,254,160,0,88,213,74,17,54,163,204,153,80,6,162,55,182,8,178,203,18,54,
dc.b 16,192,41,164,152,235,35,25,169,140,120,200,153,81,24,70,74,48,203,161,7,99,93,212,9,166,81,52,112,6,171,9,
dc.b 188,66,111,33,158,180,72,16,164,208,221,9,35,107,81,150,153,34,14,200,148,198,158,12,229,30,119,157,221,30,91,149,
dc.b 28,125,37,189,28,152,113,18,71,9,232,52,71,165,36,214,164,5,229,163,175,71,34,182,182,29,86,231,235,61,11,67,
dc.b 214,118,230,209,49,149,181,85,243,163,230,118,203,27,220,166,160,189,22,245,200,26,163,135,56,228,152,6,11,20,173,129,
dc.b 117,205,195,47,167,121,218,249,30,72,20,228,161,91,88,222,253,90,5,168,203,164,173,52,114,131,221,109,199,218,40,154,
dc.b 40,27,47,53,106,150,158,236,168,166,41,69,220,155,3,73,238,94,31,147,191,229,204,206,119,16,201,148,12,204,67,162,
dc.b 116,226,157,247,7,129,200,224,241,189,27,166,13,2,145,67,37,200,174,5,33,98,142,213,156,96,182,230,79,221,211,255,
dc.b 239,127,254,127,103,71,163,209,249,123,217,25,177,78,36,89,102,31,124,239,196,22,133,205,247,35,133,254,29,14,79,47,
dc.b 157,232,250,222,199,187,237,254,143,91,155,131,131,191,14,59,66,130,160,251,247,43,199,135,218,233,254,255,155,249,253,254,
dc.b 30,223,95,31,69,220,122,97,89,145,227,106,215,128,5,232,75,10,152,12,159,52,165,179,59,27,102,172,24,31,144,251,
dc.b 39,234,248,254,31,219,239,244,122,63,7,205,246,119,50,30,190,130,109,9,213,105,211,129,86,23,87,215,218,1,215,240,
dc.b 189,63,197,205,194,228,122,28,142,70,15,35,149,199,193,191,108,136,196,183,218,24,254,95,31,127,239,234,245,186,191,111,
dc.b 123,197,135,146,246,36,162,236,91,141,210,213,8,37,27,54,237,64,154,238,0,31,150,119,252,94,13,229,229,187,36,165,
dc.b 224,102,119,254,209,255,118,124,57,26,111,196,179,174,196,41,59,162,0,180,52,247,16,27,86,219,254,6,15,31,141,204,
dc.b 229,240,248,23,43,145,86,169,70,149,96,127,231,33,230,95,131,171,211,249,62,111,163,231,233,116,250,95,55,244,233,116,
dc.b 254,159,179,187,157,20,67,63,3,238,78,31,11,155,146,50,115,115,123,121,106,26,100,166,68,132,109,76,156,220,221,167,
dc.b 89,216,218,111,4,83,26,20,167,203,202,147,68,50,196,76,216,19,59,127,125,127,194,225,242,189,31,75,242,122,125,12,
dc.b 46,37,253,173,112,115,84,52,225,64,90,91,252,223,7,99,177,135,219,238,98,98,121,241,177,241,114,180,178,180,118,96,
dc.b 149,64,120,66,84,186,70,134,250,237,28,220,222,92,88,48,84,180,107,8,132,117,49,183,171,139,223,242,102,188,137,64,
dc.b 46,107,8,66,71,183,33,100,97,227,230,77,33,3,115,174,109,107,190,223,93,91,90,220,219,47,76,193,138,161,50,93,
dc.b 84,167,185,29,158,151,201,210,249,122,125,95,54,134,185,27,214,188,215,209,117,18,80,21,234,128,245,212,123,75,90,177,
dc.b 99,33,3,246,204,77,67,132,218,3,168,19,230,37,65,119,172,243,102,66,38,245,213,247,183,174,90,42,66,149,139,122,
dc.b 251,23,35,41,155,155,178,78,223,57,108,226,214,226,209,168,150,95,82,53,57,168,83,252,110,207,211,252,126,62,143,71,
dc.b 167,221,241,226,103,107,235,188,211,201,200,202,210,217,135,183,40,234,109,224,106,194,100,97,20,136,172,240,220,213,17,157,
dc.b 218,66,42,178,137,17,86,197,125,32,250,149,161,70,155,54,39,106,155,58,153,122,198,87,220,238,119,14,217,205,239,10,
dc.b 193,58,171,46,39,35,125,103,111,190,184,106,126,129,116,85,94,227,226,120,187,31,211,255,126,31,171,185,228,243,249,178,
dc.b 93,237,103,254,29,188,60,92,173,13,173,218,214,246,42,143,14,108,75,206,48,165,65,112,21,69,25,47,53,96,210,49,
dc.b 68,115,47,82,100,202,5,213,88,88,51,111,111,109,98,180,248,138,43,48,137,157,183,23,159,196,14,154,239,156,174,103,
dc.b 98,5,104,174,177,184,180,100,140,12,45,54,19,173,12,220,113,62,57,163,177,7,104,11,91,151,141,220,251,126,175,163,
dc.b 231,251,60,122,177,204,33,31,10,214,1,217,105,19,124,130,117,114,98,144,4,142,77,16,115,72,218,160,54,111,177,108,
dc.b 197,130,245,163,143,163,19,231,0,197,149,53,108,189,96,15,125,165,199,16,66,10,115,185,152,22,205,211,153,158,73,180,
dc.b 72,96,15,61,0,254,167,84,126,67,155,147,147,147,139,226,238,246,251,184,126,31,48,125,216,252,64,64,134,216,32,95,
dc.b 112,40,145,22,97,6,23,136,3,55,53,74,7,23,200,212,47,90,32,187,26,57,180,178,108,156,46,70,133,176,250,44,
dc.b 154,39,18,180,114,11,76,185,178,36,203,144,21,85,141,105,227,33,63,28,209,188,24,100,36,251,87,75,55,36,22,46,
dc.b 248,67,24,234,228,226,129,183,116,222,109,67,36,225,96,87,81,64,202,77,224,86,14,13,172,130,104,132,162,14,109,98,
dc.b 83,117,103,200,221,56,121,56,122,32,201,90,49,23,175,62,168,117,196,32,38,65,37,77,196,203,147,134,74,145,155,34,
dc.b 240,80,178,104,234,68,6,168,194,212,199,240,248,60,120,250,144,35,77,11,5,195,146,137,210,33,64,9,142,71,67,49,
dc.b 200,169,171,121,31,12,145,135,137,99,169,87,185,181,179,174,76,102,140,128,18,176,101,36,112,68,41,141,223,66,128,180,
dc.b 160,50,6,132,134,93,181,179,175,112,192,48,82,168,18,115,210,29,84,183,112,174,178,164,151,121,94,30,215,123,197,226,
dc.b 197,207,213,126,84,210,130,130,146,136,58,212,64,152,242,48,235,180,176,105,205,46,51,232,27,130,22,37,61,117,165,221,
dc.b 213,229,213,112,248,188,8,254,5,132,54,145,82,181,172,198,192,164,29,52,5,66,132,0,210,40,127,231,199,135,177,173,
dc.b 169,159,164,254,77,32,76,213,33,4,9,177,173,157,157,170,52,82,139,60,184,205,48,217,21,202,205,25,241,1,96,8,
dc.b 127,37,97,186,101,72,29,79,202,44,141,131,128,250,141,179,86,9,198,201,65,116,112,133,251,9,90,1,10,213,76,140,
dc.b 182,80,132,196,72,192,197,229,232,202,134,245,227,189,136,64,1,240,148,104,101,150,30,186,62,123,182,23,248,4,42,196,
dc.b 20,140,168,187,99,185,97,23,168,125,25,19,44,164,24,115,72,220,141,38,137,148,3,223,22,131,113,74,131,13,109,211,
dc.b 7,148,135,51,44,216,43,70,116,136,254,43,55,147,161,4,59,64,76,137,113,161,60,209,210,116,32,76,234,8,208,74,
dc.b 165,68,117,155,149,149,159,177,26,154,53,128,39,134,74,134,237,4,19,244,169,65,6,116,240,141,48,13,140,31,111,67,
dc.b 6,94,22,70,185,205,184,31,145,136,62,166,40,222,105,0,54,60,80,152,88,53,90,152,46,252,34,39,93,218,66,119,
dc.b 73,58,164,167,41,200,11,217,54,159,194,151,80,32,141,58,92,0,160,3,175,127,26,121,115,170,23,8,30,81,251,152,
dc.b 9,62,35,105,0,100,196,39,16,180,232,131,252,13,33,5,174,34,219,129,50,237,217,8,95,201,228,92,160,125,107,107,
dc.b 11,43,27,91,107,6,172,152,42,5,197,155,59,188,243,33,122,131,83,34,14,98,159,67,42,152,99,198,2,93,46,23,
dc.b 215,70,30,14,210,53,189,50,227,80,52,140,29,150,137,238,162,18,150,36,255,68,45,3,240,77,142,212,56,114,40,154,
dc.b 68,40,69,24,39,16,25,116,194,185,81,251,221,187,129,236,42,180,203,67,138,165,203,194,173,98,23,244,25,68,39,80,
dc.b 144,225,113,8,158,65,182,169,22,172,4,102,157,46,2,12,24,100,135,102,91,58,250,121,217,218,206,221,59,124,38,184,
dc.b 223,60,124,74,1,208,40,180,32,196,124,9,103,40,101,126,96,234,80,32,184,117,72,205,179,151,34,129,156,79,152,173,
dc.b 96,221,200,20,1,163,138,230,160,234,97,207,234,20,59,202,254,206,152,17,141,178,165,19,67,100,196,152,87,20,83,84,
dc.b 162,190,214,207,200,16,230,58,154,218,250,89,128,166,76,188,221,77,109,1,17,127,175,181,184,29,239,135,118,229,111,80,
dc.b 155,203,166,117,107,107,43,155,252,11,183,43,16,158,54,34,45,151,184,175,174,4,195,57,181,185,188,192,191,182,112,201,
dc.b 136,159,171,102,208,43,174,70,17,70,7,7,241,138,2,202,4,116,105,146,80,128,243,71,55,43,23,35,60,73,253,226,
dc.b 98,101,104,231,101,103,131,25,51,137,3,217,188,165,76,160,100,124,192,90,92,121,230,15,168,109,103,121,195,192,3,115,
dc.b 50,98,164,5,52,173,88,66,11,101,115,118,1,55,5,106,51,20,41,35,157,69,137,130,131,240,60,225,137,208,192,192,
dc.b 83,1,31,130,71,198,12,0,29,252,45,108,93,29,140,204,205,88,83,100,59,208,117,173,169,174,244,9,237,28,141,64,
dc.b 39,201,42,169,80,93,106,186,121,16,49,196,17,253,108,147,168,98,197,205,245,240,138,88,76,210,197,173,207,3,124,221,
dc.b 115,20,9,148,24,71,93,102,230,185,146,87,46,11,2,231,222,108,66,216,131,46,80,70,73,32,66,1,63,17,183,19,
dc.b 97,107,101,119,251,29,175,195,203,169,25,240,43,21,220,120,240,68,25,145,251,123,187,49,59,19,103,110,146,154,58,251,
dc.b 27,189,245,205,229,211,68,139,66,9,108,30,21,237,243,83,244,118,222,195,217,242,235,211,130,246,48,163,99,204,206,123,
dc.b 55,110,41,154,51,105,71,121,169,170,238,33,116,162,27,181,67,27,38,173,237,172,239,48,121,55,205,214,158,53,86,27,
dc.b 205,157,63,54,188,77,125,28,238,183,246,254,253,159,183,181,151,6,113,96,43,22,150,38,38,78,51,186,6,207,155,12,
dc.b 163,43,19,51,98,226,201,195,123,158,37,235,21,140,215,177,185,181,96,209,162,51,70,234,203,144,85,52,214,23,156,1,
dc.b 1,85,94,177,66,229,170,43,239,48,56,247,205,91,220,94,56,86,201,33,160,57,65,103,184,216,126,92,156,111,47,131,
dc.b 181,214,234,124,62,255,253,126,207,131,226,254,29,79,187,15,86,28,13,95,55,225,227,18,92,250,66,65,194,180,66,41,
dc.b 93,218,92,241,249,252,222,119,55,11,161,234,250,92,140,30,15,161,199,228,241,249,92,59,87,11,235,7,176,212,206,169,
dc.b 109,115,118,63,123,52,94,148,232,73,28,54,88,157,74,84,109,205,167,110,245,221,109,109,101,247,60,89,24,190,78,247,
dc.b 225,135,215,235,253,63,215,249,124,95,187,226,253,255,47,242,251,123,216,218,25,88,249,185,250,209,74,40,176,21,21,117,
dc.b 198,255,129,194,193,226,115,189,79,205,237,123,126,231,187,237,255,144,193,247,209,245,61,95,75,11,159,193,189,178,88,136,
dc.b 188,250,102,145,5,191,200,210,136,102,135,44,200,54,129,99,85,2,172,153,84,41,4,46,193,239,110,134,46,39,155,195,
dc.b 220,237,118,62,254,167,246,235,253,125,46,144,70,7,245,246,123,189,207,38,110,164,57,148,12,133,110,193,252,77,117,131,
dc.b 107,92,14,6,250,251,126,34,164,248,124,158,87,27,137,131,198,230,126,44,46,86,14,7,2,250,192,123,58,3,80,53,
dc.b 74,168,13,220,49,229,82,140,12,222,0,85,132,61,119,6,186,232,232,100,119,251,61,111,191,181,253,251,98,42,207,238,
dc.b 234,117,63,255,236,235,143,224,195,199,207,203,200,210,123,22,136,230,249,59,53,32,201,166,109,220,218,221,136,150,188,0,
dc.b 134,211,133,197,229,244,63,79,177,249,253,159,83,241,225,114,132,14,43,150,237,216,1,241,1,202,163,82,177,75,74,22,
dc.b 105,155,48,34,96,72,249,34,156,177,224,94,110,110,102,55,159,201,224,243,231,227,225,245,122,127,7,71,255,63,239,224,
dc.b 248,250,125,78,175,115,187,223,241,249,50,196,79,212,173,232,243,164,139,219,91,240,120,156,43,235,87,54,247,254,134,0,
dc.b 139,201,252,125,15,95,253,63,215,243,122,92,206,13,229,221,221,163,53,171,71,99,99,183,240,128,168,222,242,142,115,7,
dc.b 129,79,104,146,34,29,11,75,149,13,222,94,47,155,19,19,201,143,163,153,228,235,124,253,47,221,240,116,122,63,183,225,
dc.b 254,31,199,250,245,58,222,92,253,55,80,4,94,121,25,32,128,37,217,87,57,112,205,147,91,61,247,15,151,207,194,255,
dc.b 31,87,213,245,253,191,215,250,255,219,217,232,115,249,23,246,12,214,136,172,84,235,219,216,138,94,164,162,63,111,120,182,
dc.b 210,183,66,122,74,83,129,97,96,130,119,218,224,215,60,252,204,128,142,211,173,246,117,58,95,31,201,252,254,142,167,215,
dc.b 219,241,232,109,10,24,105,146,224,190,7,197,61,131,32,149,10,167,211,176,177,187,191,226,126,79,111,254,63,223,245,126,
dc.b 175,123,222,247,63,79,175,234,250,126,143,59,141,129,112,220,83,35,42,88,78,171,212,166,56,20,252,81,144,72,149,224,
dc.b 76,48,255,116,68,119,4,22,210,70,234,145,161,189,212,204,198,242,225,246,187,2,13,179,173,215,238,120,242,50,243,52,
dc.b 53,53,196,119,238,195,193,16,172,74,95,103,224,86,197,11,25,88,95,114,112,191,47,177,237,123,190,247,185,237,123,63,
dc.b 159,214,252,184,92,91,224,139,172,131,83,15,137,204,147,229,100,42,83,86,8,41,104,161,1,139,225,20,128,53,177,9,
dc.b 165,67,185,210,64,24,67,25,241,190,117,167,151,228,240,121,179,221,59,206,243,248,252,30,60,161,21,144,248,96,116,57,
dc.b 119,150,72,171,226,128,161,150,86,151,23,183,252,64,142,207,159,133,233,254,143,243,245,57,55,246,163,62,18,65,121,26,
dc.b 169,62,76,129,241,16,53,144,232,217,200,241,96,55,220,96,187,232,127,68,189,34,45,217,148,66,35,5,47,227,205,76,
dc.b 225,25,88,233,208,74,197,151,149,147,139,230,199,206,211,118,33,219,167,239,47,58,30,97,168,94,213,197,149,238,15,43,
dc.b 155,202,227,113,185,124,206,53,253,155,118,203,171,65,40,32,110,178,228,109,90,108,132,212,79,13,77,1,154,228,88,148,
dc.b 63,169,82,137,6,63,16,247,3,165,41,17,31,187,214,214,119,181,16,161,84,103,178,59,228,214,222,161,149,17,211,155,
dc.b 36,136,208,159,80,73,141,138,24,86,45,44,110,133,55,215,27,155,133,207,228,240,45,26,137,55,130,102,238,156,38,227,
dc.b 68,70,107,131,50,82,230,170,73,126,240,66,105,69,147,187,68,27,155,10,32,96,92,10,133,156,73,87,61,0,138,59,
dc.b 47,69,214,200,219,254,40,100,130,67,226,10,4,11,203,137,2,4,57,27,166,130,246,68,137,152,216,92,94,240,56,188,
dc.b 126,78,23,67,211,231,122,0,53,17,190,88,100,140,1,220,8,14,152,43,173,60,41,145,67,220,176,134,179,67,71,81,
dc.b 230,192,163,110,214,125,6,28,121,163,6,112,83,249,59,200,37,25,6,214,216,64,80,29,191,14,251,201,9,2,42,25,
dc.b 8,190,148,71,163,34,8,65,25,219,10,124,190,103,47,141,199,226,241,112,119,247,34,27,92,35,163,31,19,153,32,62,
dc.b 3,13,81,249,6,228,7,89,249,30,124,92,156,193,21,19,167,155,151,162,237,235,231,208,1,190,48,161,146,45,248,18,
dc.b 184,27,132,76,20,202,219,147,134,233,226,45,0,118,114,104,57,155,145,185,15,110,97,129,176,192,149,195,188,192,224,240,
dc.b 176,47,110,109,44,171,199,107,246,53,226,83,17,155,37,202,17,29,26,35,207,151,16,81,116,138,142,167,66,138,71,104,
dc.b 25,126,239,91,83,80,20,175,182,69,149,2,12,164,225,12,119,148,72,52,66,138,158,49,35,36,228,32,31,228,168,143,
dc.b 158,59,31,44,137,102,99,102,143,86,174,104,62,240,181,181,182,21,80,54,21,228,165,16,113,101,111,117,115,100,216,153,
dc.b 127,4,41,195,215,153,49,33,146,164,194,76,128,200,160,158,94,63,24,61,204,162,70,254,51,230,200,20,163,80,163,19,
dc.b 241,234,4,92,149,32,21,231,30,35,253,145,216,220,17,82,204,0,71,15,173,14,168,17,105,44,156,89,92,222,94,141,
dc.b 75,28,51,98,52,11,4,126,179,92,49,204,98,34,187,140,140,156,230,67,129,18,64,249,220,53,162,53,188,168,190,100,
dc.b 160,6,124,210,227,146,201,100,156,38,36,88,36,39,251,80,30,143,4,68,185,64,128,235,229,207,1,209,54,227,130,110,
dc.b 154,105,186,141,52,0,64,144,8,18,16,147,109,36,219,109,57,28,231,221,36,142,75,115,179,173,206,206,190,11,153,111,
dc.b 120,238,95,13,248,5,124,215,199,124,23,197,123,193,115,46,92,185,217,147,50,230,89,157,114,119,118,78,150,59,36,174,
dc.b 55,35,141,244,109,182,219,105,38,147,73,52,8,64,0,1,161,186,104,6,159,191,157,31,195,224,62,251,181,146,36,191,
dc.b 20,253,59,226,105,142,223,220,113,227,165,85,181,34,13,131,196,170,133,40,9,13,166,115,156,36,61,104,108,108,136,141,
dc.b 186,29,30,126,182,164,196,34,59,100,109,214,112,73,3,80,131,3,52,97,218,41,156,10,59,56,208,149,203,132,22,128,
dc.b 67,143,236,226,42,118,125,92,124,156,132,6,30,246,231,147,237,250,254,159,163,231,53,25,251,201,88,122,53,109,95,18,
dc.b 220,145,255,5,27,240,22,142,166,207,75,164,35,94,58,152,8,19,115,243,209,24,137,161,53,17,51,195,223,82,96,16,
dc.b 6,180,157,23,29,147,78,35,19,180,4,74,200,171,205,66,254,225,42,205,139,182,72,195,99,179,214,247,127,195,224,237,
dc.b 118,190,158,215,209,220,251,252,94,178,52,8,143,25,187,101,172,232,99,91,24,129,203,178,80,209,246,134,205,9,116,57,
dc.b 198,44,37,105,51,10,124,200,218,81,224,69,103,67,102,84,190,167,66,108,146,156,184,36,59,73,136,130,48,51,94,215,
dc.b 135,0,47,156,191,98,149,123,216,56,107,189,195,121,175,23,147,199,246,124,191,39,239,253,127,183,191,229,170,115,27,246,
dc.b 90,227,61,48,150,54,51,176,145,133,252,249,204,231,198,189,159,237,105,236,79,143,58,83,174,77,155,22,58,113,115,230,
dc.b 116,168,104,70,191,188,214,148,190,164,108,29,25,51,122,210,118,187,19,31,204,233,204,157,40,206,149,47,67,178,50,194,
dc.b 117,63,131,82,143,53,222,72,61,87,55,47,121,254,159,195,240,227,179,234,254,31,63,123,211,226,253,158,10,66,116,205,
dc.b 201,76,41,13,252,175,203,250,122,51,253,188,94,78,24,61,126,116,170,190,104,75,57,134,87,197,216,248,187,63,15,189,
dc.b 13,61,24,140,43,99,205,236,174,40,202,234,254,110,196,250,175,246,39,99,206,141,195,149,203,62,212,120,114,226,252,63,
dc.b 163,251,149,237,183,246,252,221,174,7,246,83,240,126,187,62,175,29,94,71,201,87,241,247,236,211,252,62,175,18,190,231,
dc.b 66,62,182,196,141,79,230,254,207,240,254,133,120,55,244,125,222,114,220,214,78,121,249,99,176,230,59,240,225,222,176,220,
dc.b 44,109,42,250,28,251,31,63,203,223,224,220,164,221,106,183,242,80,83,133,173,251,252,250,16,114,232,245,63,175,243,73,
dc.b 211,122,190,77,208,31,234,252,45,93,86,106,114,150,165,88,144,154,185,193,255,159,247,241,254,223,45,46,87,100,167,159,
dc.b 214,209,216,246,231,115,251,61,142,134,222,148,125,28,151,47,165,35,74,58,243,102,46,8,191,38,26,178,226,72,218,214,
dc.b 211,234,107,174,163,117,82,181,198,254,22,149,8,41,95,195,31,72,79,140,17,10,171,94,182,211,125,24,45,125,72,78,
dc.b 87,5,253,243,253,223,63,253,127,199,110,143,143,187,244,118,252,221,206,255,135,146,84,221,61,191,201,178,202,228,219,158,
dc.b 21,116,100,205,141,149,232,177,147,81,218,247,177,191,216,253,63,211,238,118,127,47,103,81,251,175,151,107,209,252,119,119,
dc.b 126,191,155,237,254,60,85,220,126,254,52,101,181,253,222,207,95,91,111,173,65,119,49,40,253,227,251,254,158,241,163,5,
dc.b 63,39,6,87,170,120,121,22,127,106,165,250,180,111,130,122,53,119,0,108,6,43,87,216,98,233,216,65,174,110,100,180,
dc.b 254,47,207,253,255,227,253,164,159,254,223,94,58,71,69,248,139,19,119,87,120,56,121,183,248,155,131,177,183,237,118,54,
dc.b 54,36,185,111,142,240,32,102,124,233,240,67,240,172,83,110,18,216,227,196,190,221,90,86,46,85,163,134,221,92,156,31,
dc.b 39,234,255,47,243,255,95,246,252,31,38,181,15,111,249,253,169,145,206,163,240,194,22,129,205,91,114,12,61,94,198,223,
dc.b 62,100,238,174,204,136,2,58,248,82,97,69,152,3,83,84,234,46,218,114,33,164,35,219,77,167,249,44,63,134,147,138,
dc.b 172,32,70,12,120,131,142,191,37,167,29,125,123,27,12,6,222,71,177,247,124,191,31,250,126,175,147,246,110,97,113,53,
dc.b 241,217,193,123,153,181,180,136,29,240,82,68,226,228,96,209,43,225,236,244,118,168,73,155,36,7,206,54,191,226,38,226,
dc.b 173,219,226,244,113,213,78,36,120,175,146,86,6,27,169,73,218,236,255,87,193,210,231,67,126,231,23,7,13,51,185,13,
dc.b 245,26,225,228,227,242,250,44,54,252,148,234,145,131,131,237,253,223,31,205,233,222,185,138,235,182,184,188,126,14,247,107,
dc.b 198,74,4,49,31,79,95,74,68,241,33,68,221,142,167,95,241,115,231,172,65,114,56,190,173,12,249,243,34,0,217,45,
dc.b 171,177,171,209,34,252,82,196,213,142,44,48,92,85,113,35,157,242,192,3,114,150,253,53,98,17,120,12,170,249,225,12,
dc.b 228,102,249,124,253,175,223,242,126,239,5,26,92,120,211,197,130,173,58,36,108,64,17,28,244,112,113,126,148,24,100,212,
dc.b 118,182,156,108,4,210,87,29,184,221,31,115,243,254,143,127,161,50,34,79,162,79,233,244,122,179,214,74,189,35,132,117,
dc.b 135,241,52,246,122,19,4,193,213,71,26,84,234,147,124,47,171,241,119,187,252,28,150,8,60,126,15,183,228,255,159,247,
dc.b 249,124,247,33,161,109,207,74,37,250,59,212,109,7,2,159,153,208,94,206,247,46,34,87,255,87,87,218,246,244,150,191,
dc.b 105,200,51,54,189,239,131,242,79,89,253,251,78,190,132,22,70,31,170,40,121,133,159,167,67,157,183,215,217,127,110,182,
dc.b 239,159,122,149,62,91,164,120,231,23,167,114,163,74,62,105,82,183,50,175,151,235,240,209,105,118,80,26,139,47,232,249,
dc.b 125,124,53,135,146,204,75,97,44,86,114,104,108,116,249,242,78,200,73,227,171,83,12,77,163,164,150,180,156,174,91,184,
dc.b 148,16,181,9,50,87,198,158,11,240,197,93,126,247,99,110,131,239,87,213,243,247,119,137,231,113,221,50,110,85,225,164,
dc.b 15,12,211,208,163,173,99,199,255,191,87,155,144,156,168,175,80,217,62,150,239,46,37,193,192,231,237,244,35,175,142,249,
dc.b 226,118,78,240,184,109,9,115,174,43,10,111,83,221,248,137,244,0,190,49,120,96,28,66,32,133,239,147,190,111,223,201,
dc.b 35,84,223,218,14,153,200,240,136,185,241,217,165,27,171,137,64,55,170,9,84,13,221,159,9,215,9,185,7,44,142,84,
dc.b 211,33,55,145,35,8,206,59,183,107,171,28,171,239,92,109,186,1,202,64,133,47,51,94,105,61,50,65,152,171,32,36,
dc.b 62,116,76,105,135,205,245,118,102,207,138,163,231,45,146,85,184,224,157,104,68,131,212,125,28,124,30,110,62,59,176,33,
dc.b 65,196,221,125,239,55,19,204,195,87,27,94,178,173,47,130,152,61,160,14,86,158,190,198,182,139,252,170,227,189,146,36,
dc.b 217,211,74,223,129,16,67,204,202,207,128,170,77,56,166,143,63,169,213,33,76,14,21,157,9,243,229,65,89,230,173,160,
dc.b 10,62,74,98,47,135,89,208,142,80,133,83,223,222,227,181,129,39,237,211,227,224,220,225,42,212,61,31,127,135,185,255,
dc.b 222,75,106,200,155,58,84,104,81,36,207,218,216,39,151,20,33,84,27,117,50,120,225,85,196,58,50,181,38,45,145,194,
dc.b 26,143,83,99,173,209,214,211,136,186,218,19,165,75,83,11,183,93,5,175,147,165,16,109,80,177,236,124,110,114,240,111,
dc.b 240,239,240,84,45,5,171,114,136,21,176,174,146,86,183,60,61,190,223,111,203,91,12,120,144,16,199,62,56,144,45,186,
dc.b 182,4,183,132,111,204,200,140,200,138,22,202,35,102,73,13,9,4,95,59,26,161,37,49,37,32,101,216,201,28,132,211,
dc.b 135,51,159,179,49,147,220,184,0,76,121,125,62,47,55,167,122,157,123,136,9,19,42,169,156,144,19,173,227,238,129,96,
dc.b 111,81,108,12,240,248,132,84,36,219,140,190,48,19,37,201,102,8,130,96,225,13,155,184,110,145,194,78,192,143,207,234,
dc.b 251,255,143,167,66,101,9,179,168,72,140,174,11,124,193,7,202,42,35,232,32,139,149,130,163,97,121,34,77,26,131,219,
dc.b 242,64,112,21,31,9,235,206,93,207,15,225,193,197,77,210,14,252,117,222,180,34,203,202,36,7,5,106,23,95,6,176,
dc.b 45,157,18,76,53,192,108,68,235,194,20,121,90,250,219,91,125,26,19,180,36,80,155,5,253,159,95,40,181,220,91,73,
dc.b 175,167,63,65,16,19,13,28,205,105,213,35,147,40,138,69,4,94,130,67,88,47,8,171,56,247,125,84,113,177,10,67,
dc.b 36,31,34,120,225,191,199,3,29,199,26,166,234,184,130,109,100,78,153,52,24,58,38,30,82,124,201,56,67,22,41,250,
dc.b 243,194,109,37,236,233,146,92,249,21,93,40,145,226,106,234,21,24,68,14,95,39,139,205,222,241,146,187,68,119,219,11,
dc.b 186,229,214,223,6,188,53,204,120,239,119,118,136,147,200,125,41,0,75,45,23,57,19,39,39,23,144,194,7,216,242,174,
dc.b 5,62,12,112,2,91,93,204,225,81,244,242,125,27,72,57,190,86,156,135,110,84,168,34,31,50,41,177,209,147,18,50,
dc.b 249,202,57,87,215,187,236,20,42,57,105,172,136,168,29,202,171,124,156,94,127,17,47,172,80,56,229,130,241,28,71,142,
dc.b 9,49,37,17,137,2,161,149,143,108,184,108,123,14,57,2,19,98,168,168,41,102,38,108,156,84,245,168,108,80,145,158,
dc.b 195,229,239,133,225,180,148,21,163,105,25,234,144,112,243,34,104,125,124,213,242,47,123,155,154,168,254,190,169,28,135,130,
dc.b 223,24,147,150,218,87,46,226,113,87,215,16,138,24,165,64,189,93,200,16,51,137,22,29,93,52,61,85,138,153,213,223,
dc.b 134,165,171,143,227,50,46,32,146,41,64,218,214,152,7,230,190,75,248,177,168,125,214,110,188,217,186,140,38,174,81,110,
dc.b 173,164,149,121,38,185,64,88,64,243,113,55,79,215,226,238,248,196,106,38,23,96,24,205,229,57,60,131,41,88,21,82,
dc.b 232,197,92,132,45,2,130,135,48,71,57,201,199,82,171,78,101,133,51,68,113,192,126,227,82,84,147,182,30,132,228,120,
dc.b 108,90,7,14,92,214,87,92,233,186,233,37,137,157,37,120,210,240,49,15,36,91,94,188,60,219,157,255,151,238,55,28,
dc.b 118,184,24,3,215,235,221,174,125,10,197,198,224,75,144,106,38,127,9,52,60,218,189,90,149,42,143,102,117,139,29,148,
dc.b 210,95,71,103,171,179,173,162,37,108,72,104,60,164,184,236,233,107,244,122,250,240,205,83,131,166,18,69,53,218,183,44,
dc.b 144,96,24,174,219,185,205,232,238,255,255,115,207,113,86,78,158,175,44,239,38,239,123,191,187,233,242,115,36,188,201,103,
dc.b 117,195,185,75,236,40,137,134,171,234,40,231,212,39,8,53,38,5,172,192,137,59,159,177,173,54,92,205,109,98,2,110,
dc.b 46,140,118,51,250,4,114,27,36,64,179,199,59,64,231,248,175,219,19,241,167,146,245,132,48,144,242,122,105,98,92,133,
dc.b 177,196,104,3,191,246,127,15,167,185,221,241,110,218,128,32,69,51,114,68,201,148,200,152,45,82,71,67,156,67,87,38,
dc.b 32,140,75,220,82,62,166,215,79,161,179,214,219,61,27,35,70,58,249,167,169,224,92,165,74,217,168,124,141,25,252,224,
dc.b 254,19,216,239,200,129,42,220,220,62,111,15,123,197,202,234,162,112,214,24,197,205,228,251,59,125,207,23,5,87,74,66,
dc.b 152,106,96,67,142,134,198,165,141,85,30,204,34,196,134,41,226,148,44,18,90,41,232,110,119,75,111,102,116,148,89,148,
dc.b 143,128,8,132,112,108,231,32,67,62,45,167,177,177,54,86,122,239,158,181,200,47,126,65,163,149,202,26,236,205,101,82,
dc.b 181,197,185,228,57,151,212,15,108,198,136,61,7,113,53,95,152,179,152,175,128,231,188,39,151,24,198,192,118,161,165,155,
dc.b 106,45,32,103,237,213,214,155,54,70,124,201,99,241,136,170,57,112,208,90,1,13,251,2,17,22,144,65,247,166,147,142,
dc.b 142,68,211,32,184,242,103,73,68,79,11,235,251,253,254,239,215,224,225,177,125,18,243,43,60,4,250,26,24,25,115,88,
dc.b 218,159,5,231,49,184,20,222,170,119,169,9,110,212,139,63,172,49,97,39,151,228,196,100,36,85,16,91,4,156,50,242,
dc.b 36,103,103,5,157,203,144,66,171,20,97,118,155,60,11,111,139,130,157,124,35,157,7,226,219,173,239,15,147,138,210,20,
dc.b 157,130,203,199,100,254,166,10,190,189,254,42,196,142,186,66,204,92,4,44,226,152,14,15,183,18,4,48,58,54,105,103,
dc.b 196,121,35,162,62,43,86,75,67,76,170,148,75,26,211,164,203,212,157,163,160,203,205,220,173,70,149,204,74,171,138,231,
dc.b 53,54,201,210,1,149,42,104,139,6,188,242,110,215,174,208,69,19,164,222,168,153,174,147,73,41,34,96,88,81,200,108,
dc.b 111,229,115,143,127,123,119,149,214,103,237,117,54,181,52,78,152,186,18,25,78,241,211,177,220,47,193,250,82,197,123,1,
dc.b 232,211,252,231,200,77,44,17,11,19,45,251,141,101,38,142,86,202,42,101,163,78,226,80,228,66,60,128,69,187,226,197,
dc.b 154,4,1,167,95,33,213,147,96,61,40,128,176,171,234,243,19,236,41,104,237,123,123,125,61,141,50,101,130,94,140,117,
dc.b 48,90,184,38,114,77,19,54,217,70,204,76,197,62,28,249,3,232,196,149,46,30,16,109,250,183,192,252,50,13,210,45,
dc.b 92,121,96,57,72,145,143,141,176,83,118,250,184,125,123,220,92,197,28,75,174,53,116,87,116,118,151,179,205,200,81,198,
dc.b 66,155,63,79,69,16,28,12,71,141,0,3,252,239,75,20,178,80,154,43,141,67,210,70,95,181,100,136,173,109,210,229,
dc.b 241,116,157,61,212,242,20,42,226,67,189,44,225,53,190,43,150,154,109,204,152,175,140,16,77,22,145,16,183,133,180,69,
dc.b 242,92,177,118,159,171,115,209,185,83,35,37,3,156,233,103,94,168,242,102,70,57,93,97,205,13,60,111,148,232,128,204,
dc.b 162,229,1,131,104,134,163,19,220,148,159,161,18,225,41,153,27,69,175,30,71,203,20,184,249,15,208,227,121,210,6,200,
dc.b 86,130,252,12,2,108,50,143,201,178,219,48,133,6,165,191,190,131,245,207,248,235,5,50,102,173,13,89,140,97,25,8,
dc.b 226,80,135,239,33,129,237,217,108,25,33,76,132,115,56,163,166,40,255,93,186,192,35,73,226,180,76,41,53,149,54,5,
dc.b 92,64,52,66,39,178,18,73,170,85,26,110,189,236,225,40,134,66,160,186,12,44,152,175,16,86,60,214,210,135,160,105,
dc.b 26,193,143,39,236,24,114,77,214,200,72,196,89,121,23,87,119,205,11,223,191,196,209,139,176,36,24,100,212,168,191,144,
dc.b 8,251,37,234,194,100,20,33,13,21,44,189,128,132,116,198,139,112,174,78,96,161,8,12,33,240,145,24,104,143,56,87,
dc.b 15,218,186,105,187,156,106,162,140,230,69,147,29,115,128,122,140,232,103,142,232,24,0,217,67,158,3,218,13,229,16,222,
dc.b 66,129,0,248,58,79,200,123,164,239,215,22,219,60,136,135,1,15,99,66,30,160,137,219,77,163,35,35,92,40,71,145,
dc.b 93,202,0,71,115,147,136,247,213,162,167,193,11,238,130,155,145,171,108,20,74,77,194,101,116,201,197,236,159,201,229,118,
dc.b 3,79,149,227,205,210,209,138,24,104,64,215,140,212,92,178,27,190,252,38,209,99,252,20,68,45,16,245,6,32,178,100,
dc.b 206,138,79,85,28,194,158,72,136,227,187,84,91,60,3,50,45,15,79,9,130,19,138,83,8,187,135,75,51,186,65,76,
dc.b 192,170,172,213,237,116,58,59,206,65,41,172,36,33,217,204,242,251,21,234,244,234,153,119,149,49,20,58,37,11,106,46,
dc.b 78,69,177,78,146,54,131,5,65,132,162,99,190,48,153,166,143,191,34,3,29,198,171,210,163,82,209,129,161,170,82,46,
dc.b 59,229,162,135,116,90,176,19,211,145,16,64,109,26,216,103,155,97,34,198,168,245,140,3,30,6,59,207,56,144,83,3,
dc.b 60,4,90,232,25,28,42,3,96,20,155,231,44,20,68,209,96,116,161,228,170,25,153,144,95,180,52,155,21,209,29,80,
dc.b 3,77,0,39,228,137,61,77,113,48,94,138,27,234,45,97,180,242,239,209,10,172,184,149,198,3,33,64,130,215,19,246,
dc.b 215,140,48,143,159,99,195,43,106,209,19,130,125,113,248,213,73,50,9,254,213,244,61,137,23,51,154,122,34,123,148,254,
dc.b 27,2,20,104,242,249,132,225,141,184,201,91,41,13,242,172,73,82,162,163,228,198,80,197,138,39,65,220,23,242,158,178,
dc.b 17,26,46,128,148,158,67,29,53,196,207,47,132,48,132,247,111,178,155,74,44,37,59,192,139,142,200,72,154,119,106,193,
dc.b 68,6,233,226,32,50,163,145,200,223,229,104,114,167,107,80,68,121,148,44,236,166,183,197,112,154,34,36,151,134,72,59,
dc.b 18,148,231,37,123,26,18,46,21,144,241,195,185,197,99,152,68,113,225,184,185,239,145,5,16,229,150,158,52,236,185,92,
dc.b 225,246,184,193,170,18,143,95,172,97,125,71,179,60,136,184,126,146,181,247,132,57,2,189,36,32,203,35,79,93,126,43,
dc.b 90,121,209,26,25,2,42,56,67,134,34,205,26,178,175,252,153,58,144,30,183,135,35,248,151,30,20,36,70,67,171,1,
dc.b 226,38,24,97,17,88,171,150,61,134,45,50,68,97,99,200,212,200,120,96,120,201,17,40,247,131,27,51,43,199,132,36,
dc.b 222,96,19,168,50,253,231,145,224,136,6,144,10,229,20,115,26,113,179,7,67,77,76,49,142,85,22,211,197,117,152,207,
dc.b 137,62,119,174,143,26,77,83,128,120,65,141,81,46,224,103,148,146,72,54,42,65,161,15,24,125,5,108,25,38,91,117,
dc.b 54,25,28,78,131,2,129,237,134,166,50,178,153,30,53,186,56,184,67,49,200,130,226,17,51,53,38,42,207,28,149,143,
dc.b 236,6,185,27,78,183,154,30,114,240,94,227,228,62,108,62,196,40,44,56,9,154,137,99,70,22,111,24,106,13,161,187,
dc.b 123,1,149,147,57,208,20,254,87,23,2,44,54,81,66,72,22,56,185,32,12,83,188,161,167,138,232,36,213,37,236,122,
dc.b 88,187,81,124,16,34,198,151,170,195,245,29,12,252,78,254,6,20,182,50,227,26,30,98,53,247,79,6,20,196,174,202,
dc.b 102,151,126,179,71,135,136,49,214,214,37,161,48,136,40,163,138,254,107,98,226,29,223,42,23,143,98,50,252,126,161,81,
dc.b 170,137,66,116,136,77,128,77,132,47,255,27,178,140,69,96,162,52,119,26,45,88,136,199,196,68,89,186,140,82,13,5,
dc.b 205,114,243,179,134,215,175,53,81,23,132,36,208,157,188,171,163,244,1,126,17,209,14,42,81,135,27,184,163,67,119,17,
dc.b 226,180,148,134,83,212,161,139,164,67,133,27,117,18,228,168,179,79,217,116,2,40,76,128,108,118,198,76,168,219,196,200,
dc.b 128,153,18,226,33,25,197,224,129,33,75,102,186,156,67,67,187,4,247,90,136,97,248,204,88,153,164,56,86,81,15,146,
dc.b 82,54,109,68,113,94,104,104,49,139,194,50,16,127,140,160,118,40,191,232,244,73,254,24,49,241,177,24,210,24,250,224,
dc.b 202,18,210,45,162,45,8,191,91,69,164,203,207,102,211,126,245,220,24,44,188,203,215,163,184,244,243,210,10,50,88,148,
dc.b 37,120,77,46,3,7,13,149,89,88,2,8,146,247,68,148,106,34,233,79,86,190,56,29,154,103,11,218,51,63,115,205,
dc.b 50,22,135,253,182,207,208,34,57,232,222,21,83,125,76,212,53,131,53,3,162,173,98,246,60,78,109,12,58,92,78,70,
dc.b 201,244,36,37,207,73,16,148,79,2,157,174,118,66,155,60,241,95,26,107,59,7,27,108,41,133,75,77,66,202,146,215,
dc.b 158,140,177,226,188,0,229,233,6,131,216,229,167,195,236,67,242,11,216,86,136,134,85,138,188,138,37,102,175,92,179,86,
dc.b 205,243,152,137,149,131,244,72,22,141,133,18,205,37,46,125,152,85,84,161,225,184,104,107,82,195,206,65,82,244,124,119,
dc.b 115,170,55,130,214,67,231,119,111,60,169,165,163,248,44,169,149,225,163,121,200,40,228,61,84,57,4,53,72,228,232,193,
dc.b 162,40,209,242,208,78,97,77,233,144,251,211,17,81,90,38,116,167,101,147,222,0,133,175,32,103,108,98,27,118,15,21,
dc.b 63,200,188,165,227,243,151,153,146,234,156,141,89,115,16,55,121,192,37,71,94,61,102,42,101,195,122,181,78,46,10,60,
dc.b 181,9,6,86,16,235,8,203,166,104,108,107,246,132,234,56,208,50,73,13,98,40,122,143,158,77,150,172,91,168,147,144,
dc.b 168,67,255,132,212,249,20,132,40,179,106,88,170,224,130,117,216,205,255,130,54,69,192,144,159,124,248,201,74,60,136,200,
dc.b 59,213,249,56,75,196,211,128,84,6,110,195,129,196,198,28,130,13,188,185,206,169,126,161,1,3,42,10,145,227,43,21,
dc.b 146,81,110,1,201,148,133,138,147,13,22,237,132,125,81,16,224,135,134,34,148,72,7,227,77,143,141,113,156,68,38,248,
dc.b 230,36,78,198,168,221,204,211,148,128,166,173,236,26,194,123,40,230,171,232,16,226,40,67,119,55,128,230,125,98,165,75,
dc.b 70,99,76,0,28,228,8,213,73,122,17,12,139,147,223,171,45,50,254,60,250,151,172,169,19,12,247,163,200,79,165,5,
dc.b 137,111,66,93,220,119,106,115,10,144,240,94,108,108,216,179,228,116,164,55,105,51,175,204,27,21,194,19,208,222,60,89,
dc.b 163,233,6,107,162,37,0,111,65,158,186,51,136,162,46,53,70,117,145,144,200,35,78,132,232,226,7,178,107,57,220,175,
dc.b 148,94,1,168,145,27,166,74,125,130,175,60,216,163,65,31,53,117,119,94,212,200,150,155,169,93,202,197,184,92,117,120,
dc.b 190,251,62,158,27,20,70,118,4,110,61,108,73,56,72,115,46,111,124,136,104,32,118,23,81,166,185,196,205,129,80,248,
dc.b 133,155,167,206,149,21,28,69,145,240,195,204,198,148,210,17,121,111,34,34,36,68,241,162,28,152,144,103,89,23,138,216,
dc.b 115,95,151,24,252,16,242,122,168,147,196,110,24,162,171,123,146,212,78,84,225,216,94,146,233,113,199,166,178,117,36,222,
dc.b 121,123,194,170,216,42,176,172,93,77,33,17,206,136,237,116,149,134,69,36,146,36,169,198,81,131,175,163,94,133,30,116,
dc.b 112,118,141,181,99,69,205,167,32,101,227,120,158,196,142,243,181,141,184,69,82,238,162,52,72,71,140,218,33,11,66,183,
dc.b 128,197,17,12,82,74,131,16,84,34,106,237,89,208,189,240,128,124,19,107,64,139,106,115,73,200,191,158,170,115,163,233,
dc.b 79,147,158,161,25,224,145,90,18,108,174,112,249,96,234,46,112,5,73,25,199,37,185,108,28,230,76,76,221,184,21,94,
dc.b 72,19,34,25,225,22,192,135,220,219,50,238,134,117,46,188,145,185,180,3,154,191,62,70,167,93,73,80,237,47,90,26,
dc.b 150,232,52,203,54,245,160,231,245,12,5,48,52,115,127,139,13,102,141,69,192,150,33,71,53,117,62,103,145,82,15,121,
dc.b 67,158,216,88,221,162,1,216,92,30,28,3,77,183,32,200,16,132,146,66,64,32,73,9,0,129,0,0,0,198,198,198,
dc.b 54,216,217,27,109,182,220,114,71,100,110,72,228,145,203,45,182,107,109,219,175,110,237,183,123,221,239,111,130,223,123,189,
dc.b 238,239,119,107,219,219,91,211,91,219,107,117,214,235,109,146,200,228,149,201,91,142,72,219,108,112,109,131,108,0,0,16,
dc.b 0,144,0,132,32,18,16,128,73,36,2,253,253,61,163,239,223,126,251,239,93,108,141,38,67,98,118,19,166,127,169,22,
dc.b 68,64,103,204,188,198,220,128,82,182,91,204,167,161,55,168,155,49,182,128,167,211,244,214,21,52,161,16,10,205,170,21,
dc.b 80,169,113,166,86,232,184,212,90,230,98,193,146,214,242,103,167,86,48,138,23,195,19,46,145,191,25,88,164,56,6,49,
dc.b 146,184,151,91,49,38,56,14,210,36,39,192,35,34,132,158,21,244,68,119,244,68,216,54,11,26,253,53,34,197,38,57,
dc.b 135,246,32,45,217,151,220,171,172,115,17,204,121,53,99,168,100,102,132,210,169,46,87,176,165,53,113,170,92,102,222,182,
dc.b 70,196,136,81,166,101,231,168,90,79,40,137,178,119,209,88,173,37,46,105,111,23,241,35,40,217,135,153,129,127,137,152,
dc.b 31,12,76,147,68,149,66,102,232,200,67,3,51,59,109,88,79,96,142,131,38,75,26,16,100,98,154,54,178,214,100,30,
dc.b 247,242,94,40,137,23,111,34,3,233,43,100,78,182,170,173,160,172,113,54,229,198,243,137,185,171,104,222,177,164,219,106,
dc.b 154,21,237,212,105,40,153,22,17,178,252,29,111,151,181,254,63,171,181,251,127,219,173,212,248,174,180,5,66,25,199,34,
dc.b 231,92,121,57,248,186,154,211,6,116,45,40,96,99,196,91,64,203,93,109,133,149,108,244,152,155,47,232,55,178,243,242,
dc.b 101,216,233,208,204,43,169,83,76,214,110,190,114,179,127,57,89,92,67,214,108,180,89,97,175,8,171,178,221,216,2,64,
dc.b 86,72,128,246,27,219,223,155,253,63,55,226,255,239,227,252,159,131,240,127,239,255,63,135,241,255,243,252,61,254,157,190,
dc.b 46,86,186,131,115,35,81,166,95,149,232,244,58,95,211,253,95,127,250,58,95,119,218,246,126,239,63,210,243,185,60,75,
dc.b 77,227,112,25,164,196,109,44,124,33,141,116,161,220,160,61,208,60,123,80,99,192,57,30,75,154,43,64,127,46,176,144,
dc.b 224,69,245,221,199,99,191,225,249,190,30,159,185,239,116,250,159,71,118,239,43,86,24,59,2,191,119,103,206,245,254,223,
dc.b 245,127,79,222,251,159,111,216,232,147,238,249,124,139,91,55,27,91,38,26,249,121,185,30,27,158,231,99,193,113,220,24,
dc.b 144,47,110,111,158,140,58,111,98,43,98,139,218,243,135,135,178,83,24,166,6,161,200,250,47,50,52,160,99,223,94,224,
dc.b 96,223,186,38,69,235,42,159,160,164,163,170,181,250,157,47,171,246,127,151,254,95,111,249,127,155,238,253,239,107,217,250,
dc.b 220,254,46,241,196,210,152,186,25,143,48,187,253,159,151,171,241,116,253,255,119,220,253,31,231,254,191,187,227,237,223,99,
dc.b 144,228,161,109,170,53,194,80,26,23,169,172,77,203,117,116,171,181,244,206,228,224,221,136,108,157,155,126,253,227,167,78,
dc.b 223,195,81,57,65,68,34,95,249,222,207,221,251,62,207,171,235,250,190,127,212,229,91,111,171,170,41,103,141,190,25,151,
dc.b 182,255,71,205,212,247,253,239,221,251,253,239,135,225,248,187,93,235,188,60,130,59,40,172,234,25,27,52,145,181,161,173,
dc.b 178,173,172,176,177,178,174,111,54,14,10,155,106,206,109,89,176,168,126,195,52,114,17,81,28,57,171,166,171,222,111,247,
dc.b 251,170,218,170,161,1,10,178,142,117,4,1,67,205,196,191,183,249,62,47,147,225,247,126,30,167,79,246,244,250,127,191,
dc.b 169,212,250,9,192,56,24,71,152,17,210,12,241,14,216,83,124,48,154,171,174,220,8,175,83,162,125,145,174,16,11,95,
dc.b 74,230,171,113,101,186,2,111,113,134,101,207,59,155,231,114,247,214,155,187,10,199,33,6,13,104,122,121,88,248,30,11,
dc.b 126,215,207,214,249,186,191,195,169,213,234,252,95,191,226,236,162,255,192,128,24,235,0,104,227,19,210,54,12,241,13,98,
dc.b 228,227,100,81,46,21,189,77,23,96,75,122,83,163,59,174,13,183,39,205,243,186,30,167,75,235,251,95,91,209,243,124,
dc.b 206,61,160,8,154,133,163,21,16,245,34,68,25,88,112,187,221,206,175,193,240,251,222,247,199,243,118,251,118,254,60,17,
dc.b 177,176,65,54,195,196,5,140,229,134,197,223,65,128,48,163,138,235,2,96,130,108,47,14,48,182,15,135,148,50,253,89,
dc.b 242,190,13,183,154,126,113,249,124,109,255,8,7,250,16,3,114,214,96,213,243,177,167,155,145,139,127,117,111,216,235,124,
dc.b 127,199,226,249,59,29,174,223,123,199,227,189,241,92,222,222,224,58,196,28,36,114,223,61,12,234,155,205,77,72,19,168,
dc.b 200,150,200,219,150,213,163,113,153,246,153,200,222,171,99,186,17,87,248,60,13,242,50,185,238,2,226,213,213,161,124,228,
dc.b 80,28,18,120,207,102,199,162,236,252,140,32,47,13,254,21,245,248,6,55,15,15,199,117,227,239,119,187,189,187,155,171,
dc.b 240,224,17,68,229,27,240,67,182,146,158,161,23,206,134,59,220,80,141,72,52,148,245,118,27,139,43,36,56,239,99,92,
dc.b 52,146,212,55,15,53,78,137,22,76,12,131,151,76,75,237,27,226,117,32,142,163,41,65,91,231,152,209,62,202,40,170,
dc.b 236,59,207,7,137,17,58,145,18,4,161,107,124,136,51,226,67,202,191,248,161,98,149,175,67,215,180,40,214,234,228,15,
dc.b 201,85,97,86,6,167,168,17,81,192,201,167,118,77,241,209,161,144,29,226,192,22,125,16,232,206,130,49,20,231,35,88,
dc.b 46,30,38,70,96,184,42,97,132,10,64,137,32,195,61,18,123,228,171,148,215,102,117,174,114,109,169,3,78,133,195,138,
dc.b 84,107,204,23,13,28,55,70,169,54,43,37,210,53,186,32,169,164,241,156,167,120,197,8,67,146,30,75,28,240,195,101,
dc.b 194,216,233,162,148,62,78,148,10,158,210,132,159,233,178,111,119,55,166,166,228,240,204,81,164,29,172,164,21,208,65,0,
dc.b 202,116,136,43,76,204,122,87,204,75,144,0,195,211,57,224,171,39,224,4,209,187,69,218,99,140,137,237,90,225,60,67,
dc.b 101,240,169,112,138,172,138,209,85,173,82,61,229,75,165,3,164,104,146,52,37,154,243,144,219,108,232,164,234,143,205,179,
dc.b 232,160,58,53,254,202,67,238,62,93,171,8,58,202,252,65,254,3,161,128,115,77,174,82,168,51,240,222,140,170,6,234,
dc.b 93,81,160,105,90,228,108,236,72,65,38,205,115,189,50,200,205,114,39,26,49,155,148,171,208,113,9,191,37,1,72,127,
dc.b 91,25,84,2,242,43,73,200,32,190,167,199,244,244,52,78,219,103,160,125,148,162,25,3,230,162,122,50,44,83,171,84,
dc.b 155,239,8,90,32,68,128,225,96,213,10,104,10,31,109,14,76,8,59,149,64,37,78,27,199,134,192,26,67,205,138,154,
dc.b 154,177,141,248,82,220,20,5,145,193,193,16,148,74,27,72,67,224,6,27,144,32,178,178,198,62,242,137,230,35,162,202,
dc.b 65,203,13,171,200,69,179,144,147,72,125,115,88,81,64,69,59,35,48,194,69,33,130,56,170,244,96,81,93,93,185,17,
dc.b 220,236,247,86,21,64,3,231,20,168,10,4,215,22,100,250,29,85,201,119,146,81,60,227,61,254,80,216,169,159,228,127,
dc.b 102,128,41,89,37,3,148,9,253,60,136,16,24,117,37,80,129,178,168,46,163,162,35,186,67,138,96,212,142,251,131,194,
dc.b 182,226,241,121,28,158,63,35,202,225,218,218,111,183,149,245,116,131,202,244,180,125,136,35,82,118,70,54,31,145,21,122,
dc.b 242,251,0,62,54,99,210,75,223,70,106,71,99,121,66,2,52,121,42,134,106,28,43,136,155,16,54,3,156,225,175,103,
dc.b 5,25,215,196,228,243,188,254,143,175,236,125,143,175,252,159,107,234,251,30,183,67,157,203,227,112,55,128,33,202,70,204,
dc.b 151,2,185,6,71,146,33,144,37,64,6,118,156,107,15,21,214,48,125,231,25,230,54,30,29,229,237,245,224,214,98,136,
dc.b 197,162,61,229,253,246,26,81,71,48,33,199,52,138,54,168,177,179,226,114,252,207,71,213,245,254,191,216,250,223,91,216,
dc.b 244,253,46,135,59,155,202,227,112,173,55,53,46,64,1,178,196,180,23,217,217,57,56,152,99,137,210,81,66,24,194,29,
dc.b 54,78,92,160,37,7,71,241,176,239,60,62,27,175,17,204,48,48,112,137,107,248,142,142,150,231,105,236,109,27,62,73,
dc.b 181,2,70,79,27,153,245,61,63,95,165,236,123,61,47,83,210,231,249,220,190,63,6,200,159,56,67,39,91,46,106,126,
dc.b 60,114,5,146,228,130,235,49,206,34,148,96,254,142,137,25,79,32,69,174,17,234,207,163,97,225,8,118,227,29,101,216,
dc.b 220,70,65,148,3,250,142,224,244,213,193,10,107,110,55,43,155,230,115,185,222,111,55,143,229,112,119,187,154,202,148,112,
dc.b 123,1,37,42,80,107,249,124,96,210,32,66,202,82,240,77,180,208,15,55,8,40,26,200,131,184,251,43,29,208,225,22,
dc.b 7,186,240,221,120,239,192,149,70,255,242,15,204,129,19,97,181,41,57,103,129,107,109,197,227,113,56,96,130,129,30,106,
dc.b 185,200,131,144,136,217,198,188,83,86,174,178,80,7,17,252,131,92,209,65,212,192,113,23,163,197,84,160,162,158,50,81,
dc.b 154,184,232,141,162,13,80,16,144,31,4,211,117,246,129,114,141,104,193,22,104,210,208,148,108,79,0,126,13,221,217,30,
dc.b 54,13,170,139,147,121,94,218,32,246,197,65,244,131,185,56,17,254,82,175,156,33,20,157,27,251,64,81,121,110,211,161,
dc.b 152,174,147,243,29,26,98,52,161,3,106,230,88,26,203,69,113,52,65,174,39,134,239,184,22,135,19,29,71,4,119,241,
dc.b 133,173,161,1,26,82,144,130,97,107,33,40,114,132,251,233,179,100,228,47,209,23,43,73,40,16,177,5,96,6,163,154,
dc.b 113,23,232,172,216,127,160,133,62,64,49,48,141,160,108,122,20,56,34,85,214,213,84,212,14,81,53,104,72,25,156,216,
dc.b 227,54,161,16,243,246,35,16,157,53,53,18,40,225,19,140,253,225,255,195,122,201,10,34,18,43,37,202,103,83,139,23,
dc.b 90,82,181,124,8,80,69,87,228,130,50,165,40,202,17,157,23,201,70,26,162,59,166,238,203,113,86,230,136,195,142,121,
dc.b 146,46,14,20,135,73,14,116,131,230,148,78,75,212,162,113,1,156,34,11,166,169,196,128,218,126,67,188,2,34,186,35,
dc.b 200,26,208,161,202,81,246,72,196,163,126,123,74,4,106,207,167,38,116,141,192,182,59,138,218,212,72,138,162,28,163,131,
dc.b 37,167,64,14,45,159,156,153,201,226,14,68,137,229,30,91,209,7,49,21,136,77,188,10,36,202,83,23,140,118,21,21,
dc.b 15,181,96,3,236,117,181,146,22,42,52,106,162,54,157,16,18,207,113,186,178,221,238,132,129,186,116,227,13,65,206,136,
dc.b 195,90,108,153,72,48,2,60,225,70,213,25,200,193,65,191,123,7,203,165,43,105,162,181,90,120,88,157,220,212,79,172,
dc.b 146,224,69,106,162,29,216,68,201,122,53,247,210,84,28,96,115,255,78,220,210,31,47,100,140,24,18,187,80,248,66,146,
dc.b 120,159,153,207,116,81,99,40,226,104,211,16,56,142,36,42,33,38,156,231,82,168,114,35,182,218,50,154,76,81,92,12,
dc.b 134,42,118,246,134,141,202,16,75,26,222,67,215,2,57,32,19,238,113,98,98,97,18,83,24,113,71,77,1,165,19,225,
dc.b 114,150,197,141,211,169,66,9,162,126,2,244,47,18,34,168,34,1,145,242,209,4,17,60,229,138,31,216,79,151,162,20,
dc.b 49,186,21,181,16,233,254,122,46,33,63,8,3,201,175,162,20,20,200,245,60,6,11,130,34,185,81,251,84,66,23,69,
dc.b 81,212,163,62,4,73,209,125,101,56,184,136,106,141,100,195,226,252,165,13,144,50,154,185,73,22,237,19,138,14,98,200,
dc.b 227,188,138,193,160,89,109,164,199,120,227,48,101,113,36,244,82,26,113,130,17,210,40,59,4,156,65,227,228,37,129,25,
dc.b 77,22,116,225,34,188,9,252,136,179,200,41,109,34,149,34,211,242,44,186,81,32,232,210,138,88,56,209,198,86,42,148,
dc.b 169,44,155,114,245,80,78,250,45,17,158,125,233,158,92,74,68,78,74,32,5,20,66,181,161,249,41,2,97,194,241,249,
dc.b 210,88,166,73,82,76,194,18,20,218,124,177,27,105,235,196,163,203,20,16,186,59,228,6,76,85,166,100,91,73,228,244,
dc.b 19,34,116,70,71,23,79,209,18,221,18,143,96,163,219,9,151,209,160,101,250,33,255,37,25,86,251,71,82,85,29,247,
dc.b 180,153,165,47,59,110,18,186,220,217,111,119,246,156,4,120,185,178,19,5,204,74,90,178,16,18,68,87,8,102,138,83,
dc.b 246,130,202,137,32,188,237,238,134,148,164,5,212,91,63,70,179,136,2,87,121,238,100,170,51,227,50,85,26,40,253,56,
dc.b 233,71,170,141,215,174,41,209,60,95,125,192,149,249,193,223,137,166,117,20,164,109,84,93,238,36,46,162,226,126,140,164,
dc.b 86,130,40,88,132,109,17,20,104,81,75,64,129,2,152,73,189,19,28,8,7,152,231,241,144,105,109,32,219,157,11,60,
dc.b 15,156,18,104,146,146,204,179,29,251,202,78,46,200,35,53,78,224,46,16,138,234,74,80,69,4,51,140,65,74,57,160,
dc.b 239,112,45,62,71,145,96,146,68,170,57,144,90,29,18,180,140,143,241,81,222,122,82,9,195,225,15,96,221,248,65,27,
dc.b 158,68,204,26,176,140,69,109,100,164,191,225,39,125,179,52,240,85,29,68,252,138,154,74,60,141,146,126,69,47,164,86,
dc.b 88,153,242,111,65,255,124,15,145,207,177,228,172,208,15,170,104,166,59,227,104,25,214,33,44,124,34,62,120,32,230,82,
dc.b 61,12,225,22,74,102,90,84,64,5,18,151,233,17,33,64,19,253,51,43,203,131,241,9,99,203,74,240,184,195,52,227,
dc.b 103,24,2,151,28,87,55,65,60,50,133,176,158,71,76,136,103,172,194,119,237,165,81,200,44,153,74,109,5,72,163,171,
dc.b 63,226,138,151,150,148,172,71,47,41,88,108,142,253,228,72,224,35,75,121,56,169,235,74,45,148,105,32,156,173,84,202,
dc.b 209,48,34,79,4,146,124,44,169,4,41,165,145,33,144,39,224,154,143,228,83,102,74,52,100,6,56,136,216,200,173,188,
dc.b 138,245,231,244,144,50,143,111,15,30,243,83,222,64,193,254,118,122,120,88,121,146,70,36,70,225,51,77,242,43,144,130,
dc.b 87,194,240,243,242,151,30,145,34,116,90,53,255,127,193,59,37,21,233,72,200,233,67,212,74,151,21,42,140,65,77,45,
dc.b 134,138,71,153,73,162,123,49,41,41,228,110,41,69,207,45,84,128,0,139,107,195,169,82,75,216,28,178,104,145,48,26,
dc.b 142,138,140,163,167,142,222,31,229,110,157,110,154,242,124,180,93,224,71,108,3,218,212,192,232,71,14,4,239,148,122,72,
dc.b 44,132,140,6,59,113,101,229,160,222,132,96,26,214,70,115,212,110,90,100,209,169,71,117,82,56,17,244,80,88,93,43,
dc.b 128,147,24,233,214,82,17,193,121,116,154,10,173,104,40,221,25,117,209,103,12,139,62,157,2,60,0,199,54,20,100,25,
dc.b 158,225,225,154,66,93,162,115,102,124,175,57,68,245,209,249,232,119,53,41,57,106,51,18,195,96,205,43,129,201,84,227,
dc.b 232,157,147,78,104,78,5,30,165,19,44,81,110,164,150,100,148,217,180,132,227,33,154,112,50,211,71,192,153,105,133,129,
dc.b 128,154,61,129,168,184,206,145,51,24,36,202,99,13,24,75,76,34,129,20,171,85,3,150,237,234,156,209,211,184,163,172,
dc.b 115,75,95,67,71,97,74,80,77,244,85,141,168,43,105,91,19,63,88,170,94,192,144,193,58,166,126,136,99,124,219,129,
dc.b 141,152,19,110,187,197,238,227,104,97,64,39,144,187,208,189,183,238,247,122,255,175,193,151,132,165,132,121,217,17,166,52,
dc.b 159,106,193,116,80,125,252,45,204,181,5,77,69,137,46,10,154,194,154,194,158,210,155,113,201,111,185,222,211,241,102,224,
dc.b 201,128,161,181,69,67,153,198,22,13,28,55,131,155,119,166,202,113,102,198,220,93,166,42,225,223,120,49,222,124,255,37,
dc.b 221,197,220,111,155,191,170,237,155,220,252,79,139,3,232,94,169,235,222,156,89,183,185,184,80,159,104,78,214,125,205,234,
dc.b 137,150,156,57,233,233,169,110,29,27,26,200,213,246,107,40,229,239,164,122,125,14,108,221,195,159,231,246,43,32,232,77,
dc.b 208,80,169,103,104,30,90,118,245,215,127,191,157,222,241,135,57,187,215,111,102,108,99,108,211,116,120,151,253,168,27,78,
dc.b 190,63,215,254,78,171,27,82,50,208,121,221,207,240,251,191,236,235,123,173,244,96,235,73,222,89,168,221,242,247,212,218,
dc.b 113,150,221,197,102,178,134,117,102,131,13,246,251,239,125,255,187,203,172,230,255,219,238,113,235,173,184,220,38,26,108,247,
dc.b 22,173,181,164,191,239,226,224,92,117,190,136,149,11,158,100,95,103,106,96,106,213,115,92,248,253,206,155,204,127,163,173,
dc.b 248,253,203,174,222,70,158,30,4,133,15,127,103,246,226,108,235,100,227,50,174,114,178,254,13,101,21,69,101,83,145,21,
dc.b 138,54,142,78,115,173,189,37,94,119,171,185,207,95,209,227,56,97,14,171,157,190,182,228,115,124,198,238,244,241,186,176,
dc.b 156,213,50,11,113,48,203,253,23,25,77,24,70,176,230,121,67,231,181,13,46,63,207,215,190,117,215,203,216,125,173,25,
dc.b 100,44,236,216,53,182,214,117,205,214,175,131,135,30,102,159,141,97,78,209,123,57,251,61,245,52,236,109,173,133,13,166,
dc.b 159,222,58,125,9,254,131,27,94,143,157,192,225,114,248,91,139,6,210,199,152,214,255,225,248,255,15,195,6,19,172,82,
dc.b 8,134,100,122,26,154,202,166,123,89,95,39,232,235,247,238,53,37,182,87,200,216,211,196,203,198,119,178,163,91,98,134,
dc.b 214,192,126,45,162,167,18,241,233,100,105,234,63,188,183,206,135,48,73,247,101,69,27,97,155,154,250,238,23,26,132,247,
dc.b 219,106,75,13,43,171,235,155,123,236,28,198,71,156,138,72,144,106,231,213,137,17,174,239,112,60,23,88,31,55,237,235,
dc.b 220,67,165,177,232,122,150,181,212,211,112,162,81,209,71,130,243,39,3,169,117,175,93,231,135,7,28,204,46,167,115,79,
dc.b 185,226,112,25,148,28,204,227,133,219,19,14,89,174,23,236,232,168,229,192,94,123,97,238,208,126,78,163,200,91,25,239,
dc.b 178,110,58,189,155,123,120,148,245,246,44,162,67,194,240,100,60,49,226,131,172,243,59,47,97,140,201,185,213,102,99,165,
dc.b 3,98,110,60,9,153,193,49,174,198,185,203,106,93,238,247,153,204,162,96,163,61,238,61,206,60,138,43,74,37,141,0,
dc.b 50,77,91,15,42,90,89,58,171,235,108,169,88,9,150,190,31,0,233,38,234,239,181,213,185,197,121,168,178,99,63,27,
dc.b 3,39,43,102,210,205,202,243,122,78,202,240,193,76,182,136,151,103,146,242,58,166,75,117,246,151,182,172,182,254,79,235,
dc.b 254,79,63,161,184,144,253,251,203,143,147,171,225,140,6,102,114,66,54,114,206,150,195,133,189,38,127,191,202,32,124,66,
dc.b 147,157,244,246,111,60,23,177,231,54,94,15,185,88,94,55,219,15,224,233,235,109,153,158,207,44,214,216,210,33,147,42,
dc.b 81,77,103,98,202,101,197,18,193,8,47,73,68,253,62,239,135,204,230,243,55,212,19,141,41,92,41,20,114,95,92,92,
dc.b 95,190,137,180,194,110,90,42,250,37,76,119,126,109,154,163,63,76,188,157,72,218,88,216,57,89,158,31,30,70,61,199,
dc.b 86,231,46,14,164,133,83,44,105,28,77,209,84,207,76,70,131,143,221,249,238,30,40,98,177,124,242,200,242,24,57,222,
dc.b 249,222,191,43,121,191,10,167,9,12,98,57,137,10,91,104,214,203,173,32,195,233,179,141,205,66,200,240,38,107,89,237,
dc.b 108,59,184,248,253,239,158,229,226,49,245,204,107,101,154,92,181,84,71,11,24,220,120,178,30,106,76,178,61,247,152,96,
dc.b 202,138,130,98,125,195,8,227,219,222,118,75,205,89,150,213,53,150,188,115,102,85,118,247,141,200,221,180,21,170,243,53,
dc.b 53,182,85,204,193,196,196,117,164,178,158,206,211,147,207,181,96,2,119,53,189,102,100,186,237,251,221,66,139,60,199,125,
dc.b 33,90,245,170,37,137,110,194,81,84,252,226,152,24,215,55,78,159,107,105,72,111,59,165,142,251,109,157,109,167,2,201,
dc.b 192,160,150,193,131,107,26,150,83,27,25,152,111,182,84,178,175,223,238,92,80,208,176,27,159,105,43,105,217,172,83,19,
dc.b 15,175,242,248,225,40,150,94,214,137,81,17,139,197,146,32,203,40,132,239,179,240,124,63,39,119,73,132,240,237,196,164,
dc.b 24,203,50,200,7,101,84,202,6,13,215,111,196,51,12,171,220,91,90,214,55,160,178,229,121,125,15,47,151,196,107,177,
dc.b 127,217,188,53,214,128,240,199,90,149,206,57,126,215,220,244,56,78,98,226,93,223,103,65,120,232,84,71,238,246,60,79,
dc.b 102,92,137,141,12,152,28,47,14,11,38,18,32,104,106,101,118,62,14,159,103,58,97,189,107,117,113,141,49,51,20,245,
dc.b 118,124,27,39,10,204,177,20,57,106,208,52,63,181,17,133,69,183,30,184,63,200,161,97,42,1,123,121,144,183,228,128,
dc.b 86,209,60,59,91,49,222,115,252,172,194,2,67,41,153,58,184,61,190,167,201,126,161,181,107,65,42,56,107,197,82,194,
dc.b 179,137,78,161,231,107,173,211,235,99,233,237,80,55,25,45,27,89,90,115,189,47,79,215,226,89,85,45,133,135,227,203,
dc.b 131,176,177,108,186,37,64,236,173,164,223,250,254,183,13,188,109,108,226,138,143,96,185,239,87,244,123,127,147,248,96,40,
dc.b 113,97,193,178,162,150,26,12,98,178,52,151,107,95,245,126,15,147,228,235,228,171,107,86,66,162,1,197,189,216,90,214,
dc.b 178,161,124,44,188,123,188,8,84,92,159,187,255,127,90,202,110,67,236,121,13,169,133,136,217,173,113,151,220,66,0,102,
dc.b 221,120,129,164,249,222,156,192,213,33,44,40,176,223,92,3,215,163,41,152,137,159,149,141,131,154,161,158,226,210,173,132,
dc.b 104,46,188,46,180,35,42,83,20,51,207,145,157,178,17,128,175,170,106,101,170,193,147,107,31,43,202,227,239,105,154,195,
dc.b 197,117,153,161,20,38,82,107,26,145,46,214,178,210,214,210,178,113,70,126,30,7,139,197,119,127,127,224,188,195,116,251,
dc.b 105,133,21,77,59,133,210,203,53,244,53,51,8,99,216,121,58,26,230,151,33,163,76,44,22,186,110,96,33,64,143,0,
dc.b 114,35,5,134,23,178,103,68,132,148,172,183,53,53,76,166,102,53,141,50,17,3,47,193,232,194,121,155,122,122,97,196,
dc.b 78,30,115,172,156,43,240,50,11,172,76,152,49,182,230,137,104,97,45,205,84,43,138,248,236,24,176,68,105,0,36,149,
dc.b 139,150,35,213,253,77,109,43,122,70,212,46,91,56,171,163,97,44,73,2,137,33,130,233,166,205,205,110,236,202,46,221,
dc.b 41,211,40,210,180,206,60,121,10,30,120,254,98,239,23,41,254,180,101,73,60,28,123,33,17,149,115,177,242,48,93,61,
dc.b 0,204,2,0,25,6,169,23,147,11,196,220,99,96,66,137,185,186,10,138,203,59,75,45,197,64,111,236,157,184,162,44,
dc.b 73,75,185,231,128,211,230,184,225,64,205,36,60,190,120,29,44,32,78,97,225,231,105,62,216,94,194,121,172,220,196,100,
dc.b 102,215,214,21,236,115,47,239,48,240,221,198,48,202,169,166,68,20,166,83,212,236,209,46,146,92,141,236,212,81,88,106,
dc.b 196,143,44,181,108,237,33,156,202,74,127,218,151,99,56,182,62,155,236,103,89,193,168,225,170,135,73,230,104,173,152,128,
dc.b 187,225,231,100,224,186,118,239,73,26,235,163,145,128,96,198,145,44,192,147,200,53,229,42,17,182,154,206,203,20,71,227,
dc.b 42,66,139,43,179,166,28,237,20,43,102,224,4,246,164,25,68,13,85,113,85,83,91,66,3,125,216,208,15,112,63,202,
dc.b 192,238,246,59,183,89,113,85,208,214,215,209,109,190,194,240,221,228,104,193,141,176,246,243,187,116,120,33,178,192,23,151,
dc.b 23,105,76,213,25,0,246,198,157,150,217,219,149,140,232,202,10,105,202,195,82,43,39,59,155,61,213,107,117,65,144,19,
dc.b 166,164,211,201,100,211,199,32,153,28,174,62,47,123,199,125,131,155,173,25,74,189,189,50,7,115,199,186,0,61,248,218,
dc.b 175,77,23,14,179,35,79,78,165,5,79,5,83,48,117,5,4,234,181,33,89,62,69,166,235,135,101,68,182,52,77,189,
dc.b 121,198,81,152,169,132,178,146,30,181,72,209,58,178,129,170,166,49,180,53,180,160,199,219,199,186,192,131,31,46,52,211,
dc.b 139,26,218,122,2,53,85,56,159,177,29,123,120,88,151,253,155,139,175,131,171,223,18,192,239,173,238,251,157,130,157,44,
dc.b 193,16,86,157,157,45,224,125,141,227,127,63,212,251,63,127,236,125,159,191,255,79,67,155,101,85,84,3,30,212,212,123,
dc.b 9,246,31,203,252,59,125,203,174,223,106,231,189,131,154,255,27,199,130,245,122,157,170,138,203,14,53,175,149,246,255,155,
dc.b 237,253,255,249,250,222,126,242,178,193,100,21,82,208,226,102,186,200,238,254,239,242,252,95,151,251,255,179,255,255,191,167,
dc.b 211,234,123,189,174,239,80,36,17,183,53,48,35,203,91,125,78,143,218,251,31,123,250,58,59,237,197,141,45,125,181,85,
dc.b 13,105,66,149,236,230,99,104,106,231,231,234,196,210,19,241,246,130,30,213,118,156,125,255,153,235,122,94,183,169,236,250,
dc.b 253,14,109,165,147,61,135,185,56,157,223,167,183,251,127,47,246,127,227,240,127,119,246,254,31,238,246,255,191,242,255,135,
dc.b 183,253,255,139,219,255,63,223,239,124,248,112,23,50,163,180,182,229,122,127,88,48,85,232,250,125,31,55,141,230,250,221,
dc.b 14,102,245,200,33,14,120,12,4,38,213,80,178,4,67,178,160,92,163,110,97,145,77,133,215,239,184,252,222,119,59,135,
dc.b 101,80,210,113,73,21,51,50,235,248,251,159,159,241,255,104,136,65,248,191,23,255,191,39,230,252,159,143,243,254,159,139,
dc.b 183,111,118,235,11,35,78,66,153,202,125,221,183,52,143,45,201,229,243,186,30,143,75,165,230,241,43,168,104,232,26,50,
dc.b 51,155,28,157,217,13,251,192,255,217,153,177,118,4,1,194,173,141,29,141,84,232,52,108,92,86,74,119,179,15,231,247,
dc.b 255,95,232,255,31,241,255,63,207,240,117,250,255,47,199,241,123,159,163,247,123,255,7,99,197,141,159,2,44,194,230,118,
dc.b 28,126,127,167,208,232,122,93,15,67,204,244,61,78,151,181,246,190,207,169,231,250,31,83,145,107,107,194,227,91,111,119,
dc.b 117,68,83,38,38,204,233,246,171,164,107,63,116,232,50,251,182,70,128,143,163,147,135,120,32,235,118,126,63,213,254,95,
dc.b 233,251,63,119,187,252,109,237,251,157,255,167,230,254,63,31,95,185,113,124,237,254,144,189,243,0,15,194,24,119,172,225,
dc.b 134,253,62,175,217,251,223,207,236,244,69,208,110,41,79,138,240,120,41,67,79,111,55,53,174,103,204,183,213,73,148,130,
dc.b 129,34,52,4,206,159,10,246,231,191,111,244,220,118,62,111,155,232,250,58,253,94,153,67,83,252,63,31,203,111,124,72,
dc.b 184,20,208,179,50,128,221,96,206,69,12,69,164,59,46,31,39,151,196,222,89,112,184,220,59,94,71,63,216,246,189,175,
dc.b 173,245,122,93,31,67,153,108,149,14,214,225,197,5,16,129,118,53,177,142,175,65,233,1,96,151,33,230,70,21,237,237,
dc.b 207,95,167,250,127,55,231,253,34,237,247,87,191,227,61,45,41,159,172,34,143,145,42,4,60,7,178,2,187,51,206,42,
dc.b 170,28,85,90,114,188,190,47,23,208,233,122,222,167,167,209,245,61,95,87,207,230,114,185,156,207,43,127,195,242,249,252,
dc.b 254,70,247,117,94,222,93,250,44,218,99,221,224,228,227,95,248,174,239,112,176,110,123,189,238,239,87,220,252,223,171,248,
dc.b 246,187,157,191,159,231,238,220,125,31,55,211,226,192,33,186,101,191,204,197,195,199,207,213,139,169,163,29,123,74,42,109,
dc.b 207,35,209,244,189,15,63,210,245,121,252,174,63,151,232,116,125,126,143,157,232,145,75,188,238,103,26,214,202,140,14,23,
dc.b 175,160,7,220,139,19,56,148,160,40,200,17,140,197,242,220,87,120,126,31,166,234,251,11,3,191,217,239,95,11,28,152,
dc.b 185,175,210,161,2,13,39,248,175,112,114,51,157,187,129,46,210,150,187,129,200,12,86,112,248,126,85,183,3,127,109,201,
dc.b 230,114,109,120,94,95,63,209,231,115,121,126,85,157,77,11,0,180,236,45,18,154,17,207,117,226,185,187,54,50,15,214,
dc.b 185,238,208,247,14,72,135,47,117,217,236,119,110,112,13,242,112,98,236,130,158,179,178,133,62,55,78,222,137,29,146,88,
dc.b 54,163,115,97,189,179,178,31,145,184,92,174,56,187,27,194,178,220,238,145,118,16,161,58,107,131,33,194,2,220,88,68,
dc.b 133,44,194,162,170,205,213,134,2,106,128,124,93,209,19,8,67,247,188,241,164,99,179,181,112,73,223,34,163,6,150,147,
dc.b 215,143,72,24,145,68,196,65,253,192,61,172,111,156,171,176,178,23,23,172,5,166,205,197,101,117,125,93,24,186,216,210,
dc.b 133,170,104,42,33,5,165,7,17,148,81,210,131,222,57,243,227,105,110,5,200,113,234,224,94,156,190,198,41,23,115,176,
dc.b 16,70,197,148,109,33,40,72,192,92,113,186,56,214,45,91,99,105,107,195,226,241,109,183,228,4,210,10,197,37,25,15,
dc.b 76,161,152,17,110,56,94,153,0,159,16,153,128,231,90,122,47,94,99,8,7,190,11,145,2,150,240,141,155,133,133,129,
dc.b 42,75,75,199,130,155,80,120,172,93,253,27,34,132,73,233,178,29,213,85,101,133,150,239,125,107,194,242,184,68,120,103,
dc.b 36,38,20,161,98,104,155,163,94,216,3,57,68,120,72,175,222,27,247,207,205,201,12,45,221,120,60,37,20,44,28,61,
dc.b 120,16,188,197,40,73,148,3,48,26,21,69,210,121,178,64,204,115,206,179,51,214,212,52,53,91,173,221,167,3,131,192,
dc.b 222,86,139,122,196,183,11,61,214,224,57,113,56,198,83,131,120,229,250,148,182,220,51,118,222,118,48,139,67,125,140,236,
dc.b 140,33,3,79,49,5,145,230,101,38,237,199,197,63,208,65,24,37,64,18,91,6,213,176,48,17,23,77,155,68,167,192,
dc.b 138,124,6,190,190,172,151,153,87,91,87,85,85,77,64,110,130,2,139,39,242,2,146,74,147,130,18,83,233,9,44,40,
dc.b 149,71,16,57,82,11,104,42,15,225,84,80,93,94,122,33,225,6,108,200,212,32,66,147,254,5,84,136,86,64,245,103,
dc.b 36,176,45,200,188,12,24,189,104,77,35,168,16,82,5,199,244,162,54,80,36,44,148,108,220,13,72,233,18,106,37,82,
dc.b 5,128,180,32,83,64,253,209,163,165,13,21,126,117,135,100,36,113,58,208,205,50,67,197,202,125,14,89,18,238,165,51,
dc.b 136,205,183,77,231,68,194,50,157,197,74,62,178,105,124,160,86,109,10,120,109,130,168,196,102,156,253,66,9,64,150,252,
dc.b 138,190,194,169,26,132,166,91,145,111,54,121,17,168,52,178,241,48,112,80,156,222,83,221,2,74,158,139,253,61,18,24,
dc.b 209,8,41,92,237,5,37,42,41,230,32,113,41,144,82,179,54,168,217,184,4,94,4,68,144,73,200,91,203,19,173,235,
dc.b 17,106,21,68,196,211,82,163,95,77,247,36,56,213,59,90,233,80,55,107,35,66,0,158,64,144,1,242,244,66,238,210,
dc.b 243,36,69,181,41,80,83,197,60,121,5,181,147,147,10,3,240,18,164,68,177,32,53,76,16,16,98,163,67,129,255,130,
dc.b 132,252,227,100,151,6,197,106,76,85,79,156,136,178,163,161,192,123,157,60,223,122,123,44,139,163,100,6,163,229,224,87,
dc.b 197,100,19,132,19,224,141,76,202,214,206,80,19,30,207,152,77,75,68,211,126,1,215,1,5,1,57,145,188,58,93,1,
dc.b 109,2,72,28,17,104,234,40,233,90,129,174,101,13,0,80,177,11,187,15,199,196,154,220,151,250,135,96,209,212,170,96,
dc.b 19,178,245,30,33,212,77,55,173,177,171,114,204,73,140,128,108,5,31,199,230,22,205,16,241,0,207,176,205,105,64,94,
dc.b 9,198,213,117,212,205,216,203,69,72,253,17,9,138,236,25,52,5,192,236,63,200,241,220,92,30,66,26,152,129,62,236,
dc.b 72,101,105,68,90,236,7,54,167,155,211,20,18,240,107,92,71,94,40,46,169,169,246,244,99,3,84,180,93,82,37,32,
dc.b 169,146,180,213,0,148,29,98,208,49,120,223,108,7,77,74,43,42,136,77,7,127,140,46,216,186,203,208,210,140,19,83,
dc.b 19,102,133,115,188,204,231,240,196,75,118,45,9,93,36,108,88,3,90,72,157,69,70,230,154,146,129,171,118,49,180,222,
dc.b 98,103,69,152,88,96,71,76,229,177,30,101,112,47,40,210,174,190,134,138,121,171,134,42,85,73,145,47,14,66,168,166,
dc.b 220,86,108,117,33,233,248,110,111,46,241,49,46,124,23,24,113,159,235,53,83,176,186,99,86,48,37,138,52,115,177,3,
dc.b 213,157,142,254,214,210,128,54,240,227,135,90,214,178,142,105,80,31,117,238,75,172,93,77,12,93,55,215,142,148,206,236,
dc.b 100,124,222,239,91,243,126,94,191,191,238,254,223,245,184,116,252,81,168,101,78,218,179,121,93,191,223,111,44,248,60,78,
dc.b 63,51,133,203,232,251,31,215,255,95,71,212,231,250,223,123,165,200,225,238,107,247,84,19,10,228,100,11,236,26,122,134,
dc.b 203,12,8,243,17,230,148,15,193,186,161,163,153,119,153,170,245,244,213,237,233,26,45,47,250,223,147,219,246,255,95,199,
dc.b 251,127,63,183,248,63,39,251,124,87,184,55,6,160,146,80,152,57,98,162,194,191,117,186,170,222,218,86,112,68,0,81,
dc.b 244,119,119,83,68,199,102,11,226,166,242,9,162,26,201,21,72,208,218,90,116,116,162,30,194,80,182,59,170,119,46,69,
dc.b 241,243,204,214,13,14,167,169,146,252,67,44,197,184,253,254,255,91,193,125,126,251,59,66,89,2,185,175,85,61,69,97,
dc.b 192,225,219,112,56,190,103,67,161,204,224,216,11,250,245,100,243,25,245,102,208,184,122,89,88,248,70,85,93,95,120,76,
dc.b 181,23,237,93,59,201,203,39,14,102,190,133,28,163,0,202,71,49,130,130,146,195,74,24,35,31,52,151,106,80,29,217,
dc.b 14,221,94,223,187,208,40,188,165,244,20,117,229,76,253,197,228,125,78,135,63,157,231,122,62,175,165,233,122,124,254,70,
dc.b 240,138,208,178,46,155,212,149,8,108,134,9,204,17,146,114,157,229,230,104,200,69,224,129,127,112,164,191,153,209,153,73,
dc.b 34,89,70,212,145,12,131,70,1,131,118,130,33,194,9,221,130,70,75,54,147,166,23,244,34,76,53,69,117,109,53,37,
dc.b 51,97,69,69,76,125,23,240,93,147,8,29,36,205,114,147,85,241,226,18,231,179,194,175,160,224,197,231,174,8,240,55,
dc.b 36,33,101,1,35,178,234,234,237,69,126,25,66,151,11,51,142,198,166,67,12,7,141,25,214,142,41,172,120,28,110,80,
dc.b 127,71,133,189,25,119,27,10,49,147,203,4,39,65,193,39,60,222,25,127,126,236,198,240,101,86,76,180,51,68,157,61,
dc.b 29,34,148,98,150,36,193,236,8,82,14,200,118,4,214,76,210,118,196,73,43,167,152,171,22,61,25,30,206,83,87,238,
dc.b 9,103,187,138,250,186,253,222,251,202,227,242,184,251,202,250,225,14,146,122,108,162,84,72,243,249,200,196,175,172,98,137,
dc.b 152,0,118,39,186,101,20,68,200,167,130,81,183,209,230,102,98,61,197,193,24,21,5,138,64,228,212,34,63,110,172,133,
dc.b 192,5,73,227,210,230,197,17,176,112,132,162,195,169,106,171,236,237,184,54,53,52,141,65,197,202,197,154,200,131,20,214,
dc.b 145,84,181,200,88,7,151,212,205,120,123,170,244,205,204,201,236,194,131,43,94,91,110,11,204,100,66,4,69,231,216,83,
dc.b 10,202,164,238,74,234,35,37,250,234,132,168,200,8,48,140,201,37,45,231,88,208,84,89,219,91,112,108,170,232,74,15,
dc.b 57,30,6,86,79,179,41,109,194,146,183,90,16,234,211,68,47,252,129,3,127,0,131,11,225,52,230,100,103,25,8,136,
dc.b 38,120,233,153,22,123,240,156,73,251,25,234,90,170,202,234,176,177,0,164,32,192,138,10,118,218,121,139,42,32,149,163,
dc.b 34,86,224,201,16,70,93,157,18,45,231,166,73,119,33,133,84,168,130,202,157,244,92,108,121,143,142,241,25,126,52,202,
dc.b 21,97,214,6,32,144,71,125,225,187,195,119,160,12,88,92,45,238,12,4,147,130,96,67,90,34,42,173,72,11,52,142,
dc.b 35,58,202,132,208,226,197,113,69,210,24,125,162,199,32,58,98,93,1,184,21,54,32,246,48,71,212,151,38,132,15,199,
dc.b 36,250,96,215,56,131,253,130,84,147,56,134,220,194,120,150,120,42,45,8,70,128,130,166,141,0,161,130,20,125,131,92,
dc.b 100,186,50,18,210,208,205,169,73,86,40,224,158,7,215,36,5,145,198,216,163,139,97,243,245,169,225,242,98,184,79,160,
dc.b 215,16,163,32,100,222,1,63,123,157,139,139,194,143,56,118,246,4,117,73,143,248,202,39,62,50,55,19,82,119,118,85,
dc.b 245,67,18,232,142,129,68,24,246,54,231,162,218,233,42,185,5,185,66,136,131,223,215,38,101,200,69,17,76,202,126,77,
dc.b 77,132,69,134,95,44,43,174,245,215,139,193,113,224,189,116,10,41,40,226,29,132,112,124,156,36,187,158,244,87,19,79,
dc.b 138,176,248,3,158,32,6,5,116,84,200,51,72,59,28,82,103,137,81,244,68,4,67,163,93,44,172,90,10,51,120,37,
dc.b 143,54,148,255,228,146,78,176,82,38,252,157,78,127,195,37,174,51,188,208,211,114,243,40,64,192,101,9,77,56,213,20,
dc.b 167,40,173,63,86,77,246,165,163,106,180,100,151,23,243,244,79,149,232,145,255,10,180,208,145,50,76,46,74,51,174,141,
dc.b 16,118,68,243,4,112,60,3,221,235,148,19,174,1,72,79,94,140,187,215,248,88,175,51,180,201,149,199,250,133,198,129,
dc.b 142,248,232,5,81,158,65,219,234,58,54,195,189,241,182,188,4,22,58,66,26,42,37,73,71,84,142,212,192,48,49,38,
dc.b 80,162,50,101,9,81,38,28,14,213,68,63,167,110,176,198,74,1,123,39,16,164,45,10,69,196,69,60,128,147,127,165,
dc.b 84,189,7,151,103,227,122,49,144,93,154,38,113,141,135,10,145,113,72,202,153,132,167,44,194,90,213,1,145,81,231,42,
dc.b 57,9,148,59,121,34,15,102,83,211,233,86,74,34,60,62,38,78,86,86,74,71,105,2,130,228,139,193,0,180,212,97,
dc.b 95,102,148,181,121,198,81,214,249,155,89,76,133,199,73,140,8,167,231,219,28,180,94,1,104,19,55,60,108,90,142,87,
dc.b 67,97,217,228,40,182,118,47,249,229,100,228,227,98,98,138,189,88,87,190,63,15,138,251,2,244,245,247,45,234,58,89,
dc.b 24,161,108,164,163,38,174,9,178,237,17,216,20,10,20,208,217,42,230,174,192,252,25,62,132,238,67,76,249,171,234,190,
dc.b 182,172,149,66,83,21,160,55,245,4,186,160,115,59,252,123,251,223,7,111,185,219,26,150,174,59,253,235,123,126,209,21,
dc.b 158,222,227,233,239,95,100,16,100,144,54,35,35,225,147,8,242,249,48,131,36,196,173,1,150,160,170,6,74,59,180,162,
dc.b 76,74,47,208,10,174,104,121,60,136,59,29,89,80,73,77,106,196,37,164,248,133,177,160,149,74,222,120,174,67,226,183,
dc.b 18,7,123,93,208,8,217,36,224,56,7,40,113,206,208,81,192,225,12,210,69,176,37,128,213,102,201,179,148,101,38,52,
dc.b 247,74,119,65,62,146,213,197,69,80,134,84,208,28,164,160,31,49,41,141,85,38,118,232,230,163,73,7,138,230,228,132,
dc.b 153,140,84,233,137,83,169,229,105,154,73,145,184,185,82,84,157,201,51,141,42,104,153,234,2,87,81,166,36,54,72,48,
dc.b 167,148,8,184,236,31,54,114,146,168,222,149,84,213,35,23,137,162,99,109,6,166,194,131,43,93,116,166,94,4,5,29,
dc.b 142,131,58,132,216,116,157,150,133,21,216,206,158,37,177,148,16,213,19,176,143,220,37,17,69,52,127,134,110,82,235,58,
dc.b 209,99,44,193,57,40,139,177,188,156,162,57,145,198,163,99,83,95,92,78,88,200,42,234,91,204,43,220,44,92,55,121,
dc.b 120,175,52,50,179,225,64,141,45,28,39,18,205,185,74,216,12,114,43,154,80,35,252,28,244,249,78,110,144,11,163,46,
dc.b 7,3,203,6,75,85,108,177,217,146,208,213,35,53,80,206,154,182,141,203,25,232,218,18,215,151,80,241,95,204,174,33,
dc.b 22,227,104,93,125,57,61,239,217,223,197,198,209,185,235,225,191,200,131,19,77,100,125,121,243,225,244,22,187,166,142,28,
dc.b 90,180,140,179,49,250,170,61,237,91,54,140,26,90,211,173,71,69,5,155,250,216,52,212,53,156,191,67,237,113,120,244,
dc.b 208,84,40,102,162,107,112,26,150,80,195,54,78,159,191,115,45,151,238,220,219,255,235,245,245,110,157,223,229,193,204,157,
dc.b 242,202,98,31,248,221,98,67,81,111,134,218,91,97,238,83,126,111,155,53,11,70,10,185,249,99,33,24,211,121,17,30,
dc.b 254,122,90,165,212,237,247,219,153,189,94,31,153,99,60,171,208,174,157,81,23,127,62,165,123,214,189,25,165,94,197,93,
dc.b 21,183,35,165,187,151,213,169,224,206,187,236,254,175,221,254,191,131,232,239,254,27,201,152,130,48,223,43,141,199,175,5,
dc.b 218,55,105,167,27,55,185,220,253,63,177,229,223,197,157,81,86,179,87,48,125,141,167,174,166,83,77,71,81,184,204,135,
dc.b 27,85,116,12,28,245,144,8,253,145,116,245,165,214,238,55,38,225,126,53,98,137,247,13,109,24,187,239,123,157,126,255,
dc.b 130,242,230,238,93,68,12,232,75,152,89,116,185,115,77,182,52,84,92,59,218,140,177,70,75,216,206,179,166,102,105,237,
dc.b 119,213,219,254,70,226,174,126,106,166,106,2,216,186,11,25,215,207,109,62,208,111,188,182,161,105,192,230,57,18,28,246,
dc.b 167,106,28,80,76,190,131,19,59,197,142,28,127,201,125,157,219,129,181,15,86,243,195,148,251,27,38,14,178,146,115,30,
dc.b 55,139,195,51,39,7,59,228,197,218,197,139,35,73,141,147,41,102,134,11,178,74,106,242,48,206,81,173,29,135,3,129,
dc.b 85,187,230,90,138,60,147,179,242,116,245,39,39,223,135,242,218,85,87,84,54,111,188,224,86,78,152,14,102,225,248,242,
dc.b 20,66,194,183,247,123,90,82,102,118,230,74,112,54,149,163,241,114,101,110,218,157,104,154,78,226,107,42,153,215,145,19,
dc.b 23,0,14,226,205,128,127,214,197,140,141,173,101,205,246,243,221,199,158,93,59,63,48,45,172,45,113,87,229,82,47,157,
dc.b 218,41,226,89,182,236,53,227,207,237,96,100,190,211,200,188,127,45,165,115,135,5,141,115,102,245,246,51,111,244,32,233,
dc.b 221,92,223,120,113,48,160,169,156,110,210,207,137,82,209,154,201,181,145,31,248,59,158,60,103,177,38,233,232,85,46,145,
dc.b 63,200,181,226,239,202,86,221,102,202,197,123,16,37,231,88,80,76,180,222,50,83,58,97,245,35,85,92,176,143,79,15,
dc.b 67,195,225,119,176,255,185,223,240,96,103,228,236,182,169,223,111,233,220,80,109,177,154,41,7,91,239,159,173,212,254,24,
dc.b 48,85,55,95,44,85,35,91,254,54,242,178,110,25,66,81,108,235,191,203,134,43,228,174,105,72,196,74,164,40,35,121,
dc.b 166,229,15,183,194,169,91,180,46,183,40,37,195,252,255,47,105,214,110,146,134,204,199,54,41,217,201,43,87,11,146,25,
dc.b 196,0,73,5,44,124,250,44,237,118,250,134,103,99,53,74,184,17,204,253,165,245,118,72,88,128,82,80,207,249,147,211,
dc.b 123,46,23,155,201,173,113,73,66,226,123,95,59,12,162,27,164,15,221,52,155,186,89,218,171,1,110,133,230,119,143,175,
dc.b 214,233,253,23,119,152,218,89,239,35,183,169,179,181,173,107,39,55,46,56,176,88,111,217,211,134,174,118,101,122,205,0,
dc.b 56,222,166,220,180,213,37,77,75,133,187,115,84,75,164,105,95,226,95,253,58,43,102,156,56,159,170,176,169,20,108,172,
dc.b 171,216,199,41,64,9,58,240,100,235,237,174,211,212,158,19,98,149,62,202,194,193,124,255,35,55,96,156,121,178,214,160,
dc.b 57,101,172,247,19,198,13,122,212,16,35,39,213,236,78,185,98,182,21,213,215,137,224,167,17,46,193,112,182,33,89,192,
dc.b 174,173,174,153,143,48,0,65,212,92,222,46,203,73,218,158,47,51,153,201,180,157,143,163,164,189,100,1,144,217,68,156,
dc.b 205,73,137,27,122,184,215,215,120,186,2,149,27,121,245,172,150,201,107,90,175,77,231,103,185,213,235,165,51,4,251,50,
dc.b 18,168,209,84,170,159,113,56,247,23,59,71,87,37,230,166,126,188,226,169,170,238,39,39,125,188,104,70,78,160,4,107,
dc.b 13,49,109,23,210,216,57,169,164,159,142,109,72,152,10,234,0,201,245,98,37,10,183,27,35,11,56,80,66,218,28,210,
dc.b 167,153,172,9,203,236,192,207,194,199,193,185,183,236,93,248,123,215,153,250,170,168,217,183,107,49,171,149,157,9,74,245,
dc.b 237,103,152,183,101,57,85,79,87,191,179,166,159,100,180,214,133,74,218,170,133,162,249,122,17,135,67,97,246,62,38,97,
dc.b 169,124,223,89,30,94,122,150,134,174,210,200,106,15,150,143,157,125,150,239,3,19,31,20,149,84,214,114,30,126,66,82,
dc.b 255,207,180,226,236,234,20,249,139,215,160,247,137,121,147,121,220,237,48,227,95,87,186,223,90,240,107,27,168,135,13,222,
dc.b 105,29,141,26,129,214,55,113,54,193,187,53,101,37,12,7,65,200,213,214,143,52,107,143,174,177,177,165,25,119,148,109,
dc.b 38,144,135,184,24,185,55,183,183,89,48,244,19,123,60,184,203,198,132,57,54,84,207,185,108,198,40,164,161,46,201,140,
dc.b 237,17,161,82,162,158,194,187,113,188,165,56,94,45,222,7,141,214,86,100,117,205,27,25,212,45,217,213,14,179,3,74,
dc.b 143,13,151,50,84,43,154,46,142,2,159,39,5,145,159,98,11,193,224,11,248,112,8,41,255,79,135,44,101,205,147,51,
dc.b 65,91,72,130,112,28,82,183,152,18,199,51,51,97,232,234,204,24,244,52,154,150,218,129,169,165,174,35,199,81,79,196,
dc.b 128,77,124,210,144,177,157,37,12,170,187,105,205,117,21,29,93,28,218,229,210,33,105,187,42,47,28,140,208,11,128,221,
dc.b 190,166,122,136,95,159,25,4,114,50,242,179,245,79,122,27,139,92,84,244,116,52,161,123,40,177,212,49,155,80,7,156,
dc.b 42,35,12,60,173,93,185,42,215,201,5,132,134,180,0,226,116,110,4,210,192,186,204,121,118,45,39,82,135,134,82,174,
dc.b 110,89,21,101,95,229,144,230,50,52,74,85,161,116,226,1,240,153,215,140,168,86,107,154,77,235,43,148,197,33,59,0,
dc.b 106,36,72,9,157,6,43,81,209,24,2,201,179,23,52,26,87,7,104,115,131,55,226,26,250,231,232,76,59,24,162,16,
dc.b 232,200,105,175,17,73,8,0,234,140,45,82,183,185,16,57,134,22,192,240,64,172,152,189,136,8,79,102,102,76,53,166,
dc.b 147,101,68,4,176,27,54,154,55,37,103,191,69,223,100,42,23,58,148,217,28,184,234,216,20,231,0,191,37,57,168,202,
dc.b 130,137,108,83,103,114,136,178,37,246,209,159,44,146,127,21,78,201,188,63,102,38,164,69,43,90,81,51,74,83,122,76,
dc.b 44,204,221,40,72,169,144,142,222,128,114,212,168,197,97,74,127,194,138,64,155,96,64,157,151,17,56,167,10,78,10,137,
dc.b 180,234,226,8,74,173,176,52,232,104,234,58,1,103,141,12,25,24,141,121,32,78,117,26,165,46,154,65,99,217,65,136,
dc.b 136,109,106,116,115,178,11,173,68,209,205,207,125,9,17,4,2,180,200,137,146,165,147,51,59,81,45,84,72,44,52,12,
dc.b 45,27,81,246,141,10,203,136,31,211,106,212,144,192,180,95,27,95,51,128,211,251,18,201,89,128,128,197,101,206,105,20,
dc.b 42,8,85,13,145,182,85,160,202,133,107,85,144,159,216,50,88,182,81,50,157,80,87,162,50,221,21,185,145,64,231,25,
dc.b 228,182,32,156,78,41,218,80,80,114,233,184,148,14,20,29,120,217,40,70,112,209,113,238,166,185,87,160,64,217,146,143,
dc.b 115,98,184,48,93,124,160,4,68,196,181,139,144,191,164,100,121,31,217,10,97,29,112,4,108,80,19,172,77,4,3,92,
dc.b 57,171,205,114,242,4,251,67,81,120,86,178,38,202,81,12,16,96,131,16,158,190,19,103,77,93,39,66,210,80,76,77,
dc.b 16,166,112,56,42,26,81,12,231,242,25,25,95,62,210,109,115,41,160,80,81,80,116,27,150,97,17,7,156,213,212,138,
dc.b 110,227,138,242,233,79,226,1,250,249,229,242,66,97,59,36,53,137,79,195,82,102,0,72,162,183,70,163,247,186,26,58,
dc.b 201,172,192,165,229,199,151,216,230,22,36,222,205,13,52,160,16,196,161,244,161,134,86,77,20,154,210,36,5,203,109,43,
dc.b 10,251,77,5,211,85,12,37,33,9,186,131,251,85,6,38,131,122,3,186,212,167,160,233,115,161,130,42,118,220,152,187,
dc.b 7,102,4,29,29,55,184,230,211,121,70,190,98,197,218,55,12,35,89,182,139,216,59,59,96,4,161,56,36,160,39,230,
dc.b 23,27,235,74,207,72,94,148,7,103,20,148,250,81,45,70,152,198,35,172,131,134,169,66,54,204,38,159,113,124,240,86,
dc.b 141,144,118,187,104,12,88,109,17,65,214,35,95,192,26,20,64,137,247,7,222,240,245,70,89,9,237,93,170,187,218,165,
dc.b 36,149,144,128,36,32,1,86,36,170,137,12,204,51,49,153,153,158,246,102,123,51,222,221,221,205,246,243,155,205,221,230,
dc.b 252,27,155,241,111,215,188,231,189,236,223,61,153,128,0,0,1,5,82,169,73,69,152,11,24,41,89,42,42,165,85,119,
dc.b 243,247,251,254,220,230,199,191,190,254,31,189,172,146,70,146,88,182,89,91,17,25,133,88,225,18,163,183,75,152,161,12,
dc.b 6,66,18,40,198,161,161,41,220,92,78,52,140,156,199,1,226,207,4,252,37,237,250,64,184,11,18,144,144,150,45,70,
dc.b 241,97,17,57,194,35,246,246,210,222,216,42,249,1,246,64,128,63,55,154,233,246,34,88,87,19,4,54,214,236,173,161,
dc.b 187,185,43,189,220,54,50,26,33,106,22,0,28,162,66,187,240,90,204,224,24,68,14,228,221,164,75,211,141,88,153,95,
dc.b 42,200,138,106,59,59,9,233,194,151,239,72,148,176,168,227,208,21,192,16,161,7,38,181,192,162,233,184,37,119,133,33,
dc.b 90,43,220,186,32,33,238,112,141,147,113,128,206,196,136,146,94,141,139,40,20,167,231,231,112,173,10,199,20,17,165,68,
dc.b 196,9,255,244,148,91,35,111,112,48,201,96,203,155,203,219,155,84,129,48,1,30,174,111,45,236,189,88,100,55,82,46,
dc.b 149,99,218,242,86,243,9,243,215,140,22,243,6,254,107,129,136,57,163,131,188,163,132,108,159,215,127,54,178,99,5,169,
dc.b 105,199,210,74,201,59,98,40,51,27,67,127,94,26,1,164,188,35,68,76,21,206,35,91,161,21,178,142,53,142,73,64,
dc.b 67,137,17,86,150,74,56,74,112,224,17,93,156,97,12,219,146,144,139,137,140,134,118,41,11,97,89,87,206,118,148,151,
dc.b 243,1,91,0,2,208,166,224,77,185,30,76,147,171,228,124,22,10,137,251,190,17,40,55,182,246,247,190,175,64,166,38,
dc.b 37,208,201,142,71,206,88,252,158,112,57,216,34,20,236,12,88,7,27,28,11,214,70,129,31,132,79,137,37,98,145,83,
dc.b 228,39,211,167,242,216,172,176,105,190,80,183,216,15,142,226,177,19,59,250,28,249,182,140,94,254,249,249,124,105,203,206,
dc.b 144,122,164,79,241,224,105,59,88,122,248,30,222,13,106,100,114,210,81,241,113,106,193,68,196,200,136,44,128,132,69,102,
dc.b 0,165,84,6,19,29,14,137,224,75,162,25,29,246,24,2,240,69,121,28,75,1,148,137,194,221,233,188,96,26,162,33,
dc.b 211,5,3,250,97,16,11,192,73,42,3,138,56,114,18,94,210,48,146,166,140,200,228,206,95,100,107,214,233,66,212,27,
dc.b 23,93,156,11,102,17,13,114,156,0,93,152,19,114,16,240,36,76,5,157,149,160,100,54,77,74,17,139,68,246,201,20,
dc.b 132,23,223,136,208,51,251,8,9,224,60,182,55,152,200,144,216,38,205,82,29,148,217,58,73,172,188,196,245,169,43,88,
dc.b 104,164,139,6,39,158,65,212,7,244,44,70,114,236,122,61,42,64,7,0,224,95,182,252,204,164,192,141,193,80,31,249,
dc.b 217,24,75,2,111,108,136,197,130,42,116,94,24,62,56,27,99,178,89,44,124,112,101,171,148,203,228,206,236,168,116,141,
dc.b 42,136,56,53,162,160,224,162,8,142,2,238,196,231,249,180,231,4,169,251,82,74,4,80,132,248,236,252,198,221,235,96,
dc.b 151,22,215,199,223,46,226,12,249,146,149,248,142,31,229,23,162,52,85,138,112,51,35,124,105,23,59,32,65,2,133,110,
dc.b 130,61,14,30,17,23,130,197,144,82,166,241,52,167,73,134,118,150,106,248,38,26,74,248,151,39,64,192,151,123,34,116,
dc.b 84,123,121,209,37,230,180,181,187,67,99,78,29,205,164,64,188,12,34,26,234,39,216,202,180,144,142,16,40,101,46,18,
dc.b 59,5,2,61,60,182,60,229,216,204,229,138,36,136,58,9,175,203,209,44,78,45,26,57,24,242,1,7,187,113,100,163,
dc.b 194,9,42,81,72,67,0,164,70,217,13,242,245,67,185,100,35,152,145,132,33,213,45,77,6,94,250,43,29,24,244,225,
dc.b 91,82,118,71,12,124,132,126,68,249,83,130,166,248,234,124,68,12,4,111,122,92,26,28,227,36,198,151,138,196,204,182,
dc.b 213,13,73,169,149,8,6,158,236,123,16,226,96,92,68,231,137,2,0,243,188,140,82,51,236,70,143,10,76,96,158,249,
dc.b 138,139,75,183,224,199,217,1,217,160,26,76,5,54,185,104,117,212,18,146,214,65,177,250,142,122,5,152,132,42,217,36,
dc.b 108,139,180,225,30,197,171,253,60,104,150,72,86,233,213,9,66,137,148,132,185,86,121,10,175,166,19,50,70,153,104,23,
dc.b 31,124,120,59,243,45,191,78,137,132,45,93,227,37,126,252,205,30,216,68,233,180,100,161,239,106,187,177,4,202,18,225,
dc.b 223,46,42,240,242,132,90,254,68,198,133,156,216,194,80,245,243,31,118,36,190,206,56,52,114,198,151,62,93,5,111,146,
dc.b 65,34,213,73,64,164,54,231,150,200,139,128,36,179,207,167,245,41,75,225,38,130,144,65,196,241,18,79,233,136,90,65,
dc.b 106,162,10,137,128,81,98,51,4,232,182,40,47,28,95,50,37,151,13,233,11,54,78,254,165,96,233,197,134,232,202,252,
dc.b 94,86,150,10,75,161,130,73,252,28,174,45,160,93,183,11,13,1,250,67,154,67,78,138,166,91,113,153,209,169,241,224,
dc.b 50,117,124,48,0,148,102,120,116,133,156,126,74,85,201,236,75,129,77,36,156,195,45,35,132,142,90,147,236,36,3,196,
dc.b 94,155,11,216,153,14,222,50,235,173,10,128,160,59,245,46,26,19,168,4,7,233,2,238,6,7,22,6,37,64,3,114,
dc.b 210,81,53,26,228,29,130,201,48,117,6,72,146,18,142,41,99,28,232,195,114,255,213,104,140,172,252,94,53,25,196,198,
dc.b 66,6,50,136,200,49,32,46,87,77,249,108,39,22,218,41,105,20,24,54,152,220,23,178,16,139,230,49,194,101,140,161,
dc.b 252,105,12,191,12,113,94,199,99,148,126,41,37,12,102,35,110,93,176,73,103,18,43,183,38,69,169,67,146,146,85,23,
dc.b 134,101,202,9,164,179,81,63,71,10,148,53,132,147,9,57,101,124,164,52,160,67,27,211,137,132,236,246,46,247,16,145,
dc.b 178,137,2,177,12,127,202,0,196,25,223,96,36,68,136,141,156,243,126,100,89,169,37,190,34,112,69,238,57,153,250,2,
dc.b 32,68,212,1,111,224,140,217,82,157,76,156,106,129,72,79,163,219,157,193,168,199,243,147,134,46,54,71,22,90,177,206,
dc.b 88,244,111,146,141,95,72,239,53,196,8,38,52,215,148,250,17,58,130,235,13,60,176,193,202,255,5,215,234,153,174,75,
dc.b 113,227,60,39,23,135,112,167,93,115,182,67,207,29,105,7,79,150,53,200,191,180,188,59,44,208,252,163,36,11,43,25,
dc.b 136,249,146,236,226,225,26,109,96,224,159,234,22,154,189,87,224,244,152,206,185,196,22,147,139,66,75,217,35,3,240,89,
dc.b 24,189,2,143,238,92,94,175,18,3,7,30,220,17,70,9,21,128,70,158,98,32,3,124,27,208,128,32,146,38,8,116,
dc.b 212,127,179,250,65,117,60,72,205,168,48,59,168,200,247,13,211,139,87,215,80,74,45,180,159,159,111,226,58,73,106,215,
dc.b 108,131,208,135,137,104,213,35,170,153,11,205,36,39,59,72,170,164,59,221,197,179,70,20,25,79,30,132,96,208,167,178,
dc.b 89,105,163,0,179,97,64,188,16,104,32,57,218,6,46,128,74,64,36,14,201,14,164,60,73,20,131,83,145,231,47,228,
dc.b 248,171,33,202,128,216,132,145,137,1,57,201,32,91,144,162,153,90,208,228,8,62,73,33,188,75,217,174,67,226,55,22,
dc.b 9,45,49,13,4,136,161,133,71,19,37,88,42,251,55,236,67,71,251,211,138,217,218,91,185,58,124,231,26,225,122,197,
dc.b 38,50,151,236,137,26,107,232,184,70,75,140,136,48,72,198,184,104,39,37,215,74,92,129,110,195,229,29,161,2,221,178,
dc.b 238,212,109,96,128,249,45,128,147,104,165,205,72,235,2,62,213,33,68,48,208,203,2,228,169,113,17,50,71,28,184,129,
dc.b 7,100,13,91,29,184,188,73,70,196,140,240,115,230,224,96,24,30,73,113,227,35,178,184,50,159,210,14,129,95,69,234,
dc.b 3,209,83,7,175,137,61,179,227,69,159,249,29,33,118,102,100,179,251,101,254,82,69,152,97,165,166,107,33,219,196,56,
dc.b 187,93,157,71,108,178,218,64,202,48,207,56,204,175,24,72,187,34,34,183,165,180,204,78,158,163,167,231,229,145,186,72,
dc.b 222,26,144,73,154,171,162,68,74,245,32,131,47,210,38,101,71,52,24,125,49,202,218,59,110,36,75,9,117,4,190,218,
dc.b 18,144,237,205,102,172,14,4,92,24,64,22,9,198,47,195,9,101,145,5,15,206,46,17,207,16,57,249,48,84,250,90,
dc.b 1,120,53,250,224,36,68,41,131,102,35,139,182,87,16,139,233,9,106,200,64,67,230,209,106,34,96,149,150,24,106,184,
dc.b 44,60,125,11,33,43,219,20,242,240,109,29,244,189,237,27,218,43,47,191,192,44,24,144,88,218,177,90,65,199,223,178,
dc.b 234,16,10,90,39,30,217,35,58,91,222,17,144,243,172,185,73,50,162,100,37,18,58,190,60,177,175,40,145,33,120,77,
dc.b 30,0,151,237,2,35,84,255,4,24,51,28,144,36,150,17,252,118,75,139,45,148,71,242,209,223,10,199,57,99,2,120,
dc.b 227,212,10,191,0,226,12,149,242,8,247,83,111,140,131,202,195,81,223,38,10,199,196,178,23,221,84,242,68,55,184,182,
dc.b 27,100,35,219,249,105,4,185,206,83,111,208,13,44,62,254,200,109,52,104,32,217,8,170,138,130,133,100,60,187,242,164,
dc.b 71,24,1,247,172,193,204,73,210,83,254,28,38,169,134,69,79,173,204,229,106,30,44,239,21,116,76,233,123,19,250,178,
dc.b 84,43,34,63,160,177,80,252,112,39,190,180,136,57,125,228,12,24,111,80,67,172,137,24,228,222,98,200,102,53,241,199,
dc.b 191,192,50,19,37,33,197,81,223,150,42,19,41,124,35,250,144,139,196,73,54,84,139,99,75,140,151,171,191,231,17,34,
dc.b 55,77,56,232,193,19,214,0,186,178,241,253,165,118,202,62,101,229,65,84,76,135,223,127,105,23,165,159,244,3,46,34,
dc.b 15,162,94,225,9,8,124,219,167,16,241,133,250,30,178,46,129,196,150,242,72,166,56,184,164,197,93,72,184,110,7,135,
dc.b 138,135,195,84,176,226,25,185,98,198,99,103,7,0,203,18,134,179,19,73,76,98,162,180,89,114,25,12,160,15,32,25,
dc.b 45,204,254,199,104,139,221,18,99,116,56,235,82,217,171,114,211,93,124,198,185,13,133,170,197,82,219,236,134,190,100,74,
dc.b 187,99,177,132,178,143,45,173,255,202,142,67,63,104,117,101,215,247,230,197,204,161,6,249,76,71,23,94,109,214,56,121,
dc.b 146,85,78,47,233,178,97,157,125,214,19,34,155,75,149,122,216,209,147,21,12,138,189,81,249,99,194,201,10,34,176,97,
dc.b 17,223,122,84,68,98,168,0,15,136,196,60,37,145,3,207,149,84,42,175,197,94,20,58,113,16,88,226,248,108,162,123,
dc.b 228,64,48,177,115,95,243,161,5,244,141,108,88,187,30,76,216,119,180,223,52,6,42,238,105,197,224,123,86,115,47,5,
dc.b 18,173,197,97,134,5,113,226,34,98,59,196,8,230,166,218,90,197,15,202,80,33,197,202,179,34,118,10,193,107,21,187,
dc.b 88,165,44,156,127,86,1,73,233,237,129,43,82,42,214,98,224,47,145,38,88,249,197,252,46,45,52,95,184,136,48,40,
dc.b 253,207,137,84,153,0,203,165,85,142,203,242,245,213,226,201,14,210,124,227,136,132,171,215,14,132,10,232,197,93,10,178,
dc.b 167,69,94,109,145,64,56,110,85,251,241,246,110,241,104,24,156,123,89,57,65,157,136,10,208,235,226,219,248,135,230,94,
dc.b 75,177,226,142,11,96,40,81,234,205,105,218,189,105,224,46,121,163,175,213,19,82,126,61,248,182,79,255,174,124,215,240,
dc.b 213,179,160,82,37,173,15,139,185,234,165,91,57,249,147,105,167,152,190,100,62,11,96,136,105,40,197,94,99,164,97,22,
dc.b 46,131,163,83,163,129,170,109,249,74,134,171,27,49,242,130,160,7,206,35,71,73,142,178,237,32,121,226,132,46,195,73,
dc.b 72,120,21,153,1,220,0,130,136,222,25,240,194,188,192,182,244,219,218,19,223,150,247,226,104,248,221,162,248,197,85,228,
dc.b 89,11,213,41,156,148,202,201,233,51,18,49,46,160,67,67,120,135,68,32,159,150,179,193,224,236,137,226,107,107,75,155,
dc.b 140,72,114,128,3,19,135,144,100,40,222,1,109,103,255,211,203,235,2,248,45,124,183,112,133,5,28,103,89,45,4,166,
dc.b 101,230,21,231,147,187,77,217,238,116,249,245,21,253,206,199,94,166,162,146,142,163,179,85,98,238,74,53,228,92,150,154,
dc.b 103,87,172,158,154,210,105,194,49,205,79,178,33,137,116,58,60,238,99,61,165,207,228,99,73,67,105,76,238,143,67,143,
dc.b 143,208,233,243,167,116,241,199,11,137,137,117,99,93,224,175,229,239,183,187,173,255,11,137,203,230,243,57,181,150,53,253,
dc.b 251,92,8,3,8,231,112,228,22,150,50,36,213,105,15,37,36,118,119,6,139,206,196,65,177,189,222,34,34,4,196,128,
dc.b 141,33,234,113,55,220,94,63,7,115,253,183,156,62,7,223,184,225,240,55,31,219,237,224,243,122,52,150,38,4,240,152,
dc.b 241,61,143,47,169,64,38,25,121,44,244,212,214,162,94,114,126,127,103,181,248,63,103,189,240,125,31,225,254,223,95,241,
dc.b 250,126,95,151,231,254,31,62,219,107,238,80,106,130,41,60,179,30,31,154,91,150,121,111,198,234,195,23,156,23,112,106,
dc.b 250,119,164,35,47,131,183,95,225,179,242,88,126,31,133,117,69,39,87,161,208,230,243,169,123,29,46,95,51,149,197,228,
dc.b 115,232,185,91,221,207,219,183,251,63,159,244,254,159,203,249,255,239,245,251,54,251,141,214,239,131,201,231,209,117,196,38,
dc.b 186,153,62,190,4,31,34,128,224,87,185,0,88,152,83,195,106,53,186,253,159,201,254,63,239,255,63,95,250,253,127,95,
dc.b 213,253,193,43,135,203,241,252,223,79,205,242,124,30,230,194,122,110,108,100,72,233,136,126,5,10,145,144,15,0,73,70,
dc.b 85,44,59,18,104,52,126,190,182,253,61,41,138,237,101,249,29,188,253,158,197,53,45,53,39,80,66,112,241,248,156,62,
dc.b 32,7,79,198,226,136,117,109,191,219,184,220,238,183,160,29,183,23,151,209,235,136,73,218,190,213,101,101,113,220,198,3,
dc.b 171,220,165,50,22,14,33,223,79,11,16,151,22,121,76,220,174,146,98,123,101,180,247,137,225,239,219,244,126,255,239,250,
dc.b 190,175,242,250,191,127,205,251,62,79,136,139,120,217,235,230,230,166,117,90,57,84,132,191,72,24,85,57,168,46,6,3,
dc.b 202,37,133,221,241,222,133,228,239,118,206,119,1,151,135,211,231,115,185,220,158,63,35,145,200,228,242,185,28,126,79,47,
dc.b 147,197,224,239,247,219,189,214,247,128,33,220,249,137,99,205,73,217,8,146,66,140,107,68,174,2,59,219,14,215,211,184,
dc.b 102,53,37,45,14,31,28,150,92,66,199,106,125,153,153,193,15,175,239,124,127,63,209,251,191,111,195,239,237,118,155,79,
dc.b 106,135,93,61,61,59,53,171,152,150,211,105,52,130,14,195,63,160,20,129,65,248,158,84,37,1,59,210,68,221,141,218,
dc.b 135,116,0,120,66,85,65,104,155,200,225,239,183,123,157,206,227,238,220,110,247,123,205,246,248,255,119,127,127,219,183,219,
dc.b 253,219,173,238,244,68,100,112,185,125,58,58,170,254,250,101,66,250,64,187,151,144,236,191,248,72,21,19,154,232,1,238,
dc.b 204,145,20,26,29,36,188,212,220,254,195,99,237,237,125,239,131,109,181,9,190,4,60,188,204,196,180,176,177,73,212,158,
dc.b 5,164,210,234,2,249,157,62,166,90,88,3,125,209,30,23,40,18,95,130,115,103,131,11,0,145,12,29,83,77,214,162,
dc.b 233,244,185,220,174,79,31,139,195,227,114,56,252,94,23,7,129,191,223,111,4,61,161,96,205,222,243,119,188,224,113,185,
dc.b 157,46,169,1,75,90,42,135,136,55,179,87,42,72,106,182,164,116,148,66,102,91,102,110,87,79,45,51,55,63,178,247,
dc.b 75,6,150,14,248,118,219,77,153,21,187,49,44,125,142,122,76,238,233,72,81,188,228,166,124,3,167,209,8,70,2,119,
dc.b 4,157,190,68,94,70,229,36,166,56,243,180,203,183,128,176,210,67,27,213,84,82,209,209,245,146,164,71,139,192,62,255,
dc.b 117,184,251,254,255,187,113,188,224,241,196,56,85,45,77,97,8,26,68,130,218,179,47,185,76,32,178,69,101,4,200,162,
dc.b 228,128,29,39,67,169,9,83,40,40,40,104,104,118,20,26,253,116,249,81,122,210,131,72,199,129,151,45,51,53,55,61,
dc.b 174,160,216,108,118,5,16,234,245,114,250,130,250,193,111,116,26,83,202,4,181,93,241,12,140,51,22,170,8,19,106,122,
dc.b 106,58,32,152,108,253,200,226,240,138,14,223,239,247,252,1,102,109,205,232,245,105,106,130,63,148,204,245,53,199,164,103,
dc.b 26,227,29,102,69,217,153,64,102,138,76,57,68,198,71,229,0,96,121,81,151,83,169,150,151,152,152,151,151,151,152,213,
dc.b 136,152,189,70,155,76,51,86,181,122,205,108,236,246,190,135,101,179,217,236,182,52,19,211,130,174,180,59,9,145,199,2,
dc.b 115,32,106,175,139,185,87,81,77,73,215,235,55,238,175,80,169,110,151,71,163,208,232,244,186,116,93,78,165,21,21,16,
dc.b 136,25,168,61,255,197,230,55,227,164,22,11,35,207,214,170,55,39,234,89,132,86,167,116,83,28,165,50,70,214,131,148,
dc.b 175,77,38,42,36,148,249,208,11,7,162,210,234,37,181,115,83,186,237,143,183,238,109,72,206,15,127,221,218,123,130,213,
dc.b 50,120,185,132,166,86,62,45,226,45,182,13,215,123,132,88,221,80,172,26,162,233,244,79,191,232,116,57,194,170,95,163,
dc.b 210,35,101,250,125,74,58,106,158,209,80,64,80,234,84,135,44,120,89,130,194,204,39,118,154,241,113,31,72,204,5,119,
dc.b 246,155,94,64,170,167,32,250,64,123,36,23,70,68,226,193,33,79,8,192,173,54,161,90,143,80,167,0,244,122,29,6,
dc.b 122,76,176,145,13,110,114,174,0,24,158,111,25,96,210,50,158,180,240,128,9,220,169,42,170,186,186,206,215,109,50,28,
dc.b 132,57,42,52,112,68,138,225,177,145,131,42,99,55,67,50,85,249,105,231,115,75,173,226,64,195,55,70,123,154,26,153,
dc.b 30,94,120,25,200,156,44,29,36,64,99,129,12,15,159,208,138,198,221,40,7,136,163,13,66,187,49,80,40,133,80,176,
dc.b 144,187,215,142,199,192,144,191,117,132,113,21,72,171,56,236,83,157,138,39,128,246,136,30,130,102,221,31,99,28,251,45,
dc.b 61,12,150,40,49,169,86,122,38,2,0,9,6,154,171,72,46,131,112,11,107,136,91,80,25,56,18,245,50,145,208,42,
dc.b 65,124,18,48,24,138,114,204,8,131,105,93,14,139,69,161,102,107,100,160,0,246,176,175,9,80,9,201,59,192,61,51,
dc.b 22,129,197,106,57,65,12,134,134,60,18,174,170,159,177,79,79,82,71,93,86,170,137,34,239,46,217,99,242,124,244,65,
dc.b 249,146,2,143,25,150,171,250,240,103,52,250,90,198,67,24,176,62,75,23,181,230,17,233,148,214,45,199,115,202,194,198,
dc.b 4,18,237,129,150,141,32,216,50,178,39,53,252,24,7,133,234,115,10,186,240,31,171,177,75,215,234,209,116,139,6,115,
dc.b 185,220,209,89,91,200,63,114,185,197,196,72,31,82,85,54,229,0,7,136,33,164,202,197,16,64,68,221,186,155,185,81,
dc.b 110,199,232,216,214,76,136,51,18,188,255,228,82,168,104,196,127,64,177,79,1,105,66,175,240,11,158,85,45,28,101,207,
dc.b 5,100,95,185,24,222,73,49,61,59,156,78,120,133,12,121,97,93,89,83,77,215,234,116,250,60,238,87,27,137,195,88,
dc.b 82,159,183,252,46,47,35,155,210,235,10,235,210,20,94,226,238,253,120,25,222,104,78,251,73,231,226,243,58,124,127,177,
dc.b 162,144,137,147,202,60,201,230,94,99,115,16,240,121,40,167,88,232,215,81,62,196,12,12,120,72,105,21,135,17,142,125,
dc.b 7,32,242,15,37,144,135,203,103,36,51,154,169,73,89,221,94,158,130,130,98,131,220,154,155,246,181,186,169,217,140,246,
dc.b 143,65,33,236,100,225,224,137,91,60,11,162,55,174,178,162,175,173,204,233,115,56,28,110,54,231,117,192,251,191,174,231,
dc.b 251,127,45,190,223,255,62,193,29,167,195,225,112,185,244,93,78,201,222,17,111,113,118,111,66,198,71,71,100,243,89,124,
dc.b 192,206,225,149,149,206,74,232,64,138,76,236,158,120,142,237,205,145,157,190,193,9,245,141,92,140,97,50,161,42,190,114,
dc.b 43,135,117,161,200,251,210,174,78,105,25,19,179,188,180,222,131,67,160,209,233,66,185,204,248,101,234,20,66,128,137,112,
dc.b 2,30,4,225,99,14,191,43,5,122,165,37,31,87,165,208,59,253,204,109,120,156,62,23,19,139,198,228,243,12,39,169,
dc.b 41,235,59,189,241,127,182,66,65,65,184,202,90,201,178,171,192,9,111,63,16,142,45,62,52,69,32,228,146,11,101,50,
dc.b 6,13,128,14,79,49,64,173,174,45,98,168,133,72,12,174,80,197,254,128,7,151,36,145,50,97,233,41,25,220,229,70,
dc.b 247,187,181,181,149,84,244,157,82,163,139,6,114,76,208,249,92,190,103,55,158,52,101,204,8,123,190,16,190,96,60,170,
dc.b 72,122,20,139,142,107,114,232,244,154,99,240,142,166,89,205,145,211,202,118,51,216,83,243,203,148,32,90,39,179,27,240,
dc.b 232,37,110,73,203,244,46,111,6,173,109,140,100,243,201,206,146,204,104,100,203,112,126,59,1,147,50,60,91,50,132,65,
dc.b 133,133,149,166,233,40,232,232,233,105,133,192,149,85,77,85,89,7,176,47,175,18,26,104,11,213,143,201,229,228,218,203,
dc.b 122,125,78,168,198,41,35,177,85,152,194,214,229,127,80,159,184,191,170,78,155,169,224,27,229,212,126,192,104,105,61,137,
dc.b 104,185,9,216,2,9,107,146,115,106,139,236,69,190,8,254,66,69,20,17,244,135,29,8,140,33,50,182,48,165,168,88,
dc.b 85,85,213,172,42,107,76,9,8,159,147,2,60,35,170,228,235,26,203,20,6,103,15,47,171,152,13,250,231,246,84,52,
dc.b 27,61,149,5,14,200,88,166,5,114,190,200,176,243,206,201,201,229,8,211,6,26,7,124,37,151,192,30,211,160,53,8,
dc.b 189,128,194,103,46,21,157,158,42,178,74,217,52,73,140,190,80,24,114,2,44,243,168,104,209,24,129,90,96,61,78,70,
dc.b 122,129,102,180,116,148,116,148,237,129,17,17,95,224,32,9,129,64,231,111,82,16,91,40,2,70,233,116,228,223,100,230,
dc.b 186,135,103,237,251,161,109,23,195,182,219,109,189,255,119,107,237,108,53,211,139,69,152,141,145,39,68,74,17,134,64,226,
dc.b 62,180,177,5,65,11,182,40,25,65,1,17,28,124,36,129,226,240,64,0,93,179,131,244,35,95,59,59,53,81,93,222,
dc.b 218,135,12,169,167,236,83,21,27,213,234,25,90,117,0,199,250,94,197,71,102,174,184,136,224,48,168,82,21,145,40,10,
dc.b 188,67,229,104,180,210,243,51,154,250,16,190,183,109,240,252,127,23,199,242,124,62,255,189,181,246,133,155,200,113,250,97,
dc.b 13,160,206,231,50,228,60,8,182,237,128,64,155,9,91,244,191,89,160,44,179,252,178,178,111,10,243,183,252,128,28,45,
dc.b 178,240,107,91,52,64,92,66,238,88,8,212,228,139,182,167,165,164,164,33,209,187,7,136,211,139,33,194,4,108,144,41,
dc.b 57,169,129,162,229,16,123,142,200,72,229,115,64,75,158,158,91,89,173,155,159,215,107,182,27,26,29,142,203,97,175,160,
dc.b 215,79,79,207,235,117,147,50,230,139,224,209,24,92,219,100,13,71,237,214,46,114,28,220,51,55,85,126,96,102,132,14,
dc.b 19,100,170,113,188,18,225,153,55,54,169,20,137,229,2,58,44,88,24,227,184,150,97,21,213,181,125,147,255,118,171,107,
dc.b 137,206,50,76,128,196,194,249,180,91,145,16,166,115,232,12,59,77,170,152,60,30,118,127,95,176,161,161,216,208,208,107,
dc.b 231,201,55,233,114,212,194,65,39,49,148,201,200,46,81,192,12,117,5,139,51,55,209,44,38,188,64,5,47,127,190,4,
dc.b 31,216,226,133,52,33,101,176,42,180,235,16,100,53,56,11,208,192,113,22,98,226,0,189,159,227,220,174,2,69,187,85,
dc.b 166,120,93,239,9,230,231,153,250,151,67,11,184,56,144,179,240,54,158,26,238,114,250,185,146,83,215,95,66,105,67,160,
dc.b 160,216,107,231,68,134,113,28,142,5,116,73,230,13,54,113,48,165,3,93,91,226,172,70,108,72,126,143,194,193,52,52,
dc.b 44,24,184,72,1,36,58,182,46,87,107,210,69,116,37,22,41,43,193,126,202,24,194,197,72,29,43,194,105,103,176,37,
dc.b 99,235,131,130,38,139,167,242,21,139,108,203,156,119,193,93,224,207,111,13,225,180,6,170,249,144,186,180,169,45,150,192,
dc.b 240,73,233,217,178,246,166,172,233,92,230,107,40,39,239,67,227,1,28,44,73,101,218,22,14,25,248,107,50,42,245,254,
dc.b 0,244,40,180,228,139,31,109,67,41,0,192,191,36,199,254,3,96,192,185,163,151,158,88,148,112,46,223,172,59,194,65,
dc.b 52,69,149,254,101,251,0,57,115,162,252,223,34,116,173,160,190,3,49,99,77,132,204,228,236,233,81,90,233,249,201,217,
dc.b 226,194,115,0,73,134,115,50,24,98,45,173,239,175,210,33,112,14,4,69,203,63,137,224,100,88,205,117,119,119,187,92,
dc.b 165,157,79,5,58,112,238,217,49,218,204,230,181,189,170,5,184,223,208,100,15,169,5,41,217,181,171,188,76,23,115,98,
dc.b 129,29,60,182,70,141,148,143,47,58,123,33,162,210,65,166,83,64,105,178,152,53,92,206,158,1,58,146,112,218,205,92,
dc.b 192,146,95,39,185,100,69,240,121,140,138,94,220,40,169,49,19,115,221,18,20,213,130,241,5,75,108,26,10,2,90,96,
dc.b 195,88,236,173,186,113,151,172,152,76,112,108,177,83,133,101,148,98,22,69,74,208,35,161,173,93,104,3,245,242,160,220,
dc.b 148,195,245,0,185,219,156,69,100,136,94,183,56,75,7,106,53,82,250,201,169,169,201,201,185,194,210,250,201,129,24,152,
dc.b 75,9,129,205,67,98,17,13,245,221,122,131,244,242,239,70,188,34,239,20,212,180,166,49,244,116,166,16,162,206,136,149,
dc.b 19,178,44,48,117,103,173,134,176,39,80,11,51,143,155,81,171,137,175,52,139,181,101,14,114,9,161,77,83,255,82,105,
dc.b 242,38,152,211,52,223,226,204,145,243,6,181,77,22,151,79,45,49,48,99,133,51,171,246,64,209,253,62,155,71,160,112,
dc.b 29,28,15,245,37,56,69,29,200,140,251,252,128,97,203,2,237,245,34,75,122,145,100,47,73,77,216,169,172,88,200,216,
dc.b 249,78,4,244,8,230,220,32,16,44,204,75,96,86,67,138,237,107,76,56,71,132,115,122,69,73,56,152,206,32,66,28,
dc.b 231,19,132,56,39,19,7,167,46,130,227,117,37,233,202,143,157,63,201,201,189,97,65,90,141,22,127,58,97,89,30,167,
dc.b 187,159,98,3,235,150,190,63,207,241,175,252,123,117,61,170,94,181,77,29,23,95,163,208,235,243,249,245,20,189,115,25,
dc.b 49,109,66,28,48,16,66,206,225,142,29,224,144,125,254,244,225,109,117,116,242,27,18,49,39,178,34,223,5,189,223,149,
dc.b 112,43,197,2,8,115,69,227,222,131,206,125,190,207,151,209,233,146,119,3,29,235,140,141,57,71,34,34,228,242,49,186,
dc.b 44,190,106,110,119,247,127,199,250,125,52,18,196,145,204,174,170,111,107,162,147,213,70,67,99,157,3,14,120,236,212,124,
dc.b 160,176,187,200,100,179,183,22,214,20,93,126,103,103,123,79,83,202,187,182,188,173,221,114,191,239,254,185,189,94,125,53,
dc.b 207,146,183,244,171,240,195,231,180,112,55,215,246,183,214,253,222,167,31,11,35,13,33,22,234,19,57,167,146,14,169,178,
dc.b 87,159,133,143,146,194,218,191,153,113,225,252,162,97,240,222,220,254,24,247,81,90,91,76,15,71,87,189,103,137,103,96,
dc.b 247,45,150,143,130,143,200,225,73,70,200,237,62,95,227,245,255,156,215,201,241,78,237,116,90,59,199,89,184,40,107,200,
dc.b 77,86,82,19,49,163,205,154,145,37,221,92,66,219,227,93,85,120,171,124,98,48,19,169,73,71,93,227,223,114,252,39,
dc.b 80,103,139,145,207,224,243,106,42,63,11,27,152,7,190,126,217,153,223,227,222,45,85,221,182,117,20,9,157,202,230,161,
dc.b 35,113,240,81,88,158,186,222,117,127,118,240,54,135,56,181,226,33,68,3,228,228,182,171,41,2,251,197,103,103,73,208,
dc.b 238,249,252,126,155,200,44,164,231,207,67,174,215,206,207,80,207,205,73,63,100,32,96,159,188,240,1,213,206,151,57,61,
dc.b 53,41,51,63,65,159,201,201,7,100,87,254,155,224,195,96,223,129,127,10,234,239,189,94,36,218,189,86,189,203,47,92,
dc.b 5,208,11,15,231,170,235,120,59,29,58,190,229,207,163,183,229,187,101,166,14,11,236,11,143,21,79,170,59,25,153,144,
dc.b 131,34,117,46,44,42,123,150,98,17,123,7,6,8,132,0,120,243,26,66,187,70,67,133,114,84,93,26,170,175,52,28,
dc.b 150,90,52,106,7,147,12,114,89,185,49,92,247,112,67,186,186,132,141,147,201,232,61,189,124,190,162,95,53,19,29,19,
dc.b 137,16,0,245,66,59,187,245,64,63,95,195,188,190,130,145,201,194,195,199,16,96,117,253,90,58,219,11,27,124,15,31,
dc.b 90,186,190,139,194,36,96,51,121,179,79,246,13,241,6,55,250,122,223,253,54,119,221,206,95,131,209,232,135,202,229,101,
dc.b 37,243,239,2,37,203,43,188,126,110,71,39,35,127,112,33,196,201,85,199,79,189,30,76,39,183,215,143,99,162,227,100,
dc.b 242,241,178,25,108,168,128,67,239,7,135,14,105,55,32,208,34,0,64,0,128,0,8,0,0,128,32,160,85,81,106,165,
dc.b 69,2,214,173,106,141,109,173,181,91,109,182,231,109,181,219,109,125,123,119,119,118,207,201,221,190,38,238,247,183,183,119,
dc.b 183,186,251,107,230,234,218,170,170,170,10,0,0,170,0,0,0,16,144,36,0,146,1,33,36,132,132,36,0,251,251,251,
dc.b 221,31,223,223,191,191,191,135,187,186,198,146,149,84,205,126,91,151,142,31,195,19,26,9,217,90,126,20,230,218,162,138,
dc.b 134,127,109,54,42,137,24,246,228,53,93,65,17,56,7,140,192,49,64,230,117,98,197,198,201,60,38,185,185,186,181,200,
dc.b 211,212,22,187,21,63,205,204,120,127,251,143,132,126,199,175,218,13,22,146,200,69,178,148,27,221,196,202,216,161,86,177,
dc.b 238,179,193,220,163,29,190,190,142,86,146,184,169,8,201,9,17,124,119,98,22,3,184,11,98,199,246,44,44,28,166,130,
dc.b 33,125,37,9,91,182,88,17,17,168,226,213,111,171,40,223,51,198,110,48,195,128,175,99,54,97,40,168,17,169,134,60,
dc.b 90,26,8,185,196,12,34,174,115,222,61,202,187,182,190,17,218,223,197,67,62,115,173,15,23,43,51,36,178,3,67,131,
dc.b 38,86,65,66,148,84,6,127,108,249,108,238,230,121,108,126,211,71,45,163,53,249,143,192,99,82,114,106,242,47,114,154,
dc.b 132,232,99,35,117,135,6,163,21,22,176,82,79,104,231,60,0,87,51,57,31,31,37,53,24,236,173,207,129,100,98,39,
dc.b 182,210,39,162,101,115,5,4,175,121,186,166,144,131,120,36,149,58,214,216,110,124,234,249,92,137,231,122,114,39,92,130,
dc.b 222,45,147,90,168,131,52,232,2,149,53,64,200,46,147,42,148,52,129,66,211,54,254,11,197,195,3,27,160,113,174,203,
dc.b 230,190,111,35,221,151,170,147,41,67,162,108,1,170,24,15,214,129,16,183,97,228,122,199,154,165,49,80,40,254,1,7,
dc.b 213,131,0,29,201,207,71,197,141,219,82,146,2,87,84,22,126,130,50,241,68,172,21,225,222,236,75,208,77,72,194,58,
dc.b 96,204,52,17,73,190,220,76,63,93,132,187,49,158,164,60,59,134,45,114,49,220,10,142,224,246,201,35,135,146,200,125,
dc.b 81,137,158,19,89,214,104,164,137,148,232,111,66,163,145,211,206,117,9,4,183,113,81,182,146,131,199,182,188,243,225,188,
dc.b 131,215,208,200,199,192,192,113,11,23,71,196,219,172,89,178,197,139,231,238,246,35,165,134,41,246,204,198,5,232,77,168,
dc.b 255,99,23,158,69,45,224,72,238,184,53,20,148,145,47,143,80,211,27,202,121,8,26,25,23,184,185,185,240,35,118,177,
dc.b 26,219,26,58,75,2,32,179,212,83,50,82,176,207,21,15,180,240,28,175,199,202,18,19,242,220,194,201,207,73,196,133,
dc.b 10,129,32,84,20,114,112,24,223,221,174,29,0,64,110,2,202,94,99,88,0,45,85,122,225,56,232,232,243,182,234,160,
dc.b 41,91,67,92,3,188,243,207,83,184,45,120,137,250,49,231,84,126,104,30,69,129,50,210,49,106,136,58,75,189,149,178,
dc.b 242,197,52,143,43,17,163,245,180,220,4,153,146,60,14,65,109,36,102,100,96,132,35,108,151,34,47,56,32,43,101,219,
dc.b 87,80,113,179,20,66,149,10,216,103,186,102,21,73,56,173,157,21,196,2,239,1,166,196,165,4,190,210,6,163,109,88,
dc.b 233,170,90,121,168,205,59,251,59,43,156,115,29,14,195,214,100,232,75,62,4,60,237,69,49,70,244,142,131,41,180,33,
dc.b 136,117,112,51,176,73,189,150,116,32,129,251,60,180,245,81,11,29,181,157,150,136,85,163,138,187,49,202,177,122,130,43,
dc.b 89,182,131,145,108,220,25,186,153,212,138,89,0,212,155,42,19,23,24,122,16,211,204,148,130,173,35,118,179,133,81,243,
dc.b 167,32,116,8,126,178,86,110,89,106,160,130,46,50,246,76,49,48,151,12,252,90,106,225,193,4,160,46,136,128,212,193,
dc.b 248,102,77,237,131,137,238,218,50,209,118,237,89,66,23,59,187,145,62,58,93,206,218,74,17,238,136,195,166,8,199,39,
dc.b 152,152,120,140,213,74,77,137,92,241,194,114,226,105,14,14,217,27,143,155,157,78,149,128,95,74,11,185,249,11,32,27,
dc.b 215,152,90,173,208,25,186,82,106,102,86,37,83,198,201,14,222,143,135,121,160,31,53,206,125,11,23,17,176,31,112,111,
dc.b 169,22,122,161,22,22,51,242,177,76,208,13,156,191,211,120,168,235,158,66,63,233,79,161,177,208,192,109,13,128,48,139,
dc.b 212,137,184,51,214,134,139,153,218,160,102,98,93,119,28,2,44,117,160,221,162,113,2,64,167,46,182,3,170,99,53,116,
dc.b 228,180,92,112,71,171,100,247,55,176,143,255,136,66,174,30,18,52,149,158,202,130,99,77,96,219,9,38,31,211,26,225,
dc.b 159,64,66,124,154,110,205,180,10,113,102,212,118,19,247,6,31,191,130,70,93,41,3,113,182,194,39,177,57,118,157,67,
dc.b 65,51,35,119,33,37,67,144,153,32,45,79,245,4,54,99,139,214,129,238,103,49,206,188,50,64,135,34,118,134,130,248,
dc.b 129,127,86,51,103,79,71,39,36,21,251,6,64,214,192,105,209,162,127,93,12,252,176,245,42,237,182,156,17,198,153,102,
dc.b 203,204,252,188,214,234,163,36,165,229,98,73,149,88,43,13,36,215,64,140,108,214,207,160,210,173,58,44,45,63,5,170,
dc.b 27,148,69,250,83,64,243,152,16,209,146,132,62,148,197,212,252,247,228,21,46,120,157,47,93,35,227,194,78,189,213,36,
dc.b 204,25,38,43,33,197,197,194,34,232,248,196,103,172,131,21,59,40,169,104,39,165,226,66,94,163,221,172,80,43,16,218,
dc.b 190,178,74,94,136,163,129,70,197,26,125,181,69,237,167,73,32,67,108,219,61,144,187,124,178,66,56,210,156,120,135,56,
dc.b 178,236,234,7,70,180,29,66,66,1,117,13,76,131,4,250,197,31,13,82,73,94,252,153,204,166,50,205,164,44,2,118,
dc.b 52,64,173,6,124,18,108,138,47,189,25,241,5,26,129,196,188,38,110,119,167,32,46,225,105,45,141,125,61,53,14,135,
dc.b 194,12,16,177,242,161,97,168,201,138,119,90,51,47,115,150,170,200,214,88,189,180,102,102,84,98,166,113,178,207,98,166,
dc.b 93,103,235,101,175,135,141,113,13,36,209,180,12,140,152,153,8,77,229,92,108,164,171,70,242,145,3,111,227,189,135,190,
dc.b 91,124,189,39,75,22,195,74,202,11,221,79,94,70,72,196,207,209,153,67,151,174,58,9,141,74,18,48,217,87,184,120,
dc.b 25,59,43,22,73,198,186,106,227,61,194,161,253,114,146,98,62,17,179,160,27,141,37,68,212,130,166,185,173,48,124,141,
dc.b 223,233,67,170,101,149,136,195,70,10,62,47,109,65,35,51,31,4,247,94,68,193,255,59,57,36,249,40,50,90,79,33,
dc.b 37,34,181,193,40,153,155,50,146,244,20,18,145,145,27,49,19,115,212,149,59,234,141,169,223,49,192,171,62,201,120,80,
dc.b 226,211,240,254,223,103,131,197,101,122,32,34,96,221,94,96,231,11,95,228,246,17,125,245,238,32,219,211,13,41,44,182,
dc.b 54,102,146,151,129,237,124,95,159,233,255,110,159,209,250,62,127,139,231,252,157,47,135,224,247,185,62,173,94,228,79,152,
dc.b 17,97,141,107,111,8,22,27,11,203,155,224,172,170,127,9,231,40,2,86,182,183,30,46,199,223,215,251,186,157,187,17,
dc.b 9,106,218,223,204,78,239,145,147,210,44,233,229,59,60,44,108,109,101,227,68,155,80,83,46,144,19,61,219,196,172,128,
dc.b 141,94,48,12,15,178,83,180,116,180,179,242,192,212,80,196,108,230,216,72,128,146,35,72,59,206,15,11,127,67,54,70,
dc.b 145,119,245,188,90,234,222,22,250,163,110,54,119,129,230,101,163,53,142,96,73,70,50,212,122,102,78,193,196,204,74,24,
dc.b 244,52,35,156,188,111,53,173,205,254,32,185,137,223,251,186,182,34,14,117,249,212,2,230,199,193,97,113,127,144,208,61,
dc.b 98,223,44,78,4,21,22,31,109,10,139,203,151,167,97,53,166,0,87,239,96,228,102,233,170,249,60,239,123,159,209,247,
dc.b 57,53,149,149,213,188,122,218,146,58,94,45,210,210,25,210,105,200,53,170,200,72,169,106,26,99,59,12,188,34,73,177,
dc.b 117,142,85,160,255,92,124,81,117,32,193,58,205,145,74,158,40,55,66,135,8,231,178,191,12,235,226,84,54,71,177,213,
dc.b 205,92,233,103,97,220,119,250,253,191,29,214,5,242,230,172,215,26,57,176,46,45,110,130,240,72,132,10,219,80,27,16,
dc.b 248,137,10,231,13,189,243,116,222,165,127,51,151,205,247,189,223,103,145,95,207,249,58,60,255,115,217,230,244,62,111,147,
dc.b 163,208,246,170,233,8,243,220,221,22,231,116,30,56,37,158,227,188,249,249,104,225,217,10,106,21,110,156,6,165,238,237,
dc.b 45,173,45,241,90,56,126,109,88,218,62,58,200,8,11,90,2,14,169,50,43,38,162,13,154,230,226,121,60,63,135,219,
dc.b 216,176,183,193,201,204,205,203,93,231,176,237,245,186,130,240,63,154,247,9,147,87,65,168,214,238,89,174,95,151,160,251,
dc.b 105,43,73,189,51,155,157,194,234,235,184,181,220,191,127,159,239,124,255,87,238,233,254,255,215,243,244,125,190,29,25,68,
dc.b 13,219,211,238,247,123,189,204,244,130,14,146,119,163,163,2,13,61,40,191,213,115,152,82,87,124,157,238,253,193,162,225,
dc.b 139,81,79,160,80,44,44,110,153,43,218,185,204,96,217,84,132,124,27,140,220,171,194,17,47,114,133,238,26,54,113,148,
dc.b 119,155,191,242,218,218,221,48,99,143,146,226,38,80,131,228,234,183,203,194,192,106,252,130,178,76,208,136,52,180,20,20,
dc.b 148,148,52,254,157,117,127,47,217,231,125,31,233,251,127,87,197,95,93,189,163,153,152,159,166,221,212,240,235,107,61,58,
dc.b 66,116,120,36,27,234,15,137,81,102,136,217,53,164,60,79,38,238,199,195,109,132,201,20,168,141,95,119,166,108,43,220,
dc.b 6,58,39,121,71,32,16,228,64,15,97,124,96,156,184,18,24,178,50,112,174,124,93,254,191,223,220,239,119,124,94,108,
dc.b 34,40,228,122,7,24,99,16,50,161,194,4,16,171,32,40,142,207,109,246,251,141,230,252,162,82,123,126,247,193,207,231,
dc.b 244,13,45,28,211,62,7,175,89,85,189,244,183,41,4,124,6,105,134,69,225,210,46,86,136,6,38,103,101,51,138,64,
dc.b 116,99,44,201,76,5,43,242,18,147,105,148,46,45,58,73,203,65,252,219,96,225,144,195,29,120,47,240,216,153,252,124,
dc.b 94,14,255,130,194,202,214,210,210,232,140,3,187,76,233,7,118,100,139,9,152,110,13,179,165,63,44,27,204,139,95,213,
dc.b 21,68,141,35,220,247,13,8,28,138,195,105,122,117,12,225,212,148,168,240,110,10,50,138,25,219,101,38,136,205,148,252,
dc.b 192,160,40,253,76,1,32,254,22,204,48,175,12,117,118,102,33,60,17,116,165,37,147,101,34,125,136,121,132,127,22,63,
dc.b 173,108,203,6,231,199,222,236,254,29,114,208,59,117,129,144,51,0,131,52,212,176,202,231,20,164,117,38,250,240,167,240,
dc.b 200,36,81,108,205,46,243,211,170,226,215,86,122,220,159,102,190,191,143,198,22,117,61,174,111,55,219,229,113,42,72,83,
dc.b 216,135,72,64,52,167,203,59,228,201,10,231,11,253,171,49,238,157,186,144,12,118,139,28,59,110,239,111,179,216,176,182,
dc.b 242,97,6,112,206,230,198,198,71,0,201,211,206,210,8,171,62,250,231,98,164,137,88,128,159,148,133,192,216,163,6,12,
dc.b 152,49,59,242,152,251,116,144,4,217,251,207,156,200,18,157,2,26,62,106,127,115,186,59,141,239,253,78,37,119,31,145,
dc.b 236,114,125,142,87,56,217,7,203,227,112,183,148,147,83,19,115,84,2,189,21,57,74,26,90,145,207,197,43,69,240,72,
dc.b 205,136,221,33,104,118,222,43,35,37,106,72,73,112,140,6,248,24,134,33,71,2,80,58,42,31,17,89,241,143,176,195,
dc.b 152,139,132,73,47,95,34,222,167,220,1,246,89,210,146,124,173,52,131,17,14,150,201,139,29,40,117,27,39,138,184,227,
dc.b 96,148,238,222,163,211,76,55,162,253,217,78,106,49,244,136,0,59,250,98,134,136,65,204,18,202,17,45,31,18,12,36,
dc.b 70,138,109,119,70,16,19,90,78,78,75,12,27,131,62,183,142,222,239,9,121,220,224,91,130,23,197,18,187,254,65,198,
dc.b 51,89,233,24,7,223,59,75,22,43,130,139,80,49,211,64,73,189,227,227,108,74,197,38,175,251,39,172,179,149,106,74,
dc.b 124,213,198,36,26,172,210,9,30,33,189,109,168,14,88,234,89,242,84,51,199,34,144,164,25,169,145,18,116,248,43,106,
dc.b 102,70,52,144,40,22,201,3,62,152,146,210,147,156,189,44,215,34,163,131,70,168,171,244,150,57,129,92,11,209,92,155,
dc.b 50,54,31,63,31,91,221,190,244,74,127,82,4,220,129,66,143,252,253,22,77,184,101,43,98,158,131,150,59,100,126,49,
dc.b 77,173,231,233,116,170,28,21,42,190,162,137,210,77,41,99,74,124,250,103,92,163,161,71,228,157,172,116,68,32,122,136,
dc.b 64,162,28,68,220,101,227,7,120,140,148,236,24,131,52,207,210,108,99,121,89,172,7,192,66,102,60,183,247,215,193,185,
dc.b 79,7,119,193,227,184,192,202,110,37,209,196,13,185,4,108,16,10,126,98,45,146,34,73,65,189,106,25,162,148,204,40,
dc.b 136,239,56,94,161,71,132,35,197,198,42,185,164,154,254,72,165,146,112,74,6,2,117,156,9,226,99,246,179,200,173,48,
dc.b 66,211,100,130,17,40,28,225,25,177,129,194,67,68,112,114,128,167,150,148,39,76,193,17,228,72,181,186,181,176,235,117,
dc.b 123,61,207,13,149,199,150,222,202,199,185,214,235,118,172,174,176,152,231,131,55,0,34,39,232,114,42,237,140,29,146,19,
dc.b 84,123,178,140,191,189,165,157,32,10,52,213,62,162,90,85,184,124,29,247,3,127,190,244,234,40,167,101,35,140,89,243,
dc.b 251,130,60,182,69,82,82,106,60,28,248,67,108,176,232,210,177,38,125,2,8,29,156,77,209,184,213,195,28,65,134,15,
dc.b 15,32,200,94,211,61,23,177,114,179,153,97,222,221,90,119,187,93,207,31,156,94,120,189,184,177,238,245,186,221,219,92,
dc.b 21,249,57,198,198,103,67,107,128,8,210,21,40,116,139,102,168,134,24,154,157,237,53,36,250,90,88,234,107,61,114,210,
dc.b 243,89,197,245,125,99,244,100,246,67,60,42,232,81,159,94,101,167,166,10,140,168,22,64,107,224,146,215,126,173,234,162,
dc.b 126,160,117,113,106,47,148,184,209,42,241,218,230,111,161,158,203,88,12,100,219,77,181,245,243,52,128,118,105,55,203,195,
dc.b 196,45,140,198,53,220,65,37,204,134,96,175,195,179,182,187,242,90,216,90,219,217,217,247,108,44,187,214,29,158,197,189,
dc.b 165,157,197,165,189,246,107,141,53,114,187,158,7,18,191,161,210,250,62,143,217,254,253,63,211,251,58,106,127,159,187,244,
dc.b 140,144,95,15,54,191,219,229,155,132,189,122,205,237,79,165,69,43,33,39,10,58,246,103,100,97,93,219,88,117,63,175,
dc.b 217,245,255,79,229,255,63,245,252,63,135,252,127,47,253,254,127,215,180,50,121,120,238,241,136,111,91,112,66,200,244,14,
dc.b 104,121,49,47,190,86,248,170,188,150,85,93,19,219,17,224,209,206,142,166,171,161,193,157,182,128,63,34,2,81,4,15,
dc.b 126,81,177,82,37,59,111,117,197,228,122,254,239,226,253,31,175,232,253,159,87,211,244,244,186,60,255,127,154,82,148,235,
dc.b 171,125,61,229,68,233,22,132,65,130,144,233,14,59,38,205,141,24,96,121,237,252,94,43,14,239,131,187,215,255,29,78,
dc.b 215,95,251,245,9,76,71,83,177,223,180,242,249,111,196,82,161,13,25,28,90,29,8,233,164,48,109,1,239,189,82,202,
dc.b 68,204,0,41,178,60,59,145,181,164,103,103,73,129,82,48,221,19,172,50,105,207,54,77,160,232,233,247,124,14,47,31,
dc.b 155,208,248,61,254,127,56,207,193,199,60,11,128,0,15,85,187,202,73,217,83,67,62,186,5,194,40,177,238,26,36,6,
dc.b 40,163,223,97,226,93,91,120,172,15,64,151,55,183,215,126,82,84,211,111,111,228,186,189,196,50,80,231,60,126,158,113,
dc.b 53,223,17,182,19,129,19,35,26,78,97,151,187,41,41,218,237,91,129,131,118,96,209,57,136,35,84,147,68,49,138,47,
dc.b 111,191,170,42,81,124,58,186,186,238,79,51,157,208,248,125,255,115,157,207,231,123,92,206,103,179,235,113,56,53,19,130,
dc.b 187,194,48,248,147,174,176,147,78,99,44,212,205,150,46,132,33,245,28,108,47,49,175,142,206,215,199,224,179,188,191,186,
dc.b 186,12,54,220,249,175,136,91,131,146,70,194,162,189,56,132,148,82,119,48,112,177,211,214,118,49,78,117,198,202,104,67,
dc.b 74,146,72,198,116,170,63,23,22,66,157,78,229,13,222,66,12,185,189,207,135,93,234,241,249,156,254,151,75,228,248,254,
dc.b 111,159,230,249,62,66,13,231,89,87,85,85,192,37,63,101,100,8,159,120,137,241,45,204,233,236,132,70,54,75,176,46,
dc.b 238,60,126,14,231,99,171,247,245,251,93,223,13,143,123,176,73,249,72,61,249,40,78,182,187,195,205,74,64,16,45,0,
dc.b 108,170,27,237,146,74,13,177,6,149,68,194,12,162,104,216,58,7,36,66,144,144,247,19,197,20,146,225,171,17,196,166,
dc.b 135,63,74,13,205,56,149,213,83,197,246,125,223,135,230,252,191,155,241,244,190,127,143,224,230,26,24,76,185,60,51,107,
dc.b 117,78,235,110,101,198,136,50,128,190,244,89,165,51,24,98,94,121,60,125,190,175,219,246,253,191,227,171,214,236,246,187,
dc.b 61,158,215,122,194,192,102,34,239,90,121,239,200,59,98,150,2,23,109,178,215,164,59,161,35,205,169,157,100,234,132,44,
dc.b 77,183,18,41,146,58,206,13,146,80,80,49,224,128,67,80,37,112,231,178,141,238,243,123,191,171,227,114,107,249,190,223,
dc.b 187,206,247,201,87,247,35,137,192,223,111,132,168,77,245,78,253,52,114,210,210,80,76,169,35,163,86,131,115,159,0,201,
dc.b 23,224,249,238,109,79,161,125,144,16,135,221,247,117,122,253,174,216,12,147,180,3,153,189,196,55,191,229,145,37,213,229,
dc.b 60,128,56,88,126,68,55,62,190,40,28,157,4,65,39,192,36,72,232,99,153,244,71,248,208,0,49,37,251,61,78,83,
dc.b 238,205,128,53,53,94,175,177,202,230,115,57,92,122,211,46,10,74,146,120,196,169,22,167,117,186,222,39,155,83,209,153,
dc.b 153,53,42,12,2,69,214,94,46,1,153,43,202,124,9,216,234,245,63,191,219,247,254,29,115,247,162,208,204,165,120,33,
dc.b 61,34,229,134,81,40,6,99,232,206,98,164,141,101,250,146,239,119,201,48,195,75,32,161,28,215,77,67,45,208,115,242,
dc.b 148,152,194,187,132,60,218,250,71,186,186,222,63,42,191,151,94,154,122,185,30,184,8,124,210,234,112,190,172,170,223,83,
dc.b 153,146,230,101,210,63,230,108,147,29,126,218,29,232,207,209,31,15,131,191,223,239,216,128,99,187,253,222,249,111,62,185,
dc.b 188,191,68,64,99,181,142,122,65,81,82,72,102,103,98,65,217,170,9,242,116,160,24,49,75,137,73,234,243,76,228,248,
dc.b 169,52,113,152,217,192,136,73,33,54,72,79,101,87,23,214,228,114,121,92,190,80,8,38,191,155,205,175,64,65,117,199,
dc.b 250,174,226,112,184,27,164,93,190,74,143,56,226,230,74,84,143,128,173,236,188,29,174,177,45,54,234,253,253,147,107,21,
dc.b 149,157,169,171,58,238,253,76,251,136,201,110,130,105,19,220,30,202,126,255,70,32,87,56,149,23,126,144,91,210,128,201,
dc.b 79,130,77,149,100,241,117,179,133,36,213,17,210,115,40,6,23,112,146,133,95,73,24,129,120,5,55,49,2,16,159,243,
dc.b 130,126,74,158,146,247,167,216,250,2,91,118,125,6,57,66,180,101,144,5,182,179,176,240,216,216,216,248,236,108,60,86,
dc.b 86,118,197,25,28,6,94,162,29,145,167,224,42,53,160,166,131,80,194,127,162,200,102,139,132,225,67,229,41,100,95,253,
dc.b 165,237,73,174,198,202,180,219,172,162,64,164,225,238,44,220,186,73,226,10,141,66,48,195,11,104,131,45,101,8,156,40,
dc.b 149,40,137,228,255,13,179,171,86,65,129,9,128,66,130,115,142,38,10,104,220,188,191,63,182,194,52,43,159,144,42,46,
dc.b 88,27,40,211,101,32,228,22,107,151,19,136,138,4,178,120,45,63,210,130,137,191,254,103,245,232,178,135,37,86,66,68,
dc.b 226,91,182,75,91,58,52,69,80,156,43,201,31,122,74,12,82,164,44,142,208,160,42,148,183,30,34,100,200,136,232,165,
dc.b 178,184,112,6,13,172,184,77,174,39,41,20,95,42,70,133,65,135,4,149,170,154,94,48,48,207,250,221,39,20,192,25,
dc.b 45,186,52,48,175,56,166,36,223,213,39,231,137,187,58,29,75,45,194,90,71,163,203,120,42,139,246,104,203,221,194,64,
dc.b 131,102,241,106,116,149,184,80,156,174,209,39,106,41,29,40,196,50,196,67,46,82,78,129,34,136,144,224,203,116,212,234,
dc.b 66,156,24,177,244,109,145,69,229,99,85,254,74,34,71,98,30,199,148,6,99,110,124,7,99,226,178,37,247,56,99,31,
dc.b 211,37,57,37,5,42,18,105,208,77,156,35,212,2,240,125,127,152,63,34,5,253,207,83,134,151,11,2,175,171,195,64,
dc.b 182,27,221,213,49,175,162,98,76,249,201,3,119,5,134,134,132,152,213,44,179,138,76,255,82,74,202,129,142,210,86,55,
dc.b 144,185,77,87,12,18,18,216,188,217,8,193,45,156,120,184,4,42,18,213,62,130,218,18,241,219,171,212,182,67,49,81,
dc.b 118,97,169,189,53,37,40,1,64,165,38,185,105,232,153,37,78,123,186,154,170,196,252,252,226,214,86,214,38,216,98,160,
dc.b 183,194,169,166,53,178,207,37,24,0,70,255,72,73,16,202,154,71,123,74,31,216,122,48,151,153,61,104,67,183,112,87,
dc.b 94,94,227,222,222,9,41,217,133,68,95,47,29,117,246,22,37,189,251,11,220,44,124,63,53,182,29,191,115,183,218,238,
dc.b 253,125,94,207,215,222,238,29,51,206,236,103,236,78,30,75,98,131,108,85,118,10,125,44,132,189,20,125,29,52,113,16,
dc.b 16,152,22,78,63,31,228,231,125,62,255,197,211,173,245,120,213,156,78,55,31,129,238,122,155,122,218,137,254,13,68,164,
dc.b 250,166,242,74,182,34,157,71,82,200,200,25,179,98,79,63,186,34,237,4,158,154,167,242,146,90,3,213,218,239,59,11,
dc.b 246,24,214,108,180,159,104,121,88,104,121,236,217,47,180,209,131,213,144,97,141,1,246,190,87,146,253,236,38,123,11,15,
dc.b 227,245,217,51,103,103,223,183,209,204,109,111,248,60,99,145,145,112,182,51,33,190,45,224,181,192,168,81,254,203,224,213,
dc.b 208,243,61,142,119,203,249,127,215,167,211,248,231,247,31,139,230,170,91,15,190,170,170,162,153,170,227,83,240,190,174,127,
dc.b 54,186,166,163,93,182,108,84,236,158,165,155,38,158,62,206,128,28,230,95,123,236,85,74,198,48,118,249,140,51,59,159,
dc.b 179,236,251,63,167,246,255,188,27,204,88,140,121,47,95,111,47,142,214,31,46,10,134,29,214,135,135,239,255,31,199,249,
dc.b 246,87,64,194,195,51,211,121,108,47,177,96,149,101,229,249,188,55,88,89,78,244,91,195,181,92,70,140,180,188,235,188,
dc.b 237,33,74,1,232,24,94,175,225,250,121,30,239,173,91,250,127,111,193,83,23,11,21,187,231,86,209,71,77,203,63,218,
dc.b 78,122,92,78,60,163,72,114,217,56,172,224,209,69,55,8,87,162,24,189,84,46,63,185,210,138,32,67,216,183,183,56,
dc.b 239,177,176,221,191,101,136,214,6,172,44,169,244,98,150,123,99,7,205,139,5,30,245,92,102,126,38,65,10,80,28,22,
dc.b 152,230,107,182,120,230,226,223,97,102,115,101,236,27,224,224,121,124,140,154,222,118,237,217,108,12,8,180,149,124,14,45,
dc.b 93,0,86,247,89,162,247,235,21,196,69,237,184,36,50,171,219,249,127,55,249,116,120,220,58,25,120,216,26,14,162,33,
dc.b 245,179,179,33,196,230,32,240,220,72,99,151,24,240,30,207,57,203,213,145,176,6,139,246,171,173,152,235,179,95,154,233,
dc.b 230,54,32,131,80,241,155,157,56,82,158,247,45,35,43,67,21,166,216,99,78,120,207,5,139,134,171,217,106,107,61,87,
dc.b 176,228,234,191,147,156,233,210,242,6,76,174,41,90,201,74,77,204,252,158,188,8,104,135,216,249,239,28,144,217,89,238,
dc.b 47,249,254,255,163,229,233,125,95,159,151,186,45,254,51,129,120,45,5,203,219,60,130,134,216,16,171,168,102,230,103,136,
dc.b 156,36,43,134,205,49,177,111,124,61,223,15,150,227,238,254,246,67,46,46,162,184,217,249,73,74,89,120,215,218,58,11,
dc.b 176,10,213,18,232,40,12,218,105,192,138,141,41,72,122,250,184,215,76,51,182,22,193,105,56,85,180,210,199,94,212,177,
dc.b 48,148,152,172,203,171,181,250,58,233,66,181,155,152,135,150,153,155,161,218,208,209,70,237,170,103,39,41,40,168,182,243,
dc.b 74,225,167,40,37,99,36,233,184,213,253,30,135,35,153,194,151,154,167,165,16,93,51,90,61,208,92,199,77,86,192,243,
dc.b 105,154,229,83,67,6,244,68,35,117,237,150,66,233,23,5,22,76,222,100,217,249,46,63,15,252,250,252,55,235,180,150,
dc.b 73,210,209,200,45,155,221,77,68,198,61,48,201,216,217,224,103,103,230,95,216,218,231,235,59,106,222,20,207,118,233,241,
dc.b 211,33,243,193,210,180,38,245,211,103,184,119,36,219,131,0,8,2,8,0,1,252,69,85,85,100,149,149,108,146,217,173,
dc.b 214,73,117,183,186,222,235,224,107,218,238,221,188,13,233,43,120,27,109,218,246,210,203,99,36,100,138,170,193,64,64,84,
dc.b 81,16,80,0,1,62,125,252,118,143,225,247,223,191,126,237,181,173,37,113,205,248,80,176,148,118,188,13,104,103,252,254,
dc.b 95,15,115,39,95,242,252,126,191,159,197,243,121,188,80,98,235,253,223,207,251,127,66,237,181,167,155,127,150,213,218,156,
dc.b 27,85,98,75,142,35,127,184,118,106,229,187,99,159,207,255,61,95,183,183,213,187,205,91,164,146,103,90,118,34,215,14,
dc.b 48,188,211,122,9,8,129,120,38,163,202,86,208,61,251,164,90,15,221,240,233,32,192,49,219,140,196,253,173,247,182,54,
dc.b 253,127,166,193,192,98,243,107,27,95,231,253,210,40,255,143,165,234,180,248,203,209,224,251,201,162,152,52,12,239,62,212,
dc.b 213,209,139,39,187,222,241,253,159,103,222,116,90,253,127,143,229,248,107,231,201,118,219,176,68,167,147,153,4,140,58,89,
dc.b 198,180,45,15,252,61,126,153,225,178,168,79,42,241,112,80,37,10,93,60,179,204,80,94,143,251,177,50,141,106,59,115,
dc.b 239,71,146,216,164,83,142,216,22,28,66,123,123,225,250,108,239,112,204,219,244,250,63,93,143,103,179,130,220,109,30,236,
dc.b 178,58,14,224,164,159,139,84,211,190,21,74,186,190,89,7,188,115,19,191,228,243,121,127,135,221,251,254,46,238,191,206,
dc.b 163,130,159,46,159,123,201,245,125,94,13,29,2,151,72,232,139,101,101,75,146,161,123,34,135,236,6,194,7,207,9,64,
dc.b 68,183,217,199,237,246,208,56,56,6,136,231,241,216,237,86,58,170,59,27,51,136,160,105,21,252,167,181,232,220,93,56,
dc.b 214,122,131,191,247,80,219,41,224,132,218,136,224,71,80,124,20,134,236,19,98,78,58,28,246,160,229,142,50,190,30,247,
dc.b 131,232,253,195,93,76,178,9,30,34,2,201,27,9,90,143,149,223,243,127,31,235,252,191,15,167,190,70,1,206,253,20,
dc.b 253,172,144,85,236,245,31,132,74,129,132,128,4,15,117,108,233,149,231,226,218,253,189,130,223,253,85,8,3,226,58,77,
dc.b 184,14,237,238,122,53,110,245,245,166,122,193,117,216,46,183,70,118,215,159,253,126,123,62,159,124,233,182,156,118,186,136,
dc.b 30,35,126,9,6,134,29,32,52,131,146,99,247,193,138,201,105,139,53,173,62,231,143,201,229,21,218,60,90,255,25,22,
dc.b 135,70,86,8,36,57,105,219,8,46,63,145,163,221,48,187,145,157,144,217,219,215,132,79,51,171,1,99,182,1,74,80,
dc.b 168,63,209,18,130,151,1,185,115,183,47,170,110,215,171,207,238,153,193,75,160,212,92,55,156,114,24,249,167,239,80,70,
dc.b 123,122,235,82,14,131,211,22,25,132,24,97,127,204,145,204,132,2,137,136,70,150,161,88,56,46,247,25,89,210,65,234,
dc.b 66,40,131,177,124,20,113,194,200,31,157,163,19,46,141,77,45,49,80,252,143,87,220,182,53,223,244,224,70,175,73,32,
dc.b 60,9,121,114,178,132,63,65,246,242,185,151,96,111,11,35,42,84,102,82,231,25,166,166,111,208,34,238,234,62,95,206,
dc.b 3,202,224,217,243,254,187,62,193,48,150,144,199,206,119,109,143,215,131,100,75,224,51,160,184,167,26,4,9,36,218,31,
dc.b 47,39,76,135,217,43,156,92,136,141,10,206,164,212,112,133,42,10,198,14,156,24,67,194,229,119,157,26,187,172,216,186,
dc.b 119,177,224,119,44,142,104,149,162,200,110,240,227,99,45,40,77,175,148,111,34,243,220,223,25,70,76,29,91,178,71,254,
dc.b 139,8,53,57,251,158,189,158,13,227,15,243,3,101,238,37,76,160,251,197,251,148,140,33,10,244,62,57,175,6,115,218,
dc.b 144,116,5,19,130,220,173,29,125,126,241,154,19,75,44,55,50,32,12,158,204,100,180,39,142,128,18,19,51,112,89,124,
dc.b 140,185,97,55,102,18,0,170,182,175,8,0,36,25,140,251,204,94,137,131,211,240,136,212,84,17,2,77,53,46,95,191,
dc.b 210,148,11,58,78,254,174,131,138,74,185,78,216,170,4,182,220,217,5,255,1,44,136,183,68,250,125,2,63,83,215,176,
dc.b 101,52,147,51,116,181,50,161,197,58,198,228,230,29,52,169,204,135,60,140,68,53,41,97,229,33,17,199,14,4,242,175,
dc.b 123,26,253,96,197,189,134,55,176,209,158,201,112,248,141,222,27,227,62,12,68,39,4,68,165,20,39,52,1,113,189,117,
dc.b 147,176,3,255,169,145,149,5,52,0,220,205,19,183,230,110,237,236,122,61,39,127,21,46,112,49,138,163,134,226,5,109,
dc.b 20,97,73,139,152,117,26,32,81,255,55,147,233,242,253,162,196,214,182,182,164,113,4,191,33,97,104,136,3,11,174,181,
dc.b 115,6,244,238,160,193,116,202,177,40,13,82,155,31,217,34,158,124,124,158,232,49,147,137,139,89,103,184,168,246,240,159,
dc.b 210,71,82,67,121,29,84,62,27,190,255,126,207,187,213,184,5,22,161,61,85,204,129,8,254,157,218,126,239,93,61,241,
dc.b 13,230,239,67,161,18,9,169,79,252,58,95,47,219,223,243,124,103,122,39,143,87,91,185,223,240,234,248,129,36,25,217,
dc.b 209,243,59,189,220,197,128,152,205,14,75,30,1,218,252,167,116,184,223,103,188,134,100,204,232,88,94,67,5,105,6,185,
dc.b 182,59,232,66,199,166,136,60,75,78,84,96,233,97,8,241,44,207,74,96,23,118,197,254,73,148,196,218,169,195,250,54,
dc.b 230,207,254,255,31,159,247,253,127,63,57,38,197,155,209,124,135,14,99,167,18,39,207,13,168,153,132,99,83,89,16,226,
dc.b 77,117,26,165,125,19,84,6,17,169,160,5,27,35,84,161,200,42,233,181,5,97,85,165,197,191,197,189,180,125,221,28,
dc.b 254,211,187,114,151,78,29,164,174,4,49,28,255,140,195,34,108,148,81,159,41,96,150,56,24,49,244,100,64,208,123,127,
dc.b 182,132,237,193,90,159,139,98,119,171,131,127,103,147,222,30,150,161,188,126,72,93,126,230,55,87,224,11,188,29,188,208,
dc.b 243,181,188,63,71,205,227,52,74,119,136,32,71,201,169,241,105,66,80,34,24,39,219,65,10,10,234,180,96,87,186,49,
dc.b 185,242,237,110,16,180,173,226,18,217,187,181,55,111,143,139,122,161,180,0,201,178,84,242,165,74,209,49,213,102,19,179,
dc.b 124,253,50,200,16,137,26,161,149,18,207,106,77,101,170,41,13,88,35,250,63,35,114,10,31,38,6,249,158,157,250,123,
dc.b 222,209,14,97,206,0,203,112,53,49,173,99,228,98,123,74,142,65,230,201,186,179,76,147,177,230,230,233,101,73,106,46,
dc.b 58,62,171,214,107,144,226,29,46,139,10,164,242,72,74,26,66,62,13,15,65,131,5,145,49,249,84,215,165,72,123,34,
dc.b 235,160,70,60,227,217,60,204,223,4,114,29,170,55,147,135,190,48,188,174,112,147,186,106,24,34,59,147,54,247,104,212,
dc.b 26,166,248,231,113,204,45,58,118,209,179,3,38,53,231,81,21,30,34,57,27,145,205,207,210,215,5,118,17,61,50,32,
dc.b 92,245,90,115,112,224,53,233,148,43,67,1,205,94,82,187,248,113,225,4,32,241,138,128,156,51,55,38,216,33,229,112,
dc.b 4,139,152,210,115,123,249,250,13,25,236,90,132,48,97,104,9,177,170,145,241,17,75,249,30,170,46,1,155,198,245,158,
dc.b 113,104,12,207,121,56,16,228,173,91,20,57,122,140,128,201,18,71,8,215,86,11,103,213,248,129,232,35,17,196,164,63,
dc.b 201,168,131,216,152,132,104,37,165,194,31,141,78,249,218,252,162,74,193,4,246,29,107,73,144,221,53,143,136,138,24,171,
dc.b 192,209,74,63,112,44,43,167,247,40,38,84,248,89,250,69,148,40,87,222,38,7,65,228,120,231,168,234,44,18,169,108,
dc.b 165,255,48,13,102,70,180,195,253,188,128,99,25,220,28,38,31,250,135,148,171,156,158,130,65,99,99,188,34,17,8,101,
dc.b 135,20,37,142,73,6,71,198,177,60,19,136,217,151,209,176,211,111,128,127,88,28,92,127,178,169,228,137,220,181,8,163,
dc.b 214,6,31,219,130,208,56,227,43,40,74,30,210,53,42,13,251,97,231,112,236,150,59,228,62,235,29,147,84,85,5,126,
dc.b 51,191,81,164,112,158,59,30,254,27,155,230,99,94,129,193,81,25,5,116,12,37,136,123,114,63,86,227,35,248,46,128,
dc.b 44,235,51,224,27,16,29,234,72,2,145,164,18,146,246,76,228,72,163,160,172,188,43,119,8,145,199,25,194,8,60,75,
dc.b 186,78,234,166,234,139,220,91,69,142,199,137,66,136,28,22,59,144,144,5,88,230,174,65,136,90,237,100,142,34,193,47,
dc.b 132,63,52,238,246,56,156,84,51,210,88,59,191,143,138,196,100,49,27,221,33,160,34,26,11,73,211,94,66,237,197,63,
dc.b 188,20,100,89,91,19,20,4,9,26,33,3,51,30,203,1,189,19,108,114,238,35,82,168,210,98,6,111,52,67,242,154,
dc.b 207,208,7,139,201,129,0,230,196,70,234,197,7,241,219,204,82,171,133,17,202,177,96,91,180,68,87,106,161,165,68,99,
dc.b 109,119,123,46,232,144,68,44,250,107,224,167,90,133,23,136,131,134,45,225,84,218,210,137,29,91,11,180,150,30,197,95,
dc.b 149,99,185,217,31,62,55,49,44,71,37,50,203,174,210,171,71,187,123,8,147,208,225,74,125,194,178,139,99,190,151,30,
dc.b 57,26,156,125,25,82,4,228,69,20,134,218,57,131,19,222,76,100,69,157,64,86,236,117,153,35,122,200,105,199,82,156,
dc.b 117,22,88,3,158,34,69,123,38,123,171,158,107,34,202,56,28,95,56,4,96,32,4,79,47,189,110,40,3,47,141,227,
dc.b 179,81,40,39,62,239,91,56,136,35,3,216,28,42,227,57,137,248,204,22,160,60,138,185,184,21,236,149,154,46,106,28,
dc.b 222,143,163,69,64,248,232,86,72,125,134,248,6,92,185,113,204,142,70,252,70,238,219,219,1,73,242,117,40,128,239,87,
dc.b 55,47,82,148,8,17,127,106,198,56,162,63,57,125,148,151,210,52,204,98,35,173,214,145,216,214,132,71,0,175,51,59,
dc.b 213,230,10,164,111,137,34,132,196,100,144,2,149,210,101,132,139,146,87,113,205,224,128,61,146,177,130,43,76,253,185,190,
dc.b 244,212,177,42,52,121,77,64,142,83,111,222,163,59,167,55,110,210,11,80,63,110,220,66,15,153,55,230,30,97,105,143,
dc.b 166,83,39,79,86,209,52,177,47,109,36,169,164,2,116,116,111,176,249,254,166,84,9,131,249,76,99,131,100,201,221,224,
dc.b 85,75,61,175,101,140,21,250,154,51,12,191,16,98,191,65,92,30,14,227,217,34,69,160,245,101,26,44,114,31,54,249,
dc.b 249,246,161,198,35,253,6,182,165,82,41,61,83,98,78,240,128,111,103,21,232,107,158,144,20,138,227,15,55,4,162,149,
dc.b 109,197,130,204,41,83,81,237,52,41,153,46,166,246,178,138,235,139,199,24,79,71,129,79,105,3,154,10,174,90,185,85,
dc.b 73,232,76,153,184,191,54,40,169,171,104,70,221,89,106,79,188,112,96,226,187,165,136,254,74,199,98,102,207,94,68,48,
dc.b 79,176,244,96,112,185,101,172,95,9,8,203,218,99,80,67,108,207,221,172,101,128,157,229,123,11,176,14,228,2,36,78,
dc.b 100,220,112,30,244,14,30,237,112,171,193,68,95,57,209,232,18,88,161,49,229,37,212,33,15,126,73,246,17,94,178,15,
dc.b 179,33,37,166,33,156,42,30,26,169,34,42,170,252,180,197,90,202,123,81,46,170,200,63,231,75,170,142,145,81,181,235,
dc.b 146,164,99,244,244,209,225,227,163,202,175,229,2,81,24,177,26,0,115,30,175,56,70,39,185,212,249,205,81,118,79,112,
dc.b 212,216,128,22,84,202,33,90,87,176,110,120,64,183,36,139,142,242,18,162,59,244,167,96,126,142,24,135,130,97,199,148,
dc.b 152,220,136,6,224,204,100,182,139,202,14,82,59,80,101,104,172,84,204,40,8,142,213,44,233,74,254,217,93,1,32,4,
dc.b 245,57,248,230,169,223,225,232,56,223,126,45,104,29,233,180,102,25,51,25,165,206,146,167,158,2,224,107,20,26,102,207,
dc.b 92,219,116,69,21,228,9,50,173,158,95,79,191,175,164,1,209,31,197,199,10,165,228,228,153,9,36,200,58,100,99,68,
dc.b 72,125,7,235,146,182,16,65,166,92,188,180,82,24,181,24,43,238,106,131,73,35,236,130,30,227,16,36,132,73,82,167,
dc.b 118,133,249,9,159,71,95,239,52,223,85,26,219,91,150,102,109,156,252,141,190,83,120,40,243,109,213,167,54,201,222,180,
dc.b 91,52,0,102,164,146,18,185,101,250,94,233,176,247,32,142,32,122,27,13,74,210,211,128,108,52,140,76,55,222,13,234,
dc.b 217,196,143,43,51,65,167,16,244,160,190,214,105,231,112,10,77,164,174,137,114,157,72,132,218,33,224,27,34,84,93,160,
dc.b 212,251,115,172,65,83,85,43,84,18,215,102,110,28,194,203,29,231,12,243,41,76,241,200,203,135,125,98,49,86,107,35,
dc.b 142,201,157,102,233,40,145,169,78,45,122,68,156,11,11,203,111,162,19,176,121,48,241,163,145,168,104,106,190,190,75,38,
dc.b 179,86,199,181,124,223,36,62,70,50,241,125,240,73,136,104,220,4,68,80,115,217,179,224,228,28,253,47,178,40,205,160,
dc.b 47,156,134,164,227,92,155,86,223,175,155,14,244,192,1,85,83,107,245,26,243,105,85,24,137,6,28,45,174,41,187,231,
dc.b 201,148,176,83,98,202,60,109,109,80,54,132,39,60,71,239,212,14,124,219,78,145,162,148,30,74,43,41,91,42,152,222,
dc.b 36,81,19,210,131,150,41,61,43,202,204,63,178,179,161,103,103,101,174,104,231,101,123,54,190,31,189,103,218,51,34,93,
dc.b 94,138,53,108,114,208,168,34,198,240,146,63,78,58,61,8,138,240,227,169,52,97,43,228,24,234,232,28,168,130,237,14,
dc.b 148,252,1,33,157,98,166,20,163,173,135,45,240,49,163,32,192,233,8,156,242,226,171,107,28,45,15,129,134,75,241,108,
dc.b 244,184,138,25,46,147,218,188,89,97,119,83,34,188,133,145,19,21,235,237,149,92,243,240,215,19,176,73,18,14,81,16,
dc.b 193,38,22,104,237,192,35,143,164,87,1,57,85,124,162,228,50,166,215,59,171,69,11,187,129,219,49,54,180,170,221,45,
dc.b 174,140,62,14,120,101,202,60,166,221,90,30,35,69,95,93,196,136,28,225,219,166,58,167,40,200,85,252,230,38,13,12,
dc.b 72,167,162,77,71,54,154,195,17,206,214,114,165,160,198,250,203,43,113,148,240,96,133,87,89,206,73,148,229,162,120,210,
dc.b 67,189,16,132,225,25,85,14,151,19,189,235,36,190,75,152,161,0,73,33,254,249,217,212,159,9,238,98,65,49,6,151,
dc.b 70,86,176,129,66,175,33,57,78,200,130,125,166,143,15,67,46,30,153,219,87,35,66,48,159,129,14,20,167,209,8,151,
dc.b 74,70,202,50,0,25,135,111,50,148,108,163,158,164,212,70,169,194,77,134,149,83,196,63,98,40,194,159,29,172,177,229,
dc.b 137,148,133,181,84,80,34,241,183,29,55,172,236,241,247,99,187,194,199,17,34,196,178,239,26,203,174,220,6,101,116,123,
dc.b 204,147,99,11,120,143,160,156,7,142,3,121,44,88,127,73,250,231,194,116,132,60,111,48,129,28,230,183,120,235,168,123,
dc.b 100,230,34,166,216,247,170,88,188,161,40,61,131,28,61,97,150,22,184,11,41,34,118,87,48,240,164,7,197,200,244,33,
dc.b 132,202,104,85,163,63,114,124,235,192,38,253,58,236,194,96,212,36,164,233,63,71,3,177,12,148,122,232,42,251,199,71,
dc.b 196,0,101,171,216,73,118,136,145,30,156,70,85,40,86,9,232,250,30,240,84,245,32,159,1,111,228,19,26,96,82,49,
dc.b 213,140,67,128,250,44,216,231,31,240,122,209,1,36,15,10,185,243,200,82,40,180,169,29,167,238,239,164,72,17,20,24,
dc.b 245,192,151,27,28,141,110,29,252,109,171,57,108,206,44,46,187,28,149,239,99,145,243,135,142,95,151,26,144,99,180,1,
dc.b 13,165,38,137,144,230,84,95,154,26,167,1,17,57,194,102,251,16,15,182,254,72,213,14,233,226,68,138,117,128,133,182,
dc.b 97,35,228,130,55,5,162,165,86,112,22,59,192,233,154,45,172,85,94,193,28,77,187,87,207,229,132,105,82,52,46,137,
dc.b 53,0,146,27,153,23,201,41,186,40,59,121,181,193,142,31,25,83,116,18,118,3,195,235,27,117,73,158,21,153,31,159,
dc.b 195,13,130,46,53,199,161,176,77,64,172,169,103,170,101,186,69,110,17,242,87,43,116,141,18,167,119,108,108,207,176,56,
dc.b 113,157,24,119,6,222,138,119,169,243,89,167,112,249,233,82,246,30,197,236,22,21,76,175,192,182,54,169,144,43,132,144,
dc.b 57,255,223,183,206,163,163,149,106,72,125,98,8,115,33,71,226,73,218,143,73,36,146,244,140,65,143,142,199,251,50,232,
dc.b 152,172,161,137,118,195,21,48,12,255,3,211,169,16,141,36,71,145,65,225,150,61,72,71,234,5,20,132,165,235,34,156,
dc.b 226,136,159,11,27,165,108,37,83,26,151,233,87,152,157,138,86,192,213,67,185,80,253,230,36,24,102,33,66,98,83,199,
dc.b 197,76,251,92,227,72,149,193,43,1,144,146,244,68,155,152,204,51,29,5,136,140,107,113,249,232,115,3,19,225,62,168,
dc.b 214,87,212,241,32,80,132,194,39,253,132,243,54,67,132,109,33,61,138,253,15,117,148,158,70,35,18,98,165,224,170,102,
dc.b 243,197,208,241,133,186,69,222,84,183,55,39,90,123,21,18,155,98,254,85,145,205,95,168,77,7,231,42,52,234,58,185,
dc.b 160,153,103,138,2,216,237,242,167,122,185,7,12,5,64,142,79,8,4,2,95,177,106,185,235,78,210,32,251,70,93,241,
dc.b 140,50,231,99,72,8,47,161,84,106,108,95,98,47,154,5,254,186,96,143,60,58,101,1,113,3,97,76,200,79,82,57,
dc.b 201,169,236,234,45,31,74,21,56,100,221,64,229,236,35,136,202,168,170,197,128,201,244,250,93,55,80,13,184,106,220,236,
dc.b 111,72,42,33,75,142,110,64,202,211,218,202,98,143,99,35,88,148,21,189,20,82,181,57,7,42,150,242,225,82,62,165,
dc.b 150,52,40,83,110,187,157,219,204,217,200,
sample_pac_end: 
EXPORT musix_pac, musix_pac_end
musix_pac: 
dc.b 23,194,122,124,240,26,201,27,127,239,102,238,102,102,102,103,179,72,82,146,33,228,20,42,24,146,35,108,135,27,214,34,
dc.b 208,180,153,155,214,56,60,205,149,236,58,62,211,137,106,14,173,179,126,251,238,156,220,234,194,62,210,210,55,178,218,23,
dc.b 130,210,110,116,174,19,182,16,176,121,237,150,187,71,186,220,145,202,247,100,150,16,35,218,68,16,105,160,219,239,123,28,
dc.b 124,17,200,113,193,185,239,190,251,217,239,191,230,244,131,133,189,126,162,250,139,142,161,82,84,118,149,20,68,209,223,193,
dc.b 10,84,21,93,10,142,131,45,8,134,218,84,183,240,22,162,136,42,74,154,149,39,162,0,15,180,177,182,220,238,173,63,
dc.b 101,157,236,179,161,251,16,193,7,232,82,205,218,167,38,116,153,208,253,172,233,69,77,103,11,202,177,247,191,88,45,185,
dc.b 69,229,130,242,158,41,242,120,112,94,112,46,179,255,95,248,103,189,85,234,11,53,63,183,204,118,146,248,160,191,102,81,
dc.b 109,122,75,250,255,143,154,177,87,245,255,62,92,22,207,216,180,11,100,22,192,45,112,90,192,181,65,106,30,79,252,219,
dc.b 239,234,125,225,87,232,127,92,23,234,188,83,228,240,224,181,172,184,94,215,147,242,43,229,21,216,159,28,23,219,60,83,
dc.b 228,240,224,189,224,47,130,255,215,254,25,239,225,41,250,17,47,255,89,237,9,63,255,244,159,250,231,223,248,74,127,66,
dc.b 175,170,42,253,15,140,11,219,60,83,228,240,224,183,106,255,190,251,208,211,253,9,63,161,167,250,26,127,161,18,244,52,
dc.b 255,66,79,255,10,79,254,181,39,101,251,89,191,200,47,142,11,228,102,187,5,242,129,124,183,254,182,253,120,76,77,154,
dc.b 74,241,127,208,167,253,119,29,247,32,243,169,112,121,62,118,116,190,79,40,191,107,58,222,116,190,79,185,7,54,81,109,
dc.b 203,228,243,10,207,215,159,40,176,206,45,185,69,229,214,94,11,110,221,169,80,191,182,11,228,75,130,219,183,103,31,201,
dc.b 5,77,109,182,96,182,37,70,126,228,226,235,77,137,195,47,235,249,115,138,154,223,53,152,45,169,113,63,42,113,121,83,
dc.b 98,118,101,23,247,167,23,151,91,247,89,130,216,151,5,242,39,23,157,91,201,102,11,94,92,247,230,78,47,58,183,205,
dc.b 102,11,90,95,175,229,78,47,86,158,218,245,62,93,65,237,243,23,239,121,208,231,74,83,236,212,27,86,229,41,252,121,
dc.b 15,1,79,217,183,41,79,238,65,196,224,22,27,16,202,73,123,124,2,240,20,253,118,139,231,112,11,102,181,169,69,220,
dc.b 148,91,21,86,46,60,23,128,167,234,89,95,235,148,90,212,236,207,130,213,205,177,56,181,51,44,27,239,9,190,240,155,
dc.b 239,104,223,123,82,163,175,31,147,227,22,204,226,175,83,254,189,141,185,245,7,234,180,88,86,42,240,91,118,171,203,242,
dc.b 89,171,182,107,187,5,177,90,84,159,237,172,90,230,167,214,10,126,170,202,125,120,46,117,64,167,233,219,148,188,215,190,
dc.b 249,217,176,206,45,188,200,101,49,214,18,93,43,82,153,207,146,177,96,88,172,242,120,44,203,242,118,218,43,176,88,44,
dc.b 74,104,251,147,139,224,205,130,194,191,215,56,188,137,176,91,70,38,220,191,61,153,10,252,47,32,188,121,176,91,11,193,
dc.b 103,23,188,155,5,175,46,123,185,56,189,228,216,45,105,126,187,114,19,83,224,10,126,0,167,224,10,126,0,167,224,10,
dc.b 126,0,167,224,10,126,0,167,224,10,126,0,167,224,10,126,0,167,224,94,251,249,45,242,119,20,252,11,223,125,185,197,
dc.b 106,16,243,160,17,47,2,209,46,237,233,229,86,220,5,118,244,242,193,114,96,172,64,204,226,235,77,130,173,18,251,115,
dc.b 138,153,176,91,76,72,175,54,124,189,219,211,202,199,144,153,238,77,233,72,47,58,108,21,104,151,242,103,23,157,54,11,
dc.b 89,159,93,130,152,158,114,242,240,86,224,182,207,39,155,83,207,95,200,46,177,168,60,227,87,91,180,126,174,167,242,166,
dc.b 193,108,30,246,189,247,223,157,81,253,190,102,252,234,143,241,120,5,200,168,31,179,40,188,5,63,109,101,63,190,178,159,
dc.b 182,178,145,223,89,79,176,95,53,101,63,110,212,226,216,133,98,239,172,167,237,44,164,127,133,101,63,102,204,248,45,91,
dc.b 22,23,245,214,83,245,255,2,79,240,11,223,192,47,127,0,189,247,11,200,175,130,117,239,180,85,173,191,143,95,4,235,
dc.b 209,246,213,246,1,126,28,235,209,227,130,242,43,236,78,189,30,242,108,79,249,245,60,98,28,58,155,118,70,33,236,12,
dc.b 67,216,24,135,174,49,15,92,98,30,176,196,58,245,62,64,167,228,10,126,64,167,228,10,126,64,167,228,10,126,48,167,
dc.b 227,10,126,64,167,241,5,63,32,83,241,133,63,159,73,219,239,40,179,111,190,125,39,111,187,133,208,171,159,73,155,239,
dc.b 56,171,223,126,53,94,45,44,155,211,219,52,88,86,42,240,91,114,249,63,26,175,228,44,91,54,93,130,203,228,247,106,
dc.b 241,86,43,60,158,19,201,225,60,158,19,201,220,42,107,67,63,147,180,86,180,254,188,21,173,0,217,5,175,74,118,159,
dc.b 193,83,193,242,92,211,252,51,139,173,54,38,180,131,254,37,39,52,255,236,105,57,167,255,97,56,188,169,177,53,163,230,
dc.b 157,39,20,254,101,39,52,255,94,147,154,127,206,164,230,159,255,22,147,154,127,246,52,156,211,255,176,164,226,159,179,73,
dc.b 205,63,202,44,205,63,195,73,205,63,231,82,115,79,240,210,115,79,246,105,57,167,251,52,156,211,252,52,156,211,254,117,
dc.b 39,52,255,13,39,52,255,102,147,154,127,88,173,105,254,64,251,228,15,190,64,251,228,18,127,32,147,249,4,159,198,36,
dc.b 254,49,39,242,9,63,196,36,254,65,39,241,137,63,140,105,254,65,167,252,67,79,242,13,63,198,52,255,24,211,252,131,
dc.b 79,248,134,159,228,26,127,140,105,254,49,167,249,6,159,241,13,63,200,52,255,24,211,252,99,79,242,13,63,226,26,127,
dc.b 144,105,254,49,167,248,198,159,228,26,127,196,52,255,32,211,252,99,79,241,141,63,200,52,255,136,105,254,65,167,248,198,
dc.b 159,227,26,127,144,105,255,16,211,252,131,79,241,141,63,198,52,255,32,211,254,33,167,249,6,159,227,26,127,140,105,254,
dc.b 65,167,252,67,78,50,2,198,50,95,24,211,252,131,79,248,134,159,228,26,127,140,105,254,49,167,249,6,159,241,13,63,
dc.b 200,52,255,24,211,252,99,79,242,13,63,226,26,127,144,105,254,49,167,248,198,156,100,5,196,52,255,32,211,252,99,79,
dc.b 241,141,63,200,52,255,136,105,254,78,198,167,242,166,193,108,30,246,189,247,196,20,252,129,79,198,20,252,111,41,252,65,
dc.b 79,200,20,252,97,79,198,242,159,196,20,252,129,79,181,123,240,139,223,132,94,253,161,123,235,73,254,125,39,36,253,98,
dc.b 181,39,252,89,213,3,245,90,43,18,127,159,73,201,63,106,247,235,187,5,98,79,248,180,156,147,254,202,247,249,21,220,
dc.b 189,246,138,214,159,220,189,255,109,94,200,43,151,163,199,5,228,87,114,247,251,201,177,59,11,137,254,189,233,94,167,230,
dc.b 181,81,237,23,38,160,248,224,188,17,49,231,105,199,202,5,242,243,92,168,255,43,53,202,143,242,25,130,195,46,167,248,
dc.b 249,184,150,44,186,159,180,204,22,25,117,63,107,53,101,91,11,53,63,120,105,255,120,105,255,120,105,255,120,105,255,120,
dc.b 105,255,120,105,255,120,105,255,117,101,62,193,124,197,148,253,187,51,139,89,130,238,172,167,237,216,159,19,169,40,189,168,
dc.b 138,237,129,90,221,247,220,28,119,219,28,105,96,176,144,109,237,47,125,218,232,253,151,96,182,27,4,229,205,63,248,144,
dc.b 106,100,242,117,139,55,147,248,144,113,39,242,119,11,208,169,226,65,36,13,242,118,138,191,39,215,224,23,82,111,39,214,
dc.b 169,225,130,252,25,216,177,215,5,232,84,240,217,130,227,241,156,21,60,73,197,233,77,137,195,47,235,253,57,197,232,84,
dc.b 253,86,96,182,165,196,254,20,226,235,77,137,217,148,95,210,156,93,122,159,162,204,22,196,184,47,193,156,92,21,53,217,
dc.b 130,215,151,61,253,73,197,193,193,151,175,5,173,47,215,248,83,139,213,167,47,182,204,211,252,162,204,211,251,53,5,141,
dc.b 63,227,200,114,52,255,226,65,191,6,70,159,252,62,1,114,52,255,143,5,200,211,254,61,9,200,211,254,60,23,35,79,
dc.b 248,242,22,180,254,220,21,173,63,172,90,153,153,119,222,19,125,225,55,222,209,190,246,153,250,247,229,223,123,51,138,214,
dc.b 243,219,180,107,82,191,134,11,240,103,212,30,88,42,107,99,241,153,158,111,102,39,234,234,126,213,55,106,124,222,79,105,
dc.b 101,63,174,177,108,173,220,118,20,253,133,187,142,194,5,174,183,113,217,227,53,150,237,203,60,214,170,197,102,251,212,91,
dc.b 184,254,34,197,167,101,216,44,186,159,117,162,203,169,253,203,112,90,80,203,250,245,214,44,11,207,89,130,193,105,121,236,
dc.b 226,246,205,193,96,178,191,11,156,94,52,216,45,133,224,179,139,118,108,22,190,60,244,22,236,216,45,105,126,190,187,69,
dc.b 118,251,192,20,251,23,190,188,21,171,223,199,230,185,23,191,174,178,159,98,244,124,69,148,252,1,79,193,106,113,90,189,
dc.b 252,120,46,69,239,227,213,214,175,125,184,45,88,2,159,98,247,252,54,249,59,138,125,141,63,235,183,201,220,83,242,138,
dc.b 212,33,173,167,246,139,110,1,18,240,45,3,58,224,173,218,53,160,101,186,159,100,193,68,75,192,180,75,187,122,112,55,
dc.b 33,102,122,237,233,215,5,214,155,5,178,207,11,96,167,147,216,94,11,56,184,42,59,122,122,83,121,170,209,46,237,233,
dc.b 232,77,144,214,102,123,169,51,78,58,217,69,155,5,183,47,201,215,104,166,11,47,175,154,159,210,155,5,180,123,221,169,
dc.b 126,190,185,169,238,213,221,99,83,242,139,213,166,153,213,31,219,230,74,44,203,223,76,234,129,251,50,139,145,123,233,89,
dc.b 79,177,122,41,89,79,204,46,164,235,223,66,202,125,130,234,172,167,237,217,156,86,175,125,18,224,173,94,250,241,58,150,
dc.b 253,100,159,248,126,170,79,225,88,172,212,27,75,73,251,53,118,205,119,96,182,22,147,246,37,53,140,151,196,47,126,33,
dc.b 123,241,11,223,112,186,21,98,157,123,237,21,176,193,240,206,189,30,217,162,178,24,58,240,86,195,7,218,103,147,217,118,
dc.b 10,200,96,248,86,45,118,188,223,168,65,15,118,167,200,106,123,133,232,84,145,158,79,101,98,139,223,142,125,79,214,104,
dc.b 176,172,89,39,212,253,122,152,155,169,238,193,101,212,252,21,35,130,73,245,63,124,41,253,240,167,247,194,159,223,10,127,
dc.b 124,41,253,240,167,247,194,159,243,66,159,250,129,79,253,64,167,252,208,167,247,194,159,236,239,190,213,55,111,187,69,94,
dc.b 251,252,138,110,223,127,22,155,183,223,197,166,237,247,249,20,221,190,251,84,221,190,254,69,60,187,239,188,121,62,241,228,
dc.b 251,199,147,239,13,63,239,13,63,239,13,63,239,13,56,238,130,249,131,79,254,96,211,254,232,211,254,240,211,254,240,211,
dc.b 255,209,26,127,250,67,79,255,64,105,255,116,105,255,231,5,63,229,141,63,249,131,79,255,60,105,255,248,6,159,254,144,
dc.b 211,255,208,26,127,221,26,127,221,26,127,222,26,127,249,227,79,251,195,79,251,163,79,251,163,79,251,195,79,255,60,105,
dc.b 255,120,105,255,116,105,255,116,105,254,32,251,226,15,190,32,251,226,18,127,16,147,248,132,159,225,18,127,132,73,252,66,
dc.b 79,246,132,159,196,36,255,8,147,252,43,242,122,193,163,178,39,250,240,92,234,129,163,211,90,79,214,92,171,137,254,209,
dc.b 87,19,255,141,85,120,42,226,127,246,213,118,160,212,157,160,248,154,178,150,37,165,130,187,5,99,64,49,78,47,115,54,
dc.b 11,10,255,88,211,254,17,167,252,35,79,241,13,63,237,13,63,196,52,255,132,105,255,8,211,252,67,79,251,67,79,241,
dc.b 13,63,225,26,127,194,52,255,16,211,254,208,211,252,67,79,248,70,159,240,141,63,196,52,255,180,52,255,16,211,254,17,
dc.b 167,252,35,79,241,13,63,237,13,63,196,52,255,132,105,255,8,211,252,67,79,251,67,78,49,2,225,25,47,194,52,255,
dc.b 16,211,254,208,211,252,67,79,248,70,159,240,141,63,196,52,255,180,52,255,16,211,254,17,167,252,35,79,241,13,63,237,
dc.b 13,63,196,52,255,132,105,255,8,211,140,64,187,67,79,241,13,63,225,26,127,194,52,255,16,211,254,208,211,252,93,141,
dc.b 79,214,155,5,176,123,223,221,89,191,111,152,213,155,133,62,197,239,196,47,126,33,123,241,11,223,136,94,254,17,123,254,
dc.b 48,189,255,24,94,254,17,123,241,11,223,236,178,94,154,210,9,63,144,73,252,98,79,227,18,127,32,147,252,66,79,228,
dc.b 18,127,24,147,254,202,247,244,42,239,13,63,239,13,63,239,13,63,238,130,185,122,60,96,93,10,174,94,253,218,174,94,
dc.b 255,119,73,154,131,46,167,249,121,141,212,245,138,237,65,221,5,250,57,142,105,199,233,130,249,185,142,212,255,167,153,54,
dc.b 167,179,235,241,38,137,255,187,152,189,79,92,79,255,45,152,42,226,127,249,121,139,105,253,177,63,250,193,79,245,130,159,
dc.b 235,5,63,214,10,127,172,20,255,88,41,254,176,83,253,80,167,254,216,83,255,108,41,254,168,83,253,96,167,225,165,168,
dc.b 70,247,212,35,123,241,8,222,238,223,120,105,59,125,214,43,119,222,205,39,111,75,5,99,142,240,210,115,142,249,212,156,
dc.b 227,188,52,156,227,189,154,78,105,254,138,159,250,42,127,232,169,255,162,167,254,138,159,250,42,127,232,169,255,162,167,254,
dc.b 138,159,250,42,127,232,169,255,162,167,254,138,159,250,42,127,232,169,255,162,167,254,138,159,255,246,169,255,13,29,105,63,
dc.b 105,163,137,63,94,244,216,196,193,68,159,192,180,159,177,29,112,9,63,129,137,49,5,118,244,253,123,18,52,83,5,18,
dc.b 127,40,189,163,71,153,39,236,70,11,141,31,143,215,73,136,44,111,73,252,130,79,218,104,229,79,250,245,63,54,48,86,
dc.b 248,201,83,255,2,234,127,219,130,149,63,240,21,63,240,21,63,240,21,63,240,21,63,240,21,63,240,21,63,237,73,251,
dc.b 202,127,16,83,242,5,63,27,210,127,148,167,241,5,63,32,83,241,189,39,249,74,127,17,190,242,27,239,27,247,222,67,
dc.b 125,241,27,239,195,189,47,223,121,13,247,197,216,89,189,17,63,232,137,255,68,79,250,34,127,209,19,254,136,159,244,68,
dc.b 255,162,39,253,17,63,232,137,255,68,79,250,34,127,209,19,254,136,159,244,68,255,162,39,253,17,63,232,190,255,162,251,
dc.b 254,139,239,250,47,191,241,186,63,158,58,63,158,58,63,214,131,39,147,204,43,62,190,252,213,84,237,21,126,79,212,102,
dc.b 10,191,39,244,105,236,2,252,57,112,85,145,15,80,23,171,193,242,119,230,172,145,205,169,130,113,109,84,115,176,57,181,
dc.b 63,102,113,122,180,254,43,48,91,82,226,127,17,162,175,61,158,183,135,209,167,251,19,139,212,167,250,227,176,63,14,113,
dc.b 115,106,116,89,130,215,151,61,241,103,23,54,167,197,47,104,126,32,44,190,219,51,79,242,139,51,79,236,212,22,52,255,
dc.b 143,33,200,211,254,8,55,39,180,127,216,224,23,35,79,248,240,92,141,63,227,208,156,141,63,227,193,114,52,255,143,33,
dc.b 107,79,237,193,90,211,250,197,169,153,151,125,225,55,222,19,125,214,147,247,11,241,170,227,242,118,164,253,162,175,83,246,
dc.b 42,185,237,255,214,104,176,172,85,224,171,73,254,197,86,106,237,154,238,193,101,62,255,147,87,31,147,227,41,243,83,235,
dc.b 5,62,198,159,215,130,231,84,10,126,154,236,77,215,190,235,105,253,162,173,167,253,118,146,93,37,217,4,244,86,43,44,
dc.b 133,215,130,182,196,223,97,162,187,5,101,144,78,9,197,233,77,130,194,191,215,56,189,9,176,91,70,38,220,191,126,123,
dc.b 40,126,139,69,119,147,178,202,31,98,113,112,55,5,101,148,62,9,197,192,220,21,150,80,237,200,77,79,128,41,248,2,
dc.b 159,128,41,248,2,159,128,41,248,2,159,128,41,248,2,159,128,41,248,2,159,128,41,248,2,159,99,79,253,22,249,59,
dc.b 138,125,141,63,236,78,43,80,135,157,0,137,120,22,137,119,111,79,163,79,0,43,183,167,168,11,147,5,98,6,103,22,
dc.b 209,189,57,173,218,54,103,174,222,158,164,190,247,147,47,118,244,250,56,242,19,61,157,153,16,92,211,122,109,84,232,206,
dc.b 46,111,95,122,90,41,137,231,47,47,5,110,11,108,242,119,106,123,125,126,97,79,123,180,205,23,96,171,211,62,198,167,
dc.b 250,51,98,118,15,123,95,182,244,66,159,192,20,254,192,83,251,15,41,254,136,83,248,2,159,216,10,127,97,229,63,209,
dc.b 10,127,0,83,237,52,117,164,253,166,142,36,253,147,223,250,44,20,73,252,185,15,198,106,58,224,18,127,3,18,98,10,
dc.b 237,233,216,171,49,2,152,40,147,249,69,237,26,60,201,63,98,48,92,104,250,253,116,152,130,236,61,39,248,4,159,244,
dc.b 77,247,223,21,31,190,42,63,124,84,124,194,175,235,207,107,158,209,90,189,253,249,213,31,232,211,243,65,126,164,235,209,
dc.b 234,2,245,105,249,179,175,71,54,163,113,58,194,205,194,159,182,36,253,141,63,224,89,79,219,10,126,219,10,69,101,63,
dc.b 108,41,251,97,79,172,89,89,33,107,79,237,22,181,177,39,246,194,159,99,25,187,35,58,251,35,58,251,35,58,238,23,
dc.b 218,83,217,157,157,118,138,182,89,253,155,48,85,178,179,248,212,250,64,191,26,118,114,125,152,47,180,167,210,157,156,158,
dc.b 222,108,79,250,47,233,250,21,34,47,191,226,47,191,226,47,188,112,130,248,197,247,255,140,95,127,225,47,191,226,47,191,
dc.b 226,47,191,255,108,190,255,241,203,239,255,148,95,127,225,47,191,254,73,125,255,251,69,247,255,140,95,127,237,23,223,255,
dc.b 184,95,127,248,229,247,255,202,47,191,240,151,223,248,75,239,248,139,239,253,162,251,254,34,251,255,9,125,255,132,190,255,
dc.b 136,190,255,218,47,191,226,47,191,240,151,223,248,104,190,255,162,251,254,139,239,250,47,191,255,206,251,255,104,41,248,130,
dc.b 159,194,20,254,23,148,254,208,83,241,5,63,132,41,252,47,41,253,160,167,226,10,127,239,223,127,201,150,251,252,23,166,
dc.b 113,215,253,51,142,191,140,227,175,228,25,47,221,23,191,230,11,223,253,241,123,255,56,190,255,242,203,239,255,154,95,127,
dc.b 252,194,251,199,202,5,220,47,191,246,203,239,253,178,251,255,108,190,255,219,47,188,88,44,43,23,113,139,55,93,247,255,
dc.b 146,177,108,174,251,255,113,120,45,133,223,127,179,19,174,187,239,245,224,182,235,46,251,255,113,98,213,93,247,250,240,88,
dc.b 106,46,251,255,113,98,211,93,247,250,240,88,115,107,56,92,202,198,251,182,60,254,161,61,255,136,79,127,226,19,223,221,
dc.b 125,255,33,125,255,33,125,255,25,125,255,211,47,191,250,101,247,252,101,247,252,159,219,125,255,14,91,239,240,90,244,167,
dc.b 223,112,93,14,15,146,237,247,134,113,104,169,255,162,167,254,138,159,250,42,127,232,169,255,162,167,254,138,159,250,42,127,
dc.b 232,169,255,162,167,254,138,159,250,42,127,232,169,255,162,167,254,138,159,250,42,127,232,169,255,162,251,254,139,239,250,47,
dc.b 191,232,190,255,27,207,157,136,112,167,237,139,223,99,79,242,17,63,228,34,127,200,68,241,140,23,166,68,255,233,145,63,
dc.b 227,34,127,200,68,255,144,137,255,246,8,159,253,66,39,255,164,68,255,140,137,255,232,14,143,249,228,79,254,153,19,255,
dc.b 17,19,255,211,34,127,245,8,159,254,144,232,252,100,79,255,64,116,127,207,29,31,233,142,143,226,29,31,244,199,71,250,
dc.b 131,163,254,145,89,63,25,89,63,232,21,147,254,121,89,63,211,43,39,216,83,236,232,57,253,49,167,254,160,211,255,164,
dc.b 52,255,24,211,255,160,52,255,231,141,63,244,193,93,169,255,94,195,181,63,212,177,212,102,10,180,159,250,83,139,151,83,
dc.b 246,169,250,1,79,249,225,79,244,199,239,241,15,223,250,99,247,253,65,251,31,72,22,49,251,255,64,126,255,207,31,191,
dc.b 233,176,81,167,251,107,105,255,211,156,94,69,119,20,255,31,131,47,230,153,126,66,145,246,213,220,83,252,122,238,212,254,
dc.b 69,118,234,123,19,123,62,160,248,53,221,169,253,229,119,20,255,34,191,242,148,252,100,121,249,8,243,248,136,243,242,17,
dc.b 231,227,35,207,198,71,159,144,143,63,136,143,63,33,30,126,50,60,252,100,121,254,203,247,248,255,91,145,47,158,62,47,
dc.b 197,31,9,115,247,252,170,206,126,255,151,89,207,223,205,130,216,90,6,90,253,248,248,190,114,209,47,8,248,188,35,226,
dc.b 240,143,139,194,62,47,8,248,189,145,241,118,11,11,95,149,200,238,62,179,95,37,179,93,207,216,216,172,231,243,107,214,
dc.b 114,100,243,134,159,237,180,85,248,200,211,248,158,118,37,220,23,88,78,204,205,189,194,52,254,205,79,107,205,227,109,182,
dc.b 27,57,157,208,67,252,194,18,255,206,18,127,243,68,159,252,177,39,254,72,147,253,177,39,251,130,79,246,196,159,249,2,
dc.b 79,252,129,39,251,98,79,247,4,159,208,253,255,245,63,126,69,167,132,139,79,9,22,157,150,17,228,79,252,4,79,252,
dc.b 2,247,246,8,158,59,19,234,127,41,152,155,105,131,250,45,212,247,96,172,166,15,100,91,86,106,127,60,41,254,120,83,
dc.b 252,240,167,249,225,79,243,194,159,231,133,63,207,10,127,194,10,127,224,5,63,240,2,159,240,130,159,231,133,63,239,198,
dc.b 117,253,248,179,127,126,44,221,194,232,85,247,243,172,223,65,130,182,39,255,129,57,247,246,205,21,145,63,215,130,182,39,
dc.b 255,58,115,239,208,224,253,110,137,255,224,7,222,146,136,125,37,16,250,74,33,244,149,63,233,42,127,210,84,255,164,169,
dc.b 241,64,46,169,83,255,170,84,255,160,169,255,73,83,254,146,167,255,223,21,63,253,249,83,255,204,42,127,208,84,255,247,
dc.b 197,79,255,122,84,255,234,149,63,234,42,127,249,165,79,255,126,84,255,243,10,159,244,21,63,253,241,68,63,222,148,67,
dc.b 250,165,16,250,138,33,254,105,68,63,223,148,67,252,194,136,125,5,16,255,124,81,15,247,165,16,254,169,68,62,166,121,
dc.b 58,207,191,154,82,95,247,229,37,255,48,164,191,65,73,127,223,20,151,253,233,73,99,170,10,162,146,255,154,82,95,247,
dc.b 229,37,255,48,164,191,65,217,191,247,193,79,247,161,79,234,148,151,234,41,47,249,165,37,255,126,82,88,243,1,80,82,
dc.b 95,247,197,37,255,122,82,95,234,206,47,115,85,83,148,141,218,188,217,197,208,170,226,159,227,112,101,252,67,47,200,82,
dc.b 61,181,87,20,255,26,171,181,63,66,171,181,62,237,87,106,127,115,85,218,159,118,171,138,127,66,175,242,148,250,10,201,
dc.b 244,149,147,234,43,39,210,86,79,160,172,159,65,89,62,146,178,125,69,100,250,74,201,244,21,147,232,43,39,254,250,37,
dc.b 209,234,162,94,21,138,153,250,227,253,118,159,237,149,162,93,51,245,199,248,26,133,26,235,68,187,48,90,203,68,187,17,
dc.b 75,85,121,235,48,90,139,68,187,50,26,98,37,243,108,184,92,203,46,73,253,43,11,193,74,159,244,149,63,232,42,127,
dc.b 208,84,255,165,162,187,19,206,93,79,139,5,183,156,239,123,151,80,117,193,114,234,14,0,94,145,169,248,13,79,232,63,
dc.b 83,245,141,79,155,222,235,250,221,155,250,61,94,205,254,22,149,111,18,121,155,248,252,157,179,55,219,130,213,176,20,252,
dc.b 215,118,250,131,37,250,131,37,252,65,146,247,36,255,0,147,252,2,79,246,4,152,236,21,231,248,10,243,254,137,94,127,
dc.b 128,175,63,216,43,207,246,67,71,217,13,31,100,52,125,145,39,251,34,79,246,68,159,244,132,152,244,142,205,255,100,236,
dc.b 223,254,57,217,191,236,157,155,255,74,125,247,238,233,68,117,31,241,21,65,177,29,71,252,71,81,255,17,212,127,196,117,
dc.b 31,248,78,163,255,9,212,127,196,117,31,251,71,81,255,17,212,127,225,58,143,253,224,167,247,130,159,222,10,127,120,41,
dc.b 253,224,167,247,130,159,221,10,127,116,41,253,224,167,254,120,83,251,193,79,238,133,63,235,245,31,254,188,79,252,242,3,
dc.b 62,121,1,159,60,128,207,158,64,103,207,32,51,231,144,25,243,200,12,252,82,123,255,181,39,191,251,82,123,255,20,158,
dc.b 254,220,79,238,240,93,253,190,99,104,51,201,239,236,41,248,87,61,254,217,61,253,133,35,10,231,191,204,43,157,31,92,
dc.b 248,214,180,255,94,151,54,118,159,214,45,107,100,247,251,118,39,196,234,91,176,80,19,173,39,237,160,39,116,27,117,214,
dc.b 247,242,172,46,11,26,235,123,253,70,149,109,133,191,127,101,156,31,90,223,191,100,26,154,203,126,197,144,130,234,172,86,
dc.b 65,169,168,183,239,217,7,22,157,119,96,185,171,126,253,130,230,86,237,20,251,164,35,219,37,31,219,31,191,108,72,16,
dc.b 94,153,19,255,166,68,255,140,137,255,33,19,254,50,39,251,5,133,185,234,222,27,92,79,246,192,187,39,191,216,178,232,
dc.b 161,181,219,0,247,38,167,242,27,230,181,72,159,245,9,239,242,234,127,120,220,23,54,177,2,239,214,225,15,253,104,75,
dc.b 255,216,137,120,248,81,47,60,79,247,195,175,73,14,191,156,67,175,154,32,29,102,196,31,243,166,105,253,45,193,106,19,
dc.b 223,233,146,101,243,73,210,57,141,178,135,243,166,105,253,53,177,62,123,252,100,247,248,201,239,242,19,223,240,17,63,240,
dc.b 17,63,240,17,63,240,17,63,240,17,63,240,17,63,246,8,159,251,4,79,252,6,167,244,72,159,248,8,159,251,19,234,
dc.b 127,175,9,127,181,14,191,212,153,168,219,43,20,137,255,176,68,255,216,34,127,224,34,127,244,72,159,248,8,159,251,4,
dc.b 79,254,120,104,252,240,209,249,225,163,243,196,159,243,196,159,243,196,159,243,196,152,248,64,191,0,73,255,192,18,127,225,
dc.b 9,63,231,149,63,233,53,61,38,167,164,212,244,145,63,210,68,255,73,19,253,4,79,244,17,63,210,68,255,81,19,253,
dc.b 36,79,244,17,63,249,33,79,242,66,159,228,133,63,201,10,127,146,20,255,36,41,254,72,83,253,216,83,254,240,41,255,
dc.b 120,20,255,118,20,255,36,41,253,51,125,244,205,247,211,55,223,76,137,255,166,68,255,211,34,127,247,68,79,254,232,137,
dc.b 255,166,68,255,247,100,79,253,50,39,255,116,31,125,210,254,158,233,127,79,116,191,167,186,113,47,247,78,37,254,233,196,
dc.b 191,221,56,151,27,128,190,220,226,95,253,185,196,191,220,56,151,251,167,18,255,116,226,95,255,44,226,95,251,131,137,127,
dc.b 227,156,75,253,195,137,127,252,163,129,159,252,144,192,125,185,196,191,232,156,75,255,184,56,151,254,224,135,67,199,5,184,
dc.b 113,47,247,14,37,254,233,196,191,232,156,75,253,211,137,127,184,113,47,247,14,37,254,233,196,191,232,156,75,253,211,137,
dc.b 127,184,113,47,247,14,37,254,233,193,119,221,23,107,116,224,187,238,156,75,253,211,137,127,186,113,47,247,14,37,254,225,
dc.b 196,191,221,56,151,253,19,137,127,186,113,47,247,14,37,254,225,196,191,221,56,151,253,19,137,127,186,113,47,247,14,37,
dc.b 254,225,196,191,221,56,151,253,19,132,63,186,112,135,247,14,16,254,225,194,31,221,56,151,253,19,137,127,186,113,47,247,
dc.b 14,37,254,225,196,191,221,56,151,253,19,137,127,186,113,47,247,14,37,254,225,196,191,221,56,151,253,19,137,127,186,112,
dc.b 242,183,14,27,126,225,195,111,221,56,109,253,19,134,223,186,112,219,247,14,27,126,225,195,111,221,56,109,253,19,134,223,
dc.b 186,112,219,247,14,27,126,225,195,111,221,56,99,125,19,134,55,186,112,198,247,14,37,254,225,196,191,221,56,151,253,19,
dc.b 137,113,186,11,112,226,11,238,28,75,253,211,137,127,209,56,151,251,167,18,255,112,226,95,238,28,75,253,211,137,127,209,
dc.b 56,151,251,167,18,255,112,153,51,112,226,95,238,156,75,254,137,196,191,240,239,73,196,191,254,106,240,89,83,207,232,180,
dc.b 91,109,21,104,221,151,137,127,5,234,240,11,145,59,57,181,28,45,170,158,246,116,236,230,176,85,170,63,170,220,22,210,
dc.b 253,71,243,152,125,246,89,151,174,29,122,248,112,159,122,177,88,168,251,231,13,191,124,225,183,239,156,54,253,243,134,223,
dc.b 190,112,219,247,206,27,126,241,195,111,172,86,194,95,199,130,228,132,191,165,40,173,132,190,188,21,176,151,239,44,167,235,
dc.b 208,147,255,190,147,254,45,37,148,138,226,127,234,230,48,91,108,22,125,65,230,2,248,28,2,228,94,143,130,11,225,102,
dc.b 123,215,64,33,104,176,227,23,192,102,10,184,159,252,204,197,148,250,226,127,234,179,5,92,79,253,94,15,175,191,60,79,
dc.b 251,161,79,221,10,126,232,83,247,66,159,186,20,253,208,167,238,5,63,112,41,251,161,79,232,133,63,116,41,251,129,79,
dc.b 247,3,58,253,192,206,191,112,51,174,225,122,12,99,109,178,143,218,199,74,247,223,220,78,125,250,205,21,146,143,215,130,
dc.b 182,71,127,185,105,247,187,5,100,163,255,113,194,125,238,139,79,124,143,63,124,143,63,124,149,207,124,149,207,124,149,207,
dc.b 124,149,207,120,23,185,39,191,247,36,247,251,196,247,251,228,247,251,228,247,255,204,39,191,233,147,223,253,209,61,254,241,
dc.b 61,255,220,147,223,251,130,123,255,114,79,127,210,39,191,247,68,247,253,50,123,255,186,38,111,222,38,111,222,38,111,223,
dc.b 38,111,233,19,55,239,147,55,239,19,55,239,19,55,239,147,55,244,137,155,247,201,155,247,137,155,247,137,155,247,201,71,
dc.b 247,201,71,247,201,71,247,201,71,247,201,71,247,201,71,247,137,71,247,137,71,247,201,71,250,68,163,251,228,163,251,196,
dc.b 163,251,199,18,255,124,226,95,244,142,37,254,249,196,191,222,56,151,251,199,18,255,124,226,95,244,142,37,254,249,196,191,
dc.b 222,56,151,251,199,18,255,124,226,95,244,142,37,254,249,196,191,222,56,151,251,199,18,255,124,226,95,244,142,37,254,249,
dc.b 196,191,222,56,151,251,199,18,255,124,226,95,244,142,37,254,249,196,191,222,56,109,251,199,13,191,124,225,183,244,142,27,
dc.b 126,249,195,111,222,56,109,251,199,13,191,124,225,183,244,142,27,126,249,195,111,222,56,109,251,199,13,191,124,226,95,244,
dc.b 142,37,254,249,196,191,222,56,151,251,199,18,255,124,226,95,244,142,37,198,248,45,227,136,47,188,113,47,247,206,37,255,
dc.b 72,226,95,239,156,75,253,227,137,127,188,113,47,247,206,37,255,72,226,95,239,156,75,253,227,137,127,188,79,127,190,79,
dc.b 127,210,39,191,223,39,191,222,255,137,239,252,146,102,255,36,153,191,201,38,111,242,73,155,252,146,102,255,36,153,191,221,
dc.b 147,55,251,178,102,255,36,153,191,168,76,223,228,147,55,251,178,102,253,9,63,254,196,159,247,116,146,79,127,73,61,253,
dc.b 36,247,244,147,223,210,79,127,73,61,253,4,247,244,19,223,210,79,127,81,61,253,36,247,244,19,223,253,114,159,211,25,
dc.b 215,211,25,215,211,25,215,211,40,93,244,202,23,125,50,133,223,186,40,93,251,162,133,223,76,161,119,247,101,11,190,153,
dc.b 66,239,221,112,209,183,249,197,43,63,156,82,179,186,45,58,73,92,233,29,241,73,43,157,36,174,116,2,234,147,223,245,
dc.b 73,239,232,39,191,164,158,254,146,209,255,223,22,143,253,249,104,255,204,45,31,208,90,63,247,196,121,254,244,180,127,213,
dc.b 45,31,212,90,63,243,75,71,254,252,180,127,230,22,59,232,44,119,208,88,239,164,177,223,81,99,190,146,199,125,5,142,
dc.b 250,11,29,244,150,59,234,44,119,210,88,239,160,177,223,65,99,191,217,145,223,234,77,78,219,101,98,146,143,208,74,63,
dc.b 65,40,253,36,163,245,18,143,210,74,63,65,40,253,5,121,250,74,243,245,21,231,233,43,207,208,87,159,160,175,63,73,
dc.b 94,126,162,188,253,37,121,250,10,243,244,21,231,233,47,191,212,95,127,164,190,255,65,125,254,130,251,253,37,247,250,139,
dc.b 239,244,151,223,232,47,191,208,95,127,164,190,255,81,125,254,146,251,253,5,205,250,11,155,244,151,55,234,46,111,210,92,
dc.b 223,160,185,191,65,115,126,146,230,253,69,205,250,75,155,244,23,55,236,41,248,61,100,75,163,42,37,201,239,233,39,23,
dc.b 168,158,254,146,123,250,9,239,232,39,191,164,158,254,162,123,250,73,239,232,39,191,160,158,254,146,123,250,137,239,233,39,
dc.b 191,160,158,254,130,123,250,73,239,233,39,191,164,158,254,146,123,251,133,203,168,60,224,93,99,83,249,198,167,165,250,159,
dc.b 202,53,61,190,246,42,62,122,159,255,56,169,255,230,149,63,238,153,190,146,102,250,73,155,232,38,111,160,225,183,210,112,
dc.b 219,234,56,109,244,156,54,251,10,126,191,224,158,255,178,26,62,200,104,251,33,163,236,147,223,246,73,239,251,36,247,254,
dc.b 145,61,199,164,116,224,251,39,78,15,241,206,156,31,100,233,193,250,70,251,196,106,124,70,167,196,106,124,68,247,248,137,
dc.b 239,241,11,223,194,79,127,194,79,127,136,158,255,180,79,127,136,158,255,133,158,79,235,82,95,238,245,250,143,242,167,255,
dc.b 154,84,255,184,167,247,130,159,221,10,127,179,196,107,227,169,171,116,247,248,78,37,254,201,196,191,217,56,151,248,78,37,
dc.b 255,56,226,95,225,56,151,251,39,18,255,69,247,255,173,125,255,254,87,139,244,92,223,209,196,191,209,196,191,209,196,191,
dc.b 209,196,191,209,196,191,209,196,191,209,196,191,255,127,18,254,131,201,208,121,58,79,39,80,158,116,137,231,64,158,116,9,
dc.b 217,72,42,132,75,164,79,58,4,243,160,79,58,68,243,168,79,58,68,243,160,79,58,4,243,164,79,58,132,243,164,79,
dc.b 58,31,1,157,34,121,212,47,125,47,132,190,128,167,210,20,250,130,159,75,225,47,160,41,244,133,62,160,167,210,248,75,
dc.b 232,18,126,145,39,234,18,126,145,39,232,18,126,129,39,233,18,98,160,84,137,63,64,147,244,9,63,72,147,245,5,62,
dc.b 144,167,208,20,250,3,71,72,104,234,13,29,33,156,163,40,161,163,164,52,117,62,39,250,6,159,208,52,254,145,167,245,
dc.b 62,39,250,6,159,208,52,254,145,167,245,62,39,250,6,159,208,242,159,83,226,127,160,41,244,60,167,212,248,159,232,10,
dc.b 125,15,41,245,101,137,254,244,75,229,223,116,136,151,80,137,116,189,18,253,116,82,243,68,12,185,18,233,122,37,208,34,
dc.b 93,34,37,212,34,93,47,68,187,133,229,205,130,255,92,79,245,13,56,164,21,3,79,238,23,46,160,243,166,71,92,34,
dc.b 100,200,159,236,105,253,29,132,243,242,166,193,108,9,147,177,248,35,207,137,63,80,147,244,137,63,67,210,126,145,39,252,
dc.b 41,49,5,67,210,126,145,39,234,156,94,209,163,181,29,121,205,70,8,147,254,20,152,190,81,250,132,159,164,73,251,141,
dc.b 31,180,168,246,176,102,189,79,75,205,31,148,26,63,40,52,126,88,104,249,48,90,194,251,126,234,163,251,124,196,189,123,
dc.b 232,121,79,168,41,244,189,123,232,121,79,168,41,244,133,63,217,103,95,66,171,150,111,161,85,204,235,241,170,187,122,123,
dc.b 106,169,5,118,244,241,170,204,64,166,10,184,159,249,119,221,37,43,58,138,86,116,148,172,232,41,89,208,82,179,164,165,
dc.b 103,81,74,178,144,84,20,172,232,41,89,210,82,179,168,165,103,73,74,206,130,149,157,5,43,58,74,86,117,20,172,233,
dc.b 41,89,208,82,179,161,252,39,58,138,86,116,148,172,232,41,215,208,83,175,164,167,95,81,78,190,146,157,125,5,58,250,
dc.b 10,117,244,148,235,234,41,215,210,83,175,160,167,95,65,78,190,146,157,125,80,106,7,223,168,56,155,196,18,127,196,156,
dc.b 251,241,224,185,15,189,80,111,192,227,239,212,156,248,81,194,47,18,115,239,155,87,76,21,167,223,191,252,90,159,181,77,
dc.b 15,41,245,65,196,13,31,33,79,232,55,136,229,152,209,245,3,71,212,13,31,136,26,63,16,52,119,82,95,160,169,255,
dc.b 73,83,254,162,167,253,37,79,250,10,159,244,21,63,233,42,127,212,84,255,164,169,255,65,83,254,130,167,253,37,79,250,
dc.b 130,159,72,83,232,10,125,15,41,245,5,62,144,167,208,20,250,30,83,234,10,125,33,79,160,41,252,187,238,147,125,212,
dc.b 111,186,94,137,119,111,190,191,10,34,120,81,74,244,75,160,68,186,68,75,168,68,186,94,137,119,10,34,39,133,20,186,
dc.b 245,18,244,75,160,68,186,68,75,169,252,75,250,14,205,199,40,169,59,55,245,29,155,250,78,205,253,7,102,254,131,179,
dc.b 127,73,217,191,168,212,244,157,155,250,14,205,253,29,127,239,63,199,71,245,6,159,220,83,232,122,79,242,148,250,130,159,
dc.b 72,83,232,122,79,242,148,250,130,159,72,147,244,61,39,233,18,126,161,39,233,18,126,135,164,253,34,79,212,36,253,34,
dc.b 79,209,56,189,163,71,208,170,135,164,255,174,147,17,41,162,79,208,244,159,164,169,255,110,244,149,63,236,21,218,159,186,
dc.b 11,53,79,252,11,169,255,113,163,249,185,141,242,114,167,254,81,126,139,48,88,96,175,61,82,154,197,242,217,130,195,5,
dc.b 103,85,6,253,229,239,161,229,62,160,167,210,245,239,161,229,62,160,167,210,245,239,185,39,253,166,117,250,251,238,147,125,
dc.b 212,245,155,161,251,238,147,125,213,194,125,244,64,103,254,168,12,255,129,209,247,36,253,239,223,168,126,253,47,137,254,135,
dc.b 191,126,161,251,244,190,39,250,30,253,250,158,238,62,88,159,232,123,247,252,53,62,47,137,254,135,191,126,162,39,250,95,
dc.b 19,255,45,79,251,138,124,169,241,199,225,111,137,255,150,167,253,36,79,245,17,63,210,248,159,232,121,79,169,241,231,208,
dc.b 248,75,249,74,125,79,143,62,135,194,95,113,79,246,163,123,245,228,203,168,68,186,94,137,116,62,76,186,132,75,165,232,
dc.b 151,67,228,203,168,68,186,94,137,116,62,76,186,132,75,165,232,151,112,188,190,24,158,60,49,67,95,19,253,4,79,244,
dc.b 145,63,212,68,255,75,226,127,184,82,39,143,12,80,218,37,31,255,252,163,254,210,163,211,89,47,137,254,227,71,229,125,
dc.b 200,161,188,215,65,15,124,79,255,253,148,127,161,85,68,79,244,190,39,255,12,80,210,39,250,136,159,233,124,79,244,28,
dc.b 39,58,78,19,157,71,9,206,147,132,231,65,194,115,160,225,57,210,112,155,42,5,73,194,115,160,225,57,208,112,156,233,
dc.b 56,78,117,28,39,58,78,19,157,7,9,206,131,132,231,73,194,115,168,225,57,248,76,4,225,57,208,112,156,233,56,78,
dc.b 117,15,48,245,225,215,231,137,63,207,10,125,220,54,250,142,27,125,39,13,190,131,134,223,65,195,111,164,225,183,212,112,
dc.b 219,233,56,109,244,28,54,250,14,27,125,39,241,183,252,46,38,159,198,223,160,254,54,253,7,241,183,233,63,141,191,81,
dc.b 252,109,138,65,80,127,27,126,131,248,219,244,159,198,223,168,254,54,253,33,79,160,41,244,118,10,127,161,143,104,200,243,
dc.b 238,254,54,253,7,8,99,148,84,156,33,250,142,16,253,39,8,126,131,137,127,65,196,191,164,226,95,212,113,47,233,56,
dc.b 151,244,28,75,250,14,37,253,39,18,254,163,137,127,73,196,191,160,226,95,208,113,47,249,74,125,65,79,164,41,244,5,
dc.b 62,135,148,250,130,159,72,83,232,10,125,15,41,245,5,62,144,167,208,253,247,73,190,234,17,46,151,162,93,219,211,232,
dc.b 253,196,82,245,156,129,151,162,93,2,37,210,34,93,66,37,210,244,75,187,122,114,162,151,169,79,133,153,23,162,93,194,
dc.b 230,245,247,164,226,95,210,127,37,226,140,162,159,201,127,164,254,75,253,71,242,95,233,63,146,255,65,252,151,251,133,234,
dc.b 240,167,157,71,242,95,233,63,146,255,65,252,136,58,30,83,234,10,125,33,79,161,233,63,202,83,234,10,125,33,79,161,
dc.b 233,63,202,83,234,18,127,195,77,26,244,159,164,73,250,132,159,240,164,197,233,63,72,147,245,9,63,114,83,123,38,142,
dc.b 196,26,186,66,59,210,126,144,85,9,63,72,147,244,118,18,127,197,164,237,65,213,204,114,163,245,115,28,168,254,100,200,
dc.b 165,95,18,254,227,71,240,115,28,104,254,22,97,0,135,49,218,187,224,51,5,92,79,30,96,46,171,48,88,96,172,207,
dc.b 11,223,158,39,250,94,189,244,60,167,212,20,250,94,189,244,60,167,212,20,250,94,189,254,203,58,253,10,136,126,251,240,
dc.b 239,75,214,110,135,239,186,67,239,83,227,207,161,243,223,210,74,231,83,229,115,161,243,223,210,74,231,83,229,115,161,243,
dc.b 223,210,74,231,83,229,115,161,243,223,210,74,231,83,229,115,161,243,223,232,148,127,255,210,143,251,146,123,141,210,124,110,
dc.b 133,84,62,123,250,73,239,234,39,191,164,158,254,135,207,127,73,61,253,68,247,246,228,63,249,40,254,138,65,127,227,68,
dc.b 190,191,94,123,136,42,137,239,233,39,191,161,243,223,210,79,127,118,174,244,31,65,159,215,158,254,146,92,122,159,73,126,
dc.b 135,164,255,41,79,169,244,151,232,122,79,242,148,250,159,73,126,135,164,253,34,79,212,250,75,244,61,39,249,105,51,84,
dc.b 250,75,244,61,39,254,188,216,126,202,163,218,193,154,245,63,160,243,71,214,225,21,218,131,174,26,62,90,43,156,31,241,
dc.b 78,191,217,103,93,127,37,187,238,178,47,201,190,255,34,155,183,167,197,166,128,89,183,165,159,37,130,152,42,255,220,127,
dc.b 202,125,244,90,63,209,104,255,68,163,250,45,31,232,180,127,162,209,254,139,71,250,45,31,255,186,209,255,235,82,65,125,
dc.b 226,144,85,23,223,233,47,191,208,95,127,160,190,255,73,125,254,162,251,253,37,247,250,11,239,244,23,223,235,243,88,127,
dc.b 238,209,253,235,55,67,247,223,42,209,84,245,155,163,177,190,253,170,117,244,214,67,211,206,167,180,255,195,72,46,244,243,
dc.b 169,237,63,229,165,103,67,211,206,167,180,255,150,149,157,15,79,58,158,211,255,252,211,175,189,167,244,61,39,249,106,127,
dc.b 212,246,159,209,148,87,212,255,169,237,63,255,137,163,190,167,253,79,105,255,47,39,254,135,212,255,169,237,63,229,228,255,
dc.b 208,250,159,255,249,116,125,238,59,169,237,63,161,239,139,143,132,245,209,74,244,75,161,245,63,234,123,79,249,81,46,135,
dc.b 212,255,169,237,63,229,68,186,31,83,254,167,180,254,140,173,56,190,167,253,79,105,253,3,79,232,125,79,250,158,211,250,
dc.b 6,159,220,47,250,186,62,250,138,244,61,251,245,61,167,254,20,152,189,251,245,61,167,247,63,155,218,52,126,189,121,250,
dc.b 30,253,255,244,243,39,253,165,71,245,234,127,212,251,239,244,101,21,245,63,234,125,247,255,174,232,255,101,157,125,10,168,
dc.b 125,79,250,159,125,254,130,167,253,29,138,159,240,
musix_pac_end: 
