;
; file generated by: F:\HL970519\MAKE_ANI.C
;

EXPORT ani_base

DATA

dc.b 30,112,120,
ani_base:

dc.b 38,113,121,

dc.b 39,114,122,

dc.b 40,113,123,

dc.b 41,112,123,

dc.b 42,119,122,

dc.b 43,118,121,

dc.b 44,119,120,

dc.b 59,112,120,

dc.b 44,113,121,

dc.b 43,114,122,

dc.b 42,113,123,

dc.b 41,112,123,

dc.b 40,119,122,

dc.b 39,118,121,

dc.b 38,119,120,
