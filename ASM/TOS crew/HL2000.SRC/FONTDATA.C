/*
// file generated by: F:\HL970519\MAKEFONT.C
*/

#include "hland.h"
extern const byte font[2048UL] = {
124,130,130,130,130,130,124,0,16,48,16,16,16,16,56,0,
124,130,130,12,48,64,254,0,60,66,2,28,2,130,124,0,
4,12,20,36,68,254,4,0,254,128,252,2,2,130,124,0,
124,128,252,130,130,130,124,0,254,2,2,4,8,16,16,0,
124,130,124,130,130,130,124,0,124,130,130,130,126,2,124,0,
24,60,60,60,126,16,56,16,24,28,22,16,16,112,240,96,
240,192,254,216,222,24,24,0,240,192,223,219,255,30,27,0,
5,5,5,13,13,25,121,113,160,160,160,176,176,152,158,142,
124,198,198,0,198,198,124,0,6,6,6,0,6,6,6,0,
124,6,6,124,192,192,124,0,124,6,6,124,6,6,124,0,
198,198,198,124,6,6,6,0,124,192,192,124,6,6,124,0,
124,192,192,124,198,198,124,0,124,6,6,0,6,6,6,0,
124,198,198,124,198,198,124,0,124,198,198,124,6,6,124,0,
0,0,60,6,126,102,60,0,120,96,120,96,126,24,30,0,
7,15,31,24,24,16,30,23,240,248,236,4,4,4,60,84,
17,11,13,6,7,46,57,56,4,40,216,40,208,16,224,0,
0,0,0,0,0,0,0,0,16,16,16,16,16,0,16,0,
68,68,68,0,0,0,0,0,0,68,254,68,68,254,68,0,
16,62,80,60,18,124,16,0,0,98,100,8,16,38,70,0,
56,68,40,80,138,140,118,0,16,16,16,0,0,0,0,0,
14,16,16,16,16,16,14,0,112,8,8,8,8,8,112,0,
0,66,36,255,36,66,0,0,0,16,16,124,16,16,0,0,
0,0,0,0,0,32,32,64,0,0,0,126,0,0,0,0,
0,0,0,0,0,24,24,0,0,2,4,8,16,32,64,0,
60,70,74,82,98,66,60,0,16,48,16,16,16,16,56,0,
60,66,2,4,24,32,126,0,126,4,24,4,2,66,60,0,
12,20,36,68,126,4,4,0,126,64,124,2,2,66,60,0,
60,64,64,124,66,66,60,0,126,2,4,8,16,16,16,0,
60,66,66,60,66,66,60,0,60,66,66,62,2,4,56,0,
0,16,16,0,16,16,0,0,0,16,16,0,16,16,32,0,
4,8,16,32,16,8,4,0,0,0,126,0,0,126,0,0,
32,16,8,4,8,16,32,0,60,66,2,4,8,0,8,0,
60,102,110,106,110,96,62,0,24,36,66,66,126,66,66,0,
124,66,66,124,66,66,124,0,60,66,64,64,64,66,60,0,
120,68,66,66,66,68,120,0,126,64,64,120,64,64,126,0,
126,64,64,120,64,64,64,0,62,64,64,78,66,66,62,0,
66,66,66,126,66,66,66,0,56,16,16,16,16,16,56,0,
2,2,2,2,2,66,60,0,68,72,80,112,72,68,66,0,
64,64,64,64,64,64,126,0,198,170,146,146,130,130,130,0,
66,98,82,74,70,66,66,0,60,66,66,66,66,66,60,0,
124,66,66,124,64,64,64,0,60,66,66,66,82,76,54,0,
124,66,66,124,72,68,66,0,60,66,64,60,2,66,60,0,
254,16,16,16,16,16,16,0,66,66,66,66,66,66,62,0,
66,66,66,66,66,36,24,0,130,130,146,146,170,198,130,0,
66,66,36,24,36,66,66,0,130,130,130,124,16,16,16,0,
126,4,8,16,32,64,126,0,30,16,16,16,16,16,30,0,
64,32,16,8,4,2,0,0,120,8,8,8,8,8,120,0,
16,40,68,130,0,0,0,0,0,0,0,0,0,0,254,0,
0,64,32,16,0,0,0,0,0,0,60,2,62,66,62,0,
64,64,124,66,66,66,124,0,0,0,60,64,64,64,60,0,
2,2,62,66,66,66,62,0,0,0,60,66,126,64,60,0,
28,32,124,32,32,32,32,0,0,0,62,66,66,62,2,124,
64,64,124,66,66,66,66,0,16,0,48,16,16,16,56,0,
16,0,16,16,16,16,16,96,64,64,72,80,112,72,68,0,
48,16,16,16,16,16,56,0,0,0,236,146,146,130,130,0,
0,0,124,66,66,66,66,0,0,0,60,66,66,66,60,0,
0,0,124,66,66,66,124,64,0,0,62,66,66,66,62,2,
0,0,124,66,64,64,64,0,0,0,62,64,60,2,124,0,
0,16,124,16,16,16,14,0,0,0,66,66,66,66,62,0,
0,0,66,66,66,36,24,0,0,0,130,130,146,146,108,0,
0,0,66,36,24,36,66,0,0,0,66,66,66,62,2,124,
0,0,126,4,24,32,126,0,14,16,16,32,16,16,14,0,
16,16,16,16,16,16,16,16,112,8,8,4,8,8,112,0,
0,96,146,146,12,0,0,0,0,16,40,68,68,130,254,0,
0,60,102,96,102,60,8,56,102,0,0,102,102,102,62,0,
12,24,0,60,126,96,60,0,24,102,0,60,6,126,62,0,
102,0,60,6,62,102,62,0,48,24,0,60,6,126,62,0,
24,24,0,60,6,126,62,0,0,0,60,96,96,60,8,24,
24,102,0,60,126,96,60,0,102,0,60,102,126,96,60,0,
48,24,0,60,126,96,60,0,102,0,0,56,24,24,60,0,
24,102,0,56,24,24,60,0,96,48,0,56,24,24,60,0,
102,0,24,60,102,126,102,0,24,0,24,60,102,126,102,0,
12,24,126,96,124,96,126,0,0,0,126,27,127,216,126,0,
63,120,216,222,248,216,223,0,24,102,0,60,102,102,60,0,
102,0,0,60,102,102,60,0,48,24,0,60,102,102,60,0,
24,102,0,102,102,102,62,0,48,24,0,102,102,102,62,0,
102,0,102,102,102,62,6,124,102,0,60,102,102,102,60,0,
102,0,102,102,102,102,62,0,24,24,60,96,96,60,24,24,
28,58,48,124,48,48,126,0,102,102,60,24,60,24,24,0,
28,54,102,124,102,102,124,96,30,48,124,48,48,48,96,0,
12,24,0,60,6,126,62,0,12,24,0,56,24,24,60,0,
12,24,0,60,102,102,60,0,12,24,0,102,102,102,62,0,
52,88,0,124,102,102,102,0,52,88,0,102,118,110,102,0,
0,60,6,62,102,62,0,60,0,60,102,102,102,60,0,60,
0,24,0,24,48,96,102,60,0,0,0,62,48,48,48,0,
0,0,0,124,12,12,12,0,198,204,216,54,107,195,134,15,
198,204,216,54,110,214,159,6,0,24,0,24,24,24,24,24,
27,54,108,216,108,54,27,0,216,108,54,27,54,108,216,0,
52,88,0,60,6,126,62,0,52,88,0,60,102,102,60,0,
2,60,102,110,118,102,60,64,0,2,60,110,118,102,60,64,
0,0,126,219,223,216,126,0,127,216,216,222,216,216,127,0,
48,24,0,24,60,102,126,102,52,88,0,24,60,102,126,102,
52,88,60,102,102,102,102,60,102,0,0,0,0,0,0,0,
12,24,48,0,0,0,0,0,0,16,56,16,16,16,0,0,
122,202,202,202,122,10,10,10,126,195,189,177,177,189,195,126,
126,195,189,165,185,173,195,126,241,91,95,85,81,0,0,0,
102,0,230,102,102,246,6,28,246,102,102,102,102,246,6,28,
0,102,118,60,110,102,0,0,0,124,12,12,12,126,0,0,
0,30,6,14,30,54,0,0,0,126,12,12,12,12,0,0,
0,124,6,102,102,102,0,0,0,28,12,12,12,12,0,0,
0,30,12,6,6,6,0,0,0,126,54,54,54,54,0,0,
96,110,102,102,102,126,0,0,0,60,12,12,0,0,0,0,
0,62,6,6,6,62,0,0,96,126,6,6,6,14,0,0,
0,108,62,102,102,110,0,0,0,28,12,12,12,60,0,0,
0,62,54,54,54,28,0,0,0,54,54,54,54,126,0,0,
0,126,102,118,6,126,0,0,0,102,102,60,14,126,0,0,
0,62,6,54,54,52,48,0,0,120,12,12,12,12,0,0,
0,214,214,214,214,254,0,0,0,124,108,108,108,236,0,0,
0,28,12,12,12,12,12,0,0,62,6,6,6,6,6,0,
0,254,102,102,102,126,0,0,0,126,102,118,6,6,6,0,
0,54,54,28,12,12,12,0,14,27,60,102,102,60,216,112,
0,16,56,108,198,130,0,0,102,247,153,153,239,102,0,0,
0,0,118,220,200,220,118,0,28,54,102,124,102,102,124,96,
0,254,102,98,96,96,96,248,0,0,254,108,108,108,108,72,
254,102,48,24,48,102,254,0,0,30,56,108,108,108,56,0,
0,0,108,108,108,108,127,192,0,0,126,24,24,24,24,16,
60,24,60,102,102,60,24,60,0,60,102,126,102,102,60,0,
0,60,102,102,102,36,102,0,28,54,120,220,204,236,120,0,
12,24,56,84,84,56,48,96,0,16,124,214,214,214,124,16,
62,112,96,126,96,112,62,0,60,102,102,102,102,102,102,0,
0,126,0,126,0,126,0,0,24,24,126,24,24,0,126,0,
48,24,12,24,48,0,126,0,12,24,48,24,12,0,126,0,
0,14,27,27,24,24,24,24,24,24,24,24,216,216,112,0,
24,24,0,126,0,24,24,0,0,50,76,0,50,76,0,0,
56,108,56,0,0,0,0,0,56,124,56,0,0,0,0,0,
0,0,0,0,24,24,0,0,0,0,15,24,216,112,48,0,
56,108,108,108,108,0,0,0,56,108,24,48,124,0,0,0,
120,12,56,12,120,0,0,0,0,254,0,0,0,0,0,0,
};
