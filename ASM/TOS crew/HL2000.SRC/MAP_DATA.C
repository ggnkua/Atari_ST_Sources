/*
// file generated by: F:\HL001128\DATA\MAKE_MAP.C
*/

extern signed char game_map[54000UL] = {
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,81,16,81,81,81,16,16,81,16,16,81,81,16,16,81,
16,16,81,16,16,16,16,16,81,16,16,16,81,16,16,81,
16,16,16,81,81,16,16,16,16,16,16,81,16,81,16,81,
16,81,16,16,81,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,4,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,4,4,4,16,4,4,
4,16,4,4,4,16,4,4,4,16,4,4,4,16,4,4,
4,16,4,4,4,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,81,16,16,16,
81,16,16,81,16,81,16,81,16,81,16,16,16,81,16,81,
16,16,16,16,81,16,16,81,16,81,16,81,81,81,16,81,
16,81,16,16,16,16,81,16,16,81,16,81,16,16,81,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,4,16,16,16,16,
16,16,16,16,16,16,16,16,4,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,4,16,16,16,16,4,16,16,4,16,
4,16,4,16,16,16,4,16,16,16,4,16,16,16,4,16,
4,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,81,16,16,81,16,16,81,
81,81,16,81,16,16,16,81,16,81,16,81,16,16,16,16,
81,16,16,81,81,81,16,81,16,81,16,81,16,81,16,16,
16,16,16,81,16,81,16,81,16,16,16,81,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,4,16,16,16,16,16,16,16,16,
16,16,16,16,4,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,4,22,31,22,4,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,4,4,4,16,16,4,16,16,4,16,4,16,4,4,
4,16,4,4,4,16,4,4,4,16,4,4,4,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,81,16,16,16,81,16,16,81,16,81,16,81,
16,16,16,81,16,16,81,16,16,16,16,16,81,81,16,81,
16,81,16,81,16,81,16,81,81,16,16,16,16,16,81,16,
16,16,81,16,16,81,16,16,81,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,4,16,16,16,16,16,16,16,16,16,16,16,16,
4,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,4,14,32,14,4,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
4,16,16,4,16,16,4,16,4,16,16,16,4,16,16,16,
4,16,4,16,16,16,4,4,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,4,
16,16,16,16,16,16,16,16,16,16,16,16,4,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,4,14,33,14,4,17,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,4,4,4,16,16,4,
16,16,4,4,4,16,4,4,4,16,4,4,4,16,4,4,
4,16,4,16,4,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,4,4,4,4,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,4,4,4,4,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,4,4,4,
4,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,4,16,16,16,16,
16,16,16,16,16,16,16,16,4,4,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,4,
4,4,4,4,17,17,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,4,4,4,4,4,4,4,4,4,4,4,4,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,4,4,4,4,4,4,4,4,4,4,4,
4,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,4,4,4,4,4,4,4,4,4,
4,4,4,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,4,16,16,16,16,16,16,16,16,
16,16,16,16,4,4,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,4,4,4,4,4,4,4,
4,4,4,4,4,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,16,16,16,16,16,16,16,16,16,16,4,4,
4,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,4,4,22,31,22,31,22,31,22,31,22,31,22,31,22,
31,14,14,14,14,14,14,14,14,14,14,22,31,22,31,22,
31,22,31,22,31,22,31,22,31,22,31,22,31,22,31,22,
31,22,31,22,31,22,31,22,31,22,31,22,31,22,31,22,
31,22,31,22,31,22,31,22,31,22,31,22,31,22,31,22,
4,4,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,4,4,22,31,22,31,22,31,22,31,22,31,22,
31,22,31,14,14,14,14,14,14,4,14,14,14,22,31,22,
31,22,31,22,31,22,31,22,31,22,31,22,31,22,31,22,
31,22,31,22,31,22,31,22,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,31,22,31,22,
31,22,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,4,4,22,31,22,31,22,31,22,31,22,
31,22,31,22,31,14,14,14,14,14,14,4,4,4,4,22,
31,22,31,22,31,22,31,22,31,22,31,22,31,22,31,22,
31,22,31,22,31,22,31,22,31,22,31,22,31,22,31,22,
31,22,31,22,31,22,31,22,31,22,31,22,31,22,31,22,
31,22,31,22,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,16,16,16,16,16,16,16,16,16,16,16,16,
4,4,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,4,4,22,31,22,31,22,31,22,
31,22,31,22,31,14,14,14,14,14,14,14,14,14,14,14,
14,14,31,22,31,22,31,22,31,22,31,22,31,22,31,22,
31,22,31,22,31,22,31,22,31,22,31,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
16,16,16,16,16,16,16,16,16,16,4,4,4,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,4,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,4,4,4,4,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,4,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,4,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,4,4,4,
4,4,4,4,4,4,4,4,14,14,14,14,14,14,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
4,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,4,4,4,4,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,4,
16,16,16,16,16,16,16,16,16,16,16,16,4,4,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,4,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,16,16,16,16,
16,16,16,16,16,16,4,4,4,31,22,31,22,31,22,31,
22,31,22,31,22,31,22,31,22,31,22,31,22,31,22,31,
22,31,22,22,31,22,31,22,22,31,22,31,22,31,22,31,
22,22,31,22,31,22,22,31,22,31,22,31,22,31,22,31,
22,31,22,31,22,31,22,31,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,120,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,45,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,22,31,22,31,22,31,22,31,
22,31,22,31,22,22,31,22,31,22,22,31,22,31,22,31,
22,31,22,22,31,22,31,22,22,31,22,31,22,31,22,31,
22,31,22,31,22,31,22,31,22,31,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,4,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,4,4,4,4,4,4,4,
4,4,4,4,14,14,14,14,14,14,22,31,22,31,22,31,
22,31,22,31,22,31,22,22,31,22,31,22,22,31,22,31,
22,31,22,31,22,22,31,22,31,22,22,31,22,31,22,31,
22,31,22,31,22,31,22,31,22,31,22,31,28,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,4,4,4,4,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,4,31,22,22,31,
22,31,22,31,22,31,22,22,4,4,31,22,22,31,22,31,
22,31,22,31,22,31,22,31,22,31,22,31,22,31,28,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,16,16,16,16,16,16,16,16,
16,16,4,4,4,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,45,45,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,120,14,14,14,120,14,14,14,120,14,14,14,4,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,4,4,4,4,4,4,4,4,4,4,4,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,28,14,14,14,14,14,14,14,
14,14,14,120,14,14,14,120,14,14,14,120,14,14,14,4,
4,4,4,14,14,14,14,14,14,14,14,14,14,14,14,14,
120,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,4,14,14,14,14,14,14,14,14,
14,14,14,14,4,4,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,28,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,16,16,16,16,16,16,16,16,16,16,4,4,
4,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,45,45,45,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,120,14,14,14,120,
14,14,14,120,14,14,14,120,14,4,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,4,4,4,4,4,4,4,4,4,4,4,14,120,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,28,14,14,14,14,14,14,14,14,120,14,14,
14,120,14,14,14,120,14,14,14,120,14,4,4,4,4,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,120,4,14,14,14,14,14,14,14,14,14,14,14,14,
4,4,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,28,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
16,16,16,16,16,16,16,16,16,16,4,4,4,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,66,67,66,67,66,67,14,14,
30,30,14,14,14,14,14,14,14,24,66,67,46,47,47,47,
47,46,14,14,14,14,14,14,45,45,45,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,90,91,92,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,30,30,30,30,30,30,30,30,30,30,
30,30,30,30,30,4,14,14,14,14,66,67,66,67,66,67,
66,67,66,67,21,47,47,47,47,47,47,47,47,47,47,47,
47,47,47,47,47,14,14,14,14,14,14,14,14,4,4,4,
4,4,4,4,4,4,4,4,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
28,14,14,14,14,14,14,14,30,30,30,30,30,30,30,30,
30,30,30,30,30,30,30,4,4,4,4,14,14,14,14,14,
14,14,14,14,14,14,21,47,47,47,47,47,47,47,47,47,
47,47,14,14,14,14,14,60,24,66,67,66,67,66,67,24,
66,67,66,67,66,67,66,67,66,67,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,4,
14,14,14,14,14,14,14,14,14,14,14,14,4,4,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,28,14,14,14,14,14,14,14,30,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,16,16,16,16,
16,16,16,16,16,16,4,4,4,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,12,
6,6,2,2,2,2,2,2,2,2,2,2,2,2,2,2,
2,2,4,3,3,3,3,3,3,3,3,3,3,3,11,14,
14,14,14,45,45,45,45,45,45,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,93,94,20,47,47,47,47,47,47,
47,47,21,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,12,6,6,2,2,2,2,2,2,2,2,2,2,2,2,
2,4,6,6,3,3,3,3,3,3,3,3,3,3,3,0,
0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
1,0,1,14,14,14,14,14,14,4,4,4,4,4,4,4,
4,4,4,4,47,47,47,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,28,14,14,14,
14,14,14,12,6,6,2,2,2,2,2,2,2,2,2,2,
2,2,2,4,4,4,4,14,14,14,14,14,14,14,14,14,
14,12,1,1,0,0,0,0,0,0,0,0,0,0,0,0,
0,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,7,6,11,14,0,0,0,0,0,0,0,0,
0,0,4,4,4,4,4,4,4,4,4,4,14,14,14,14,
14,14,14,14,120,14,14,14,4,4,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,28,14,
14,14,14,14,14,12,6,2,2,2,2,2,2,11,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
120,120,120,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,16,16,16,16,16,16,16,16,
16,16,4,4,4,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,12,29,16,16,4,4,
4,4,4,4,16,16,16,16,16,16,16,16,16,16,4,16,
16,16,16,16,16,16,16,16,45,16,84,11,14,14,14,45,
45,45,45,45,45,45,14,14,14,12,3,3,3,3,3,3,
3,3,3,3,3,7,0,0,0,0,0,0,0,0,4,11,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,120,120,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,12,29,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,4,1,1,
4,16,16,16,16,16,16,16,16,16,16,83,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,12,3,3,4,4,4,4,4,4,4,4,4,4,4,
0,0,0,0,1,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,28,14,14,14,14,14,12,29,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,4,
4,4,4,14,14,14,14,14,14,14,14,14,12,29,83,14,
14,14,14,14,14,14,14,14,14,14,14,79,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,84,11,14,14,14,14,14,14,14,14,14,14,4,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,4,4,14,14,14,14,14,14,14,14,8,9,
14,8,9,14,8,9,14,14,14,14,28,14,14,14,14,14,
12,29,16,16,16,16,16,16,16,84,11,14,1,1,1,1,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,16,16,16,16,16,16,16,16,16,16,4,4,
4,120,14,14,14,14,14,14,14,48,49,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,12,29,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,4,16,16,16,16,16,
16,45,16,16,45,16,16,45,11,14,45,45,45,45,45,45,
45,45,14,14,12,29,16,16,16,16,16,16,16,16,16,16,
16,16,14,14,14,14,14,14,14,14,4,84,11,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,120,120,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,12,29,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,18,19,4,14,14,4,16,16,16,
16,16,16,16,16,16,16,82,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,12,16,16,
16,4,4,4,4,4,4,4,4,4,4,4,14,14,14,14,
47,47,47,47,47,47,47,47,47,47,47,47,47,14,14,14,
14,14,14,14,14,14,46,46,46,46,46,46,46,46,46,46,
46,46,46,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,28,14,14,14,14,12,29,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,18,19,4,4,4,4,14,
14,14,14,14,14,14,14,12,29,16,82,14,14,14,14,14,
14,14,14,14,14,14,14,80,16,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,16,84,
11,14,14,14,14,14,14,14,14,14,4,14,14,14,14,14,
14,14,14,14,14,14,14,21,46,46,46,46,46,46,20,14,
4,4,14,14,14,14,14,8,9,14,14,14,14,14,14,14,
14,14,14,8,9,14,28,14,14,14,14,12,29,16,16,16,
16,6,7,16,16,16,84,11,14,14,14,1,1,1,1,1,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
16,16,16,16,16,16,16,16,16,16,4,4,4,14,14,14,
14,14,14,14,14,14,51,14,14,14,14,14,14,12,3,2,
3,3,3,3,3,3,3,6,7,6,11,14,14,14,14,14,
48,49,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,120,
12,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,6,7,4,16,16,16,16,16,45,45,16,45,
16,45,45,45,45,11,45,45,45,45,45,45,45,45,45,12,
45,45,45,45,16,16,16,16,16,16,16,16,16,16,14,14,
14,14,14,14,14,14,4,16,84,11,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,85,14,14,14,
14,120,12,29,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,4,14,1,4,16,16,16,16,16,16,16,
16,16,16,83,14,14,14,14,14,112,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,12,16,16,81,16,4,4,4,
4,4,4,4,4,4,4,4,14,14,14,14,0,0,0,0,
0,0,0,0,0,0,0,0,0,1,1,1,1,14,12,3,
3,3,1,1,1,1,1,1,1,1,1,1,1,1,1,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
28,14,14,120,12,29,16,16,16,16,16,16,16,16,36,37,
16,16,16,16,16,16,16,4,4,4,4,14,14,14,14,14,
14,14,12,29,16,16,83,14,24,14,85,112,14,14,14,14,
14,14,14,79,5,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,16,16,84,11,14,14,
14,14,14,14,14,14,4,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,1,1,1,1,1,4,4,14,14,
14,8,9,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,28,14,14,120,12,29,16,16,16,16,16,16,16,16,
36,16,16,84,11,14,14,14,14,14,14,14,14,1,1,1,
1,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
1,1,1,1,1,1,1,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,16,16,16,16,
16,16,16,16,16,16,4,4,4,46,47,47,61,68,69,14,
14,14,53,88,60,30,14,14,12,29,16,4,4,16,16,16,
16,16,16,16,16,16,84,11,14,14,14,14,14,50,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,12,29,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,4,16,16,78,3,3,3,3,3,3,3,3,3,3,
3,3,3,3,3,3,3,3,3,3,3,3,3,3,3,3,
3,3,3,3,3,3,3,3,6,3,6,7,7,7,7,14,
14,4,4,16,16,84,11,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,12,6,7,83,1,0,0,0,0,0,0,
0,0,0,0,0,0,0,1,14,14,1,1,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,14,14,4,16,16,16,16,16,3,3,3,3,3,3,
3,3,3,3,3,3,3,3,3,3,3,3,3,3,3,3,
3,3,3,3,3,3,3,3,3,16,16,16,16,16,16,16,
16,16,16,16,83,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,12,16,16,4,4,4,14,
14,14,14,14,14,14,14,14,14,14,14,14,8,9,0,0,
0,0,0,11,14,14,14,14,14,14,14,14,1,1,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,4,14,14,14,14,14,14,12,6,2,
2,2,3,3,3,3,3,3,3,4,14,14,14,14,14,80,
16,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,16,16,16,84,11,14,14,14,14,14,
14,14,4,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,4,4,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,12,2,2,2,2,2,
2,2,2,2,2,2,2,2,2,2,2,2,2,16,16,16,
84,11,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,70,
71,72,23,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,16,16,16,16,16,16,16,16,
16,16,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,16,16,16,16,16,16,16,
16,16,16,84,11,14,14,14,14,51,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,12,29,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,6,7,16,16,4,16,
16,77,16,16,16,16,16,16,16,16,16,4,14,14,14,14,
52,14,14,14,14,14,14,14,14,14,80,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,4,14,14,4,4,16,
16,16,84,11,14,14,14,14,14,14,14,14,14,14,14,14,
12,16,36,37,82,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,1,
4,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
82,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,12,16,16,16,4,4,4,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,79,84,
11,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,45,45,
45,45,4,14,14,14,14,14,12,29,16,16,16,16,16,16,
16,16,16,16,16,4,14,14,14,14,14,79,16,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,16,16,16,16,84,11,14,14,14,14,14,14,4,14,
14,14,14,14,14,14,14,14,14,14,120,14,14,14,14,14,
14,14,14,14,4,4,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,12,29,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,84,11,14,
14,14,14,14,14,14,14,14,14,14,14,1,1,1,14,14,
14,14,14,14,14,14,14,14,14,14,14,73,74,75,23,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,16,16,16,16,16,16,16,16,16,16,4,4,
4,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,4,4,16,16,16,16,16,16,16,16,16,16,16,
84,11,14,14,14,52,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,12,29,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,4,16,16,78,16,16,
16,16,16,16,16,16,16,4,14,14,14,14,52,14,14,14,
14,14,14,14,14,14,79,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,4,14,14,4,4,16,16,16,16,84,
11,14,14,14,14,52,14,14,12,6,6,3,4,4,4,4,
4,4,4,6,3,11,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,4,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,83,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,12,
16,16,16,16,4,4,4,11,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,80,16,84,11,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,45,45,45,45,45,45,4,14,
14,14,14,12,29,16,16,16,16,16,16,16,16,16,16,16,
16,4,14,14,14,14,14,80,5,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,16,16,
16,16,16,84,11,14,14,14,14,12,4,14,0,1,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
4,4,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
12,29,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,84,11,120,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,66,67,
66,67,66,67,26,27,14,96,97,98,23,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
16,16,16,16,16,16,16,16,16,16,4,4,4,16,16,16,
16,16,16,16,6,7,16,16,16,16,16,16,16,16,16,4,
4,16,16,16,16,16,16,16,16,16,16,16,16,84,11,21,
46,46,46,46,46,46,46,46,46,46,46,46,46,46,46,46,
46,46,46,46,46,46,46,46,46,46,46,46,12,29,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,4,3,3,3,13,16,16,16,16,16,
16,16,16,4,14,14,14,14,52,14,14,14,14,14,14,14,
14,14,80,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,4,14,14,4,16,16,16,16,16,16,84,11,14,68,
69,53,14,12,29,16,16,4,4,4,4,4,4,4,4,4,
4,84,11,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,1,4,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,82,14,14,14,120,14,14,14,
120,14,14,14,120,14,14,14,14,14,12,16,16,16,16,16,
4,4,4,81,11,14,14,24,66,67,66,67,66,67,66,67,
66,67,66,67,66,67,79,16,16,84,11,30,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,45,45,45,45,45,45,4,14,14,14,14,4,
4,16,16,16,16,16,16,16,16,16,16,16,16,4,14,14,
14,14,14,79,16,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,14,14,14,12,29,4,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,24,66,67,4,4,66,67,
24,14,14,14,14,14,14,14,14,14,120,12,29,16,16,16,
16,16,16,16,16,16,16,16,16,16,6,7,16,16,16,16,
16,16,16,16,16,16,16,84,11,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,1,1,1,1,1,1,1,
1,1,1,1,1,1,1,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,16,16,16,16,
16,16,16,16,16,16,4,4,4,16,16,16,16,16,16,16,
6,7,16,16,16,16,16,16,16,16,16,4,4,16,16,16,
16,4,4,4,4,4,4,4,4,4,4,4,1,0,0,0,
0,0,0,0,1,0,0,3,3,3,3,3,3,3,3,3,
3,3,3,3,3,3,3,3,3,2,2,2,2,2,2,2,
2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,16,
16,16,4,16,16,16,84,13,16,16,16,16,16,16,16,4,
14,14,14,14,52,14,14,14,14,14,14,14,14,14,79,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,4,14,
14,4,16,16,16,16,16,16,2,2,2,6,7,7,7,7,
7,4,4,4,4,4,4,4,4,4,4,4,4,16,84,11,
14,14,14,14,14,14,14,14,8,9,8,9,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,4,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,83,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,12,16,16,16,16,16,16,4,4,4,3,
6,7,3,3,3,3,3,3,3,3,3,3,3,3,3,3,
3,3,3,3,3,3,3,4,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
45,45,45,45,45,45,4,14,14,14,14,4,4,16,16,16,
16,16,16,16,16,16,16,16,16,4,14,14,14,14,14,80,
16,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,14,14,14,14,14,14,14,14,14,12,
29,16,4,2,2,2,2,2,2,2,2,2,2,2,2,2,
2,2,2,2,2,3,3,3,3,3,3,3,3,11,120,14,
14,14,14,14,14,14,12,29,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,6,7,16,16,16,16,16,16,16,16,
16,16,16,16,84,11,120,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,16,16,16,16,16,16,16,16,
16,16,4,4,4,16,16,16,16,16,16,16,6,7,16,16,
16,16,16,16,16,16,16,4,4,16,16,16,16,4,4,4,
4,4,4,4,4,4,4,4,14,14,14,14,14,14,14,14,
14,14,14,22,31,22,31,22,31,58,58,58,58,58,58,58,
58,58,58,58,58,58,58,58,58,58,58,1,1,1,1,1,
1,1,1,1,1,80,16,16,16,16,16,16,16,16,4,16,
16,16,16,84,13,16,16,16,16,16,16,4,14,14,14,14,
52,14,14,14,14,14,14,14,14,14,80,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,4,14,14,4,22,31,
22,31,22,31,22,31,22,31,22,31,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,16,16,84,11,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,52,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
4,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
82,14,30,30,30,30,30,30,30,30,30,30,30,30,30,14,
12,16,16,16,16,16,16,16,4,4,4,16,16,16,16,16,
16,16,16,16,16,16,16,16,4,4,4,4,4,4,4,4,
4,4,4,4,14,14,14,14,88,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,45,45,45,45,45,45,
45,45,4,14,14,14,14,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,14,14,14,14,14,79,5,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,14,14,14,14,14,14,14,14,12,29,16,16,4,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,84,11,14,14,14,14,14,
14,12,29,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,84,11,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,16,16,16,16,16,16,16,16,16,16,4,4,
4,16,16,16,16,16,16,16,6,7,16,16,16,16,16,16,
16,16,16,4,4,16,16,16,16,4,4,4,4,4,4,4,
4,4,4,4,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,58,58,58,58,58,58,58,58,58,58,58,
58,58,58,58,58,58,58,14,14,14,14,14,14,14,14,14,
14,79,16,16,16,16,16,16,16,16,4,16,16,16,16,16,
78,3,3,3,3,2,2,83,14,14,14,14,52,14,14,14,
14,14,14,14,14,14,79,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,4,14,14,4,14,14,14,14,14,14,
14,14,14,14,14,14,80,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,84,11,14,14,14,14,14,14,
14,14,14,14,14,112,14,14,14,14,14,14,14,14,14,14,
14,52,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,8,9,8,9,8,9,4,16,16,16,
16,16,16,6,2,2,2,2,2,2,2,2,3,3,3,3,
3,3,3,3,3,3,3,3,3,3,3,3,3,3,3,3,
3,3,3,3,3,3,3,3,3,3,3,3,3,3,3,3,
3,3,3,3,3,3,3,3,3,3,3,3,3,3,3,13,
16,16,16,16,16,16,16,16,6,7,16,16,16,16,16,16,
100,101,16,16,82,28,28,28,28,28,28,28,28,28,28,28,
14,14,14,14,89,26,27,120,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,45,45,45,45,45,45,45,45,4,14,
14,14,14,14,14,14,28,14,14,14,14,14,14,14,14,14,
14,28,14,14,14,14,14,80,16,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,14,14,
14,14,14,14,14,12,29,16,16,16,4,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,6,7,16,16,16,16,
16,16,100,101,16,16,84,11,14,14,14,14,12,29,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,4,4,4,4,4,16,16,16,16,16,16,16,84,11,
120,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
16,16,16,16,16,16,16,16,16,16,4,4,4,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,4,
4,16,16,16,16,4,4,4,4,4,4,4,4,4,4,4,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,58,54,55,58,58,58,58,55,58,58,58,58,58,58,58,
58,58,58,14,14,14,14,14,14,14,14,14,14,80,16,16,
16,16,16,16,16,16,4,16,16,16,16,16,77,16,16,16,
16,16,16,82,14,14,14,14,52,120,48,49,14,14,14,14,
14,14,80,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,4,14,14,4,14,14,14,14,14,14,14,14,14,14,
14,14,79,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,84,11,14,14,14,14,14,14,14,14,14,
8,9,14,14,14,14,14,14,14,14,14,14,14,52,52,14,
14,52,14,14,14,14,14,14,14,14,120,120,14,14,14,14,
14,14,14,70,71,72,23,14,4,16,16,16,16,16,16,16,
16,83,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,79,16,16,16,16,16,16,84,13,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,104,16,16,16,
83,28,28,28,28,28,28,28,28,28,28,28,14,14,14,4,
4,4,4,4,14,14,14,14,14,14,14,14,45,45,45,45,
45,45,45,45,45,45,45,45,45,45,4,14,14,14,14,14,
14,14,28,14,14,14,14,14,14,14,14,14,14,28,14,14,
14,14,14,79,16,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,14,14,14,14,14,14,
12,29,16,16,16,16,4,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,104,16,
16,16,16,84,11,14,14,14,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,4,4,
4,4,16,16,16,16,16,16,16,16,16,84,11,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,16,16,16,16,
16,16,16,16,16,16,4,4,4,16,16,16,16,16,6,7,
16,16,16,16,16,16,16,16,16,16,16,4,4,22,31,22,
31,4,4,4,4,4,4,4,4,4,4,4,14,120,120,120,
14,14,14,14,14,14,14,14,14,14,14,14,14,58,55,58,
57,54,58,56,58,54,58,58,58,58,58,58,58,58,58,14,
14,14,14,14,14,120,14,14,14,79,16,16,16,16,16,100,
101,16,4,16,16,16,16,16,78,16,16,16,16,16,16,83,
48,49,14,14,53,14,14,52,14,14,14,48,49,14,79,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,4,14,
14,4,14,14,14,14,14,14,14,14,14,14,14,14,80,16,
16,16,16,16,16,100,101,16,16,16,16,16,16,16,16,16,
16,16,84,11,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,88,14,90,91,92,14,52,52,14,14,52,52,14,
14,14,14,14,14,14,120,120,14,14,14,14,14,14,14,73,
74,75,23,14,4,16,16,16,16,16,16,16,16,82,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
80,16,16,16,16,16,16,16,84,13,16,16,16,16,16,16,
6,7,16,16,16,16,100,101,104,16,16,16,82,28,28,28,
28,28,28,28,28,28,28,28,14,14,14,28,14,14,14,28,
14,14,14,14,14,14,14,14,45,14,45,45,45,14,45,45,
45,45,0,0,0,0,4,14,14,14,14,14,14,14,28,14,
14,14,14,14,14,14,14,14,14,28,14,14,14,14,14,80,
5,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,11,14,14,14,14,12,29,16,16,16,
16,16,4,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,6,7,16,16,16,16,100,101,104,16,16,16,16,16,
84,11,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,80,16,16,16,
16,16,16,16,16,16,16,16,84,11,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,16,16,16,16,16,16,16,16,
16,16,4,4,4,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,81,4,62,62,62,62,62,62,63,63,
63,4,4,4,4,4,4,4,14,120,120,120,14,14,90,91,
92,14,14,14,14,14,14,14,14,57,58,54,58,58,58,54,
58,58,56,58,58,58,58,58,58,58,58,14,14,14,14,14,
14,120,14,48,49,80,16,16,100,101,106,16,104,106,4,3,
3,3,3,3,3,16,16,16,16,16,16,82,60,52,68,69,
51,24,60,52,48,49,61,53,53,24,80,16,16,81,16,16,
16,81,16,16,16,16,16,16,16,16,4,14,14,4,14,14,
14,14,14,14,14,14,14,14,14,14,79,16,16,16,100,101,
16,105,16,16,100,101,16,16,16,16,16,16,16,16,16,84,
11,14,14,14,14,14,14,14,14,14,14,14,14,24,14,89,
14,93,94,95,24,53,53,53,52,53,53,14,14,30,112,112,
14,14,14,14,14,14,14,14,14,14,14,96,97,98,23,14,
4,16,16,16,16,16,16,16,16,83,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,79,16,16,16,
16,16,16,16,16,84,13,109,16,16,16,16,16,16,16,16,
16,16,16,104,104,16,16,16,83,28,28,28,28,28,28,28,
28,28,28,28,14,14,14,28,14,14,14,28,14,14,14,14,
14,14,14,14,45,45,45,45,45,45,45,45,45,45,70,71,
72,23,4,14,14,14,14,14,14,14,28,14,14,14,14,14,
14,14,14,14,14,28,14,14,14,14,14,79,16,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,84,11,14,14,14,4,4,4,4,4,4,4,4,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,104,104,16,16,16,16,16,16,84,11,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,79,16,16,16,16,16,16,16,
16,16,16,16,16,84,11,120,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,16,16,16,16,16,16,16,16,16,16,4,4,
4,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,4,4,62,62,62,62,62,63,63,63,14,4,4,4,
4,4,4,4,14,120,120,120,14,14,93,94,95,14,14,14,
14,14,14,14,14,55,56,58,55,58,54,58,56,58,58,54,
58,58,58,58,58,58,58,14,14,14,14,120,30,30,30,120,
53,79,100,101,81,105,107,106,100,101,4,16,16,16,16,16,
16,16,16,16,16,16,6,3,3,3,3,3,3,3,3,3,
3,3,3,3,3,3,3,3,3,3,3,3,3,3,3,3,
3,3,3,16,16,16,4,14,14,4,11,14,14,14,14,14,
14,14,14,14,14,85,80,100,101,100,101,105,81,104,100,101,
29,105,100,101,16,16,16,16,16,16,16,16,84,11,14,14,
14,14,14,14,14,14,14,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,16,16,16,
16,16,16,16,16,82,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,80,16,16,16,16,16,16,16,
16,16,84,13,16,16,16,16,6,7,16,16,16,16,16,104,
104,100,101,16,82,28,28,28,28,28,28,28,28,28,28,28,
14,14,14,28,90,91,92,28,14,14,14,14,14,14,45,45,
45,45,45,45,45,14,14,45,45,45,73,74,75,23,4,14,
14,14,14,14,14,14,28,14,14,14,14,14,14,14,14,14,
14,28,14,120,120,120,14,80,16,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,16,84,
11,14,14,14,14,14,14,14,14,14,4,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,6,7,16,16,16,16,
16,104,104,100,101,16,16,16,16,16,84,11,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,8,9,
14,14,14,14,80,16,16,16,16,16,16,16,16,16,16,16,
16,16,84,11,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
16,16,16,16,16,16,16,16,16,16,4,4,4,16,16,16,
16,16,6,7,16,16,16,16,16,16,16,16,16,16,4,4,
62,62,62,62,63,63,63,14,14,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,1,5,5,5,5,5,5,5,5,5,5,5,5,5,5,
5,5,5,16,16,10,6,7,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,16,16,16,16,16,16,16,16,16,
16,16,16,4,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,4,14,14,4,84,11,14,14,14,14,14,12,2,2,
4,4,2,2,2,2,2,2,2,2,3,3,3,3,3,3,
3,16,16,16,16,16,16,16,16,84,11,14,14,14,14,14,
14,14,14,86,86,86,86,4,58,58,58,58,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,16,16,16,16,16,16,45,
45,83,47,46,47,47,47,47,47,47,47,47,47,47,47,47,
47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,47,
47,47,47,47,47,47,47,47,20,88,88,25,25,88,25,25,
25,25,25,25,79,16,16,81,81,16,16,16,16,16,16,84,
13,16,16,36,37,16,16,81,81,100,101,105,105,16,105,29,
83,28,28,28,28,28,28,28,28,28,28,28,14,14,14,28,
93,94,95,28,45,14,45,112,14,45,45,45,45,45,45,45,
45,45,45,45,45,45,96,97,98,23,4,14,14,14,14,14,
14,14,28,14,47,46,47,47,47,47,47,47,47,28,30,120,
120,120,30,79,5,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,16,16,84,11,14,14,
14,14,14,14,14,14,4,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,36,37,16,16,81,81,100,101,105,105,16,
105,16,16,16,16,16,16,84,11,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
79,16,16,16,16,16,16,16,16,16,16,16,16,16,16,84,
11,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,16,16,16,16,
16,16,16,16,16,16,4,4,4,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,4,4,62,62,62,63,
63,63,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,79,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
10,29,16,100,101,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,10,3,3,3,3,3,3,3,4,
3,3,3,3,3,3,3,3,3,3,3,3,3,3,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,4,14,
14,4,16,84,11,14,14,14,14,16,16,16,4,4,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,84,11,14,14,14,14,14,14,14,86,
86,86,86,4,58,58,58,58,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,14,14,1,1,1,1,1,1,1,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,4,4,4,4,4,4,4,4,4,4,4,4,
3,3,3,3,3,3,3,3,3,3,3,3,3,3,3,3,
3,3,3,3,3,3,3,3,3,4,0,0,0,0,0,0,
1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,14,14,1,1,1,1,1,1,1,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,80,
16,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,16,16,16,84,11,14,14,14,14,14,
14,12,4,6,3,3,3,3,3,3,3,3,3,3,3,3,
3,3,3,3,3,3,3,3,3,3,3,4,0,0,0,0,
0,0,1,0,0,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,80,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,84,11,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,8,9,8,
9,8,9,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,16,16,16,16,16,16,16,16,
16,16,4,4,4,16,16,16,16,16,16,16,6,7,16,16,
16,16,16,16,16,16,4,4,62,62,63,63,63,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,80,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,10,29,16,16,104,
16,100,101,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,10,29,16,16,16,16,16,16,16,4,14,14,86,86,
86,52,14,14,86,86,87,86,86,86,80,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,4,14,14,4,16,16,
84,11,14,14,14,16,16,16,4,4,22,31,22,31,22,31,
22,31,22,31,22,31,22,31,22,16,16,16,16,16,16,16,
16,16,16,84,11,14,14,14,14,14,14,86,86,86,86,4,
16,16,16,16,83,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
4,14,14,64,64,64,64,64,14,14,4,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,4,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,79,16,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,16,16,16,16,84,11,14,14,14,14,12,29,4,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,4,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,8,9,14,14,14,14,79,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,84,11,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,70,71,72,23,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,16,16,16,16,16,16,16,16,16,16,4,4,
4,16,16,16,16,16,16,16,16,16,16,6,7,16,16,16,
16,16,4,4,62,63,63,63,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,79,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,10,100,101,16,16,104,16,16,104,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,10,29,16,
16,16,16,16,16,16,16,4,14,14,86,86,86,52,14,14,
86,86,14,87,86,86,79,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,4,14,14,4,16,16,16,84,11,14,
14,16,16,16,4,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,79,16,16,16,16,16,16,16,16,16,16,16,
84,11,14,14,14,14,14,86,86,86,86,4,16,16,16,16,
82,14,120,14,14,14,14,14,14,45,45,14,14,14,14,14,
14,45,45,45,45,14,14,14,14,14,14,14,14,45,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,4,4,120,120,14,
65,64,65,64,14,14,4,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,4,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,120,14,14,14,14,14,14,14,14,14,14,88,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,80,5,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,14,14,14,12,29,16,4,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,4,0,1,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,120,14,14,14,14,14,14,14,14,14,
14,14,14,14,80,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,84,11,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,73,74,75,23,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
16,16,16,16,16,16,16,16,16,16,4,4,4,16,16,16,
16,16,16,16,16,16,16,16,16,6,7,16,16,16,4,4,
63,63,63,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,120,14,14,14,14,14,14,14,14,14,
14,80,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,10,29,16,104,16,16,104,16,16,104,16,16,16,16,16,
16,16,16,16,16,16,16,16,10,29,16,16,16,16,16,16,
16,16,16,4,14,14,86,86,86,52,14,14,86,86,14,14,
86,86,80,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,4,14,14,4,16,16,16,16,84,11,14,16,16,16,
4,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
80,16,16,16,16,16,16,16,16,16,16,16,16,4,11,14,
14,14,14,86,86,86,86,4,16,16,16,16,83,14,14,14,
14,14,14,14,14,45,45,45,45,45,14,45,45,14,14,45,
45,45,14,14,14,14,14,14,14,45,45,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,4,4,120,120,14,14,14,14,64,
8,9,4,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,4,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,86,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,79,16,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,14,14,14,14,14,14,
14,14,12,29,16,16,4,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,4,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,4,0,
0,0,1,0,14,14,14,14,14,14,14,14,14,14,14,14,
79,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,84,11,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,96,97,98,23,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,16,16,16,16,
16,16,16,16,16,16,4,4,4,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,6,7,16,4,4,63,63,14,14,
14,14,14,14,14,14,14,14,14,14,8,9,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,79,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,10,29,100,101,
104,16,16,104,16,16,104,16,16,16,16,16,16,16,36,37,
16,16,16,10,29,16,16,16,16,16,16,16,16,16,16,4,
14,14,86,86,14,52,14,14,86,86,14,14,87,14,79,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,4,14,
14,4,4,4,4,4,7,7,14,4,4,4,4,120,120,120,
14,14,120,14,14,120,120,120,14,120,14,120,79,16,16,16,
16,16,16,16,16,16,16,16,16,4,84,11,14,14,14,86,
86,86,86,4,16,16,16,29,82,14,68,69,14,112,14,14,
45,14,45,14,45,45,45,45,45,45,45,45,45,45,45,45,
14,14,45,14,45,45,45,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,4,4,120,120,14,14,68,69,65,14,14,4,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,4,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,85,68,69,14,112,
14,60,61,61,14,14,14,86,14,14,61,60,60,61,60,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,80,
16,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,14,14,14,14,14,14,14,12,29,16,
16,16,4,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,4,1,0,14,14,
14,14,14,14,14,14,14,14,14,14,4,14,14,14,14,14,
14,0,1,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,16,16,16,16,16,16,16,16,
16,16,4,4,4,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,4,4,63,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,88,51,14,51,
50,14,14,14,14,14,14,14,14,80,16,16,16,16,16,16,
16,16,16,16,16,16,16,10,29,16,104,106,104,16,16,104,
16,106,104,100,101,16,16,16,6,6,3,3,2,2,2,2,
2,2,2,16,16,16,16,16,16,16,16,4,14,14,86,86,
14,52,14,14,86,86,14,14,14,14,80,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,4,14,14,4,16,16,
4,4,4,4,14,4,4,4,4,14,120,14,14,120,14,120,
14,120,14,120,14,14,120,14,80,106,16,16,16,16,16,16,
16,16,16,16,16,4,16,84,11,14,14,87,86,86,86,4,
16,16,16,4,4,4,4,4,4,4,3,3,3,3,3,3,
3,3,3,3,3,3,3,3,3,3,4,3,3,3,2,2,
2,2,2,2,2,11,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,4,
0,0,0,0,0,0,0,4,9,9,4,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,4,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,12,4,4,4,4,4,4,4,3,3,3,3,
3,11,14,86,12,3,3,3,3,3,3,3,4,3,3,3,
2,2,2,2,2,2,2,11,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,79,5,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,14,14,14,14,14,14,12,29,16,16,16,16,4,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,4,14,14,0,1,14,14,14,14,
14,14,14,14,14,14,4,14,14,14,14,14,14,0,0,4,
4,4,4,4,4,4,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,16,16,16,16,16,16,16,16,16,16,4,4,
4,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,4,4,63,66,67,66,67,14,14,14,8,9,8,9,
14,14,14,68,69,52,26,27,89,52,51,51,51,26,27,24,
24,14,14,14,14,79,16,16,16,16,16,16,16,16,36,37,
103,81,10,29,100,101,105,107,105,105,100,101,81,107,105,81,
104,103,16,81,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,4,14,14,14,87,14,52,14,14,
87,14,14,14,14,14,79,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,4,14,14,4,16,16,4,4,4,4,
14,4,4,4,4,14,120,14,14,14,120,14,14,120,14,120,
14,14,120,14,79,107,104,36,37,16,16,16,16,16,16,16,
16,4,16,16,84,11,14,14,86,87,86,4,16,16,16,4,
4,4,4,4,4,4,16,16,16,16,16,16,16,16,16,16,
16,16,16,56,16,16,4,16,16,16,16,16,16,16,16,16,
16,84,11,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,4,14,14,14,14,
14,14,14,4,14,14,4,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,4,14,14,14,14,14,14,14,14,14,14,14,14,14,12,
29,4,4,4,4,4,4,4,4,4,4,4,4,4,88,86,
4,4,4,4,4,4,4,4,4,16,16,16,16,16,16,16,
16,16,16,84,11,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,80,16,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,14,14,
14,14,14,12,29,16,16,16,16,16,4,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,4,14,14,14,14,1,0,14,14,14,14,14,14,
14,12,4,14,14,14,14,14,14,0,0,4,4,4,4,4,
4,4,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
16,16,16,16,16,16,16,16,16,16,4,4,4,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,4,4,
6,2,2,3,7,11,14,14,14,14,14,4,4,4,4,2,
2,2,2,2,2,2,2,2,2,3,3,3,3,3,3,3,
3,3,3,3,3,3,3,3,3,3,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,6,7,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,4,14,14,14,14,14,52,120,48,49,14,14,14,
14,14,80,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,4,14,14,4,16,16,4,4,4,4,120,4,1,1,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,2,2,2,2,2,2,16,16,16,16,16,16,4,16,16,
16,84,11,14,86,14,86,4,16,16,16,4,4,17,4,4,
4,4,16,16,16,16,16,16,16,16,16,16,16,16,36,37,
16,16,4,16,16,16,16,16,16,16,16,16,16,16,84,11,
14,14,14,14,14,14,14,14,14,14,14,52,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,4,14,14,14,14,14,14,14,4,
8,9,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,14,14,
14,14,14,14,14,14,14,14,14,14,12,29,16,4,4,4,
4,4,4,4,4,4,4,4,4,4,86,86,4,4,4,4,
4,4,4,4,4,16,16,16,16,16,16,16,16,16,16,16,
84,11,14,14,14,14,14,14,14,14,14,14,14,52,14,120,
14,14,14,79,16,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,14,14,14,14,12,29,
16,16,16,16,16,16,4,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
14,14,14,14,14,14,14,14,14,14,14,14,12,16,4,14,
14,14,14,14,14,1,0,4,4,4,4,4,4,4,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,16,16,16,16,
16,16,16,16,16,16,4,4,4,16,16,16,16,16,16,16,
16,16,16,16,16,16,6,7,7,16,4,4,16,16,16,16,
16,84,11,14,14,14,14,4,4,4,4,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,54,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
56,16,16,16,16,16,16,16,16,16,16,16,4,4,4,16,
16,36,37,16,3,3,3,3,3,16,16,16,16,16,16,4,
14,48,49,88,14,53,14,14,52,14,14,14,48,49,79,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,4,14,
14,4,16,16,16,16,4,4,14,4,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,22,31,22,
31,22,31,22,31,22,31,22,31,4,16,16,16,16,84,11,
87,14,86,22,31,22,31,4,4,4,4,17,4,4,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,4,16,
16,16,16,16,36,37,16,16,16,16,16,84,11,14,14,14,
14,14,14,48,49,88,14,53,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,4,14,14,14,14,14,14,14,4,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,12,29,16,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,86,86,4,4,4,4,4,4,4,4,
4,16,16,36,37,36,37,16,16,16,16,16,16,84,11,14,
14,14,120,14,14,48,49,88,14,53,14,14,14,14,14,80,
5,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,14,14,14,12,29,16,16,16,16,16,
16,16,4,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
0,1,14,14,14,14,14,12,16,16,4,14,14,14,1,0,
14,14,14,4,4,4,4,4,4,4,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
120,14,14,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,16,16,16,16,16,16,16,16,
16,16,4,4,4,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,4,4,16,16,16,16,16,16,84,11,
14,14,14,4,4,4,16,16,16,16,16,16,16,54,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,54,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,4,4,4,4,4,4,4,4,
4,4,4,16,16,16,16,36,37,16,16,4,112,60,52,89,
24,51,88,60,52,48,49,24,53,53,80,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,4,14,14,4,16,16,
16,16,4,4,14,4,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,4,16,16,106,16,16,84,11,14,87,14,
14,14,14,4,4,4,4,4,4,4,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,4,4,4,4,4,4,
4,4,4,4,4,16,16,16,84,11,14,14,14,14,112,60,
52,89,62,51,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,4,
14,14,30,30,30,30,14,4,9,9,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
12,29,16,16,83,14,14,14,14,14,14,14,14,28,14,14,
86,86,86,86,86,86,86,86,86,14,14,14,4,4,4,4,
4,4,4,4,4,4,4,16,16,16,84,11,14,14,14,14,
112,60,52,89,60,51,14,14,14,14,14,79,16,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,14,14,12,4,4,4,4,4,4,4,4,4,4,14,
63,63,14,14,14,14,14,14,14,14,14,14,14,14,62,14,
14,14,14,14,14,14,63,14,14,14,14,14,14,14,14,14,
14,14,12,16,16,16,4,1,0,14,14,14,14,14,14,28,
14,14,86,86,86,86,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,16,16,16,16,16,16,16,16,16,16,4,4,
4,16,16,16,16,16,16,16,16,16,16,16,6,7,16,16,
16,16,4,4,4,4,4,4,4,4,4,4,14,14,14,4,
4,58,58,58,58,58,58,58,58,58,58,58,58,58,58,58,
58,58,58,58,58,56,58,58,58,58,58,58,58,58,58,58,
58,58,58,58,58,58,58,58,58,58,58,58,58,58,58,58,
58,58,58,58,14,14,14,14,14,14,14,14,14,14,4,16,
16,16,16,3,3,3,3,3,3,3,3,3,3,3,3,3,
3,3,3,3,3,3,2,2,2,2,16,16,16,3,3,3,
3,3,3,3,3,3,4,14,14,4,16,16,16,16,4,4,
14,4,14,14,112,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,4,104,105,107,16,36,37,4,11,14,14,14,14,14,4,
4,4,4,4,4,4,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,16,16,
16,16,16,16,16,3,3,3,3,3,3,3,3,3,3,3,
3,3,3,3,3,3,3,3,2,2,2,2,16,16,16,3,
3,3,3,3,3,3,3,3,4,1,1,4,1,1,4,4,
4,4,120,4,14,14,14,14,14,14,14,14,14,14,14,120,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,12,29,16,16,16,
82,14,14,14,14,14,14,14,14,28,14,14,86,86,86,86,
86,86,86,86,86,14,14,14,28,14,14,14,14,14,14,14,
14,14,4,16,16,16,16,3,3,3,3,3,3,3,3,3,
3,3,3,3,3,3,3,80,16,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,14,14,
4,4,4,4,4,4,16,16,16,16,4,14,14,14,14,14,
14,14,62,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,12,16,16,
16,16,4,14,14,14,14,14,14,14,14,28,14,14,86,86,
86,86,14,14,14,14,14,14,14,30,30,30,30,30,30,30,
30,30,30,30,30,30,30,30,30,30,30,30,30,30,30,30,
30,30,30,30,30,30,30,30,30,30,30,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
16,16,16,16,16,16,16,16,16,16,4,4,4,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,4,4,
4,4,4,4,4,4,4,4,83,14,14,58,58,58,58,58,
58,58,58,58,58,58,58,58,58,58,58,58,58,58,58,58,
58,58,58,58,58,58,58,58,58,58,58,58,56,58,58,58,
58,58,58,58,58,58,58,58,58,58,58,58,58,58,58,58,
14,14,14,14,14,14,14,14,14,14,14,22,31,22,31,22,
31,22,31,22,31,22,31,22,31,22,31,22,31,22,31,22,
31,22,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,4,14,14,4,16,16,16,16,16,4,14,4,8,9,
8,9,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,0,1,0,
1,1,1,0,4,84,11,14,14,14,14,14,4,4,4,4,
17,4,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,79,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,4,0,0,4,0,0,4,4,4,4,120,4,
8,9,14,14,14,14,88,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,12,29,16,16,16,16,83,14,14,14,
14,14,14,14,14,28,14,14,86,86,86,86,86,86,86,86,
86,14,14,14,28,14,14,14,14,14,14,14,14,14,28,14,
14,14,14,14,14,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,79,5,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,14,14,4,4,4,4,
4,4,16,16,16,16,4,14,14,14,63,14,14,14,14,14,
14,14,14,62,14,14,14,14,14,14,14,14,14,62,14,14,
14,14,14,14,0,0,14,14,12,16,16,16,16,16,4,14,
14,14,14,14,14,14,14,28,14,14,86,86,86,86,14,14,
14,14,14,14,1,1,0,0,0,1,1,1,1,0,0,0,
0,0,1,1,1,1,1,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,16,16,16,16,
16,16,16,16,16,16,4,4,4,16,16,16,16,16,16,16,
16,16,6,7,16,16,16,16,16,16,16,16,16,16,16,16,
16,4,4,4,82,14,14,58,58,58,58,58,58,58,58,58,
58,58,58,58,58,58,58,58,58,58,58,58,58,58,58,58,
58,58,58,58,58,58,58,58,58,58,58,58,58,58,58,58,
58,58,58,58,58,58,58,58,58,58,58,58,14,120,120,120,
120,120,120,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,80,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,4,14,
14,4,16,16,16,16,4,4,14,4,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
4,16,84,11,14,14,14,14,14,4,4,4,4,4,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,120,
120,120,120,120,120,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
80,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
4,0,0,4,0,0,4,4,4,4,120,4,25,25,25,25,
25,88,89,25,112,25,25,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,12,29,16,16,16,16,16,82,14,14,14,14,14,14,14,
14,28,14,14,86,86,86,86,87,86,86,87,86,14,14,14,
28,120,120,120,120,120,120,14,14,14,28,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,80,
16,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,11,14,14,14,14,14,14,4,16,16,
16,16,4,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,63,14,14,14,14,14,14,14,14,14,
14,14,14,14,4,4,4,4,4,4,4,0,1,14,14,14,
14,14,14,28,14,14,86,86,86,86,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,16,16,16,16,16,16,16,16,
16,16,4,4,4,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,18,19,16,16,4,4,4,
83,14,14,58,58,58,58,58,58,58,58,58,58,58,58,58,
58,58,58,58,58,58,58,58,58,58,58,58,58,58,58,58,
58,58,58,58,58,58,58,58,58,58,58,58,58,58,58,58,
58,58,58,58,58,58,58,58,14,120,120,120,120,120,120,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,79,16,16,16,16,16,
16,16,16,16,3,3,3,3,3,16,4,14,14,4,16,16,
16,4,16,4,14,4,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,4,4,106,106,
11,14,14,14,14,14,4,4,4,4,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,120,120,120,120,120,
120,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,79,16,16,16,
16,16,16,16,16,16,16,100,101,16,106,16,4,0,0,4,
0,0,4,4,4,4,120,4,8,9,8,9,8,9,8,9,
8,9,8,9,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,12,29,16,16,
16,16,16,16,83,14,14,14,14,14,14,14,14,28,14,14,
86,87,86,86,14,87,86,14,87,14,14,14,28,120,120,120,
120,120,120,14,14,14,28,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,79,16,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,84,11,14,14,14,14,14,4,16,16,16,16,4,14,
14,14,14,14,14,14,63,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,0,1,14,14,
14,4,4,4,4,4,4,14,14,14,14,14,14,14,14,28,
14,14,86,87,86,86,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,16,16,16,16,16,16,16,16,16,16,4,4,
4,16,16,16,16,16,16,16,6,7,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,4,4,4,82,14,14,58,
58,54,58,58,58,58,58,58,58,58,58,54,58,58,58,58,
58,58,58,58,58,56,58,58,58,58,58,58,58,55,58,58,
58,58,58,58,58,58,58,58,58,55,58,58,58,58,54,58,
58,58,58,58,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,80,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,4,14,14,4,16,16,16,16,16,4,
120,4,14,14,14,8,9,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,4,4,4,107,84,11,14,14,
14,14,14,4,4,4,14,120,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,80,16,16,16,16,16,16,16,
81,16,100,101,105,106,107,81,4,0,0,4,0,0,4,4,
4,4,120,4,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,12,29,16,16,16,106,16,16,16,
82,14,14,14,14,14,14,14,14,28,14,88,14,14,86,86,
14,14,87,88,14,14,14,14,28,14,14,14,14,14,14,14,
14,14,28,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,80,5,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,16,84,
11,14,14,14,14,4,16,16,16,16,4,14,14,14,14,14,
14,14,14,14,14,62,14,14,14,14,63,14,14,14,14,14,
63,14,14,14,14,1,0,14,14,14,14,14,14,4,4,4,
4,4,4,14,14,14,14,14,14,14,14,28,14,88,14,14,
86,86,14,14,14,88,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,1,1,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
16,16,16,16,16,16,16,16,16,16,4,4,4,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,4,4,4,83,14,14,58,58,58,58,54,
58,58,58,58,58,58,58,58,58,58,58,58,54,58,58,58,
58,58,58,58,58,58,58,58,58,58,58,56,58,58,54,58,
58,58,58,58,58,58,58,58,58,58,58,58,58,58,55,58,
30,30,46,46,30,46,46,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,79,16,3,3,3,3,3,3,3,3,3,16,16,16,
16,16,4,14,14,4,16,16,16,16,16,4,14,4,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
120,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,4,4,4,4,16,104,11,14,14,14,14,14,
4,4,14,14,14,14,14,14,66,67,24,68,69,66,67,68,
69,14,50,30,46,46,30,46,46,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,79,16,3,3,3,3,3,3,3,3,3,3,
3,3,3,3,4,0,0,4,0,0,4,16,16,4,120,4,
8,9,14,14,14,14,14,14,14,14,14,14,8,9,14,14,
14,14,14,14,14,14,14,14,120,14,14,14,14,14,14,30,
30,30,12,29,81,16,81,16,107,29,16,16,83,14,14,14,
14,14,14,14,14,28,88,86,14,88,89,89,14,68,69,86,
88,68,69,14,28,30,46,46,30,46,46,14,14,14,28,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,79,16,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,16,16,84,11,14,14,
14,4,16,16,16,16,4,14,63,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,120,4,4,4,4,4,4,1,
1,14,14,14,14,14,14,28,88,86,14,88,89,89,14,14,
14,86,88,68,69,14,14,14,14,14,14,14,14,14,14,14,
14,14,1,1,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,16,16,16,16,
16,16,16,16,16,16,4,4,4,16,16,16,16,16,6,7,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,4,4,4,82,14,14,5,5,5,5,5,5,5,5,5,
5,5,5,5,5,5,5,5,5,5,5,5,5,5,5,5,
5,5,5,5,5,5,5,5,5,5,5,5,5,5,5,5,
5,5,5,5,5,5,5,5,4,4,4,4,4,6,3,3,
3,3,3,11,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,80,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,4,14,
14,4,16,16,16,4,16,4,14,4,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,8,9,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
4,4,4,4,4,4,4,11,14,14,14,14,64,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,11,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
80,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
4,0,0,4,0,0,4,16,16,4,120,4,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,8,9,8,
9,8,9,8,9,14,14,14,14,14,14,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,11,14,14,14,14,14,14,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,0,0,0,0,0,0,0,0,14,
14,14,14,14,14,14,12,0,0,0,0,0,0,0,0,80,
16,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,16,16,16,84,11,14,14,4,16,16,
16,16,4,14,14,14,14,14,62,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,4,4,4,4,4,4,14,14,14,14,1,
1,1,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,2,2,11,14,14,14,14,14,14,14,1,1,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,16,16,16,16,16,16,16,16,
16,16,4,4,4,16,16,16,16,16,16,16,16,16,16,16,
16,81,16,16,16,16,16,16,16,16,16,16,16,16,16,4,
83,14,14,22,31,22,31,22,31,22,31,22,31,22,31,22,
31,22,31,22,31,22,31,22,31,22,31,22,31,22,31,22,
31,22,31,22,31,22,31,22,31,22,31,22,31,22,31,22,
31,22,31,22,4,4,4,4,4,16,16,16,16,16,16,84,
11,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,79,16,16,16,16,16,
16,16,16,16,3,3,3,3,3,3,4,14,14,4,16,16,
16,16,78,4,14,4,14,14,8,8,9,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,112,14,14,14,120,14,4,4,4,4,
4,4,16,84,11,14,14,14,64,64,64,64,64,64,64,14,
14,14,14,14,4,4,4,4,4,4,4,4,4,4,4,4,
4,84,11,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,79,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,4,0,0,4,
0,0,4,16,16,4,120,4,8,9,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,64,64,14,14,14,14,
14,14,14,14,14,14,14,14,28,14,14,14,14,14,14,14,
14,14,4,4,16,84,11,14,14,14,14,14,64,64,64,64,
64,14,14,14,14,14,4,4,4,4,4,4,4,4,4,4,
4,4,4,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,12,4,14,14,14,14,14,14,14,14,79,5,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,16,16,16,16,84,11,14,4,16,16,16,16,4,14,
14,14,14,14,14,14,14,14,14,14,63,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,0,1,14,14,14,14,14,
14,4,4,4,4,4,4,14,14,14,14,14,14,14,64,64,
64,64,64,14,14,14,14,14,4,4,4,4,4,4,16,16,
16,11,14,14,14,1,1,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,16,16,16,16,16,16,16,16,16,16,4,4,
4,16,16,16,6,7,16,16,16,16,16,4,4,4,4,13,
16,16,16,16,16,16,16,16,16,16,16,4,82,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
4,16,16,16,4,16,16,16,16,16,16,16,84,11,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,80,3,3,3,3,3,16,16,16,16,
16,16,16,16,16,16,4,14,14,4,16,16,16,4,4,4,
14,4,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
8,9,14,14,14,14,14,14,14,14,14,14,14,14,14,0,
1,0,0,0,0,1,1,0,4,4,4,4,4,4,16,16,
84,11,14,14,64,64,65,64,64,64,64,14,14,14,14,14,
14,14,4,4,4,4,4,4,4,4,17,4,4,16,106,11,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,80,3,3,3,3,3,16,16,
16,16,16,16,16,16,16,16,4,0,0,4,0,0,4,16,
16,4,120,4,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,8,9,14,14,64,14,14,14,14,14,14,14,14,14,
14,14,14,14,28,14,14,14,14,14,14,14,14,14,4,4,
81,81,84,11,14,14,14,14,65,64,64,64,64,14,14,14,
14,14,14,14,4,4,4,4,4,4,4,4,4,4,4,88,
14,14,88,14,14,14,14,14,14,14,14,14,12,29,4,14,
14,14,14,14,14,14,14,80,16,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,120,4,16,16,16,16,4,14,14,14,62,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,0,1,0,0,1,4,4,4,
4,4,2,2,2,11,14,14,14,14,65,64,64,64,64,14,
14,14,14,14,14,14,4,4,4,4,4,4,4,4,1,1,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
16,16,16,16,16,16,16,16,16,16,4,4,4,16,16,16,
16,16,16,16,16,16,16,35,16,77,4,84,13,16,16,16,
16,16,16,16,16,16,16,4,83,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,48,49,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,4,16,16,16,
4,16,16,16,16,16,16,16,16,84,11,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,79,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,4,14,14,4,16,16,16,4,4,4,14,4,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,70,71,72,23,
14,14,14,14,14,14,14,14,4,4,16,16,16,84,11,14,
64,65,14,64,64,64,64,14,14,14,14,14,14,14,4,4,
17,4,17,4,4,4,4,4,4,106,107,29,11,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,79,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,4,0,0,4,0,0,4,16,16,4,120,4,
8,9,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,64,14,88,14,14,14,48,49,14,14,14,14,14,14,
28,14,14,14,14,14,14,14,14,14,4,4,4,4,4,84,
11,14,14,14,14,64,64,64,64,14,14,14,14,14,14,14,
4,4,4,4,4,4,4,4,4,4,4,86,88,88,86,14,
14,14,14,14,14,14,120,12,29,16,4,14,14,14,14,14,
14,14,14,79,16,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,14,14,14,14,14,4,
120,4,16,16,16,16,4,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,48,49,14,14,14,14,
14,14,14,14,14,70,71,72,23,4,4,4,4,4,4,4,
4,16,11,14,14,14,14,64,64,64,64,14,14,14,14,14,
14,14,4,4,4,4,4,4,4,4,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,16,16,16,16,
16,16,16,16,16,16,4,4,4,16,6,7,16,16,16,16,
16,16,16,35,16,16,4,16,84,13,16,16,16,16,16,16,
16,16,16,4,82,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,48,49,14,14,52,14,14,14,14,14,14,14,
14,14,120,14,14,14,14,14,14,14,14,14,14,45,45,45,
14,14,14,14,14,14,14,14,4,16,16,16,4,16,16,16,
16,16,16,16,16,16,84,11,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,80,16,
16,3,3,3,3,3,3,16,16,16,16,16,16,16,4,14,
14,4,16,16,16,16,16,4,14,4,9,8,9,14,14,14,
120,14,14,14,14,8,9,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,48,49,73,74,75,23,14,14,14,14,
14,14,14,14,4,4,16,16,36,37,84,11,65,14,14,65,
64,64,64,14,14,14,14,14,14,14,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,11,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
80,16,16,3,3,3,3,3,3,16,16,16,16,16,16,16,
4,0,0,4,0,0,4,16,16,4,120,4,14,14,14,14,
14,14,14,14,14,14,14,8,9,14,14,14,14,14,64,14,
86,14,14,88,52,48,49,14,48,49,14,14,28,14,14,14,
14,14,14,14,14,14,4,4,4,4,4,16,84,11,14,14,
14,65,64,64,64,14,14,14,14,14,14,14,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,14,14,14,14,14,
14,14,12,29,16,16,4,14,14,14,14,14,14,14,14,80,
5,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,14,62,62,14,14,4,120,4,16,16,
16,16,4,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,88,14,14,88,14,48,49,14,48,49,14,14,14,14,
14,73,74,75,23,4,4,4,4,4,4,4,4,16,16,11,
14,14,14,65,64,64,64,14,14,14,14,14,14,14,4,4,
4,4,4,4,4,4,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,16,16,16,16,16,16,16,16,
16,16,4,4,4,16,16,16,16,6,7,16,16,16,16,35,
16,16,4,16,16,84,13,16,16,16,16,16,16,16,16,4,
83,14,14,14,14,14,14,14,14,14,14,14,14,61,60,14,
53,25,14,14,53,20,14,14,14,14,14,14,14,14,20,14,
14,14,14,14,14,112,14,14,45,45,45,45,45,14,14,14,
14,14,14,120,4,16,16,16,4,16,16,16,16,4,4,4,
4,4,4,4,11,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,79,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,4,14,14,4,16,16,
16,16,16,4,120,4,14,14,14,14,14,8,9,14,14,14,
14,14,14,14,14,14,14,14,24,14,14,14,14,14,14,61,
60,14,53,25,96,97,98,23,14,14,14,14,14,14,14,14,
4,4,16,16,18,19,16,84,11,14,14,14,64,64,64,14,
14,14,14,14,14,14,4,4,4,4,4,4,4,4,17,4,
4,4,4,4,4,4,11,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,79,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,4,0,0,4,
0,0,4,16,16,4,120,4,8,9,14,14,14,14,14,14,
14,14,14,14,25,25,25,25,25,14,65,61,89,60,88,89,
53,51,48,49,53,60,68,69,28,14,14,14,14,14,14,14,
14,14,4,4,14,14,4,16,16,84,11,14,14,14,64,64,
64,14,14,14,14,14,14,14,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,14,14,14,14,14,14,12,29,16,
16,16,4,14,14,14,14,14,14,14,14,79,16,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,63,14,14,63,14,4,120,4,16,16,16,16,4,14,
14,14,14,14,14,14,14,14,14,14,14,14,112,61,89,60,
88,89,53,51,48,49,53,60,68,69,14,14,14,96,97,98,
23,4,4,4,4,4,4,4,4,16,16,16,11,14,14,14,
64,64,64,14,14,14,14,14,14,14,4,4,4,4,4,4,
4,4,1,1,1,1,1,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,16,16,16,16,16,16,16,16,16,16,4,4,
4,17,16,16,16,16,16,16,16,16,16,34,16,16,4,16,
16,16,84,13,16,16,16,16,16,16,10,4,82,14,14,6,
2,2,2,2,2,2,2,2,6,6,4,4,4,4,4,4,
4,0,0,0,0,1,14,14,14,12,6,3,2,2,2,2,
2,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,16,16,16,4,16,16,16,16,4,4,4,4,4,4,4,
84,11,120,14,14,14,14,14,14,14,14,14,14,14,14,120,
14,14,14,14,14,14,80,16,16,16,16,16,16,16,16,3,
3,3,16,16,16,16,4,14,14,4,16,16,16,16,16,4,
14,4,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,6,2,2,2,2,2,2,2,2,6,6,4,4,4,4,
4,4,4,4,4,4,14,14,14,14,14,12,4,4,16,16,
16,16,16,16,84,11,120,14,64,65,64,14,14,14,14,14,
14,14,4,16,16,16,4,4,4,4,4,4,4,17,4,4,
4,4,4,11,14,14,14,14,14,14,14,14,14,14,14,14,
14,120,14,14,14,14,14,14,80,16,16,16,16,16,16,16,
16,3,3,3,16,16,16,16,4,0,0,4,0,0,4,16,
16,4,120,4,14,14,14,14,14,14,14,14,14,14,14,12,
4,6,3,3,2,2,2,2,2,2,2,2,6,6,4,4,
4,4,4,4,4,14,14,14,14,14,14,14,14,12,4,4,
14,14,4,16,16,16,84,11,14,14,64,65,64,14,14,14,
14,14,14,14,4,16,16,16,4,4,4,4,4,4,4,4,
4,4,4,14,14,14,14,14,12,29,16,16,16,16,4,14,
14,14,14,14,14,14,14,80,16,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,14,14,
62,14,14,4,120,4,16,16,16,16,4,14,14,14,14,14,
14,12,4,6,3,3,2,2,2,2,2,2,2,2,6,6,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,16,16,11,14,14,64,65,64,14,
14,14,14,14,14,14,4,17,17,17,4,4,4,4,14,14,
14,14,14,14,1,1,14,14,14,14,14,120,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
16,16,16,16,16,16,16,16,16,16,4,4,4,17,17,16,
16,16,16,16,16,16,16,16,16,16,4,16,16,16,16,84,
13,16,16,16,16,10,29,4,83,14,14,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,31,14,14,14,
14,14,14,14,12,29,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,83,14,14,14,14,14,14,4,16,16,16,
4,16,16,16,16,4,4,4,4,4,4,4,16,84,11,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,90,91,
92,14,79,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,4,14,14,4,16,16,16,16,16,4,14,4,14,14,
14,8,9,14,14,14,14,14,14,14,14,14,14,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,14,14,
14,14,14,14,14,14,12,4,4,4,16,16,16,16,16,16,
16,84,11,14,65,14,64,14,14,14,14,14,14,14,4,106,
16,16,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
11,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
90,91,92,14,79,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,4,0,0,4,0,0,4,16,16,4,120,4,
8,9,14,14,14,14,14,14,14,14,12,29,4,17,17,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
14,14,14,14,14,14,14,14,12,4,4,4,14,14,4,16,
16,16,16,84,11,14,65,14,64,14,14,14,14,14,14,14,
4,16,106,16,4,4,4,4,4,4,4,4,4,4,4,14,
14,14,14,12,29,16,16,16,16,16,4,14,14,14,14,14,
14,14,14,79,5,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,14,14,14,14,14,4,
120,4,16,16,16,16,4,14,14,14,14,14,12,29,4,22,
31,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,16,16,11,14,65,14,64,14,14,14,14,14,
14,14,4,17,17,17,4,4,4,4,14,14,14,14,14,14,
14,14,14,1,1,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,16,16,16,16,
16,16,16,16,16,16,4,4,4,4,4,4,4,3,7,16,
16,16,16,16,16,16,4,16,16,16,16,16,84,13,16,16,
10,29,16,4,82,14,14,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,31,14,14,14,14,14,14,14,12,
29,16,35,17,17,17,17,17,17,17,17,17,17,17,17,17,
17,82,14,14,14,14,14,14,4,16,16,16,4,16,16,16,
16,4,4,4,4,4,4,4,16,16,84,11,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,93,94,95,14,80,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,4,14,
14,4,16,16,16,16,16,4,14,4,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,14,14,14,14,14,14,14,
14,12,4,4,4,4,16,16,16,16,16,16,16,16,84,11,
14,14,64,14,14,14,14,14,14,14,4,107,36,37,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,11,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,93,94,95,14,
80,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
4,0,0,4,0,0,4,16,16,4,120,4,14,14,14,14,
14,14,14,14,14,12,29,16,4,6,7,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,14,14,14,14,14,
14,14,14,12,4,4,4,16,14,14,17,17,16,16,16,16,
84,11,14,14,64,14,14,14,14,14,14,14,4,106,107,106,
4,4,4,4,4,4,4,31,14,14,14,14,14,14,12,29,
16,16,16,16,16,16,4,14,14,14,14,14,14,14,14,80,
16,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,14,14,63,14,14,4,120,4,16,16,
16,16,4,14,14,14,14,12,29,16,4,0,0,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
16,16,16,11,14,14,64,14,14,14,14,14,14,14,4,17,
17,17,4,4,4,4,14,14,14,14,14,14,14,14,14,14,
14,14,1,1,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,16,16,16,16,16,16,16,16,
16,16,4,4,4,4,4,4,4,4,4,4,4,6,3,7,
99,16,4,16,16,16,16,16,16,16,16,10,29,16,16,4,
83,14,14,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,31,14,14,14,14,14,14,14,12,29,16,35,35,17,
17,17,17,17,17,17,17,17,17,17,17,17,17,83,14,14,
14,14,14,14,4,16,16,16,4,16,16,16,16,4,4,4,
4,4,4,4,16,16,16,84,11,14,14,14,14,14,14,14,
14,14,14,14,14,14,4,4,4,4,4,3,3,3,3,3,
3,3,3,3,3,3,3,3,3,16,4,14,14,4,4,16,
16,16,16,4,14,4,14,14,14,14,14,14,8,9,14,14,
14,14,14,14,14,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,14,14,14,14,14,14,14,14,12,4,4,4,
4,4,16,17,17,17,17,17,17,17,17,84,11,14,65,14,
14,14,14,14,14,14,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,11,14,14,14,14,14,
14,14,14,14,14,14,14,14,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,0,0,4,
0,0,4,16,16,4,120,4,8,9,14,14,14,14,14,14,
12,29,16,16,4,17,17,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,14,14,14,14,14,14,14,14,12,4,
4,16,16,16,14,14,17,17,16,16,16,16,16,84,11,14,
65,14,14,14,14,14,14,14,4,4,4,4,4,4,4,4,
4,4,4,14,14,14,14,14,14,12,29,16,16,16,16,16,
16,16,4,14,14,14,14,14,14,14,14,79,16,4,16,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,14,14,14,14,14,4,120,4,16,16,16,16,4,14,
14,14,12,29,16,16,4,14,14,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,16,16,16,16,
11,14,65,14,14,14,14,14,14,14,4,4,4,4,4,4,
4,4,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,1,1,14,14,14,14,14,14,14,14,14,14,14,14,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,16,16,16,16,16,16,16,16,16,16,4,4,
4,4,4,4,4,4,4,4,4,16,16,16,76,16,4,16,
16,16,16,16,16,16,10,29,16,16,16,4,82,14,14,4,
64,64,64,64,64,64,64,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,12,29,16,16,35,35,17,17,17,17,17,
17,17,17,17,17,17,17,17,17,82,14,14,14,14,14,14,
4,16,16,16,4,16,16,16,16,4,4,35,35,35,35,35,
16,16,16,16,84,11,14,14,14,14,14,14,14,14,14,14,
14,14,4,4,4,4,4,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,4,14,14,4,4,16,16,16,78,4,
14,4,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,4,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,12,4,4,4,4,4,4,16,17,
16,16,16,16,16,16,17,16,84,11,14,14,14,14,14,14,
14,14,4,4,4,4,4,4,4,4,4,4,4,16,16,16,
16,16,16,16,16,16,84,11,14,14,14,14,14,14,14,14,
14,14,14,14,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,0,0,4,0,0,4,16,
16,4,120,4,14,14,14,14,14,14,14,12,29,16,16,16,
4,6,7,4,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,12,4,4,16,16,16,16,
14,14,17,17,16,16,16,16,16,16,84,11,14,14,14,14,
14,14,14,14,4,4,4,4,4,4,4,4,4,4,4,14,
14,14,14,14,12,29,16,16,16,16,16,16,16,16,4,14,
14,14,14,14,14,14,14,80,5,4,16,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,14,63,
62,14,14,4,120,4,16,16,16,16,4,14,14,79,16,16,
16,16,4,14,14,4,64,64,64,64,64,64,64,64,64,64,
64,64,64,64,64,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,16,16,16,16,16,11,14,14,
14,14,14,14,14,14,4,4,4,4,4,4,4,4,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
1,1,14,14,14,14,14,14,14,14,14,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
16,16,16,16,16,16,16,16,16,16,4,4,4,4,4,4,
4,4,4,4,4,16,16,16,99,16,4,16,16,16,16,16,
108,10,29,16,16,16,16,4,83,14,14,4,64,64,64,64,
64,64,64,14,14,14,14,14,14,14,14,14,14,14,14,14,
12,29,16,16,16,35,35,17,17,17,17,17,17,17,17,17,
17,17,17,17,17,83,14,14,14,14,14,14,4,16,16,16,
16,16,16,16,16,4,4,35,35,35,35,35,16,16,16,16,
16,84,11,14,14,14,14,14,14,14,14,14,14,14,4,4,
4,4,4,16,16,16,16,16,16,16,16,16,16,3,3,3,
3,3,4,14,14,4,4,16,16,16,4,4,14,4,14,14,
14,14,8,9,14,14,14,14,14,14,14,120,14,4,14,14,
62,63,62,63,62,63,62,63,62,14,14,14,14,14,14,14,
14,14,12,4,4,4,4,4,4,4,81,17,81,81,81,81,
105,81,17,81,104,84,11,14,14,14,14,14,14,14,4,17,
4,4,4,4,4,4,4,4,4,16,16,16,16,16,16,16,
16,16,16,84,11,14,14,14,14,14,14,14,14,14,14,14,
4,4,17,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,0,0,4,0,0,4,16,16,4,120,4,
8,9,14,14,14,14,12,106,16,16,16,16,4,17,17,4,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,12,4,4,4,16,16,16,16,120,120,17,17,
16,16,16,16,16,16,16,84,11,14,14,14,14,14,14,14,
4,4,4,4,4,4,4,4,4,4,4,14,14,14,14,12,
29,16,16,16,16,16,16,16,16,16,4,14,14,14,14,14,
14,14,14,79,16,4,16,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,14,14,14,62,14,4,
120,4,4,4,4,4,4,14,14,80,16,16,16,16,4,0,
0,4,64,64,64,64,64,64,64,64,64,64,64,64,64,64,
64,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,16,16,16,16,16,16,11,120,14,14,14,14,
14,14,4,4,4,4,4,4,4,4,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,1,
1,14,14,14,14,14,14,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,16,16,16,16,
16,16,16,16,16,16,4,4,4,16,16,16,16,16,16,16,
77,6,3,7,76,16,4,13,16,16,16,16,10,29,16,16,
16,16,16,4,82,14,14,4,64,64,64,64,64,64,64,14,
14,14,14,14,14,14,14,14,14,14,14,12,29,16,16,16,
16,35,35,17,17,17,17,17,17,17,17,17,17,17,17,17,
17,82,14,14,14,14,14,14,4,16,16,16,16,16,16,16,
16,4,4,35,35,35,35,35,16,16,16,16,16,16,84,11,
14,14,14,14,14,14,14,14,14,14,4,4,4,4,4,16,
81,16,16,16,16,16,81,81,16,16,16,81,16,16,4,14,
14,4,16,16,16,16,4,4,120,4,14,14,14,14,14,14,
14,14,14,14,14,14,8,9,14,4,14,14,63,62,63,62,
63,62,63,62,63,14,14,14,14,14,14,14,14,12,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,11,120,14,14,14,14,14,4,4,4,4,17,4,
4,17,4,4,4,16,16,16,16,16,16,16,16,16,16,16,
84,11,14,14,14,14,14,14,14,14,14,14,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,0,0,4,0,0,4,16,16,4,120,4,14,14,14,14,
14,12,29,107,81,81,16,16,4,6,7,4,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,12,
4,4,4,4,16,16,16,16,14,14,17,17,16,16,16,16,
16,106,16,16,84,11,14,14,14,14,14,14,4,4,4,4,
4,4,4,31,14,14,14,14,14,120,12,29,16,16,16,16,
16,16,16,16,16,16,4,14,14,14,14,14,14,14,14,80,
16,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,14,14,14,14,14,4,120,4,4,4,
4,4,4,14,14,79,81,16,16,16,4,14,14,4,65,64,
14,64,64,64,64,64,64,64,64,64,64,64,64,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
16,16,16,100,101,16,16,11,14,14,14,14,14,14,4,4,
4,4,4,4,4,4,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,1,1,
14,14,14,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,16,16,16,16,16,16,16,16,
16,16,4,4,4,16,16,16,16,16,16,16,78,16,16,16,
99,16,4,84,13,16,16,10,29,16,16,16,16,16,16,4,
83,14,14,4,64,64,14,64,64,64,64,14,14,14,14,14,
14,14,14,14,14,14,12,29,16,16,16,16,16,35,35,17,
17,17,17,17,17,17,17,17,17,17,17,17,17,83,14,14,
14,14,14,14,4,16,16,16,16,16,16,16,16,4,4,35,
35,35,35,35,16,16,16,16,16,16,16,84,11,14,14,14,
14,14,14,14,14,14,14,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,14,14,4,16,16,
16,16,16,4,14,4,14,14,8,9,14,14,14,14,14,120,
14,14,14,14,14,4,14,14,62,63,62,63,62,63,62,63,
62,14,14,14,14,14,14,14,12,16,16,16,16,16,16,16,
16,16,16,4,4,4,4,4,4,4,4,4,4,4,4,4,
11,14,14,14,14,14,4,4,4,4,4,4,4,17,4,4,
4,16,16,16,16,16,16,16,16,16,16,16,16,84,11,14,
14,14,14,14,14,14,14,14,14,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,0,0,4,
0,0,4,16,16,4,120,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,5,5,4,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,12,4,4,4,4,4,
16,16,16,16,30,30,17,17,16,111,81,106,81,107,16,16,
16,84,11,14,14,14,14,14,4,4,4,4,4,4,4,14,
14,14,14,14,14,12,29,16,16,16,16,16,16,16,16,16,
16,16,4,14,14,14,14,14,14,14,14,79,5,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,14,63,14,14,14,4,120,4,4,4,4,4,4,14,
14,80,4,4,4,4,4,14,14,4,120,64,14,64,65,64,
64,64,64,64,64,64,64,64,64,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,81,106,81,104,
16,100,101,16,11,14,14,14,14,14,4,4,4,4,4,4,
4,4,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,16,16,16,16,16,16,16,16,16,16,4,4,
4,16,16,16,16,16,16,16,77,16,16,16,76,16,4,16,
84,13,16,16,16,16,16,16,16,16,16,4,82,14,14,4,
64,64,14,64,64,64,64,14,14,14,14,14,14,14,14,14,
14,12,29,16,16,16,16,16,16,35,35,17,17,17,17,17,
17,17,17,17,17,17,17,17,17,82,14,14,14,14,14,14,
4,16,16,16,16,16,16,16,16,16,16,35,35,35,35,35,
16,16,16,16,16,16,16,16,84,11,14,14,14,14,14,14,
14,14,14,14,14,14,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,14,14,4,16,16,16,16,16,4,
14,4,30,30,14,14,14,14,14,14,8,9,14,14,14,14,
14,4,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,12,16,16,16,16,16,16,16,16,16,16,16,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,11,14,14,
14,14,14,4,4,4,4,4,4,4,4,4,4,16,16,16,
16,16,16,16,16,16,16,16,16,16,84,11,14,14,14,14,
14,14,14,14,14,14,14,14,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,0,0,4,0,0,4,16,
16,4,14,14,64,64,64,64,14,64,14,64,64,14,64,14,
64,0,0,4,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,12,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,11,
14,14,14,14,14,22,4,4,4,4,4,14,14,14,14,14,
12,29,16,16,16,16,16,16,16,16,16,16,16,16,4,14,
14,14,14,14,14,14,14,80,16,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,14,14,
14,63,14,4,120,4,4,4,4,4,4,14,14,14,64,14,
64,14,64,0,0,4,14,65,14,64,14,64,64,64,64,64,
64,64,64,64,64,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,11,14,14,14,14,14,4,4,4,4,4,4,4,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
16,16,16,16,16,16,16,16,16,16,4,4,4,16,16,16,
16,16,16,16,78,2,3,3,99,16,4,16,16,84,13,16,
16,16,16,16,16,16,16,4,83,14,14,4,64,65,14,64,
64,64,64,14,14,14,14,14,14,14,14,14,12,29,16,16,
16,16,16,16,16,35,34,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,83,14,14,14,14,14,14,4,16,16,16,
16,16,16,16,16,16,16,35,35,35,35,35,16,16,16,16,
16,16,16,16,16,84,11,14,14,14,14,14,14,14,14,14,
14,14,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,14,14,4,16,16,16,16,78,4,14,4,4,4,
14,14,14,14,14,14,14,14,14,14,14,14,14,4,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,12,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,82,22,31,
80,16,16,16,16,16,16,16,16,84,11,14,14,14,14,14,
4,4,4,4,4,4,4,4,4,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,84,11,14,14,14,14,14,14,14,
14,14,14,14,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,0,0,4,0,0,4,4,4,4,14,14,
64,64,64,64,14,64,14,64,64,14,64,14,64,14,14,4,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
12,29,16,16,16,16,16,16,16,16,16,16,16,16,16,82,
22,31,80,16,16,16,4,4,4,4,4,4,11,14,14,14,
14,14,4,4,4,4,4,14,14,14,14,12,29,16,16,16,
16,16,16,16,16,16,16,16,16,16,4,14,14,14,14,14,
14,14,14,79,16,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
120,4,4,4,4,4,4,14,14,14,64,14,64,14,64,14,
14,4,14,14,14,65,14,64,65,64,64,64,64,64,64,64,
64,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,11,14,
14,14,14,14,4,4,4,4,4,4,14,14,120,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,1,1,14,120,14,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,16,16,16,16,
16,16,16,16,16,16,4,4,4,16,16,16,16,16,16,16,
77,16,16,16,76,16,4,16,16,16,84,13,16,16,16,16,
16,16,16,4,82,14,14,4,64,14,14,64,65,64,64,14,
14,14,14,14,14,14,14,12,29,16,16,16,16,16,16,16,
16,35,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,82,8,8,8,9,8,9,4,16,16,16,16,16,16,16,
16,16,16,35,35,35,34,35,16,16,16,16,16,16,16,16,
16,16,84,11,14,14,14,14,14,14,14,14,14,14,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,14,
14,4,16,16,16,4,4,4,14,4,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,4,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,12,16,104,16,16,16,16,
16,16,16,16,16,16,16,16,16,83,14,14,79,16,16,16,
16,16,16,16,16,16,84,11,14,14,14,14,14,4,4,4,
17,4,4,4,4,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,84,11,14,14,14,14,14,14,14,14,14,14,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,0,0,4,0,0,4,4,4,4,14,14,64,64,64,65,
14,64,14,65,64,14,65,14,64,0,0,4,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,12,29,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,83,14,14,79,16,
16,16,4,14,4,4,4,4,4,11,14,14,14,14,14,22,
4,4,4,14,14,14,12,29,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,4,11,14,14,14,14,14,14,14,80,
5,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,120,4,4,4,
4,4,4,14,14,14,64,14,65,14,64,14,14,4,9,14,
14,14,14,65,14,64,65,64,64,64,64,64,64,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,11,14,14,14,14,
14,4,4,4,4,4,14,14,120,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,16,16,16,16,16,16,16,16,
16,16,4,4,4,16,16,16,16,16,16,16,78,16,16,16,
99,16,4,16,16,16,16,84,13,16,16,16,16,16,16,4,
83,14,14,4,64,14,14,65,14,64,64,14,14,14,14,14,
14,14,12,29,16,16,16,16,16,16,16,16,16,34,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,83,14,14,
70,71,72,23,4,16,16,16,16,16,16,16,16,16,16,35,
34,35,16,35,16,16,16,16,16,16,16,16,16,16,16,84,
11,14,14,14,14,14,14,14,14,14,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,14,14,4,16,16,
16,4,4,4,14,4,14,14,14,8,9,14,14,14,14,14,
14,14,14,14,14,4,14,14,120,14,14,14,14,14,14,14,
14,14,14,14,12,104,104,104,16,16,16,16,16,16,16,16,
16,16,16,16,16,82,120,120,80,16,16,16,16,16,16,16,
16,16,16,84,11,14,14,14,14,14,4,4,4,4,4,4,
4,16,106,16,100,101,16,16,16,16,16,16,16,81,16,16,
16,84,11,14,14,14,14,14,14,14,14,14,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,0,0,4,
0,0,4,4,4,4,14,14,65,65,64,14,14,65,14,14,
64,14,14,14,64,14,14,4,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,12,29,16,16,16,16,16,16,16,16,
16,16,16,16,5,5,16,82,120,120,80,16,16,16,4,14,
4,4,4,4,4,4,11,14,14,14,14,14,14,14,14,14,
14,12,29,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,4,4,11,14,14,14,14,14,14,79,16,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,120,4,4,4,4,4,4,14,
14,14,64,14,120,14,64,0,0,4,14,8,9,14,14,14,
14,64,14,64,64,64,64,64,64,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,11,14,14,14,14,14,14,14,
14,14,14,14,120,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,16,16,16,16,16,16,16,16,16,16,4,4,
4,16,16,16,16,16,16,16,77,81,16,16,76,16,4,16,
16,16,16,16,84,13,16,16,16,16,16,4,82,14,14,4,
14,14,14,14,14,14,65,14,14,14,14,14,14,12,29,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,82,14,14,73,74,75,23,
4,16,16,16,16,16,16,16,16,16,16,34,16,34,16,35,
16,16,16,16,16,16,16,16,16,16,16,16,84,11,14,14,
14,14,14,14,14,14,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,14,14,4,16,16,16,4,4,4,
120,4,14,14,14,14,14,14,14,14,14,14,14,14,120,14,
14,4,14,14,14,14,88,14,14,90,91,92,14,14,14,12,
16,104,104,104,104,16,16,16,16,16,16,16,100,101,16,16,
16,83,14,14,79,16,104,16,16,16,16,16,16,16,16,16,
84,11,14,14,14,14,14,4,4,4,4,4,4,106,107,81,
81,100,101,16,16,16,16,16,18,19,16,16,16,16,84,11,
14,14,14,14,14,14,14,14,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,0,0,4,0,0,4,4,
4,4,14,14,14,14,65,14,14,14,14,14,65,14,14,14,
65,0,0,4,14,14,14,14,14,14,14,14,14,14,14,14,
14,12,29,16,16,16,16,16,16,16,106,16,16,16,16,16,
16,16,16,83,14,14,79,16,16,16,4,14,4,4,4,4,
4,4,84,11,14,14,14,14,14,14,14,14,12,29,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,4,4,
4,11,14,14,14,14,14,80,16,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,14,14,14,14,12,4,4,14,14,14,65,14,
14,14,65,14,14,4,14,14,14,8,9,14,14,65,14,14,
64,64,64,64,64,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,16,11,14,14,14,14,14,14,14,14,14,14,
120,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,1,1,1,1,1,1,1,1,1,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
16,16,16,16,16,16,16,16,16,16,4,4,4,16,78,6,
6,3,3,3,3,3,3,4,4,4,4,16,16,81,16,81,
81,84,13,16,16,16,81,4,83,14,14,4,120,120,120,120,
120,120,120,14,14,14,14,14,12,29,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,81,16,83,14,14,96,97,98,23,4,16,81,16,
16,16,16,16,16,16,36,37,16,16,16,34,16,16,16,16,
16,16,16,16,16,16,16,16,16,84,11,14,14,14,14,14,
14,14,14,80,16,16,16,16,16,16,16,16,16,16,16,16,
31,14,14,14,14,14,16,16,16,78,4,4,14,4,30,30,
30,30,30,30,30,30,30,30,30,30,30,30,14,4,88,88,
24,50,89,88,24,93,94,95,88,88,12,36,37,105,104,104,
104,104,81,16,16,16,16,16,16,104,36,37,104,82,30,30,
80,16,105,81,81,81,104,36,37,16,16,16,16,84,11,14,
14,14,14,14,4,4,4,4,4,4,4,4,4,4,4,16,
16,16,16,16,16,16,16,16,16,16,16,84,11,14,14,14,
14,14,14,14,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,31,14,14,0,0,14,0,0,4,4,4,4,14,14,
30,30,30,30,30,30,30,30,30,30,30,30,30,30,30,4,
30,112,30,112,30,112,112,30,30,112,30,112,12,29,16,16,
16,16,16,16,81,16,107,16,16,81,81,16,16,16,16,82,
30,30,80,16,16,81,4,14,4,4,4,4,4,4,16,84,
11,14,14,14,14,14,14,12,29,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,4,4,4,4,11,14,
14,14,14,79,5,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
14,14,14,12,29,4,4,30,30,30,30,30,30,30,30,30,
30,4,14,14,14,14,14,8,9,14,14,14,65,64,64,64,
64,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
16,16,11,14,14,14,14,14,14,14,14,14,120,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,1,0,14,14,14,
14,14,14,14,14,14,14,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,16,16,16,16,
16,16,16,16,16,16,4,4,4,6,7,99,16,16,16,16,
16,16,16,16,16,4,4,4,4,4,4,4,4,4,4,22,
31,22,31,4,82,14,14,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,6,2,2,2,2,7,16,6,2,2,
2,2,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,16,16,16,16,16,16,16,
16,16,16,16,16,16,84,11,120,14,14,14,14,14,14,14,
22,31,22,31,22,31,22,31,22,31,22,31,14,14,14,14,
14,14,4,4,4,4,4,4,14,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,3,3,3,
3,3,16,16,3,3,3,3,3,3,3,3,3,3,3,3,
3,3,3,3,3,3,3,3,6,7,4,11,14,14,14,14,
14,4,4,4,4,4,4,4,4,4,4,16,16,16,16,16,
16,16,16,16,16,16,16,16,84,11,14,14,14,14,14,14,
22,31,22,31,22,31,22,31,22,31,22,31,22,31,14,14,
14,0,0,14,0,0,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,0,0,14,0,0,
0,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,31,22,31,14,14,14,
14,120,12,29,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,4,4,4,4,4,11,14,14,14,80,
16,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,14,14,14,14,14,14,14,14,12,29,
16,4,4,4,4,4,4,4,4,4,4,4,4,4,14,14,
14,14,14,14,14,8,9,14,14,14,64,64,64,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,31,22,31,14,
14,14,14,14,14,14,14,14,120,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,16,16,16,16,16,16,16,16,
16,16,4,4,4,16,16,76,16,16,16,16,16,16,16,16,
16,16,16,16,16,83,14,14,14,14,14,14,14,14,45,14,
14,14,14,22,31,22,31,22,31,22,31,22,31,22,31,22,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,16,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,35,35,
35,35,35,35,35,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,84,11,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,28,28,
14,14,14,14,14,14,14,14,14,64,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,64,64,64,64,64,64,64,64,
64,64,64,64,14,64,14,12,16,16,16,16,16,16,16,16,
16,16,16,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,16,16,4,4,11,120,14,14,14,14,4,4,
4,17,4,4,4,4,4,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,84,11,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,0,0,14,
0,0,4,4,4,14,14,14,14,14,14,64,14,14,14,14,
26,27,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,80,7,11,14,14,14,14,14,14,14,
14,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,14,14,14,14,14,14,14,12,29,5,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,4,4,11,14,14,79,16,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,14,14,14,14,14,14,14,12,29,16,16,4,4,14,
14,14,26,27,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,8,9,14,64,64,64,64,64,64,14,62,14,14,
14,14,62,14,14,14,14,14,14,14,14,14,14,14,62,63,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,120,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,16,16,16,16,16,16,16,16,16,16,4,4,
4,16,16,99,16,16,16,16,16,16,16,16,16,16,16,16,
16,82,14,14,14,14,14,14,45,45,45,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,16,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,16,16,16,16,16,16,16,35,35,35,35,35,35,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
84,11,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,28,28,14,14,14,14,
14,14,14,14,14,64,14,14,14,14,14,26,27,14,14,14,
14,14,14,14,14,64,64,64,64,64,64,64,64,64,14,65,
14,65,12,16,16,16,16,16,16,16,16,16,16,16,16,4,
4,4,17,4,4,4,4,4,4,4,4,4,4,4,4,4,
16,16,4,4,4,11,120,14,14,14,14,4,4,4,4,4,
4,17,4,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,84,11,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,0,0,14,0,0,4,4,
4,14,14,14,14,14,14,64,14,14,14,14,28,26,27,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,79,16,84,11,14,14,14,14,14,14,14,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,14,14,14,14,14,14,12,29,16,5,82,4,4,4,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,4,4,4,14,14,80,5,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,14,14,
14,14,14,14,12,29,16,16,16,4,4,14,14,14,28,26,
27,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,64,64,65,64,14,65,14,14,14,62,63,14,14,14,
14,62,63,14,14,14,14,14,14,14,14,14,14,14,14,14,
63,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
120,14,14,14,14,14,14,14,14,14,14,14,14,14,14,1,
1,1,1,14,14,14,14,14,14,14,14,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
16,16,16,16,16,16,16,16,16,16,4,4,4,6,7,76,
16,16,16,16,16,16,16,16,16,16,16,16,16,83,14,14,
14,14,14,14,45,45,45,45,14,14,14,48,49,14,14,14,
14,14,14,14,14,14,14,14,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
22,4,4,4,4,4,4,4,4,4,4,4,4,4,4,16,
16,16,16,16,16,16,35,35,34,35,35,35,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,84,11,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,28,28,14,14,14,14,14,14,14,14,
14,64,14,14,14,14,14,28,14,14,14,14,14,14,14,14,
14,64,64,14,64,64,64,64,14,64,14,14,14,12,16,16,
16,18,19,16,16,16,16,16,16,16,16,4,4,4,17,4,
4,4,4,4,4,4,17,4,4,4,4,4,6,7,4,4,
4,84,11,120,14,14,14,14,4,4,4,4,4,4,4,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,84,
11,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,0,0,14,0,0,4,4,4,14,14,14,
14,14,14,64,14,14,14,26,28,28,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,80,16,
16,84,11,14,14,14,14,14,14,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,14,14,
14,14,14,12,29,16,5,5,83,14,4,4,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,4,4,
4,14,14,79,16,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,14,14,14,14,14,12,
29,16,16,16,16,4,4,14,14,26,28,28,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,64,64,
14,65,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,62,63,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,120,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,1,
0,14,14,14,14,14,14,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,16,16,16,16,
16,16,16,16,16,16,4,4,4,16,16,99,16,16,16,16,
16,16,16,16,16,16,16,16,16,82,14,14,14,14,14,45,
45,14,45,45,14,14,14,14,51,48,49,14,14,14,14,14,
14,14,14,14,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,120,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,16,16,16,16,16,
100,101,16,35,16,34,16,35,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,84,11,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,28,28,14,14,14,26,27,14,14,14,14,64,14,26,
27,14,14,28,14,14,14,14,14,14,14,14,14,65,64,14,
64,14,64,64,14,65,14,14,12,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,16,16,4,4,4,16,84,11,
120,14,14,14,14,4,4,4,4,4,4,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,84,11,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,0,0,14,0,0,4,4,4,26,27,14,14,14,14,64,
14,26,27,28,28,28,14,14,14,14,14,14,14,14,14,14,
14,14,120,14,14,14,14,14,14,14,79,16,16,16,84,11,
14,14,14,14,14,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,14,14,14,14,14,12,29,
16,5,5,5,82,14,14,4,4,4,4,4,4,16,16,16,
16,16,16,16,16,16,16,16,16,16,4,4,4,14,14,80,
16,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,14,14,14,14,12,29,16,16,16,16,
16,4,4,26,27,28,28,28,14,14,14,14,14,14,14,14,
14,8,9,14,8,9,14,8,9,14,64,65,14,14,14,14,
14,14,14,14,14,14,62,14,14,14,14,14,14,14,14,14,
14,14,14,14,63,14,14,14,14,62,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,120,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,0,1,
14,14,14,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,16,16,16,16,16,16,16,16,
16,16,4,4,4,16,16,76,16,16,16,16,16,16,16,16,
36,37,16,106,16,83,30,14,14,14,45,45,45,45,45,45,
45,45,48,49,52,60,51,14,14,14,14,14,14,14,14,14,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,120,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,16,16,16,100,101,16,104,16,34,
106,16,16,35,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,84,11,14,14,14,14,48,49,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,28,28,
14,14,14,28,14,14,14,26,27,65,14,28,14,14,14,28,
14,14,14,14,14,14,14,14,14,14,65,14,64,14,64,64,
14,14,14,12,16,16,16,16,16,106,16,104,16,16,16,16,
16,16,16,4,4,4,4,4,4,4,4,4,17,4,4,4,
4,4,4,4,16,16,4,17,4,16,16,84,11,120,14,14,
14,14,4,4,4,4,4,16,16,16,16,106,104,16,16,104,
16,16,16,16,16,16,16,16,16,84,11,14,14,14,14,48,
49,14,14,14,14,14,14,14,14,14,14,14,14,0,0,14,
0,0,4,4,4,28,14,14,14,26,27,65,14,28,14,28,
28,28,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,80,16,16,106,16,84,11,14,14,88,
14,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,14,14,14,14,14,14,12,29,16,16,5,5,5,
83,14,14,14,4,4,4,4,4,16,16,16,16,16,16,16,
16,16,16,16,16,16,4,4,4,14,14,79,5,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,11,14,14,14,4,4,4,4,4,4,4,4,4,28,
120,28,28,28,14,14,14,14,14,14,8,9,14,14,14,14,
14,14,14,14,14,14,65,14,14,14,14,62,63,14,14,14,
14,14,14,63,14,14,14,14,14,63,14,14,14,14,14,62,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,120,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,16,16,16,16,16,16,16,16,16,16,4,4,
4,6,7,99,16,16,16,16,16,78,3,3,3,3,2,2,
2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,
2,4,4,14,14,14,14,14,14,14,14,14,22,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,120,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,16,81,16,105,36,37,105,100,101,107,106,16,34,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,106,16,16,84,11,14,14,68,69,52,60,14,66,67,66,
67,66,67,66,67,66,67,14,14,14,28,28,60,26,27,28,
26,26,27,28,14,26,27,28,60,14,14,28,60,26,27,60,
60,14,14,14,14,14,14,14,65,14,64,64,14,14,12,16,
16,16,106,36,37,107,104,105,36,37,36,36,37,36,37,4,
4,4,17,4,4,4,4,4,4,4,4,4,17,4,4,4,
6,7,4,4,4,16,81,16,84,11,120,14,14,14,14,4,
4,4,4,16,105,102,103,107,105,103,103,104,36,37,105,16,
102,104,16,104,105,102,84,11,14,14,68,69,52,60,14,66,
67,66,67,66,67,66,67,66,67,0,0,14,0,0,4,4,
4,28,26,26,27,28,14,26,27,28,60,28,28,28,60,26,
27,60,60,14,46,47,47,47,47,47,47,47,47,14,14,14,
14,14,79,16,16,107,16,16,100,49,30,89,88,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,14,14,14,
14,14,14,14,12,29,5,5,16,16,16,5,82,14,14,14,
14,4,4,4,4,16,16,16,16,16,16,16,16,16,16,16,
16,16,4,4,4,14,14,80,16,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,84,11,
14,14,14,14,14,14,14,14,4,4,4,28,60,28,28,28,
60,26,27,60,60,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,21,14,14,
14,14,20,14,14,14,14,14,14,14,14,14,112,14,14,14,
14,14,14,14,14,14,14,14,112,14,14,14,14,14,14,14,
14,14,14,14,112,14,14,14,14,14,14,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
16,16,16,16,16,16,16,16,16,16,4,4,4,16,16,76,
16,16,16,16,16,77,16,16,82,22,31,22,31,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,14,
14,14,14,14,14,14,14,14,14,22,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
120,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,3,3,3,3,3,2,2,2,2,2,2,2,2,2,
2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,
2,2,3,3,3,3,3,3,3,3,3,3,3,3,3,3,
3,3,3,3,3,3,4,4,3,3,3,3,3,3,3,3,
3,3,3,3,3,3,3,3,3,3,3,3,3,3,3,3,
4,83,14,14,14,14,64,14,14,12,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,16,16,4,4,
4,4,4,4,4,4,11,14,14,14,14,14,4,4,4,2,
2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,
2,2,2,2,3,3,3,3,3,3,3,3,3,3,3,3,
3,3,3,3,3,3,3,3,4,4,3,3,3,3,3,3,
3,3,3,3,3,3,3,3,3,3,3,3,3,3,3,3,
3,3,3,1,1,1,1,1,1,1,14,12,7,3,3,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,14,14,14,14,14,14,12,
29,16,16,16,16,16,16,16,11,14,14,14,14,14,4,4,
4,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,
2,14,14,79,16,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,16,84,11,14,14,14,
14,14,14,14,4,88,4,3,3,3,3,3,3,3,3,3,
3,3,3,3,3,3,7,11,14,14,14,14,14,12,7,6,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,1,14,14,1,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,6,7,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,16,16,16,16,
16,16,16,16,16,16,4,4,4,16,16,99,16,16,16,16,
16,78,16,16,83,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
22,4,4,4,4,4,4,4,4,4,4,4,4,4,31,22,
31,22,31,22,31,22,31,22,31,22,31,22,31,22,31,22,
31,22,31,22,31,22,31,22,31,4,4,4,4,4,17,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,4,4,16,16,16,16,16,16,16,16,17,16,17,16,
17,16,17,16,17,16,17,16,17,16,17,16,4,82,14,14,
14,14,65,14,12,16,16,16,16,16,16,83,14,14,28,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,4,16,16,16,4,4,4,4,4,
4,4,4,11,14,14,14,14,14,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
17,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,4,4,16,16,16,16,16,16,16,16,17,16,
17,16,17,16,17,16,17,16,17,16,17,16,17,82,14,14,
14,14,14,14,14,14,12,29,16,16,16,4,4,4,4,4,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,12,29,16,16,16,16,
16,16,16,16,84,11,14,14,14,14,14,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,31,14,14,80,
5,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,16,16,84,11,14,14,14,14,14,14,
4,86,4,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,84,11,14,14,14,12,29,16,16,4,4,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,86,86,86,86,86,86,
48,49,87,86,86,86,86,14,86,86,14,86,14,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,31,14,
79,16,16,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,16,16,16,16,16,16,16,16,
16,16,4,4,4,3,3,16,16,16,16,16,16,77,16,16,
82,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,63,63,63,63,80,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,4,4,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,14,14,14,14,14,14,12,
16,16,16,16,16,16,16,82,14,14,28,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,79,6,7,16,16,16,16,16,16,16,16,4,84,
11,14,14,14,14,14,4,4,4,63,63,63,4,63,63,63,
63,63,63,63,63,63,63,63,63,63,63,63,80,16,16,16,
16,18,19,16,16,16,16,16,16,16,16,16,16,16,16,16,
4,4,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,31,14,14,14,14,14,14,14,
14,12,29,16,16,16,16,4,4,82,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,12,29,16,16,16,16,16,16,16,106,16,
16,84,11,14,14,14,14,14,4,4,4,4,4,4,4,14,
14,14,14,14,14,14,14,14,14,14,14,79,16,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,16,84,11,120,14,14,14,14,4,86,4,22,
31,22,31,22,31,22,31,22,31,22,31,22,31,22,31,22,
31,14,14,12,29,16,16,16,16,4,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,48,49,86,86,87,86,86,86,86,52,14,87,
86,86,86,14,14,87,14,86,14,14,4,4,4,4,4,4,
4,14,14,14,14,14,14,14,14,14,14,14,80,16,16,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,16,16,16,16,16,16,16,16,16,16,4,4,
4,16,16,16,16,16,16,16,106,78,16,16,83,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,63,63,63,63,79,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,4,4,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,12,16,16,16,16,16,
16,16,16,83,14,14,28,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,80,
16,16,16,16,16,16,16,16,16,16,4,16,84,11,14,14,
14,14,14,4,4,63,32,63,4,63,63,63,63,63,63,63,
63,63,63,63,63,63,63,63,79,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,4,4,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,1,14,14,14,14,14,14,14,14,12,29,16,16,
16,16,16,4,4,83,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,80,16,16,16,16,16,16,106,106,107,16,16,16,84,11,
14,14,14,14,14,4,4,4,4,4,4,14,14,14,14,14,
14,14,14,14,14,14,14,80,16,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
16,16,84,11,14,14,14,14,4,86,4,14,14,14,14,14,
14,14,14,14,14,14,8,9,14,14,14,14,14,120,12,29,
16,16,16,16,16,4,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,48,49,14,14,14,14,14,14,14,14,14,14,
14,52,86,87,14,87,86,86,86,52,48,49,87,86,86,14,
14,14,14,87,14,14,86,4,4,4,4,4,4,14,14,14,
14,14,14,14,14,14,14,14,79,6,7,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
16,16,16,16,16,16,16,16,16,16,4,4,4,16,16,6,
3,7,4,4,2,2,2,2,2,11,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,8,9,8,9,8,9,4,
4,8,9,8,9,8,9,14,14,14,14,14,14,14,63,63,
63,63,80,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,4,4,14,45,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,79,16,16,16,16,18,19,16,16,16,82,
14,14,28,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,79,16,16,16,16,
16,16,16,16,16,16,4,16,16,84,11,14,14,14,14,14,
4,63,33,63,4,63,63,63,63,63,63,63,63,63,63,63,
63,63,63,63,80,16,16,16,16,18,19,16,16,16,16,16,
16,16,16,16,16,16,16,16,4,4,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,12,29,6,3,4,4,4,4,4,
4,82,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,79,6,7,
4,4,1,1,1,1,1,1,4,3,3,7,11,14,14,14,
14,14,4,4,4,4,4,14,14,14,14,14,14,14,14,14,
14,14,14,79,5,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,16,16,16,84,
11,14,14,14,4,86,4,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,12,29,16,16,16,16,16,
16,4,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,52,14,14,14,14,14,14,14,14,14,14,14,52,86,48,
49,14,86,87,86,52,52,14,14,86,87,48,49,14,14,14,
14,14,86,86,4,4,4,4,4,14,14,14,14,14,14,14,
14,14,14,14,80,16,16,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,16,16,16,16,
16,16,16,16,16,16,4,4,4,16,16,16,16,16,4,4,
16,17,16,16,16,84,11,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,70,71,72,23,4,4,120,120,120,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,79,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,4,4,45,45,14,14,45,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,80,16,16,16,16,16,16,16,16,16,83,14,14,28,14,
14,14,14,14,14,14,14,14,14,26,27,14,14,120,14,14,
14,14,14,14,14,14,14,80,6,7,16,16,16,16,16,16,
16,16,4,16,16,16,84,11,14,14,14,14,14,4,63,63,
4,120,14,14,14,14,14,14,14,14,14,14,14,14,14,52,
79,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,4,4,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,12,29,100,101,16,70,71,72,23,4,4,83,14,48,
49,14,14,14,14,48,49,48,49,14,14,14,14,14,14,120,
48,49,14,14,14,14,14,14,14,80,16,16,4,4,14,14,
14,14,14,14,4,16,16,16,84,11,14,14,14,14,14,4,
4,4,4,14,14,14,14,14,14,14,14,14,14,14,14,80,
16,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,14,14,12,
4,86,4,14,14,14,14,14,14,14,14,14,14,14,8,9,
14,14,14,14,12,29,100,101,16,100,101,16,16,4,14,14,
14,48,49,14,14,14,14,48,49,48,49,14,14,52,14,14,
14,120,48,49,14,14,14,14,14,52,87,14,52,14,87,14,
14,52,52,14,14,87,14,52,14,14,14,14,14,14,86,14,
86,4,4,4,4,14,14,14,14,14,14,14,14,14,14,14,
79,16,16,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,16,16,16,16,16,16,16,16,
16,16,4,4,4,3,3,7,4,4,4,4,4,4,4,4,
16,16,84,11,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,48,49,14,14,14,14,14,14,14,14,14,48,49,14,14,
48,49,14,14,14,52,14,14,14,14,14,14,14,14,14,14,
14,14,14,73,74,75,23,4,4,120,120,120,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,80,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,4,4,
45,45,45,45,45,45,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,79,16,16,
16,16,16,16,16,16,16,82,14,14,28,14,14,14,14,14,
14,14,14,26,27,28,14,14,14,14,14,14,14,24,14,14,
14,14,14,79,16,16,16,16,16,16,16,16,16,16,4,16,
16,104,16,84,11,14,14,14,14,14,4,4,4,120,14,14,
14,14,14,52,14,14,14,14,14,14,14,52,80,16,16,16,
16,18,19,16,16,16,16,16,16,16,16,16,16,16,16,16,
4,4,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,12,29,16,
104,100,101,73,74,75,23,4,4,82,14,52,48,49,48,49,
88,52,48,49,51,48,49,14,14,14,88,48,49,52,14,14,
48,49,14,88,14,79,6,7,4,4,14,14,14,14,14,14,
4,16,16,16,16,84,11,14,14,14,14,14,4,4,4,14,
14,14,14,14,14,14,14,14,14,14,14,79,16,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,14,14,14,14,14,14,12,29,4,86,4,14,
14,14,14,14,14,14,14,14,8,9,14,14,14,14,14,12,
29,16,104,100,101,104,16,100,101,4,14,14,14,52,48,49,
48,49,88,52,48,49,51,48,49,52,14,14,88,48,49,52,
14,14,48,49,52,52,48,49,52,14,14,14,14,52,52,88,
14,48,49,52,14,14,48,49,14,14,87,14,86,86,4,4,
4,14,14,14,14,14,14,14,14,14,14,14,80,6,7,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,16,16,16,16,16,16,16,16,16,16,4,4,
4,16,16,4,4,4,4,4,4,4,4,4,16,16,16,84,
11,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,30,24,66,67,66,67,66,67,66,67,60,
60,14,14,14,14,14,60,14,14,14,112,48,49,61,52,14,
14,14,14,14,14,14,14,14,14,52,61,14,51,14,30,30,
14,53,30,48,49,14,14,68,69,30,30,30,30,30,14,96,
97,98,23,4,4,120,120,120,112,14,14,68,69,14,60,60,
60,60,61,60,60,14,79,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,4,4,45,45,45,120,
45,45,45,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,80,16,81,81,16,16,16,
16,16,16,83,14,14,28,14,60,14,14,12,7,3,3,3,
3,3,3,3,3,3,3,3,3,3,3,3,3,3,11,80,
16,16,16,16,81,16,81,16,16,16,4,16,16,18,19,16,
84,11,14,14,14,14,14,4,4,120,112,14,24,68,69,52,
60,60,60,60,61,60,60,53,79,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,4,4,14,14,
14,120,14,14,14,47,47,47,47,47,47,47,47,47,47,47,
47,47,47,47,47,47,47,20,12,29,16,81,105,106,104,96,
97,98,23,4,4,83,48,49,53,52,88,52,89,53,60,48,
49,61,53,88,48,49,89,52,51,53,88,48,49,52,61,89,
88,80,16,16,4,4,14,14,14,14,14,14,4,16,16,16,
16,16,84,11,14,14,14,14,14,4,4,14,14,14,14,14,
14,14,14,14,14,14,14,80,5,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
14,14,14,14,14,12,29,16,4,86,4,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,12,29,16,81,105,106,
104,100,101,105,16,4,68,69,48,49,53,52,88,52,89,53,
60,48,49,61,53,53,48,49,89,52,51,53,88,48,49,52,
53,53,60,51,53,60,48,49,24,53,53,89,26,27,51,53,
48,49,60,51,48,49,14,14,87,86,86,86,4,14,14,14,
14,14,14,14,14,14,14,14,79,16,16,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
16,16,16,16,16,16,16,16,16,16,4,4,4,16,16,4,
4,4,4,4,4,4,4,4,16,16,16,16,84,11,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,12,3,3,
2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,
2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,
2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,
2,2,2,2,2,2,2,2,2,7,3,3,3,3,3,3,
3,3,3,3,3,3,3,3,3,3,3,3,3,3,3,3,
3,3,3,3,3,3,3,3,3,3,3,16,16,16,16,16,
16,16,16,16,16,16,4,4,45,45,45,45,45,45,45,45,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
12,7,2,2,2,2,2,2,2,2,2,2,2,2,2,2,
2,2,2,2,2,2,2,4,4,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,79,2,2,2,2,
2,2,2,2,16,16,4,16,16,16,16,16,16,84,11,14,
14,14,14,14,4,3,3,3,3,3,3,3,3,3,3,3,
3,3,3,3,3,3,3,3,3,3,3,3,3,3,3,3,
3,3,3,3,3,3,3,3,4,4,14,14,14,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,6,2,2,2,2,2,2,2,2,2,2,2,2,
2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,
2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,
2,82,14,14,14,14,14,14,4,16,16,16,16,16,16,84,
11,14,14,14,14,14,4,14,30,112,120,30,30,30,30,30,
30,30,30,79,16,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,11,14,14,14,
12,29,16,16,4,89,4,3,3,3,3,3,11,14,8,9,
14,12,3,3,3,3,3,3,3,3,3,3,3,3,3,3,
2,4,6,2,2,2,2,2,2,2,2,2,2,2,2,2,
2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,
2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,
2,7,11,14,14,86,87,86,4,14,14,14,14,14,14,14,
14,14,14,14,80,16,16,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,16,16,16,16,
16,16,16,16,16,16,4,4,4,6,7,76,17,17,17,16,
16,16,16,16,16,16,16,16,16,84,11,14,14,14,14,14,
14,14,14,14,14,14,14,14,79,16,16,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,22,31,22,31,22,31,22,31,22,31,22,
31,79,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,82,22,31,22,31,22,31,22,31,22,
31,22,31,22,31,22,31,22,31,22,31,22,31,22,31,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,4,4,4,4,4,4,4,4,4,4,45,14,8,9,
14,14,8,9,14,14,8,9,14,14,8,9,4,4,4,110,
16,16,16,16,16,16,16,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,82,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,80,16,16,16,16,100,101,16,16,
16,16,4,16,16,16,16,104,16,16,84,11,14,14,14,14,
14,22,31,22,31,22,31,22,31,22,31,22,31,22,31,22,
4,4,4,4,4,1,1,1,1,1,1,1,1,1,1,1,
1,1,1,1,4,4,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,4,
4,16,16,16,16,16,16,16,16,4,4,4,4,4,4,4,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,79,16,16,16,16,16,16,16,83,14,14,
14,14,14,14,4,16,16,16,16,16,16,16,84,11,14,14,
14,14,0,0,0,0,0,0,0,0,0,0,0,0,0,80,
16,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,84,11,14,14,4,4,4,4,
4,4,4,1,1,1,1,1,1,14,14,14,14,1,1,1,
1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,
1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,
1,1,1,1,1,1,1,79,4,4,1,1,1,0,0,1,
1,1,1,1,0,4,4,16,16,16,16,16,16,16,84,11,
14,86,14,87,0,14,14,14,14,14,14,120,12,2,2,2,
2,2,7,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,16,16,16,16,16,16,16,16,
16,16,4,4,4,16,16,99,17,17,17,16,16,16,16,16,
16,16,16,16,16,16,84,11,14,14,14,14,14,14,14,14,
14,14,14,14,80,16,16,4,4,17,17,17,17,17,17,17,
17,4,4,4,4,4,4,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,80,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,83,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,79,16,16,16,16,16,
16,16,16,6,7,16,16,16,16,16,16,16,16,16,4,4,
4,4,4,4,4,4,4,4,45,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,4,4,4,16,106,16,16,16,
106,16,16,4,4,4,4,4,4,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,79,16,16,16,16,106,100,101,16,16,16,4,16,
16,106,16,104,16,16,16,84,11,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,86,86,86,86,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
4,4,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,4,4,16,16,16,
16,16,16,16,16,4,4,4,4,4,4,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,80,16,16,104,16,16,16,16,82,14,14,14,14,14,14,
4,16,16,16,16,16,16,16,16,84,11,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,79,5,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,16,84,11,14,14,14,14,14,14,14,4,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,63,63,63,63,63,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,80,4,4,14,14,14,14,14,14,14,14,14,14,
14,14,4,16,16,16,16,16,16,16,16,84,11,87,14,14,
14,14,14,14,14,14,14,12,29,16,16,16,16,16,16,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,16,16,16,16,16,16,16,16,16,16,4,4,
4,16,16,76,17,17,17,16,16,16,16,16,16,16,16,16,
16,16,16,84,11,14,14,14,14,14,14,14,14,14,14,14,
79,16,16,4,4,17,17,17,17,17,17,17,17,4,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,79,16,16,81,16,16,16,
16,16,16,16,16,16,36,37,16,81,36,37,16,16,82,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,80,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,4,4,4,4,4,4,
17,17,4,4,45,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,4,4,4,16,107,16,16,16,107,106,16,4,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,80,
16,16,16,16,107,81,105,100,101,81,4,106,106,107,106,104,
16,16,16,16,84,11,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,86,86,86,86,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,4,4,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,4,4,16,16,16,16,16,16,16,
16,4,28,28,28,28,28,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,79,16,16,
104,104,16,16,16,83,14,14,14,14,14,79,4,16,16,16,
16,16,16,16,16,16,84,11,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,80,16,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
16,16,84,11,14,14,14,14,14,14,4,14,14,14,14,14,
14,14,8,9,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,63,63,63,63,63,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,79,
4,4,14,14,14,14,14,120,14,14,14,14,14,14,4,16,
16,16,16,16,16,16,16,16,84,11,14,14,14,14,14,14,
14,14,12,29,16,16,16,16,78,6,7,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
16,16,16,16,16,16,16,16,16,16,4,4,4,6,7,99,
17,17,17,16,16,16,16,16,16,16,16,16,16,16,16,16,
84,11,14,14,14,14,14,14,14,14,14,14,80,16,16,4,
4,4,4,4,4,4,4,4,4,4,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,12,2,2,3,3,3,3,3,3,3,3,3,3,3,
3,3,3,3,3,3,3,3,3,3,83,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,79,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,78,4,4,4,4,4,17,17,4,4,
45,14,120,14,14,14,14,14,14,14,14,14,14,14,14,14,
4,4,4,4,4,4,4,4,4,4,4,4,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,12,3,3,3,3,
3,3,3,3,3,3,3,3,3,3,3,3,16,16,16,16,
16,84,11,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,86,86,86,86,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,4,14,14,14,14,14,14,
14,14,14,14,120,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,4,4,4,4,4,4,4,4,4,4,4,28,28,
28,28,28,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,80,16,104,104,104,16,16,
104,82,120,120,120,120,120,80,4,16,16,16,16,16,16,16,
16,16,16,84,11,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,79,16,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,16,4,16,16,16,84,
11,120,14,14,14,14,4,45,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,63,63,
63,63,63,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,80,4,4,14,14,
14,14,8,9,14,14,14,14,14,14,4,16,16,16,16,16,
16,16,16,16,16,84,11,14,14,14,14,14,14,12,29,16,
16,16,16,16,77,16,16,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,16,16,16,16,
16,16,16,16,16,16,4,4,4,16,16,76,17,17,17,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,84,11,14,
14,14,14,14,14,14,14,14,14,22,31,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,12,29,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,82,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,80,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,77,4,4,4,4,4,17,17,4,4,45,88,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,28,28,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,24,14,14,14,12,16,104,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,36,37,16,84,11,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
86,86,86,86,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,4,14,14,14,14,14,14,14,14,14,88,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,28,
28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,30,30,79,16,104,104,105,105,104,104,83,30,30,
30,30,30,79,4,16,16,16,16,16,16,16,16,16,16,16,
84,11,14,14,14,14,14,14,14,14,14,14,14,14,14,80,
5,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,16,4,16,16,16,16,84,11,14,14,
14,14,4,45,45,14,14,14,14,14,14,14,14,14,14,14,
14,85,14,14,26,27,60,26,27,63,63,63,63,63,63,63,
60,14,14,14,60,14,14,60,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,79,4,4,14,14,14,14,14,14,
14,14,14,14,14,14,4,16,16,16,16,16,16,16,16,16,
16,16,84,11,14,14,14,14,12,29,16,16,16,16,16,16,
16,6,7,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,16,16,16,16,16,16,16,16,
16,16,4,4,4,16,16,99,17,17,17,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,84,11,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,12,29,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,17,83,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,79,16,16,16,16,16,
16,16,16,6,7,16,16,16,16,16,16,16,16,16,16,4,
4,4,4,4,4,4,4,4,45,89,88,88,60,60,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,28,28,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,12,3,3,3,3,3,
3,3,3,3,3,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,18,19,16,16,84,11,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,86,86,86,86,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,4,30,30,30,30,30,30,30,30,61,89,88,88,60,60,
61,14,14,14,14,14,14,14,14,14,14,28,28,28,28,28,
28,28,28,28,28,28,28,28,28,28,28,14,14,14,14,14,
14,14,14,14,14,14,46,47,46,14,14,14,14,14,14,1,
0,0,0,0,0,0,0,0,0,1,1,1,1,1,1,1,
4,16,16,16,16,16,16,16,16,16,16,16,16,84,11,14,
14,14,14,14,14,14,14,14,14,14,14,79,16,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,16,4,4,4,4,4,4,4,11,14,14,14,4,4,
4,4,4,3,3,3,3,3,3,3,3,3,3,3,3,3,
3,3,3,3,3,3,3,3,3,3,3,3,3,3,3,3,
3,3,3,3,3,3,3,3,3,3,3,3,11,14,14,14,
14,14,14,80,4,4,14,14,14,14,14,14,14,14,14,14,
14,14,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
14,14,14,12,29,16,16,16,16,16,78,6,7,16,16,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,16,16,16,16,16,16,16,16,16,16,4,4,
4,6,7,76,17,17,17,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,84,11,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,12,6,6,3,3,3,3,
3,3,3,2,2,2,2,2,2,2,13,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,82,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,80,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,77,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,11,14,14,14,14,
14,14,14,14,14,14,14,14,14,28,28,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,12,2,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,84,11,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,86,86,86,86,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,80,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,11,14,14,
14,14,14,14,14,14,14,28,28,28,28,28,28,28,28,28,
28,28,28,28,28,28,28,14,14,14,14,14,14,14,8,9,
4,4,2,2,2,2,2,11,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,80,16,16,16,
16,16,16,16,16,16,16,16,16,16,84,11,14,14,14,14,
14,14,14,14,14,14,14,80,16,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,14,14,12,4,4,4,4,4,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,84,11,120,14,14,14,14,79,
4,4,14,14,14,14,8,9,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,12,29,
16,16,16,16,16,16,77,16,16,16,16,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
16,16,16,16,16,16,16,16,16,16,4,4,4,16,16,99,
17,17,17,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,84,11,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,12,29,16,16,16,16,16,16,16,100,101,16,
16,16,16,16,16,16,84,13,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,83,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,79,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,84,11,14,14,14,14,14,14,14,
14,14,14,14,14,28,28,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,12,
29,16,16,16,6,7,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,104,
16,16,16,16,16,84,11,14,14,14,14,14,14,14,14,14,
14,14,14,14,86,86,86,87,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,80,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,84,11,14,14,14,14,14,
14,14,14,28,28,28,28,28,28,28,28,28,28,28,28,28,
28,28,28,14,14,14,14,14,8,9,14,79,4,4,16,16,
16,16,16,84,11,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,8,9,14,14,14,79,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,84,11,14,14,14,14,14,14,14,
14,14,14,79,5,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,14,14,14,14,14,14,
14,14,14,14,12,29,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,84,11,14,14,14,14,80,4,4,14,14,
14,14,14,14,14,8,9,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,12,29,16,16,16,16,16,
16,16,78,16,16,16,16,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,16,16,16,16,
16,16,16,16,16,16,4,4,4,16,16,76,17,17,17,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,84,11,14,14,14,14,14,48,49,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,12,
29,16,16,16,16,16,16,100,101,16,105,16,16,16,16,16,
16,16,16,84,13,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,82,14,120,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,80,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,84,11,14,14,14,14,48,49,14,14,14,14,
14,28,28,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,12,29,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,104,16,16,104,16,16,16,16,
16,16,84,11,14,14,14,14,14,14,14,14,14,14,14,14,
86,86,86,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,79,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,84,11,14,14,14,14,14,14,14,28,
28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,14,
14,14,8,9,14,14,14,80,4,4,16,16,16,16,16,16,
84,11,14,14,14,14,26,27,14,52,14,14,14,14,14,14,
14,14,14,14,80,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,84,11,14,14,14,14,14,14,14,14,14,80,
16,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,14,14,14,14,14,14,14,14,14,12,
29,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,5,5,5,5,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,84,11,14,14,14,79,4,4,14,52,14,14,14,14,
14,14,14,14,14,14,62,14,14,14,62,14,14,14,62,14,
14,14,14,14,12,29,16,16,16,16,16,16,16,16,77,16,
16,16,16,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,16,16,16,16,16,16,16,16,
16,16,4,4,4,6,3,3,3,3,3,3,3,3,3,3,
3,3,99,16,16,16,16,16,16,16,16,16,16,16,84,11,
14,14,14,14,51,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,12,29,16,16,16,16,
36,37,100,101,104,106,100,101,16,16,36,37,16,6,3,3,
2,7,16,16,16,16,16,2,2,2,2,2,2,2,2,2,
2,2,11,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,79,16,2,2,2,2,
7,4,4,4,4,4,4,4,6,2,2,2,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,84,11,14,14,14,51,14,14,14,14,14,14,28,28,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,12,29,16,16,16,16,16,6,7,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,104,16,104,104,16,104,16,16,16,16,16,84,
11,14,14,48,49,14,14,14,14,14,14,14,87,14,86,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,80,16,16,17,17,17,17,17,17,17,17,17,17,17,
17,16,16,84,11,14,14,14,14,14,14,28,28,28,28,28,
28,28,28,28,28,28,28,28,28,28,28,14,8,9,14,14,
14,14,14,79,4,4,16,16,16,16,16,16,16,84,11,14,
14,14,28,14,14,52,14,52,14,14,14,8,9,14,14,14,
79,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,84,11,14,14,14,14,14,14,14,14,79,16,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,14,14,14,14,14,14,14,14,12,29,16,16,16,16,
16,16,16,16,16,16,5,5,5,5,5,5,5,5,5,5,
5,5,5,5,5,5,5,5,5,5,5,5,5,5,5,5,
5,5,5,5,5,5,5,5,5,5,5,5,5,16,16,84,
11,14,14,80,4,4,14,52,14,52,14,14,14,8,9,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,12,
29,16,16,16,16,16,16,16,16,16,16,6,2,2,2,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,16,16,16,16,16,16,16,16,16,16,4,4,
4,16,16,16,16,16,16,16,16,16,16,16,16,16,76,16,
16,16,16,16,16,16,16,16,16,16,16,84,11,14,14,14,
52,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,12,3,3,3,3,2,2,2,7,2,3,3,3,3,
3,3,3,3,3,3,3,3,3,3,3,13,16,16,16,16,
16,100,101,16,16,16,16,16,16,16,16,16,16,17,16,11,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,80,16,16,16,16,16,4,4,4,4,
4,4,4,4,4,16,16,16,16,16,16,16,16,16,16,16,
16,16,106,106,106,16,16,16,16,16,16,106,16,16,84,11,
14,14,52,14,14,14,14,14,14,28,28,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
12,29,16,16,16,16,16,16,104,36,37,16,16,16,16,16,
106,16,16,16,16,106,16,16,100,101,16,16,16,16,106,16,
104,104,104,104,104,104,16,16,104,104,16,16,84,11,48,49,
51,48,49,14,88,14,14,14,14,14,87,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,79,16,
16,16,16,16,16,16,16,106,16,16,16,16,16,16,16,16,
84,11,14,14,14,14,14,28,28,28,28,28,28,28,28,28,
28,28,28,28,28,28,28,14,14,14,14,14,14,14,14,80,
4,4,16,16,16,16,106,16,16,16,84,11,14,14,28,14,
14,52,52,52,14,14,14,14,14,14,14,14,80,16,16,16,
16,106,16,16,16,16,16,106,16,16,16,16,16,16,84,11,
14,14,14,14,14,14,14,80,5,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,14,14,
14,14,14,14,14,12,29,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,106,16,16,16,16,83,14,79,
4,4,14,52,52,52,14,14,14,14,14,14,14,62,14,14,
62,14,14,14,62,14,14,14,62,14,12,29,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
16,16,16,16,16,16,16,16,16,4,4,4,4,16,81,81,
16,81,81,81,16,16,16,16,16,16,99,16,16,16,16,16,
16,16,16,16,16,16,16,16,84,11,14,14,53,53,30,14,
26,27,14,14,14,30,61,61,14,14,25,25,25,12,29,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,84,13,81,81,106,81,104,100,101,
106,4,4,4,4,4,4,4,36,37,16,16,11,14,14,30,
60,61,66,67,66,67,66,67,66,67,120,14,30,14,14,14,
14,14,79,16,16,16,16,78,4,4,4,4,4,4,4,4,
4,99,16,16,16,16,16,16,16,16,16,16,16,106,107,107,
107,16,16,106,106,16,16,107,16,36,37,84,11,14,53,53,
30,14,26,27,14,28,28,30,61,61,14,14,25,25,25,14,
14,14,14,14,24,14,14,14,14,14,14,12,29,16,16,16,
16,4,4,4,4,4,4,4,4,7,16,81,107,16,102,103,
81,107,16,106,106,105,81,81,106,16,107,81,104,105,105,104,
105,104,104,105,104,105,16,16,16,81,11,53,48,49,52,61,
89,88,60,61,21,66,67,66,67,66,67,66,67,66,67,68,
69,66,67,46,20,14,14,14,66,67,80,16,16,16,16,16,
16,81,16,107,16,16,16,16,106,16,81,16,16,84,11,14,
24,66,67,28,28,28,28,28,28,28,28,28,28,28,28,28,
28,28,28,14,14,14,30,30,30,30,30,79,4,4,16,16,
16,81,107,81,16,106,16,84,11,14,28,26,27,52,53,52,
14,26,27,26,27,14,14,14,79,16,16,16,16,107,16,16,
106,16,106,107,16,16,16,16,81,16,16,84,11,30,30,30,
30,30,30,79,16,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,14,112,30,30,30,30,
12,29,16,81,16,16,16,16,16,16,106,16,81,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,81,107,81,16,106,16,82,112,80,4,4,112,52,
53,52,14,26,27,26,27,30,30,30,30,30,30,30,14,30,
30,30,30,30,30,12,29,16,16,16,81,16,16,16,16,16,
16,16,16,16,16,16,16,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,16,16,16,16,
16,16,16,16,16,4,4,3,3,3,3,3,3,3,3,3,
3,3,3,3,3,3,3,3,3,3,3,3,3,3,3,3,
3,3,3,3,3,3,3,3,3,2,2,2,2,2,2,2,
2,2,2,2,2,2,2,2,2,2,2,2,2,2,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,3,3,3,3,3,3,
3,3,3,3,3,3,3,3,3,3,3,3,3,3,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,3,3,3,3,3,3,3,3,3,3,3,3,3,3,
3,3,3,3,3,3,3,3,3,3,3,2,2,2,2,2,
2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,3,3,3,3,
3,3,3,3,3,3,3,3,3,3,3,3,3,3,3,3,
1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
4,4,4,4,3,3,3,3,3,3,3,3,3,3,3,3,
3,3,3,3,3,3,3,3,3,3,3,3,3,2,2,2,
2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,
2,2,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,3,3,
3,3,3,3,3,3,3,3,3,3,3,3,3,3,3,4,
4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,
4,4,4,4,4,4,3,3,3,3,3,3,3,3,3,3,
3,3,3,3,3,3,3,3,3,3,3,3,3,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,83,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,79,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,4,4,4,4,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,83,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,82,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,80,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,4,4,4,4,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,82,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,83,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,79,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,4,4,4,4,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,83,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
82,14,14,14,14,14,14,14,14,14,14,14,14,14,14,80,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,82,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,83,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,79,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,83,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,82,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,80,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,
16,16,16,16,16,82,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,14,
};
