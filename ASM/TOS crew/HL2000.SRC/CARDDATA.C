/*
// file generated by: F:\HL001128\DATA\MAKECARD.C
*/

#include "hland.h"
extern const int baan[980] = {
-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,
-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,
-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,
-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,
-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,
-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,
-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,
-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,-40,
-40,-40,-40,-38,-36,-34,-32,-30,-28,-26,-24,-22,-20,-18,-16,-14,
-12,-10,-8,-6,-4,-2,0,2,4,6,8,10,12,14,16,18,
20,22,24,26,28,30,32,34,36,38,40,42,44,46,48,50,
52,54,56,58,60,62,64,66,68,70,72,74,76,78,80,82,
84,86,88,90,88,86,84,82,80,79,77,76,74,73,72,70,
69,68,67,66,65,64,64,63,62,62,61,61,60,60,60,60,
60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,
60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,
60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,
60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,
60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,
60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,
60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,
60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,
60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,
60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,
60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,
60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,
60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,
60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,
60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,
60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,
60,60,60,60,60,60,60,59,59,58,58,57,57,56,56,55,
55,54,54,53,53,52,52,51,51,50,50,51,51,52,52,53,
53,54,54,55,55,56,56,57,57,58,58,59,59,60,60,60,
60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,
60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,
60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,
60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,
60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,
60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,
60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,
60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,
60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,
60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,
60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,
60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,
60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,
60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,
60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,
60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,60,
60,60,60,60,60,60,61,61,62,62,63,64,64,65,66,67,
68,69,70,72,73,74,76,77,79,80,82,84,86,88,90,92,
94,96,98,100,103,105,108,110,113,116,118,121,124,127,130,133,
136,140,143,146,150,153,157,160,170,170,170,170,170,170,170,170,
170,170,170,170,170,170,170,170,170,170,170,170,170,170,170,170,
170,170,170,170,170,170,170,170,170,170,170,170,170,170,170,170,
170,170,170,170,170,170,170,170,170,170,170,170,170,170,170,170,
170,170,170,170,170,170,170,170,170,170,170,170,170,170,170,170,
170,170,170,170,170,170,170,170,170,170,170,170,170,170,170,170,
170,170,170,170,170,170,170,170,170,170,170,170,170,170,170,170,
170,170,170,170,170,170,170,170,170,170,170,170,170,170,170,170,
170,170,170,170,170,170,170,170,170,170,170,170,170,170,170,170,
170,170,170,170,};
extern const byte carddata_pac[2411] = {
8,19,115,190,190,251,180,105,175,143,255,187,186,222,252,23,
139,223,139,141,53,202,82,241,129,104,226,37,231,103,32,16,
135,118,147,104,145,211,107,100,192,171,23,109,68,99,180,69,
111,0,77,108,81,59,226,93,11,245,45,183,238,145,140,89,
129,78,118,210,42,98,74,102,44,195,133,14,32,230,231,42,
90,104,109,76,161,175,215,25,105,32,7,126,182,245,191,113,
175,94,251,253,241,169,143,222,7,241,157,34,146,158,10,158,
85,240,88,111,34,248,8,249,183,133,242,104,248,95,6,242,
62,13,228,63,138,251,214,187,135,69,35,113,203,163,54,67,
244,102,219,156,229,109,206,111,150,117,139,212,172,137,3,254,
3,107,10,5,232,37,231,116,69,71,225,44,94,69,225,23,
107,70,69,229,241,136,187,44,162,197,115,220,145,102,182,196,
92,2,34,205,185,143,205,140,120,39,159,165,34,247,251,85,
139,75,242,200,182,190,33,23,153,181,34,248,58,85,139,107,
98,69,165,214,17,126,145,127,241,28,191,238,69,248,207,254,
209,127,239,156,191,217,11,255,157,235,95,171,63,238,39,252,
177,127,217,57,127,245,197,255,209,232,167,247,226,255,56,229,
255,108,47,255,18,179,253,20,250,179,254,226,125,91,158,173,
239,84,7,170,11,213,9,241,177,43,110,114,78,152,127,182,
7,207,39,31,185,21,246,137,61,112,175,91,139,126,163,169,
127,114,43,205,98,163,212,191,148,43,58,145,254,201,230,138,
30,44,91,64,122,167,15,48,80,249,97,168,100,72,198,58,
115,244,160,236,243,53,93,210,197,12,30,74,85,238,107,58,
222,203,126,208,168,201,63,16,85,149,73,247,130,173,18,79,
198,21,101,63,194,191,134,42,235,177,78,165,122,175,241,25,
252,104,127,241,193,244,105,95,218,138,234,82,126,94,211,164,
238,108,76,82,97,177,83,145,218,143,188,201,138,166,10,240,
202,212,142,81,27,169,107,0,196,93,90,244,186,91,114,62,
146,12,232,88,21,166,39,108,47,0,160,17,219,101,180,45,
158,49,86,91,46,249,220,10,19,222,179,134,133,187,16,127,
214,187,253,200,199,247,16,123,136,92,13,73,141,152,216,47,
67,242,152,136,124,229,87,38,46,15,166,98,117,60,188,246,
27,4,119,213,79,162,181,130,19,253,106,253,108,176,175,129,
38,134,225,174,72,62,77,124,158,98,81,30,234,77,213,195,
87,227,31,182,176,219,93,131,210,179,74,140,29,9,137,245,
179,27,222,244,31,209,170,240,98,163,242,153,235,234,150,58,
202,203,85,143,71,35,237,34,247,65,64,237,235,54,148,220,
152,18,79,240,224,254,59,132,67,25,255,213,105,64,192,79,
248,210,47,80,141,160,207,221,175,175,164,11,252,220,142,53,
194,50,193,94,203,14,187,200,17,15,151,43,180,34,105,150,
125,164,95,228,84,83,193,63,1,153,112,145,122,101,158,58,
178,129,106,30,253,186,204,162,95,16,197,60,242,210,150,240,
35,249,85,87,113,90,254,1,31,225,177,249,59,16,199,241,
224,201,132,213,120,60,198,38,91,3,232,162,104,170,90,252,
230,39,152,86,56,85,128,236,44,196,124,10,112,116,88,197,
171,7,142,81,207,123,187,49,79,179,104,207,118,15,247,74,
65,239,124,19,59,159,214,90,86,89,106,14,125,63,129,20,
247,252,51,19,221,85,150,171,202,203,145,243,187,232,71,68,
67,69,124,195,27,186,48,123,205,243,39,65,5,123,108,55,
73,86,71,190,89,7,191,218,140,127,95,101,26,212,35,254,
249,76,62,0,191,118,91,22,223,126,242,59,220,140,209,143,
114,94,70,247,186,109,5,66,218,61,88,95,229,10,167,211,
13,248,2,172,138,79,200,21,81,116,97,253,128,120,184,176,
254,163,170,31,239,36,152,143,13,120,121,48,223,249,133,56,
237,108,204,69,171,95,87,155,168,26,191,34,105,218,218,3,
233,151,211,30,1,21,250,39,21,125,41,138,43,43,179,70,
54,127,9,153,199,175,250,96,254,106,247,246,96,250,230,117,
199,243,183,102,91,47,18,194,77,229,172,19,210,196,134,124,
23,53,254,226,198,227,123,40,231,167,90,28,124,10,80,118,
108,89,222,5,124,57,48,238,37,195,51,247,213,76,113,246,
118,167,61,92,136,200,151,24,209,39,228,48,206,85,196,252,
76,45,186,16,104,243,213,12,91,67,7,189,16,158,215,122,
108,145,95,47,133,195,99,187,59,166,99,35,7,233,24,206,
176,44,43,48,152,132,123,25,25,212,75,7,121,129,177,239,
238,70,63,236,149,170,17,173,17,95,197,178,212,124,248,6,
63,197,47,65,8,239,132,55,198,93,184,116,228,126,73,74,
66,56,217,10,9,248,182,17,183,85,112,97,108,202,50,47,
91,16,63,42,210,84,219,115,212,242,96,182,132,74,53,19,
239,37,139,158,83,25,152,255,26,37,91,145,94,66,3,216,
129,3,32,123,233,28,68,34,180,68,254,209,141,164,234,119,
103,158,170,124,132,103,204,103,120,54,115,166,211,194,60,251,
57,212,96,87,9,15,155,99,54,96,139,247,210,95,92,53,
189,49,138,90,243,101,136,63,160,147,65,113,129,120,103,174,
230,47,55,15,80,232,238,252,7,145,209,227,4,254,185,125,
119,127,166,35,248,182,150,241,209,70,15,116,188,105,151,99,
63,66,248,232,49,20,11,117,163,114,134,159,236,11,96,123,
238,0,95,231,87,135,159,7,223,22,248,237,46,48,29,178,
241,158,94,17,230,155,22,31,213,13,234,61,232,170,135,165,
15,247,66,184,56,167,142,24,250,164,195,254,9,13,31,110,
195,70,248,55,243,11,202,62,33,233,167,134,143,250,107,86,
159,94,237,251,200,179,118,56,102,27,94,212,152,71,215,215,
191,45,102,142,210,182,101,59,154,158,71,223,189,126,80,118,
91,28,46,208,99,247,43,110,14,143,122,254,138,121,235,13,
124,112,143,252,5,184,61,247,88,252,238,141,97,50,252,29,
249,63,61,244,55,240,167,138,205,31,132,99,251,117,187,120,
232,23,243,230,98,102,172,108,253,148,75,42,148,103,95,194,
112,254,61,57,207,163,147,242,110,37,252,33,21,248,54,59,
166,134,231,190,17,95,125,179,126,79,62,179,13,212,49,18,
166,146,15,230,139,123,79,66,78,174,152,157,178,183,35,206,
145,245,54,232,244,129,219,98,107,156,79,183,19,63,83,47,
65,145,39,77,88,206,170,112,242,35,109,240,122,161,181,237,
217,182,205,91,243,223,201,110,225,172,201,150,119,79,177,225,
30,157,225,230,142,91,239,247,6,132,235,37,103,27,190,17,
127,25,155,84,94,221,208,208,23,137,105,247,50,128,247,76,
180,137,119,70,126,242,21,142,134,210,3,211,234,25,250,168,
151,200,17,223,69,99,239,56,240,31,156,245,67,154,252,224,
211,253,253,134,255,139,0,208,156,59,95,176,196,93,130,253,
132,218,135,240,138,68,13,187,86,224,240,151,133,197,168,23,
235,82,199,107,232,3,253,133,233,56,54,250,56,80,86,148,
124,30,184,103,248,107,210,65,177,40,94,126,102,234,44,190,
92,215,174,87,122,242,133,69,67,150,169,150,112,121,75,191,
137,175,147,10,30,115,119,23,6,64,199,247,139,229,138,1,
66,109,111,74,225,166,66,62,149,126,168,170,28,61,20,127,
86,31,242,13,160,167,211,15,248,66,167,164,74,62,60,63,
248,96,255,49,48,191,226,138,244,157,3,211,3,240,86,43,
232,196,89,37,136,188,39,132,93,212,213,137,152,97,182,146,
69,56,29,210,79,231,3,252,4,158,184,52,122,220,37,138,
56,207,213,140,253,178,228,89,234,197,136,193,62,209,17,74,
224,145,30,153,98,201,3,223,122,254,47,249,145,71,238,88,
168,134,127,144,51,243,157,133,126,26,197,4,39,238,146,191,
170,7,218,127,38,61,183,196,69,49,98,64,207,192,88,29,
128,120,171,20,192,159,114,233,187,161,68,21,139,12,29,223,
175,226,62,171,245,103,255,138,125,75,245,51,234,111,212,239,
243,159,254,8,161,205,31,104,104,249,136,155,92,29,205,63,
226,17,52,231,144,123,208,119,53,127,179,26,191,186,74,255,
54,23,252,15,232,199,167,71,233,136,137,205,223,237,70,239,
249,9,127,252,209,87,95,253,143,228,138,180,31,235,209,255,
122,43,208,164,248,65,159,122,152,127,253,1,191,207,255,120,
127,124,69,173,78,207,219,48,23,233,219,249,67,119,207,208,
223,250,98,34,74,253,74,255,235,171,239,72,137,49,255,203,
219,244,199,255,51,119,249,241,255,194,20,102,22,42,64,127,
69,195,218,10,53,43,22,120,30,217,48,255,20,39,216,246,
25,245,59,252,248,255,13,99,179,38,63,248,129,166,202,166,
63,251,50,40,31,230,31,244,225,127,179,74,255,150,183,73,
247,162,173,15,75,209,255,30,31,249,215,244,194,255,255,67,
255,253,246,175,196,214,253,80,99,236,253,136,47,84,55,243,
162,61,81,95,142,223,169,255,234,67,255,243,133,254,156,63,
227,124,43,237,10,204,147,202,12,249,211,15,254,128,111,242,
254,204,63,240,136,142,54,191,237,131,252,223,111,225,31,233,
242,159,211,239,63,24,254,220,55,165,255,231,248,231,171,225,
255,148,42,63,71,225,159,199,227,255,118,43,136,147,215,138,
235,122,156,127,227,237,127,252,241,175,199,219,255,246,215,180,
26,243,37,175,211,134,191,102,150,61,208,99,231,98,195,254,
59,95,141,198,253,216,171,44,147,225,138,157,244,184,255,84,
47,170,31,213,238,62,208,111,204,150,254,208,59,250,158,164,
63,251,191,51,255,83,143,252,79,107,245,113,223,141,15,234,
191,198,135,245,125,13,246,226,184,88,191,31,253,120,107,235,
82,215,242,67,159,147,234,67,255,186,126,164,63,171,182,245,
67,122,190,62,251,241,83,245,103,250,95,31,250,188,123,213,
17,237,114,133,252,255,54,123,216,64,207,192,79,1,232,34,
36,158,228,31,52,147,215,76,16,254,251,155,159,182,154,33,
253,231,55,130,249,65,151,59,175,107,115,241,62,123,126,106,
253,77,126,49,253,78,67,211,159,154,68,73,111,249,156,135,
251,77,250,147,252,197,251,67,10,100,179,252,64,207,229,82,
223,239,3,127,162,73,248,192,249,69,59,233,209,251,209,159,
232,113,254,168,111,85,254,39,39,248,253,191,225,10,222,226,
251,127,238,195,223,17,61,95,226,66,127,63,170,251,144,124,
210,79,93,52,99,211,213,253,180,224,159,79,87,252,190,99,
241,186,191,255,231,84,111,170,63,233,101,17,50,116,235,253,
177,18,51,201,61,112,62,181,39,185,7,205,122,222,17,234,
244,63,198,241,223,87,195,63,141,219,248,};
