/*
// file generated by: F:\HL001128\DATA\MAKE_EGG.C
*/

#include "hland.h"
extern const byte eggs[14520UL] = {
3,255,224,0,255,255,255,255,252,0,252,0,255,255,255,255,
31,255,31,255,3,255,224,0,255,255,254,8,252,0,253,247,
255,255,63,255,31,255,223,255,3,255,224,0,255,255,254,8,
252,0,253,247,255,255,63,255,31,255,223,255,3,247,224,0,
255,190,254,28,252,8,253,170,255,255,63,255,31,255,223,255,
1,247,192,0,255,255,255,28,254,8,254,235,255,255,127,255,
63,255,191,255,0,227,128,0,255,255,255,255,255,28,255,28,
255,255,255,255,127,255,127,255,0,255,128,0,255,255,255,255,
255,0,255,0,255,255,255,255,127,255,127,255,1,255,192,0,
255,67,255,128,254,0,254,0,127,255,255,255,63,255,63,255,
123,255,239,0,255,0,254,0,132,0,132,0,191,255,127,255,
16,255,16,255,255,255,255,128,252,28,134,62,0,0,120,0,
95,255,48,255,0,127,15,127,255,255,255,128,252,65,132,65,
0,0,120,0,63,255,16,255,0,127,15,127,255,255,255,128,
252,128,132,0,0,0,120,0,63,255,144,255,0,127,15,127,
127,255,255,0,252,0,228,0,128,0,152,0,63,255,19,255,
0,255,12,255,31,255,252,0,254,0,252,119,224,0,224,0,
63,255,31,255,3,255,3,255,3,255,224,0,254,8,254,136,
252,0,252,0,63,255,191,255,31,255,31,255,3,255,224,0,
254,170,254,170,252,0,252,0,191,255,191,255,31,255,31,255,
3,255,224,0,254,8,254,136,252,0,252,0,63,255,191,255,
31,255,31,255,1,255,192,0,255,0,255,73,254,0,254,0,
127,255,127,255,63,255,63,255,1,255,192,0,255,128,255,54,
254,0,254,0,255,255,127,255,63,255,63,255,0,255,128,0,
255,128,255,128,255,0,255,0,255,255,255,255,127,255,127,255,
0,127,0,0,255,193,255,193,255,128,255,128,255,255,255,255,
255,255,255,255,0,62,0,0,255,255,255,255,255,193,255,193,
255,255,255,255,255,255,255,255,3,255,224,0,255,255,255,255,
252,0,252,0,255,255,255,255,31,255,31,255,3,255,224,0,
255,255,254,8,252,0,253,247,255,255,63,255,31,255,223,255,
3,255,224,0,255,255,254,8,252,0,253,247,255,255,63,255,
31,255,223,255,3,255,224,0,255,190,254,8,252,0,253,182,
255,255,63,255,31,255,223,255,1,247,192,0,255,255,255,28,
254,8,254,235,255,255,127,255,63,255,191,255,0,255,128,0,
255,255,255,255,255,0,255,0,255,255,255,255,127,255,127,255,
1,255,192,0,255,67,255,128,254,0,254,0,127,255,255,255,
63,255,63,255,3,255,224,0,255,0,254,0,252,0,252,0,
191,255,127,255,31,255,31,255,3,255,224,0,254,28,254,62,
252,0,252,0,127,255,63,255,31,255,31,255,7,255,240,0,
254,65,252,65,248,0,248,0,63,255,31,255,15,255,15,255,
63,255,254,0,252,128,252,0,192,0,192,0,63,255,159,255,
1,255,1,255,127,255,255,0,252,0,196,0,128,0,184,0,
63,255,17,255,0,255,14,255,255,255,255,128,252,0,132,119,
0,0,120,0,63,255,16,255,0,127,15,127,255,255,255,128,
254,8,132,136,0,0,120,0,31,255,176,255,0,127,15,127,
123,255,239,0,254,170,206,170,132,0,180,0,191,255,185,255,
16,255,22,255,51,255,230,0,254,8,254,136,204,0,204,0,
63,255,191,255,25,255,25,255,1,255,192,0,255,0,255,73,
254,0,254,0,127,255,127,255,63,255,63,255,1,255,192,0,
255,128,255,54,254,0,254,0,255,255,127,255,63,255,63,255,
0,255,128,0,255,128,255,128,255,0,255,0,255,255,255,255,
127,255,127,255,0,127,0,0,255,193,255,193,255,128,255,128,
255,255,255,255,255,255,255,255,0,62,0,0,255,255,255,255,
255,193,255,193,255,255,255,255,255,255,255,255,0,0,0,0,
255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,
0,0,0,0,255,255,255,255,255,255,255,255,255,255,255,255,
255,255,255,255,0,0,0,0,255,255,255,255,255,255,255,255,
255,255,255,255,255,255,255,255,0,0,0,0,255,255,255,255,
255,255,255,255,255,255,255,255,255,255,255,255,0,227,128,0,
255,255,255,255,255,28,255,28,255,255,255,255,127,255,127,255,
1,247,192,0,255,255,255,28,254,8,254,235,255,255,127,255,
63,255,191,255,3,255,224,0,255,255,254,8,252,0,253,247,
255,255,63,255,31,255,223,255,3,255,224,0,255,125,254,8,
252,0,253,117,255,255,63,255,31,255,223,255,1,255,192,0,
255,255,255,127,254,0,254,128,255,255,127,255,63,255,191,255,
1,255,192,0,255,190,255,193,254,0,254,0,255,255,255,255,
63,255,63,255,49,255,198,0,255,128,255,0,206,0,206,0,
255,255,127,255,57,255,57,255,123,255,239,0,255,0,206,0,
132,0,180,0,63,255,121,255,16,255,22,255,251,255,239,128,
254,119,142,119,4,0,116,0,127,255,56,255,16,127,23,127,
255,255,255,128,252,136,132,136,0,0,120,0,191,255,144,255,
0,127,15,127,127,255,255,0,252,170,196,170,128,0,184,0,
191,255,145,255,0,255,14,255,63,255,254,0,252,8,236,136,
192,0,208,0,63,255,155,255,1,255,5,255,23,255,244,0,
252,8,252,73,232,0,232,0,63,255,31,255,11,255,11,255,
7,255,240,0,252,0,252,54,248,0,248,0,63,255,31,255,
15,255,15,255,3,255,224,0,254,0,254,0,252,0,252,0,
63,255,63,255,31,255,31,255,3,255,224,0,254,0,254,0,
252,0,252,0,127,255,63,255,31,255,31,255,1,255,192,0,
255,0,255,0,254,0,254,0,255,255,127,255,63,255,63,255,
0,255,128,0,255,193,255,193,255,0,255,0,255,255,255,255,
127,255,127,255,0,62,0,0,255,255,255,255,255,193,255,193,
255,255,255,255,255,255,255,255,0,0,0,0,255,255,255,255,
255,255,255,255,255,255,255,255,255,255,255,255,0,0,0,0,
255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,
0,0,0,0,255,255,255,255,255,255,255,255,255,255,255,255,
255,255,255,255,0,0,0,0,255,255,255,255,255,255,255,255,
255,255,255,255,255,255,255,255,0,0,0,0,255,255,255,255,
255,255,255,255,255,255,255,255,255,255,255,255,0,62,0,0,
255,255,255,255,255,193,255,193,255,255,255,255,255,255,255,255,
0,255,128,0,255,201,255,201,255,0,255,0,255,255,255,255,
127,255,127,255,1,255,192,0,255,183,255,54,254,0,254,0,
127,255,255,255,63,255,63,255,51,255,230,0,255,0,254,0,
204,0,204,0,63,255,127,255,25,255,25,255,123,255,239,0,
254,0,206,0,132,0,180,0,127,255,57,255,16,255,22,255,
255,255,239,128,254,0,140,0,0,0,112,0,63,255,56,255,
16,127,23,127,63,255,254,0,252,0,236,0,192,0,208,0,
63,255,27,255,1,255,5,255,19,255,236,0,254,0,254,0,
236,0,236,0,63,255,63,255,19,255,19,255,3,255,224,0,
255,0,254,0,252,0,252,0,127,255,63,255,31,255,31,255,
1,255,192,0,255,128,255,0,254,0,254,0,255,255,127,255,
63,255,63,255,1,255,192,0,255,227,255,193,254,0,254,0,
255,255,255,255,63,255,63,255,1,255,192,0,255,255,255,62,
254,0,254,193,255,255,127,255,63,255,191,255,0,227,128,0,
255,255,255,255,255,28,255,28,255,255,255,255,127,255,127,255,
0,0,0,0,255,255,255,255,255,255,255,255,255,255,255,255,
255,255,255,255,0,0,0,0,255,255,255,255,255,255,255,255,
255,255,255,255,255,255,255,255,0,0,0,0,255,255,255,255,
255,255,255,255,255,255,255,255,255,255,255,255,0,0,0,0,
255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,
0,0,0,0,255,255,255,255,255,255,255,255,255,255,255,255,
255,255,255,255,0,0,0,0,255,255,255,255,255,255,255,255,
255,255,255,255,255,255,255,255,0,62,0,0,255,255,255,255,
255,193,255,193,255,255,255,255,255,255,255,255,0,255,128,0,
255,195,255,193,255,0,255,0,255,255,255,255,127,255,127,255,
1,255,192,0,255,0,255,0,254,0,254,0,255,255,127,255,
63,255,63,255,51,255,230,0,254,0,254,0,204,0,204,0,
127,255,63,255,25,255,25,255,123,255,239,0,254,0,206,0,
132,0,180,0,63,255,57,255,16,255,22,255,255,255,255,128,
252,0,140,0,0,0,112,0,63,255,24,255,0,127,7,127,
255,255,255,128,252,0,132,0,0,0,120,0,63,255,16,255,
0,127,15,127,127,255,255,0,252,0,196,0,128,0,184,0,
63,255,17,255,0,255,14,255,63,255,254,0,252,0,236,0,
192,0,208,0,63,255,27,255,1,255,5,255,23,255,244,0,
254,0,252,0,232,0,232,0,63,255,31,255,11,255,11,255,
7,255,240,0,252,0,254,0,248,0,248,0,31,255,63,255,
15,255,15,255,3,255,224,0,255,0,254,0,252,0,252,0,
127,255,63,255,31,255,31,255,1,255,224,0,255,65,255,128,
254,0,254,0,127,255,255,255,31,255,31,255,1,255,192,0,
255,255,255,255,254,0,254,0,255,255,255,255,63,255,63,255,
3,255,224,0,255,255,254,8,253,0,253,247,255,255,63,255,
95,255,223,255,3,255,224,0,255,255,254,8,252,0,253,247,
255,255,63,255,31,255,223,255,1,247,192,0,255,255,255,28,
254,8,254,235,255,255,127,255,63,255,191,255,0,227,128,0,
255,255,255,255,255,28,255,28,255,255,255,255,127,255,127,255,
0,0,0,0,255,255,255,255,255,255,255,255,255,255,255,255,
255,255,255,255,0,0,0,0,255,255,255,255,255,255,255,255,
255,255,255,255,255,255,255,255,0,0,0,0,255,255,255,255,
255,255,255,255,255,255,255,255,255,255,255,255,0,28,0,0,
255,255,255,255,255,227,255,227,255,255,255,255,255,255,255,255,
0,127,0,0,255,255,255,227,255,128,255,128,255,255,255,255,
255,255,255,255,0,255,128,0,255,193,255,128,255,0,255,0,
255,255,255,255,127,255,127,255,1,255,192,0,255,128,255,0,
254,0,254,0,255,255,127,255,63,255,63,255,1,255,192,0,
255,0,255,0,254,0,254,0,127,255,127,255,63,255,63,255,
99,255,227,0,254,0,254,0,156,0,156,0,127,255,63,255,
28,255,28,255,251,255,239,128,254,0,158,0,4,0,100,0,
63,255,60,255,16,127,19,127,255,255,255,128,252,0,132,0,
0,0,120,0,63,255,16,255,0,127,15,127,255,255,255,128,
252,0,132,0,0,0,120,0,63,255,16,255,0,127,15,127,
255,255,255,128,252,0,132,0,0,0,120,0,63,255,16,255,
0,127,15,127,255,255,255,128,252,0,140,0,0,0,112,0,
63,255,24,255,0,127,7,127,115,255,231,0,254,0,254,0,
140,0,140,0,63,255,63,255,24,255,24,255,3,255,224,0,
254,0,254,0,252,0,252,0,127,255,63,255,31,255,31,255,
1,255,192,0,255,128,255,0,254,0,254,0,255,255,127,255,
63,255,63,255,0,255,128,0,255,255,255,255,255,0,255,0,
255,255,255,255,127,255,127,255,1,247,192,0,255,255,255,28,
254,8,254,235,255,255,127,255,63,255,191,255,3,255,224,0,
255,255,254,8,252,0,253,247,255,255,63,255,31,255,223,255,
3,255,224,0,255,255,254,8,252,0,253,247,255,255,63,255,
31,255,223,255,3,255,224,0,255,255,254,8,252,0,253,247,
255,255,63,255,31,255,223,255,1,247,192,0,255,255,255,255,
254,8,254,8,255,255,255,255,63,255,63,255,0,0,0,0,
255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,
0,0,0,0,255,255,255,255,255,255,255,255,255,255,255,255,
255,255,255,255,0,0,0,0,255,255,255,255,255,255,255,255,
255,255,255,255,255,255,255,255,0,0,0,0,255,255,255,255,
255,255,255,255,255,255,255,255,255,255,255,255,0,62,0,0,
255,255,255,255,255,193,255,193,255,255,255,255,255,255,255,255,
0,255,128,0,255,195,255,193,255,0,255,0,255,255,255,255,
127,255,127,255,1,255,192,0,255,0,255,0,254,0,254,0,
255,255,127,255,63,255,63,255,59,255,238,0,254,0,254,0,
196,0,196,0,127,255,63,255,17,255,17,255,127,255,255,0,
254,0,198,0,136,0,184,0,63,255,49,255,8,255,14,255,
255,255,255,128,252,0,132,0,0,0,120,0,63,255,16,255,
0,127,15,127,255,255,255,128,252,0,132,0,0,0,120,0,
63,255,16,255,0,127,15,127,255,255,255,128,252,0,156,0,
0,0,96,0,63,255,28,255,0,127,3,127,103,255,243,0,
252,0,252,0,152,0,152,0,63,255,31,255,12,255,12,255,
7,255,240,0,254,0,252,0,248,0,248,0,95,255,63,255,
15,255,15,255,3,255,240,0,255,96,254,0,252,0,252,0,
223,255,63,255,15,255,15,255,3,255,224,0,254,239,255,243,
252,0,252,0,191,255,255,255,31,255,31,255,1,255,192,0,
255,247,255,28,254,128,254,227,255,255,127,255,191,255,191,255,
1,255,192,0,255,255,255,28,254,0,254,227,255,255,127,255,
63,255,191,255,3,255,224,0,255,255,254,8,252,0,253,247,
255,255,63,255,31,255,223,255,3,255,224,0,255,255,254,8,
252,0,253,247,255,255,63,255,31,255,223,255,1,247,192,0,
255,255,255,28,254,8,254,235,255,255,127,255,63,255,191,255,
0,227,128,0,255,255,255,255,255,28,255,28,255,255,255,255,
127,255,127,255,0,0,0,0,255,255,255,255,255,255,255,255,
255,255,255,255,255,255,255,255,0,0,0,0,255,255,255,255,
255,255,255,255,255,255,255,255,255,255,255,255,0,0,0,0,
255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,
0,0,0,0,255,255,255,255,255,255,255,255,255,255,255,255,
255,255,255,255,0,0,0,0,255,255,255,255,255,255,255,255,
255,255,255,255,255,255,255,255,0,62,0,0,255,255,255,255,
255,193,255,193,255,255,255,255,255,255,255,255,0,255,128,0,
255,199,255,193,255,0,255,0,255,255,255,255,127,255,127,255,
1,255,192,0,255,0,255,0,254,0,254,0,255,255,127,255,
63,255,63,255,59,255,238,0,254,0,254,0,196,0,196,0,
127,255,63,255,17,255,17,255,127,255,255,0,254,0,198,0,
128,0,184,0,63,255,49,255,0,255,14,255,255,255,255,128,
252,29,132,0,0,0,120,0,255,255,16,255,0,127,15,127,
255,255,255,128,252,63,140,0,0,0,112,0,255,255,24,255,
0,127,7,127,247,255,247,128,254,255,156,227,8,0,104,0,
255,255,156,255,8,127,11,127,103,255,243,0,255,255,255,20,
152,0,152,227,255,255,127,255,12,255,140,255,7,255,240,0,
255,255,254,8,248,0,249,247,255,255,63,255,15,255,207,255,
3,255,224,0,255,255,254,8,252,0,253,247,255,255,63,255,
31,255,223,255,3,255,224,0,255,255,254,8,252,0,253,247,
255,255,63,255,31,255,223,255,1,255,192,0,255,247,255,28,
254,0,254,227,255,255,127,255,63,255,191,255,0,255,128,0,
255,255,255,255,255,0,255,0,255,255,255,255,127,255,127,255,
0,0,0,0,255,255,255,255,255,255,255,255,255,255,255,255,
255,255,255,255,0,0,0,0,255,255,255,255,255,255,255,255,
255,255,255,255,255,255,255,255,0,0,0,0,255,255,255,255,
255,255,255,255,255,255,255,255,255,255,255,255,0,0,0,0,
255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,
0,0,0,0,255,255,255,255,255,255,255,255,255,255,255,255,
255,255,255,255,0,0,0,0,255,255,255,255,255,255,255,255,
255,255,255,255,255,255,255,255,0,227,128,0,255,255,255,255,
255,28,255,28,255,255,255,255,127,255,127,255,1,247,192,0,
255,255,255,28,254,8,254,235,255,255,127,255,63,255,191,255,
3,255,224,0,255,255,254,8,252,0,253,247,255,255,63,255,
31,255,223,255,3,255,224,0,255,255,254,8,252,0,253,247,
255,255,63,255,31,255,223,255,3,255,224,0,255,255,254,8,
252,0,253,247,255,255,63,255,31,255,223,255,3,255,240,0,
255,255,255,20,252,0,252,227,255,255,127,255,15,255,143,255,
7,255,254,0,253,247,254,227,248,0,248,0,223,255,191,255,
1,255,1,255,63,255,255,0,254,0,252,0,192,0,192,0,
127,255,17,255,0,255,14,255,127,255,255,128,252,62,196,62,
128,0,184,0,63,255,16,255,0,127,15,127,255,255,255,128,
252,65,132,65,0,0,120,0,63,255,24,255,0,127,7,127,
255,255,247,128,252,128,140,0,0,0,112,0,191,255,28,255,
8,127,11,127,247,255,243,0,252,119,156,119,8,0,104,0,
63,255,31,255,12,255,12,255,99,255,224,0,254,170,254,170,
156,0,156,0,191,255,191,255,31,255,31,255,3,255,224,0,
254,201,254,73,252,0,252,0,127,255,63,255,31,255,31,255,
1,255,192,0,255,118,255,54,254,0,254,0,255,255,127,255,
63,255,63,255,0,255,128,0,255,195,255,193,255,0,255,0,
255,255,255,255,127,255,127,255,0,62,0,0,255,255,255,255,
255,193,255,193,255,255,255,255,255,255,255,255,0,0,0,0,
255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,
0,0,0,0,255,255,255,255,255,255,255,255,255,255,255,255,
255,255,255,255,0,0,0,0,255,255,255,255,255,255,255,255,
255,255,255,255,255,255,255,255,0,255,128,0,255,255,255,255,
255,0,255,0,255,255,255,255,127,255,127,255,1,255,128,0,
255,255,255,32,254,0,254,223,255,255,255,255,127,255,127,255,
1,255,128,0,255,251,255,32,254,0,254,219,255,255,255,255,
127,255,127,255,0,255,128,0,255,255,255,144,255,0,255,111,
255,255,255,255,127,255,127,255,0,127,128,0,255,255,255,232,
255,128,255,151,255,255,255,255,127,255,127,255,0,31,0,0,
255,255,255,255,255,224,255,224,255,255,255,255,255,255,255,255,
0,255,128,0,255,225,255,255,255,0,255,0,255,255,255,255,
127,255,127,255,1,255,192,0,255,67,255,128,254,0,254,0,
127,255,255,255,63,255,63,255,3,255,224,0,254,28,255,28,
252,0,252,0,191,255,127,255,31,255,31,255,3,255,224,0,
255,190,255,162,252,0,252,28,127,255,63,255,31,255,31,255,
7,255,240,0,254,62,252,98,248,0,248,28,63,255,31,255,
15,255,15,255,7,255,240,0,252,62,252,34,248,0,248,28,
63,255,31,255,15,255,15,255,7,255,240,0,252,124,252,124,
248,0,248,0,63,255,31,255,15,255,15,255,7,255,240,0,
252,16,252,128,248,0,248,0,63,255,31,255,15,255,15,255,
3,255,224,0,254,192,254,208,252,0,252,0,63,255,63,255,
31,255,31,255,3,255,224,0,254,144,254,144,252,0,252,0,
63,255,63,255,31,255,31,255,3,255,224,0,254,144,254,128,
252,0,252,0,127,255,63,255,31,255,31,255,1,255,192,0,
255,64,255,96,254,0,254,0,127,255,127,255,63,255,63,255,
1,255,192,0,255,0,255,0,254,0,254,0,255,255,127,255,
63,255,63,255,0,255,128,0,255,128,255,128,255,0,255,0,
255,255,255,255,127,255,127,255,0,127,0,0,255,195,255,193,
255,128,255,128,255,255,255,255,255,255,255,255,0,62,0,0,
255,255,255,255,255,193,255,193,255,255,255,255,255,255,255,255,
0,119,0,0,255,255,255,255,255,136,255,136,255,255,255,255,
255,255,255,255,1,255,192,0,255,255,255,136,254,0,254,119,
255,255,255,255,63,255,63,255,3,255,224,0,255,255,254,8,
252,0,253,247,255,255,63,255,31,255,223,255,7,255,240,0,
255,255,252,4,248,0,251,251,255,255,31,255,15,255,239,255,
7,255,240,0,255,127,252,6,248,0,251,121,255,255,31,255,
15,255,239,255,3,251,224,0,255,255,255,206,252,4,252,53,
255,255,63,255,31,255,223,255,0,255,192,0,255,255,255,255,
255,0,255,0,255,255,255,255,63,255,63,255,1,255,192,0,
255,66,255,129,254,0,254,0,127,255,255,255,63,255,63,255,
3,255,224,0,255,1,254,0,252,0,252,0,255,255,255,255,
31,255,31,255,3,255,240,0,255,193,255,193,252,0,252,0,
255,255,31,255,15,255,239,255,7,255,240,0,254,3,252,34,
248,0,248,1,255,255,31,255,15,255,239,255,7,255,240,0,
252,19,252,2,248,0,248,1,255,255,31,255,15,255,239,255,
7,255,240,0,252,99,252,2,248,0,248,1,255,255,63,255,
15,255,207,255,7,255,240,0,252,17,252,129,248,0,248,0,
223,255,255,255,15,255,15,255,3,255,224,0,254,192,254,208,
252,0,252,0,63,255,63,255,31,255,31,255,3,255,224,0,
254,144,254,144,252,0,252,0,63,255,63,255,31,255,31,255,
3,255,224,0,254,144,254,128,252,0,252,0,127,255,63,255,
31,255,31,255,1,255,192,0,255,64,255,96,254,0,254,0,
127,255,127,255,63,255,63,255,1,255,192,0,255,0,255,0,
254,0,254,0,255,255,127,255,63,255,63,255,0,255,128,0,
255,128,255,128,255,0,255,0,255,255,255,255,127,255,127,255,
0,127,0,0,255,195,255,193,255,128,255,128,255,255,255,255,
255,255,255,255,0,62,0,0,255,255,255,255,255,193,255,193,
255,255,255,255,255,255,255,255,0,0,0,0,255,255,255,255,
255,255,255,255,255,255,255,255,255,255,255,255,3,0,96,0,
255,255,255,255,252,255,252,255,255,255,255,255,159,255,159,255,
7,128,240,0,255,255,252,255,248,127,251,127,255,255,159,255,
15,255,111,255,15,192,248,0,255,255,248,127,240,63,247,191,
255,255,143,255,7,255,119,255,31,224,252,0,255,255,240,63,
224,31,239,223,255,255,135,255,3,255,123,255,31,224,254,0,
253,255,240,63,224,31,237,223,255,255,131,255,1,255,125,255,
15,255,252,0,255,255,254,127,240,0,241,128,255,255,135,255,
3,255,123,255,1,255,248,0,255,99,255,128,254,0,254,0,
127,255,207,255,7,255,55,255,3,255,240,0,255,0,254,0,
252,0,252,0,191,255,127,255,15,255,15,255,59,255,238,0,
255,192,255,192,196,0,196,0,127,255,63,255,17,255,17,255,
127,255,255,0,254,0,196,32,128,0,184,0,63,255,17,255,
0,255,14,255,127,255,255,0,252,16,196,0,128,0,184,0,
63,255,17,255,0,255,14,255,127,255,255,0,252,96,196,0,
128,0,184,0,63,255,33,255,0,255,30,255,63,255,254,0,
252,16,228,128,192,0,216,0,63,255,35,255,1,255,29,255,
31,255,252,0,252,192,244,208,224,0,232,0,63,255,55,255,
3,255,11,255,11,255,232,0,254,144,254,144,244,0,244,0,
63,255,63,255,23,255,23,255,3,255,224,0,254,144,254,128,
252,0,252,0,127,255,63,255,31,255,31,255,1,255,192,0,
255,64,255,96,254,0,254,0,127,255,127,255,63,255,63,255,
1,255,192,0,255,0,255,0,254,0,254,0,255,255,127,255,
63,255,63,255,0,255,128,0,255,128,255,128,255,0,255,0,
255,255,255,255,127,255,127,255,0,127,0,0,255,195,255,193,
255,128,255,128,255,255,255,255,255,255,255,255,0,62,0,0,
255,255,255,255,255,193,255,193,255,255,255,255,255,255,255,255,
0,119,0,0,255,255,255,255,255,136,255,136,255,255,255,255,
255,255,255,255,1,255,192,0,255,255,255,136,254,0,254,119,
255,255,255,255,63,255,63,255,3,255,224,0,255,255,254,8,
252,0,253,247,255,255,63,255,31,255,223,255,3,255,240,0,
255,253,254,8,252,0,253,245,255,255,31,255,15,255,239,255,
3,255,240,0,255,255,254,6,252,0,253,249,255,255,31,255,
15,255,239,255,1,251,224,0,255,255,255,206,254,4,254,53,
255,255,63,255,31,255,223,255,0,127,192,0,255,255,255,255,
255,128,255,128,255,255,255,255,63,255,63,255,1,255,192,0,
255,186,255,193,254,0,254,0,127,255,255,255,63,255,63,255,
3,255,224,0,255,216,255,96,252,0,252,128,191,255,127,255,
31,255,31,255,3,255,224,0,255,240,254,32,252,0,253,192,
127,255,63,255,31,255,31,255,3,255,240,0,255,240,254,16,
252,0,253,224,63,255,31,255,15,255,15,255,7,255,240,0,
253,240,253,16,248,0,248,224,63,255,31,255,15,255,15,255,
7,255,240,0,252,224,252,224,248,0,248,0,63,255,31,255,
15,255,15,255,7,255,240,0,252,144,252,144,248,0,248,0,
63,255,31,255,15,255,15,255,3,255,224,0,254,192,254,208,
252,0,252,0,63,255,63,255,31,255,31,255,3,255,224,0,
254,144,254,144,252,0,252,0,63,255,63,255,31,255,31,255,
3,255,224,0,254,144,254,128,252,0,252,0,127,255,63,255,
31,255,31,255,1,255,192,0,255,64,255,96,254,0,254,0,
127,255,127,255,63,255,63,255,1,255,192,0,255,0,255,0,
254,0,254,0,255,255,127,255,63,255,63,255,0,255,128,0,
255,128,255,128,255,0,255,0,255,255,255,255,127,255,127,255,
0,127,0,0,255,195,255,193,255,128,255,128,255,255,255,255,
255,255,255,255,0,62,0,0,255,255,255,255,255,193,255,193,
255,255,255,255,255,255,255,255,0,0,0,0,255,255,255,255,
255,255,255,255,255,255,255,255,255,255,255,255,3,0,96,0,
255,255,255,255,252,255,252,255,255,255,255,255,159,255,159,255,
7,128,240,0,255,255,252,255,248,127,251,127,255,255,159,255,
15,255,111,255,15,193,248,0,255,255,248,127,240,62,247,190,
255,255,15,255,7,255,247,255,31,225,252,0,255,255,240,63,
224,30,239,222,191,255,7,255,3,255,187,255,31,224,254,0,
255,255,240,63,224,31,239,223,255,255,131,255,1,255,125,255,
15,255,252,0,255,255,254,127,240,0,241,128,255,255,135,255,
3,255,123,255,1,255,248,0,255,99,255,128,254,0,254,0,
127,255,207,255,7,255,55,255,3,255,240,0,254,128,255,0,
252,0,252,0,191,255,127,255,15,255,15,255,59,255,238,0,
255,192,255,192,196,0,196,0,127,255,63,255,17,255,17,255,
127,255,255,0,254,0,198,32,128,0,184,0,63,255,17,255,
0,255,14,255,127,255,255,0,254,16,196,0,128,0,184,0,
63,255,33,255,0,255,30,255,127,255,255,0,254,96,194,0,
128,0,188,0,63,255,33,255,0,255,30,255,63,255,254,0,
254,16,226,128,192,0,220,0,63,255,35,255,1,255,29,255,
31,255,252,0,254,192,246,208,224,0,232,0,63,255,55,255,
3,255,11,255,11,255,232,0,254,144,254,144,244,0,244,0,
63,255,63,255,23,255,23,255,3,255,224,0,254,144,254,128,
252,0,252,0,127,255,63,255,31,255,31,255,1,255,192,0,
255,64,255,96,254,0,254,0,127,255,127,255,63,255,63,255,
1,255,192,0,255,0,255,0,254,0,254,0,255,255,127,255,
63,255,63,255,0,255,128,0,255,128,255,128,255,0,255,0,
255,255,255,255,127,255,127,255,0,127,0,0,255,195,255,193,
255,128,255,128,255,255,255,255,255,255,255,255,0,62,0,0,
255,255,255,255,255,193,255,193,255,255,255,255,255,255,255,255,
0,255,128,0,255,255,255,255,255,0,255,0,255,255,255,255,
127,255,127,255,0,255,192,0,255,255,255,130,255,0,255,125,
255,255,127,255,63,255,191,255,0,255,192,0,255,239,255,130,
255,0,255,109,255,255,127,255,63,255,191,255,0,255,128,0,
255,255,255,132,255,0,255,123,255,255,255,255,127,255,127,255,
0,255,0,0,255,255,255,139,255,0,255,116,255,255,255,255,
255,255,255,255,0,124,0,0,255,255,255,255,255,131,255,131,
255,255,255,255,255,255,255,255,0,255,128,0,255,195,255,255,
255,0,255,0,255,255,255,255,127,255,127,255,1,255,192,0,
255,97,255,128,254,0,254,0,127,255,255,255,63,255,63,255,
3,255,224,0,254,156,255,28,252,0,252,0,63,255,127,255,
31,255,31,255,3,255,224,0,255,62,254,34,252,0,252,28,
255,255,255,255,31,255,31,255,7,255,240,0,254,62,252,35,
248,0,248,28,63,255,31,255,15,255,15,255,7,255,240,0,
254,62,252,34,248,0,248,28,31,255,31,255,15,255,15,255,
7,255,240,0,254,31,252,31,248,0,248,0,31,255,31,255,
15,255,15,255,7,255,240,0,254,4,252,0,248,0,248,0,
31,255,159,255,15,255,15,255,3,255,224,0,254,1,254,5,
252,0,252,0,191,255,191,255,31,255,31,255,3,255,224,0,
254,4,254,4,252,0,252,0,191,255,191,255,31,255,31,255,
3,255,224,0,255,4,254,0,252,0,252,0,191,255,191,255,
31,255,31,255,1,255,192,0,255,1,255,3,254,0,254,0,
127,255,127,255,63,255,63,255,1,255,192,0,255,128,255,0,
254,0,254,0,127,255,127,255,63,255,63,255,0,255,128,0,
255,128,255,128,255,0,255,0,255,255,255,255,127,255,127,255,
0,127,0,0,255,225,255,193,255,128,255,128,255,255,255,255,
255,255,255,255,0,62,0,0,255,255,255,255,255,193,255,193,
255,255,255,255,255,255,255,255,0,119,0,0,255,255,255,255,
255,136,255,136,255,255,255,255,255,255,255,255,1,255,192,0,
255,255,255,136,254,0,254,119,255,255,255,255,63,255,63,255,
3,255,224,0,255,255,254,8,252,0,253,247,255,255,63,255,
31,255,223,255,7,255,240,0,255,255,252,16,248,0,251,239,
255,255,31,255,15,255,239,255,7,255,240,0,255,255,252,48,
248,0,251,207,127,255,31,255,15,255,111,255,3,239,224,0,
255,255,254,57,252,16,253,214,255,255,255,255,31,255,31,255,
1,255,128,0,255,255,255,255,254,0,254,0,255,255,255,255,
127,255,127,255,1,255,192,0,255,33,255,192,254,0,254,0,
127,255,255,255,63,255,63,255,3,255,224,0,255,192,255,128,
252,0,252,0,127,255,63,255,31,255,31,255,7,255,224,0,
255,193,252,65,248,0,251,128,255,255,255,255,31,255,31,255,
7,255,240,0,255,224,252,34,248,0,251,192,63,255,31,255,
15,255,15,255,7,255,240,0,255,228,252,32,248,0,251,192,
31,255,31,255,15,255,15,255,7,255,240,0,255,227,254,32,
248,0,249,192,31,255,31,255,15,255,15,255,7,255,240,0,
253,196,255,192,248,0,248,0,31,255,159,255,15,255,15,255,
3,255,224,0,254,1,254,5,252,0,252,0,191,255,191,255,
31,255,31,255,3,255,224,0,254,4,254,4,252,0,252,0,
191,255,191,255,31,255,31,255,3,255,224,0,255,4,254,0,
252,0,252,0,191,255,191,255,31,255,31,255,1,255,192,0,
255,1,255,3,254,0,254,0,127,255,127,255,63,255,63,255,
1,255,192,0,255,128,255,0,254,0,254,0,127,255,127,255,
63,255,63,255,0,255,128,0,255,128,255,128,255,0,255,0,
255,255,255,255,127,255,127,255,0,127,0,0,255,225,255,193,
255,128,255,128,255,255,255,255,255,255,255,255,0,62,0,0,
255,255,255,255,255,193,255,193,255,255,255,255,255,255,255,255,
0,0,0,0,255,255,255,255,255,255,255,255,255,255,255,255,
255,255,255,255,3,0,96,0,255,255,255,255,252,255,252,255,
255,255,255,255,159,255,159,255,7,128,240,0,255,255,252,255,
248,127,251,127,255,255,159,255,15,255,111,255,15,129,248,0,
255,255,248,255,240,126,247,126,255,255,15,255,7,255,247,255,
31,131,252,0,255,255,240,254,224,124,239,125,255,255,7,255,
3,255,251,255,63,131,252,0,255,255,224,254,192,124,223,125,
223,255,7,255,3,255,219,255,31,255,248,0,255,255,240,255,
224,0,239,0,255,255,63,255,7,255,199,255,15,255,192,0,
255,99,249,128,240,0,246,0,127,255,255,255,63,255,63,255,
7,255,224,0,254,128,255,0,248,0,248,0,127,255,63,255,
31,255,31,255,59,255,238,0,255,1,254,1,196,0,196,0,
255,255,255,255,17,255,17,255,127,255,255,0,254,0,196,2,
128,0,184,0,63,255,17,255,0,255,14,255,127,255,255,0,
254,4,196,0,128,0,184,0,31,255,17,255,0,255,14,255,
127,255,255,0,254,3,194,0,128,0,188,0,31,255,17,255,
0,255,14,255,63,255,254,0,254,4,226,0,192,0,220,0,
31,255,147,255,1,255,13,255,31,255,252,0,254,1,246,5,
224,0,232,0,159,255,151,255,3,255,11,255,11,255,232,0,
254,4,254,4,244,0,244,0,191,255,191,255,23,255,23,255,
3,255,224,0,255,4,254,0,252,0,252,0,191,255,191,255,
31,255,31,255,1,255,192,0,255,1,255,3,254,0,254,0,
127,255,127,255,63,255,63,255,1,255,192,0,255,128,255,0,
254,0,254,0,127,255,127,255,63,255,63,255,0,255,128,0,
255,128,255,128,255,0,255,0,255,255,255,255,127,255,127,255,
0,127,0,0,255,225,255,193,255,128,255,128,255,255,255,255,
255,255,255,255,0,62,0,0,255,255,255,255,255,193,255,193,
255,255,255,255,255,255,255,255,0,119,0,0,255,255,255,255,
255,136,255,136,255,255,255,255,255,255,255,255,1,255,192,0,
255,255,255,136,254,0,254,119,255,255,255,255,63,255,63,255,
3,255,224,0,255,255,254,8,252,0,253,247,255,255,63,255,
31,255,223,255,7,255,224,0,255,223,252,8,248,0,251,215,
255,255,63,255,31,255,223,255,7,255,224,0,255,255,252,48,
248,0,251,207,255,255,63,255,31,255,223,255,3,239,192,0,
255,255,254,57,252,16,253,214,255,255,255,255,63,255,63,255,
1,255,0,0,255,255,255,255,254,0,254,0,255,255,255,255,
255,255,255,255,1,255,192,0,255,46,255,193,254,0,254,0,
255,255,255,255,63,255,63,255,3,255,224,0,254,141,255,3,
252,0,252,0,255,255,127,255,31,255,159,255,3,255,224,0,
255,7,254,2,252,0,252,1,255,255,63,255,31,255,223,255,
7,255,224,0,254,7,252,4,248,0,248,3,255,255,63,255,
31,255,223,255,7,255,240,0,254,7,252,4,248,0,248,3,
223,255,95,255,15,255,143,255,7,255,240,0,254,3,252,3,
248,0,248,0,159,255,159,255,15,255,15,255,7,255,240,0,
254,4,252,4,248,0,248,0,159,255,159,255,15,255,15,255,
3,255,224,0,254,1,254,5,252,0,252,0,191,255,191,255,
31,255,31,255,3,255,224,0,254,4,254,4,252,0,252,0,
191,255,191,255,31,255,31,255,3,255,224,0,255,4,254,0,
252,0,252,0,191,255,191,255,31,255,31,255,1,255,192,0,
255,1,255,3,254,0,254,0,127,255,127,255,63,255,63,255,
1,255,192,0,255,128,255,0,254,0,254,0,127,255,127,255,
63,255,63,255,0,255,128,0,255,128,255,128,255,0,255,0,
255,255,255,255,127,255,127,255,0,127,0,0,255,225,255,193,
255,128,255,128,255,255,255,255,255,255,255,255,0,62,0,0,
255,255,255,255,255,193,255,193,255,255,255,255,255,255,255,255,
0,0,0,0,255,255,255,255,255,255,255,255,255,255,255,255,
255,255,255,255,3,0,96,0,255,255,255,255,252,255,252,255,
255,255,255,255,159,255,159,255,7,128,240,0,255,255,252,255,
248,127,251,127,255,255,159,255,15,255,111,255,15,193,248,0,
255,255,248,127,240,62,247,190,255,255,15,255,7,255,247,255,
31,195,252,0,254,255,240,126,224,60,238,189,255,255,7,255,
3,255,251,255,63,131,252,0,255,255,224,254,192,124,223,125,
255,255,7,255,3,255,251,255,31,255,248,0,255,255,240,255,
224,0,239,0,255,255,63,255,7,255,199,255,15,255,192,0,
255,99,249,128,240,0,246,0,127,255,255,255,63,255,63,255,
7,255,224,0,254,128,255,0,248,0,248,0,191,255,127,255,
31,255,31,255,59,255,238,0,251,1,254,1,192,0,192,0,
255,255,255,255,17,255,17,255,127,255,255,0,254,0,196,2,
128,0,184,0,63,255,49,255,0,255,14,255,127,255,255,0,
254,4,194,0,128,0,188,0,63,255,17,255,0,255,14,255,
127,255,255,0,254,3,194,0,128,0,188,0,63,255,33,255,
0,255,30,255,63,255,254,0,254,4,226,0,192,0,220,0,
63,255,163,255,1,255,29,255,31,255,252,0,254,1,246,5,
224,0,232,0,191,255,183,255,3,255,11,255,11,255,232,0,
254,4,254,4,244,0,244,0,191,255,191,255,23,255,23,255,
3,255,224,0,255,4,254,0,252,0,252,0,191,255,191,255,
31,255,31,255,1,255,192,0,255,1,255,3,254,0,254,0,
127,255,127,255,63,255,63,255,1,255,192,0,255,128,255,0,
254,0,254,0,127,255,127,255,63,255,63,255,0,255,128,0,
255,128,255,128,255,0,255,0,255,255,255,255,127,255,127,255,
0,127,0,0,255,225,255,193,255,128,255,128,255,255,255,255,
255,255,255,255,0,62,0,0,255,255,255,255,255,193,255,193,
255,255,255,255,255,255,255,255,0,0,0,0,255,255,255,255,
255,255,255,255,255,255,255,255,255,255,255,255,0,0,0,0,
255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,
0,0,0,0,255,255,255,255,255,255,255,255,255,255,255,255,
255,255,255,255,0,3,128,0,255,255,255,255,255,252,255,252,
255,255,255,255,127,255,127,255,0,7,192,0,255,255,255,252,
255,248,255,251,255,255,255,255,63,255,63,255,0,7,224,0,
255,255,255,253,255,248,255,250,255,255,63,255,31,255,223,255,
0,7,240,0,255,255,255,255,255,248,255,248,255,255,31,255,
15,255,239,255,0,251,248,0,255,255,255,255,255,4,255,4,
127,255,15,255,7,255,119,255,3,255,248,0,255,119,255,143,
252,0,252,0,255,255,15,255,7,255,247,255,7,255,248,0,
254,69,252,67,248,0,248,0,255,255,15,255,7,255,247,255,
15,255,240,0,248,114,248,113,240,0,240,0,255,255,255,255,
15,255,15,255,15,255,192,0,249,57,249,40,240,0,240,16,
127,255,255,255,63,255,63,255,31,255,192,0,242,252,242,68,
224,0,224,56,255,255,127,255,63,255,63,255,31,255,192,0,
246,124,246,68,224,0,224,56,255,255,127,255,63,255,63,255,
63,255,192,0,232,184,232,184,192,0,192,0,255,255,127,255,
63,255,63,255,63,255,192,0,233,0,233,0,192,0,192,0,
255,255,127,255,63,255,63,255,63,255,128,0,230,0,230,0,
192,0,192,0,255,255,255,255,127,255,127,255,63,255,128,0,
224,1,224,0,192,0,192,0,255,255,255,255,127,255,127,255,
63,255,0,0,224,3,224,1,192,0,192,0,255,255,255,255,
255,255,255,255,31,254,0,0,240,15,240,7,224,1,224,1,
255,255,255,255,255,255,255,255,15,248,0,0,248,127,248,63,
240,7,240,7,255,255,255,255,255,255,255,255,7,192,0,0,
255,255,255,255,248,63,248,63,255,255,255,255,255,255,255,255,
0,0,0,0,255,255,255,255,255,255,255,255,255,255,255,255,
255,255,255,255,0,60,0,0,255,255,255,255,255,195,255,195,
255,255,255,255,255,255,255,255,1,255,0,0,255,251,255,199,
254,0,254,0,255,255,255,255,255,255,255,255,7,255,134,0,
255,130,254,3,248,0,248,0,255,255,255,255,121,255,121,255,
15,255,143,0,249,227,249,226,240,0,240,0,255,255,249,255,
112,255,118,255,31,255,223,0,242,84,242,84,224,0,224,0,
255,255,113,255,32,255,46,255,63,255,223,0,226,30,226,30,
192,0,192,0,255,255,119,255,32,255,40,255,63,255,255,0,
225,255,225,241,192,0,192,14,255,255,105,255,0,255,22,255,
63,255,255,0,224,31,224,17,192,0,192,14,251,255,113,255,
0,255,10,255,63,255,255,0,224,31,224,17,192,0,192,14,
255,255,97,255,0,255,30,255,63,255,255,0,224,14,224,14,
192,0,192,0,255,255,97,255,0,255,30,255,31,255,255,0,
240,0,240,0,224,0,224,0,255,255,97,255,0,255,30,255,
15,255,158,0,248,1,248,0,240,0,240,0,255,255,255,255,
97,255,97,255,7,255,128,0,254,2,254,1,248,0,248,0,
255,255,255,255,127,255,127,255,1,255,0,0,255,255,255,195,
254,0,254,0,255,255,255,255,255,255,255,255,0,60,0,0,
255,255,255,255,255,195,255,195,255,255,255,255,255,255,255,255,
0,0,0,0,255,255,255,255,255,255,255,255,255,255,255,255,
255,255,255,255,0,0,0,0,255,255,255,255,255,255,255,255,
255,255,255,255,255,255,255,255,0,0,0,0,255,255,255,255,
255,255,255,255,255,255,255,255,255,255,255,255,0,0,0,0,
255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,
0,0,0,0,255,255,255,255,255,255,255,255,255,255,255,255,
255,255,255,255,0,0,0,0,255,255,255,255,255,255,255,255,
255,255,255,255,255,255,255,255,3,224,0,0,255,255,255,255,
252,31,252,31,255,255,255,255,255,255,255,255,7,248,0,0,
254,63,252,31,248,7,248,7,255,255,255,255,255,255,255,255,
15,254,0,0,248,111,248,103,240,1,240,1,255,255,255,255,
255,255,255,255,31,255,0,0,248,147,240,145,224,0,224,0,
255,255,255,255,255,255,255,255,31,255,128,0,240,153,240,152,
224,0,224,0,255,255,255,255,127,255,127,255,31,255,128,0,
240,68,240,68,224,0,224,0,255,255,255,255,127,255,127,255,
31,255,192,0,240,41,240,32,224,0,224,0,255,255,255,255,
63,255,63,255,31,255,192,0,240,31,240,31,224,0,224,0,
255,255,127,255,63,255,63,255,15,255,192,0,248,62,248,34,
240,0,240,28,255,255,127,255,63,255,63,255,15,255,192,0,
248,62,248,34,240,0,240,28,255,255,127,255,63,255,63,255,
15,255,192,0,248,60,248,36,240,0,240,24,127,255,255,255,
63,255,63,255,7,255,152,0,252,25,252,24,248,0,248,0,
255,255,255,255,103,255,103,255,7,255,252,0,252,0,252,1,
248,0,248,0,255,255,231,255,3,255,27,255,3,255,252,0,
254,3,254,1,252,0,252,0,255,255,231,255,3,255,27,255,
1,255,252,0,255,203,255,135,254,0,254,0,191,255,23,255,
3,255,171,255,0,127,248,0,255,255,255,254,255,128,255,129,
255,255,15,255,7,255,247,255,0,7,240,0,255,255,255,252,
255,248,255,251,255,255,31,255,15,255,239,255,0,3,224,0,
255,255,255,254,255,252,255,253,255,255,63,255,31,255,223,255,
0,1,192,0,255,255,255,255,255,254,255,254,255,255,255,255,
63,255,63,255,0,0,0,0,255,255,255,255,255,255,255,255,
255,255,255,255,255,255,255,255,0,0,0,0,255,255,255,255,
255,255,255,255,255,255,255,255,255,255,255,255,0,0,0,0,
255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,
0,0,0,0,255,255,255,255,255,255,255,255,255,255,255,255,
255,255,255,255,0,248,0,0,255,255,255,255,255,7,255,7,
255,255,255,255,255,255,255,255,1,252,0,0,255,15,255,7,
254,3,254,3,255,255,255,255,255,255,255,255,3,254,0,0,
254,3,254,3,252,1,252,1,255,255,255,255,255,255,255,255,
7,255,0,0,252,3,252,1,248,0,248,0,255,255,255,255,
255,255,255,255,7,255,0,0,252,1,252,13,248,0,248,0,
255,255,255,255,255,255,255,255,15,255,128,0,248,3,248,18,
240,0,240,0,255,255,255,255,127,255,127,255,15,255,128,0,
248,2,248,18,240,0,240,0,255,255,255,255,127,255,127,255,
31,255,128,0,248,22,240,22,224,0,224,0,255,255,255,255,
127,255,127,255,31,255,192,0,240,18,240,18,224,0,224,0,
255,255,127,255,63,255,63,255,31,255,192,0,240,124,240,124,
224,0,224,0,255,255,127,255,63,255,63,255,31,255,192,0,
240,248,240,136,224,0,224,112,255,255,127,255,63,255,63,255,
31,255,192,0,248,252,240,140,224,0,224,112,255,255,127,255,
63,255,63,255,15,255,128,0,248,251,248,139,240,0,240,112,
255,255,255,255,127,255,127,255,15,255,128,0,252,114,248,113,
240,0,240,0,255,255,255,255,127,255,127,255,7,255,0,0,
252,5,254,3,248,0,248,0,255,255,255,255,255,255,255,255,
3,254,0,0,255,7,255,255,252,1,252,1,255,255,255,255,
255,255,255,255,1,248,0,0,255,255,255,255,254,7,254,7,
255,255,255,255,255,255,255,255,3,220,0,0,255,255,254,111,
252,35,253,179,255,255,255,255,255,255,255,255,3,254,0,0,
255,255,254,19,252,1,253,237,255,255,255,255,255,255,255,255,
3,255,0,0,255,223,254,9,252,0,253,214,255,255,255,255,
255,255,255,255,3,255,0,0,255,255,255,255,252,0,252,0,
255,255,255,255,255,255,255,255,0,7,192,0,255,255,255,255,
255,248,255,248,255,255,255,255,63,255,63,255,0,63,224,0,
255,252,255,248,255,192,255,192,127,255,63,255,31,255,31,255,
0,255,240,0,255,224,255,192,255,0,255,0,31,255,31,255,
15,255,15,255,1,255,248,0,255,128,255,0,254,0,254,0,
15,255,15,255,7,255,7,255,3,255,248,0,255,0,254,0,
252,0,252,0,15,255,15,255,7,255,7,255,3,255,248,0,
254,0,254,0,252,0,252,0,207,255,207,255,7,255,7,255,
7,255,248,0,254,1,252,1,248,0,248,0,47,255,47,255,
7,255,7,255,7,255,248,0,254,58,252,58,248,0,248,0,
47,255,47,255,7,255,7,255,7,255,240,0,254,124,252,68,
248,0,248,56,223,255,95,255,15,255,15,255,7,255,240,0,
254,126,252,68,248,0,248,56,159,255,223,255,15,255,15,255,
15,255,224,0,253,57,254,57,240,0,240,0,63,255,191,255,
31,255,31,255,31,255,224,0,254,132,255,4,224,0,224,0,
63,255,63,255,31,255,31,255,63,255,192,0,255,68,225,132,
192,0,222,0,255,255,127,255,63,255,63,255,63,255,128,0,
255,221,225,227,192,0,222,0,255,255,255,255,127,255,127,255,
63,190,0,0,253,255,225,255,192,65,220,65,255,255,255,255,
255,255,255,255,31,192,0,0,255,255,241,255,224,63,238,63,
255,255,255,255,255,255,255,255,15,192,0,0,255,255,249,127,
240,63,246,191,255,255,255,255,255,255,255,255,7,192,0,0,
255,255,254,127,248,63,249,191,255,255,255,255,255,255,255,255,
3,128,0,0,255,255,255,255,252,127,252,127,255,255,255,255,
255,255,255,255,0,0,0,0,255,255,255,255,255,255,255,255,
255,255,255,255,255,255,255,255,0,0,0,0,255,255,255,255,
255,255,255,255,255,255,255,255,255,255,255,255,0,0,0,0,
255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,
0,0,0,0,255,255,255,255,255,255,255,255,255,255,255,255,
255,255,255,255,0,0,0,0,255,255,255,255,255,255,255,255,
255,255,255,255,255,255,255,255,0,62,0,0,255,255,255,255,
255,193,255,193,255,255,255,255,255,255,255,255,0,255,128,0,
255,255,255,193,255,0,255,0,255,255,255,255,127,255,127,255,
1,255,224,0,255,64,255,128,254,0,254,0,127,255,127,255,
31,255,31,255,121,255,240,0,255,128,255,0,134,0,134,0,
31,255,31,255,15,255,15,255,255,255,248,0,255,0,134,0,
0,0,120,0,15,255,15,255,7,255,7,255,255,255,252,0,
254,112,134,112,0,0,120,0,7,255,7,255,3,255,3,255,
255,255,252,0,254,248,134,136,0,0,120,112,7,255,7,255,
3,255,3,255,255,255,252,0,222,248,142,136,0,0,80,112,
7,255,7,255,3,255,3,255,255,255,252,0,254,255,150,143,
0,0,104,112,135,255,135,255,3,255,3,255,251,255,252,0,
254,120,238,120,4,0,20,0,71,255,71,255,3,255,3,255,
251,255,248,0,255,42,142,42,4,0,116,0,79,255,79,255,
7,255,7,255,241,255,240,0,255,199,159,71,14,0,110,0,
159,255,159,255,15,255,15,255,97,255,224,0,255,64,255,192,
158,0,158,0,255,255,127,255,31,255,31,255,0,255,128,0,
255,227,255,193,255,0,255,0,255,255,255,255,127,255,127,255,
0,62,0,0,255,255,255,255,255,193,255,193,255,255,255,255,
255,255,255,255,0,0,0,0,255,255,255,255,255,255,255,255,
255,255,255,255,255,255,255,255,0,0,0,0,255,255,255,255,
255,255,255,255,255,255,255,255,255,255,255,255,0,0,0,0,
255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,
0,0,0,0,255,255,255,255,255,255,255,255,255,255,255,255,
255,255,255,255,0,0,0,0,255,255,255,255,255,255,255,255,
255,255,255,255,255,255,255,255,0,0,0,0,255,255,255,255,
255,255,255,255,255,255,255,255,255,255,255,255,0,0,0,0,
255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,
1,192,0,0,255,255,255,255,254,63,254,63,255,255,255,255,
255,255,255,255,3,224,0,0,255,255,254,63,252,31,253,223,
255,255,255,255,255,255,255,255,7,240,0,0,255,255,252,31,
248,15,251,239,255,255,255,255,255,255,255,255,15,255,0,0,
255,255,248,31,240,0,247,224,255,255,255,255,255,255,255,255,
31,255,192,0,254,247,248,56,224,0,230,192,255,255,255,255,
63,255,63,255,31,255,224,0,255,208,247,224,224,0,232,0,
255,255,63,255,31,255,31,255,31,255,240,0,255,192,243,192,
224,0,236,0,63,255,31,255,15,255,15,255,14,255,240,0,
255,156,255,156,241,0,241,0,31,255,31,255,15,255,15,255,
1,255,248,0,255,158,255,18,254,0,254,12,31,255,15,255,
7,255,7,255,1,255,248,0,255,62,255,34,254,0,254,28,
15,255,15,255,7,255,7,255,1,255,248,0,255,62,255,34,
254,0,254,28,15,255,15,255,7,255,7,255,1,255,252,0,
255,124,255,124,254,0,254,0,15,255,7,255,3,255,3,255,
1,255,252,0,255,202,255,138,254,0,254,0,15,255,7,255,
3,255,3,255,0,255,252,0,255,145,255,145,255,0,255,0,
15,255,7,255,3,255,3,255,0,255,252,0,255,204,255,140,
255,0,255,0,143,255,135,255,3,255,3,255,0,127,252,0,
255,196,255,196,255,128,255,128,143,255,135,255,3,255,3,255,
0,63,248,0,255,243,255,243,255,192,255,192,15,255,15,255,
7,255,7,255,0,15,240,0,255,252,255,252,255,240,255,240,
31,255,31,255,15,255,15,255,0,3,224,0,255,255,255,255,
255,252,255,252,255,255,255,255,31,255,31,255,0,0,0,0,
255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,
0,0,0,0,255,255,255,255,255,255,255,255,255,255,255,255,
255,255,255,255,0,0,0,0,255,255,255,255,255,255,255,255,
255,255,255,255,255,255,255,255,0,0,0,0,255,255,255,255,
255,255,255,255,255,255,255,255,255,255,255,255,3,128,0,0,
255,255,255,255,252,127,252,127,255,255,255,255,255,255,255,255,
7,192,0,0,255,255,254,127,248,63,249,191,255,255,255,255,
255,255,255,255,15,192,0,0,255,255,249,127,240,63,246,191,
255,255,255,255,255,255,255,255,31,192,0,0,255,255,241,255,
224,63,238,63,255,255,255,255,255,255,255,255,63,190,0,0,
253,255,225,255,192,65,220,65,255,255,255,255,255,255,255,255,
63,255,128,0,255,221,225,227,192,0,222,0,255,255,255,255,
127,255,127,255,63,255,192,0,255,68,225,132,192,0,222,0,
255,255,127,255,63,255,63,255,31,255,224,0,254,156,255,28,
224,0,224,0,63,255,63,255,31,255,31,255,7,255,224,0,
253,57,254,41,248,0,248,16,63,255,63,255,31,255,31,255,
7,255,240,0,254,126,252,68,248,0,248,56,159,255,159,255,
15,255,15,255,7,255,240,0,254,124,252,68,248,0,248,56,
223,255,223,255,15,255,15,255,7,255,248,0,254,58,252,58,
248,0,248,0,47,255,47,255,7,255,7,255,7,255,248,0,
254,1,252,1,248,0,248,0,47,255,47,255,7,255,7,255,
3,255,248,0,254,0,254,0,252,0,252,0,207,255,207,255,
7,255,7,255,3,255,248,0,255,0,254,0,252,0,252,0,
15,255,15,255,7,255,7,255,1,255,248,0,255,128,255,0,
254,0,254,0,15,255,15,255,7,255,7,255,0,255,240,0,
255,224,255,192,255,0,255,0,31,255,31,255,15,255,15,255,
0,63,224,0,255,252,255,248,255,192,255,192,63,255,63,255,
31,255,31,255,0,7,192,0,255,255,255,255,255,248,255,248,
255,255,255,255,63,255,63,255,0,0,0,0,255,255,255,255,
255,255,255,255,255,255,255,255,255,255,255,255,0,60,0,0,
255,255,255,255,255,195,255,195,255,255,255,255,255,255,255,255,
0,255,128,0,255,223,255,227,255,0,255,0,255,255,255,255,
127,255,127,255,97,255,224,0,255,65,255,192,158,0,158,0,
255,255,127,255,31,255,31,255,241,255,240,0,255,199,159,71,
14,0,110,0,159,255,159,255,15,255,15,255,251,255,248,0,
255,42,142,42,4,0,116,0,79,255,79,255,7,255,7,255,
251,255,252,0,255,120,238,120,4,0,20,0,71,255,71,255,
3,255,3,255,255,255,252,0,255,255,150,143,0,0,104,112,
135,255,135,255,3,255,3,255,255,255,252,0,223,248,142,136,
0,0,80,112,7,255,7,255,3,255,3,255,255,255,252,0,
255,248,134,136,0,0,120,112,7,255,7,255,3,255,3,255,
255,255,252,0,255,112,134,112,0,0,120,0,7,255,7,255,
3,255,3,255,255,255,248,0,255,0,134,0,0,0,120,0,
15,255,15,255,7,255,7,255,121,255,240,0,255,128,255,0,
134,0,134,0,31,255,31,255,15,255,15,255,1,255,224,0,
255,64,255,128,254,0,254,0,127,255,127,255,31,255,31,255,
0,255,128,0,255,255,255,195,255,0,255,0,255,255,255,255,
127,255,127,255,0,60,0,0,255,255,255,255,255,195,255,195,
255,255,255,255,255,255,255,255,0,0,0,0,255,255,255,255,
255,255,255,255,255,255,255,255,255,255,255,255,0,0,0,0,
255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,
0,0,0,0,255,255,255,255,255,255,255,255,255,255,255,255,
255,255,255,255,0,0,0,0,255,255,255,255,255,255,255,255,
255,255,255,255,255,255,255,255,0,0,0,0,255,255,255,255,
255,255,255,255,255,255,255,255,255,255,255,255,0,0,0,0,
255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,
0,7,192,0,255,255,255,255,255,248,255,248,255,255,255,255,
63,255,63,255,0,31,224,0,255,252,255,248,255,224,255,224,
127,255,63,255,31,255,31,255,0,127,240,0,255,246,255,230,
255,128,255,128,31,255,31,255,15,255,15,255,0,255,248,0,
255,201,255,137,255,0,255,0,31,255,15,255,7,255,7,255,
1,255,248,0,255,153,255,25,254,0,254,0,15,255,15,255,
7,255,7,255,1,255,248,0,255,34,255,34,254,0,254,0,
15,255,15,255,7,255,7,255,3,255,248,0,255,148,255,4,
252,0,252,0,15,255,15,255,7,255,7,255,3,255,248,0,
255,248,254,248,252,0,252,0,15,255,15,255,7,255,7,255,
3,255,240,0,255,124,254,68,252,0,252,56,31,255,31,255,
15,255,15,255,3,255,240,0,255,124,254,68,252,0,252,56,
31,255,31,255,15,255,15,255,3,255,240,0,254,60,255,36,
252,0,252,24,31,255,31,255,15,255,15,255,25,255,224,0,
255,152,255,24,230,0,230,0,63,255,63,255,31,255,31,255,
63,255,224,0,255,0,231,128,192,0,216,0,63,255,63,255,
31,255,31,255,63,255,192,0,255,192,231,128,192,0,216,0,
127,255,127,255,63,255,63,255,63,255,128,0,253,211,232,225,
192,0,213,0,255,255,255,255,127,255,127,255,31,254,0,0,
255,255,240,127,224,1,239,129,255,255,255,255,255,255,255,255,
15,224,0,0,255,255,248,63,240,31,247,223,255,255,255,255,
255,255,255,255,7,192,0,0,255,255,252,127,248,63,251,191,
255,255,255,255,255,255,255,255,3,128,0,0,255,255,255,255,
252,127,252,127,255,255,255,255,255,255,255,255,0,0,0,0,
255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,
0,0,0,0,255,255,255,255,255,255,255,255,255,255,255,255,
255,255,255,255,0,0,0,0,255,255,255,255,255,255,255,255,
255,255,255,255,255,255,255,255,0,0,0,0,255,255,255,255,
255,255,255,255,255,255,255,255,255,255,255,255,0,62,0,0,
255,255,255,255,255,193,255,193,255,255,255,255,255,255,255,255,
0,127,0,0,255,225,255,193,255,128,255,128,255,255,255,255,
255,255,255,255,0,255,128,0,255,128,255,128,255,0,255,0,
255,255,255,255,127,255,127,255,1,255,192,0,255,128,255,0,
254,0,254,0,127,255,127,255,63,255,63,255,1,255,192,0,
255,0,255,96,254,0,254,0,127,255,127,255,63,255,63,255,
3,255,224,0,255,128,254,144,252,0,252,0,63,255,63,255,
31,255,31,255,3,255,224,0,254,128,254,144,252,0,252,0,
63,255,63,255,31,255,31,255,3,255,240,0,254,208,254,208,
252,0,252,0,63,255,31,255,15,255,15,255,7,255,240,0,
254,144,252,144,248,0,248,0,31,255,31,255,15,255,15,255,
7,255,240,0,254,124,252,124,248,0,248,0,31,255,31,255,
15,255,15,255,7,255,240,0,254,62,252,34,248,0,248,28,
31,255,31,255,15,255,15,255,7,255,240,0,254,126,252,98,
248,0,248,28,63,255,31,255,15,255,15,255,3,255,224,0,
255,190,255,162,252,0,252,28,63,255,63,255,31,255,31,255,
3,255,224,0,254,156,255,28,252,0,252,0,127,255,63,255,
31,255,31,255,1,255,192,0,255,64,255,128,254,0,254,0,
127,255,255,255,63,255,63,255,0,255,128,0,255,193,255,255,
255,0,255,0,255,255,255,255,127,255,127,255,0,63,0,0,
255,255,255,255,255,192,255,192,255,255,255,255,255,255,255,255,
0,119,128,0,255,255,255,236,255,136,255,155,255,255,255,255,
127,255,127,255,0,255,128,0,255,255,255,144,255,0,255,111,
255,255,255,255,127,255,127,255,1,255,128,0,255,247,255,32,
254,0,254,215,255,255,255,255,127,255,127,255,1,255,128,0,
255,255,255,255,254,0,254,0,255,255,255,255,127,255,127,255,
3,224,0,0,255,255,255,255,252,31,252,31,255,255,255,255,
255,255,255,255,7,252,0,0,254,63,252,31,248,3,248,3,
255,255,255,255,255,255,255,255,15,255,0,0,248,7,248,3,
240,0,240,0,255,255,255,255,255,255,255,255,31,255,128,0,
240,1,240,0,224,0,224,0,255,255,255,255,127,255,127,255,
31,255,192,0,240,0,240,0,224,0,224,0,255,255,127,255,
63,255,63,255,31,255,192,0,243,0,243,0,224,0,224,0,
127,255,127,255,63,255,63,255,31,255,224,0,244,128,244,128,
224,0,224,0,127,255,63,255,31,255,31,255,31,255,224,0,
244,92,244,92,224,0,224,0,127,255,63,255,31,255,31,255,
15,255,224,0,251,62,250,34,240,0,240,28,127,255,63,255,
31,255,31,255,15,255,224,0,249,126,251,34,240,0,240,28,
127,255,63,255,31,255,31,255,7,255,240,0,252,156,253,156,
248,0,248,0,191,255,127,255,15,255,15,255,7,255,248,0,
252,33,252,32,248,0,248,0,127,255,255,255,7,255,7,255,
3,255,252,0,255,34,254,33,252,0,252,0,255,255,135,255,
3,255,123,255,1,255,252,0,255,187,255,199,254,0,254,0,
255,255,135,255,3,255,123,255,0,125,252,0,255,255,255,255,
255,130,255,130,191,255,135,255,3,255,59,255,0,3,248,0,
255,255,255,255,255,252,255,252,255,255,143,255,7,255,119,255,
0,3,240,0,255,255,255,254,255,252,255,253,255,255,159,255,
15,255,111,255,0,3,224,0,255,255,255,254,255,252,255,253,
255,255,127,255,31,255,159,255,0,1,192,0,255,255,255,255,
255,254,255,254,255,255,255,255,63,255,63,255,0,0,0,0,
255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,
0,0,0,0,255,255,255,255,255,255,255,255,255,255,255,255,
255,255,255,255,0,0,0,0,255,255,255,255,255,255,255,255,
255,255,255,255,255,255,255,255,0,0,0,0,255,255,255,255,
255,255,255,255,255,255,255,255,255,255,255,255,0,0,0,0,
255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,
1,240,0,0,255,255,255,255,254,15,254,15,255,255,255,255,
255,255,255,255,7,252,0,0,255,255,254,15,248,3,248,3,
255,255,255,255,255,255,255,255,31,254,0,0,248,11,248,7,
224,1,224,1,255,255,255,255,255,255,255,255,63,254,120,0,
224,7,224,3,192,1,192,1,255,255,255,255,135,255,135,255,
127,255,252,0,192,3,192,1,128,0,128,0,255,255,135,255,
3,255,123,255,255,255,252,0,128,57,128,57,0,0,0,0,
255,255,135,255,3,255,123,255,255,255,252,0,128,125,128,69,
0,0,0,56,255,255,135,255,3,255,123,255,255,255,252,0,
128,125,128,69,0,0,0,56,239,255,199,255,3,255,43,255,
255,255,252,0,135,253,135,197,0,0,0,56,255,255,167,255,
3,255,91,255,255,255,124,0,136,121,136,121,0,0,0,0,
255,255,223,255,131,255,163,255,127,255,124,0,201,83,201,81,
128,0,128,0,255,255,199,255,131,255,187,255,63,254,60,0,
231,143,231,139,192,1,192,1,255,255,231,255,195,255,219,255,
31,254,24,0,252,11,248,15,224,1,224,1,255,255,255,255,
231,255,231,255,7,252,0,0,255,31,254,15,248,3,248,3,
255,255,255,255,255,255,255,255,1,240,0,0,255,255,255,255,
254,15,254,15,255,255,255,255,255,255,255,255,0,0,0,0,
255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,
0,0,0,0,255,255,255,255,255,255,255,255,255,255,255,255,
255,255,255,255,0,0,0,0,255,255,255,255,255,255,255,255,
255,255,255,255,255,255,255,255,0,0,0,0,255,255,255,255,
255,255,255,255,255,255,255,255,255,255,255,255,0,0,0,0,
255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,255,
0,0,0,0,255,255,255,255,255,255,255,255,255,255,255,255,
255,255,255,255,0,0,0,0,255,255,255,255,255,255,255,255,
255,255,255,255,255,255,255,255,0,1,192,0,255,255,255,255,
255,254,255,254,255,255,255,255,63,255,63,255,0,3,224,0,
255,255,255,254,255,252,255,253,255,255,63,255,31,255,223,255,
0,7,240,0,255,255,255,252,255,248,255,251,255,255,31,255,
15,255,239,255,0,127,248,0,255,255,255,252,255,128,255,131,
255,255,15,255,7,255,247,255,1,255,252,0,255,247,255,142,
254,0,254,1,191,255,15,255,3,255,179,255,3,255,252,0,
255,133,254,3,252,0,252,0,255,255,247,255,3,255,11,255,
7,255,252,0,254,1,252,1,248,0,248,0,255,255,231,255,
3,255,27,255,7,255,184,0,252,28,252,28,248,0,248,0,
255,255,255,255,71,255,71,255,15,255,192,0,252,60,248,36,
240,0,240,24,255,255,127,255,63,255,63,255,15,255,192,0,
248,62,248,34,240,0,240,28,127,255,127,255,63,255,63,255,
15,255,192,0,248,62,248,34,240,0,240,28,127,255,127,255,
63,255,63,255,31,255,192,0,248,31,240,31,224,0,224,0,
127,255,127,255,63,255,63,255,31,255,192,0,248,41,240,40,
224,0,224,0,255,255,255,255,63,255,63,255,31,255,128,0,
248,68,240,68,224,0,224,0,255,255,255,255,127,255,127,255,
31,255,128,0,248,153,240,152,224,0,224,0,255,255,255,255,
127,255,127,255,31,255,0,0,248,145,240,145,224,0,224,0,
255,255,255,255,255,255,255,255,15,254,0,0,248,103,248,103,
240,1,240,1,255,255,255,255,255,255,255,255,7,248,0,0,
252,31,252,31,248,7,248,7,255,255,255,255,255,255,255,255,
3,224,0,0,255,255,255,255,252,31,252,31,255,255,255,255,
255,255,255,255,0,0,0,0,255,255,255,255,255,255,255,255,
255,255,255,255,255,255,255,255,};
