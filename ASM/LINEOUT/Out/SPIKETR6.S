; Vertices
	dc.w 216
	dc.w 108
	dc.w 206,189,1190
	dc.w -187,-176,1490
	dc.w 206,-175,1486
	dc.w 205,186,1480
	dc.w -189,187,1489
	dc.w -575,-8,1981
	dc.w 12,-619,1968
	dc.w 598,2,1972
	dc.w 9,566,1971
	dc.w -2,-3,2560
	dc.w 207,-170,1968
	dc.w -185,-171,1975
	dc.w -187,192,1974
	dc.w 207,197,1961
	dc.w 207,195,-773
	dc.w -1160,-185,-187
	dc.w -1160,191,-188
	dc.w -1160,-183,207
	dc.w -1556,-176,-188
	dc.w -1554,-175,206
	dc.w -1551,186,206
	dc.w -1556,187,-190
	dc.w -2024,-8,-584
	dc.w -2042,-577,17
	dc.w -2033,2,606
	dc.w -2043,606,14
	dc.w -2606,-3,13
	dc.w -2031,-170,208
	dc.w -2035,-171,-187
	dc.w -2035,192,-189
	dc.w -2027,197,207
	dc.w -1160,191,206
	dc.w -964,390,403
	dc.w 205,-176,-1565
	dc.w -175,-175,-1563
	dc.w -175,186,-1559
	dc.w 207,187,-1564
	dc.w 588,-8,-2052
	dc.w 9,-602,-2042
	dc.w -563,2,-2043
	dc.w 6,565,-2046
	dc.w 12,-3,-2603
	dc.w -177,-170,-2041
	dc.w 204,-171,-2046
	dc.w 206,192,-2045
	dc.w -176,197,-2038
	dc.w -964,390,-383
	dc.w -964,-386,-382
	dc.w 1490,-176,212
	dc.w 1486,-175,-182
	dc.w 1480,186,-182
	dc.w 1489,187,214
	dc.w 1975,-8,596
	dc.w 1973,-591,6
	dc.w 1965,2,-571
	dc.w 1973,591,8
	dc.w 2560,-3,9
	dc.w 1966,-170,-184
	dc.w 1973,-171,210
	dc.w 1972,192,212
	dc.w 1959,197,-184
	dc.w -964,-385,403
	dc.w -769,-192,207
	dc.w 206,-181,1190
	dc.w -186,-182,1190
	dc.w -187,190,1190
	dc.w -380,-383,993
	dc.w 402,-382,993
	dc.w 402,388,993
	dc.w -381,389,993
	dc.w 207,-189,797
	dc.w 207,193,797
	dc.w -185,193,797
	dc.w -184,-189,797
	dc.w -178,191,-1166
	dc.w -178,-183,-1166
	dc.w -769,195,207
	dc.w -769,-193,-185
	dc.w 207,197,208
	dc.w -183,197,208
	dc.w 207,-197,208
	dc.w -183,-197,208
	dc.w 207,197,-184
	dc.w -183,197,-184
	dc.w 207,-197,-184
	dc.w -183,-197,-184
	dc.w 996,-383,406
	dc.w 996,389,407
	dc.w 996,388,-380
	dc.w 996,-382,-380
	dc.w 800,-189,-184
	dc.w 800,193,-183
	dc.w 800,-189,209
	dc.w 800,193,210
	dc.w 1191,-182,211
	dc.w 1191,190,212
	dc.w 1191,-181,-183
	dc.w 1191,189,-183
	dc.w -769,195,-185
	dc.w 206,-185,-1166
	dc.w 207,191,-1166
	dc.w -375,-385,-970
	dc.w -375,390,-970
	dc.w 402,-386,-970
	dc.w 403,390,-970
	dc.w 207,-193,-773
	dc.w -181,-192,-773
	dc.w -181,195,-773

; Normal List
	dc.w 78,77,65
	dc.w -87,-86,-35
	dc.w 87,-86,-35
	dc.w 86,87,-35
	dc.w -87,87,-34
	dc.w -124,-2,29
	dc.w 1,-125,26
	dc.w 124,0,27
	dc.w 1,125,26
	dc.w 0,-1,127
	dc.w 70,-69,80
	dc.w -68,-71,80
	dc.w -69,70,80
	dc.w 69,71,80
	dc.w 78,78,64
	dc.w -65,-77,-77
	dc.w -65,77,-78
	dc.w -66,-77,77
	dc.w 34,-88,-85
	dc.w 34,-87,86
	dc.w 36,86,87
	dc.w 36,86,-87
	dc.w -27,-2,-124
	dc.w -28,-124,1
	dc.w -27,-1,125
	dc.w -26,125,1
	dc.w -127,-1,0
	dc.w -80,-70,70
	dc.w -81,-71,-68
	dc.w -81,68,-70
	dc.w -80,69,70
	dc.w -65,77,77
	dc.w 0,90,90
	dc.w 86,-87,34
	dc.w -87,-86,35
	dc.w -87,87,35
	dc.w 87,87,34
	dc.w 124,-3,-29
	dc.w -1,-125,-27
	dc.w -124,-1,-27
	dc.w -1,125,-27
	dc.w 0,-1,-127
	dc.w -70,-69,-80
	dc.w 68,-71,-81
	dc.w 69,70,-81
	dc.w -70,70,-80
	dc.w 0,90,-90
	dc.w 0,-90,-90
	dc.w -34,-87,86
	dc.w -35,-86,-87
	dc.w -36,86,-87
	dc.w -35,86,87
	dc.w 29,-2,124
	dc.w 27,-124,-2
	dc.w 27,-1,-125
	dc.w 26,125,-2
	dc.w 127,-1,-1
	dc.w 80,-69,-71
	dc.w 81,-71,68
	dc.w 81,69,69
	dc.w 79,70,-71
	dc.w -1,-90,90
	dc.w 64,-78,78
	dc.w 78,-77,65
	dc.w -77,-77,65
	dc.w -78,77,65
	dc.w -90,-90,0
	dc.w 90,-90,1
	dc.w 90,90,0
	dc.w -90,90,0
	dc.w 78,-78,-63
	dc.w 78,78,-64
	dc.w -78,78,-64
	dc.w -78,-78,-64
	dc.w -77,77,-65
	dc.w -77,-77,-66
	dc.w 64,78,78
	dc.w 64,-78,-77
	dc.w 38,115,38
	dc.w -38,115,38
	dc.w 38,-115,39
	dc.w -38,-115,38
	dc.w 38,115,-38
	dc.w -38,115,-38
	dc.w 39,-115,-38
	dc.w -38,-115,-38
	dc.w 0,-90,90
	dc.w 0,90,90
	dc.w 0,90,-90
	dc.w 0,-90,-90
	dc.w -64,-78,-78
	dc.w -64,78,-78
	dc.w -64,-78,78
	dc.w -64,78,77
	dc.w 65,-77,77
	dc.w 65,77,78
	dc.w 65,-77,-77
	dc.w 65,77,-77
	dc.w 64,78,-77
	dc.w 77,-77,-66
	dc.w 77,77,-65
	dc.w -90,-90,-1
	dc.w -90,90,0
	dc.w 90,-90,-1
	dc.w 90,90,0
	dc.w 78,-78,64
	dc.w -78,-78,63
	dc.w -78,78,64

	dc.w 0	;0 texture vertices

; Face List
	dc.w 146
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,63,2,1,64,171,110,109,172
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,7,2,3,115,110,111
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,64,1,4,65,172,109,112,173
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,8,13,3,116,121,111
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,83,79,78,82,191,187,186,190
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,3,13,7,111,121,115
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,73,81,80,70,181,189,188,178
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,65,4,3,0,173,112,111,108
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,71,68,67,70,179,176,175,178
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,80,81,85,84,188,189,193,192
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,73,66,69,72,181,174,177,180
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,4,1,5,112,109,113
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,68,0,63,67,176,108,171,175
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,11,5,1,119,113,109
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,0,3,2,63,108,111,110,171
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,72,69,68,71,180,177,176,179
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,69,65,0,68,177,173,108,176
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,12,8,4,120,116,112
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,72,79,81,73,180,187,189,181
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,2,10,6,110,118,114
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,66,64,65,69,174,172,173,177
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,8,3,4,116,111,112
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,71,78,79,72,179,186,187,180
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,4,5,12,112,113,120
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,67,63,64,66,175,171,172,174
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,2,7,10,110,115,118
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,70,67,66,73,178,175,174,181
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,70,80,78,71,178,188,186,179
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,1,2,6,109,110,114
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,1,6,11,109,114,119
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,13,10,7,121,118,115
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,13,12,9,121,120,117
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,9,12,11,117,120,119
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,12,13,8,120,121,116
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,10,13,9,118,121,117
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,5,11,12,113,119,120
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,6,10,11,114,118,119
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,11,10,9,119,118,117
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,100,36,35,74,208,144,143,182
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,77,85,81,62,185,193,189,170
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,29,25,21,137,133,129
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,107,102,101,106,215,210,209,214
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,98,46,32,76,206,154,140,184
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,101,75,99,103,209,183,207,211
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,21,18,22,129,126,130
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,102,74,75,101,210,182,183,209
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,16,21,20,31,124,129,128,139
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,105,84,85,106,213,192,193,214
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,106,85,83,107,214,193,191,215
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,76,32,61,62,184,140,169,170
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,74,35,34,75,182,143,142,183
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,61,17,15,47,169,125,123,155
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,77,47,46,98,185,155,154,206
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,106,101,103,105,214,209,211,213
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,19,27,23,127,135,131
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,15,18,21,16,123,126,129,124
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,75,34,33,99,183,142,141,207
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,25,20,21,133,128,129
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,47,15,16,46,155,123,124,154
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,20,30,24,128,138,132
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,62,61,47,77,170,169,155,185
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,24,19,20,132,127,128
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,21,22,29,129,130,137
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,98,83,85,77,206,191,193,185
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,14,104,102,107,122,212,210,215
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,104,100,74,102,212,208,182,210
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,32,31,17,61,140,139,125,169
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,62,81,79,76,170,189,187,184
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,17,19,18,15,125,127,126,123
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,76,79,83,98,184,187,191,206
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,31,20,19,17,139,128,127,125
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,46,16,31,32,154,124,139,140
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,28,22,18,136,130,126
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,19,24,27,127,132,135
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,25,30,20,133,138,128
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,107,83,82,14,215,191,190,122
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,18,23,28,126,131,136
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,18,19,23,126,127,131
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,26,29,28,134,137,136
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,22,28,29,130,136,137
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,29,30,25,137,138,133
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,27,30,26,135,138,134
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,30,27,24,138,135,132
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,30,29,26,138,137,134
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,23,27,28,131,135,136
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,28,27,26,136,135,134
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,105,103,104,14,213,211,212,122
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,99,33,36,100,207,141,144,208
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,14,82,84,105,122,190,192,213
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,36,33,37,144,141,145
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,35,45,39,143,153,147
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,34,42,38,142,150,146
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,44,40,36,152,148,144
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,36,37,44,144,145,152
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,43,37,33,151,145,141
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,40,45,35,148,153,143
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,40,35,36,148,143,144
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,39,34,35,147,142,143
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,34,39,42,142,147,150
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,103,99,100,104,211,207,208,212
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,33,38,43,141,146,151
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,33,34,38,141,142,146
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,45,44,41,153,152,149
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,45,42,39,153,150,147
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,42,45,41,150,153,149
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,37,43,44,145,151,152
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,44,45,40,152,153,148
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,41,44,43,149,152,151
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,38,42,43,146,150,151
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,43,42,41,151,150,149
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,92,86,87,93,200,194,195,201
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,96,49,48,94,204,157,156,202
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,50,60,54,158,168,162
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,92,80,84,90,200,188,192,198
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,90,84,82,91,198,192,190,199
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,59,55,51,167,163,159
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,93,87,88,91,201,195,196,199
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,55,60,50,163,168,158
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,58,52,48,166,160,156
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,94,86,89,96,202,194,197,204
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,49,57,53,157,165,161
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,97,88,87,95,205,196,195,203
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,49,54,57,157,162,165
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,54,49,50,162,157,158
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,94,48,51,95,202,156,159,203
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,51,48,52,159,156,160
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,93,78,80,92,201,186,188,200
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,95,51,50,97,203,159,158,205
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,91,82,78,93,199,190,186,201
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,90,89,86,92,198,197,194,200
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,55,50,51,163,158,159
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,91,88,89,90,199,196,197,198
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,51,52,59,159,160,167
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,97,50,49,96,205,158,157,204
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,95,87,86,94,203,195,194,202
	dc.w 3<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,96,89,88,97,204,197,196,205
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,48,53,58,156,161,166
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,48,49,53,156,157,161
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,56,59,58,164,167,166
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,60,59,56,168,167,164
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,59,60,55,167,168,163
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,52,58,59,160,166,167
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,60,57,54,168,165,162
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,57,60,56,165,168,164
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,58,57,56,166,165,164
	dc.w 2<<Primitive.TYPESHIFT|Polygon.ENVMAPPED|0,53,57,58,161,165,166
