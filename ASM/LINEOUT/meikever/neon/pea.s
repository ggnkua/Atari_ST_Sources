	dc.w	$0028,$FFF1 ;0.051006,-0.563991

	dc.w	$002C,$FFF1 ;0.068685,-0.563991

	dc.w	$0030,$FFF1 ;0.086364,-0.563991

	dc.w	$0033,$FFF3 ;0.099322,-0.559269

	dc.w	$0031,$FFF5 ;0.091416,-0.549496

	dc.w	$002D,$FFF5 ;0.073737,-0.549496

	dc.w	$0029,$FFF5 ;0.056058,-0.549496

	dc.w	$0028,$FFF2 ;0.051006,-0.562123

	dc.w	$0020,$FFEA ;0.015279,-0.597812

	dc.w	$0024,$FFEA ;0.032958,-0.597812

	dc.w	$0028,$FFEA ;0.050638,-0.597812

	dc.w	$002C,$FFEA ;0.068317,-0.597812

	dc.w	$0030,$FFEA ;0.085996,-0.597812

	dc.w	$0034,$FFEA ;0.102936,-0.595938

	dc.w	$0037,$FFED ;0.115846,-0.583861

	dc.w	$003A,$FFF0 ;0.128757,-0.571783

	dc.w	$003D,$FFF2 ;0.141668,-0.559705

	dc.w	$003F,$FFF6 ;0.150860,-0.546014

	dc.w	$003F,$FFFA ;0.150860,-0.528335

	dc.w	$003F,$FFFE ;0.150860,-0.510655

	dc.w	$003F,$0001 ;0.150860,-0.492976

	dc.w	$003F,$0005 ;0.150860,-0.475297

	dc.w	$003F,$0009 ;0.150860,-0.457617

	dc.w	$003D,$000C ;0.143891,-0.442890

	dc.w	$003A,$000F ;0.131193,-0.430589

	dc.w	$0037,$0012 ;0.118495,-0.418288

	dc.w	$0034,$0015 ;0.105797,-0.405986

	dc.w	$0033,$0014 ;0.099321,-0.408379

	dc.w	$0033,$0010 ;0.099318,-0.426059

	dc.w	$0033,$000C ;0.099315,-0.443738

	dc.w	$0033,$0008 ;0.099312,-0.461417

	dc.w	$0033,$0004 ;0.099309,-0.479096

	dc.w	$0033,$0000 ;0.099306,-0.496776

	dc.w	$0030,$0000 ;0.084420,-0.499569

	dc.w	$002B,$0000 ;0.066740,-0.499569

	dc.w	$0028,$0000 ;0.052616,-0.496013

	dc.w	$0028,$0004 ;0.052616,-0.478334

	dc.w	$0028,$0008 ;0.052616,-0.460655

	dc.w	$0028,$000C ;0.052616,-0.442975

	dc.w	$0028,$0010 ;0.052616,-0.425296

	dc.w	$0028,$0014 ;0.052616,-0.407617

	dc.w	$0026,$0016 ;0.042839,-0.399714

	dc.w	$0022,$0016 ;0.025160,-0.399714

	dc.w	$001E,$0016 ;0.007481,-0.399714

	dc.w	$001C,$0014 ;-0.000532,-0.409381

	dc.w	$001C,$0010 ;-0.000532,-0.427060

	dc.w	$001C,$000C ;-0.000532,-0.444739

	dc.w	$001C,$0008 ;-0.000532,-0.462419

	dc.w	$001C,$0004 ;-0.000532,-0.480098

	dc.w	$001C,$0000 ;-0.000532,-0.497777

	dc.w	$001C,$FFFD ;-0.000532,-0.515457

	dc.w	$001C,$FFF9 ;-0.000532,-0.533136

	dc.w	$001C,$FFF5 ;-0.000532,-0.550815

	dc.w	$001C,$FFF0 ;-0.000532,-0.568494

	dc.w	$001C,$FFEC ;-0.000532,-0.586174

	dc.w	$FFF0,$FFEA ;-0.194200,-0.597812

	dc.w	$FFF5,$FFEA ;-0.176520,-0.597812

	dc.w	$FFF9,$FFEA ;-0.158841,-0.597812

	dc.w	$FFFD,$FFEA ;-0.141162,-0.597812

	dc.w	$0000,$FFEA ;-0.123483,-0.597812

	dc.w	$0004,$FFEA ;-0.105803,-0.597812

	dc.w	$0008,$FFEA ;-0.088124,-0.597812

	dc.w	$000C,$FFEA ;-0.070445,-0.597812

	dc.w	$0010,$FFEA ;-0.052765,-0.597812

	dc.w	$000F,$FFEB ;-0.057735,-0.591689

	dc.w	$000B,$FFED ;-0.073006,-0.582781

	dc.w	$0008,$FFEF ;-0.088277,-0.573873

	dc.w	$0004,$FFF1 ;-0.103548,-0.564965

	dc.w	$0000,$FFF1 ;-0.120964,-0.563991

	dc.w	$FFFD,$FFF1 ;-0.138643,-0.563991

	dc.w	$FFFB,$FFF4 ;-0.149095,-0.554980

	dc.w	$FFFD,$FFF5 ;-0.138253,-0.549496

	dc.w	$0000,$FFF5 ;-0.120573,-0.549496

	dc.w	$0004,$FFF5 ;-0.102894,-0.549496

	dc.w	$0009,$FFF5 ;-0.085215,-0.549496

	dc.w	$000D,$FFF5 ;-0.067536,-0.549496

	dc.w	$0011,$FFF5 ;-0.050491,-0.548860

	dc.w	$0011,$FFF9 ;-0.050481,-0.531181

	dc.w	$000F,$FFFB ;-0.057479,-0.520506

	dc.w	$000B,$FFFB ;-0.075158,-0.520506

	dc.w	$0007,$FFFB ;-0.092838,-0.520506

	dc.w	$0003,$FFFB ;-0.110517,-0.520506

	dc.w	$0000,$FFFB ;-0.128196,-0.520506

	dc.w	$FFFC,$FFFB ;-0.145876,-0.520506

	dc.w	$FFFB,$FFFE ;-0.150155,-0.509010

	dc.w	$FFFD,$0000 ;-0.140576,-0.499568

	dc.w	$0000,$0000 ;-0.122897,-0.499568

	dc.w	$0004,$0000 ;-0.105218,-0.499568

	dc.w	$0008,$0000 ;-0.087538,-0.499568

	dc.w	$000C,$0000 ;-0.069859,-0.499569

	dc.w	$0010,$0000 ;-0.052180,-0.499569

	dc.w	$0011,$0003 ;-0.050459,-0.483610

	dc.w	$0011,$0007 ;-0.050459,-0.465930

	dc.w	$0011,$000B ;-0.050459,-0.448251

	dc.w	$0011,$000F ;-0.050459,-0.430572

	dc.w	$0011,$0013 ;-0.050459,-0.412893

	dc.w	$0010,$0016 ;-0.054960,-0.399714

	dc.w	$000B,$0016 ;-0.072640,-0.399714

	dc.w	$0007,$0016 ;-0.090319,-0.399714

	dc.w	$0003,$0016 ;-0.107998,-0.399714

	dc.w	$0000,$0016 ;-0.125678,-0.399714

	dc.w	$FFFC,$0016 ;-0.143357,-0.399714

	dc.w	$FFF8,$0016 ;-0.161036,-0.399714

	dc.w	$FFF4,$0016 ;-0.178715,-0.399714

	dc.w	$FFF0,$0016 ;-0.196395,-0.399714

	dc.w	$FFEF,$0013 ;-0.200241,-0.413548

	dc.w	$FFEF,$000F ;-0.200241,-0.431227

	dc.w	$FFEF,$000B ;-0.200241,-0.448906

	dc.w	$FFEF,$0007 ;-0.200241,-0.466586

	dc.w	$FFEF,$0003 ;-0.200241,-0.484265

	dc.w	$FFEF,$0000 ;-0.200241,-0.501944

	dc.w	$FFEF,$FFFC ;-0.200241,-0.519624

	dc.w	$FFEF,$FFF8 ;-0.200241,-0.537303

	dc.w	$FFEF,$FFF4 ;-0.200241,-0.554982

	dc.w	$FFEF,$FFF0 ;-0.200241,-0.572661

	dc.w	$FFEF,$FFEB ;-0.200241,-0.590341

	dc.w	$FFC4,$FFEA ;-0.389741,-0.597812

	dc.w	$FFC8,$FFEA ;-0.372062,-0.597812

	dc.w	$FFCC,$FFEA ;-0.354383,-0.597812

	dc.w	$FFD0,$FFEA ;-0.336703,-0.597812

	dc.w	$FFD4,$FFEA ;-0.319024,-0.597812

	dc.w	$FFD8,$FFEA ;-0.301345,-0.597812

	dc.w	$FFDC,$FFEA ;-0.283665,-0.597812

	dc.w	$FFE0,$FFEA ;-0.265986,-0.597812

	dc.w	$FFE3,$FFEB ;-0.251778,-0.594341

	dc.w	$FFE3,$FFEF ;-0.251778,-0.576661

	dc.w	$FFE3,$FFF3 ;-0.251778,-0.558982

	dc.w	$FFE2,$FFF6 ;-0.259163,-0.544014

	dc.w	$FFDF,$FFF9 ;-0.270601,-0.530533

	dc.w	$FFDC,$FFFC ;-0.282039,-0.517052

	dc.w	$FFDA,$FFFF ;-0.293477,-0.503572

	dc.w	$FFD6,$0000 ;-0.309303,-0.499569

	dc.w	$FFD2,$0000 ;-0.326982,-0.499569

	dc.w	$FFCE,$0000 ;-0.344662,-0.499569

	dc.w	$FFCD,$0003 ;-0.348411,-0.485639

	dc.w	$FFCD,$0007 ;-0.348411,-0.467960

	dc.w	$FFCD,$000B ;-0.348411,-0.450280

	dc.w	$FFCD,$000F ;-0.348411,-0.432601

	dc.w	$FFCD,$0013 ;-0.348411,-0.414922

	dc.w	$FFCC,$0016 ;-0.350883,-0.399714

	dc.w	$FFC8,$0016 ;-0.368563,-0.399714

	dc.w	$FFC4,$0016 ;-0.386242,-0.399714

	dc.w	$FFC1,$0015 ;-0.399949,-0.403686

	dc.w	$FFC1,$0011 ;-0.399949,-0.421366

	dc.w	$FFC1,$000D ;-0.399949,-0.439045

	dc.w	$FFC1,$0009 ;-0.399949,-0.456724

	dc.w	$FFC1,$0005 ;-0.399949,-0.474403

	dc.w	$FFC1,$0001 ;-0.399949,-0.492083

	dc.w	$FFC1,$FFFE ;-0.399949,-0.509762

	dc.w	$FFC1,$FFFA ;-0.399949,-0.527441

	dc.w	$FFC1,$FFF6 ;-0.399949,-0.545121

	dc.w	$FFC1,$FFF2 ;-0.399949,-0.562800

	dc.w	$FFC1,$FFEE ;-0.399949,-0.580479

	dc.w	$FFCD,$FFF5 ;-0.348411,-0.549842

	dc.w	$FFCE,$FFF1 ;-0.344881,-0.563991

	dc.w	$FFD2,$FFF1 ;-0.327201,-0.563991

	dc.w	$FFD6,$FFF1 ;-0.309522,-0.563991

	dc.w	$FFD8,$FFF3 ;-0.301006,-0.555789

	dc.w	$FFD5,$FFF5 ;-0.313053,-0.549496

	dc.w	$FFD1,$FFF5 ;-0.330732,-0.549496

