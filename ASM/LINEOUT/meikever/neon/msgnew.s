	dc.w	$FFC1,$FFEA ;-0.399510,-0.399510

	dc.w	$FFC5,$FFEA ;-0.379359,-0.399510

	dc.w	$FFCA,$FFEA ;-0.359209,-0.399510

	dc.w	$FFCE,$FFEA ;-0.339058,-0.399510

	dc.w	$FFD3,$FFEA ;-0.318907,-0.399510

	dc.w	$FFD8,$FFEA ;-0.298757,-0.399510

	dc.w	$FFDC,$FFEA ;-0.278606,-0.399510

	dc.w	$FFE1,$FFEA ;-0.258456,-0.399510

	dc.w	$FFE3,$FFEC ;-0.247549,-0.390266

	dc.w	$FFE3,$FFF1 ;-0.247549,-0.370115

	dc.w	$FFE3,$FFF5 ;-0.247549,-0.349965

	dc.w	$FFE3,$FFFA ;-0.247549,-0.329814

	dc.w	$FFE3,$FFFF ;-0.247549,-0.309663

	dc.w	$FFE3,$0002 ;-0.247549,-0.289513

	dc.w	$FFE3,$0007 ;-0.247549,-0.269362

	dc.w	$FFE3,$000B ;-0.248107,-0.249442

	dc.w	$FFE0,$000F ;-0.262355,-0.235194

	dc.w	$FFDD,$0012 ;-0.276604,-0.220945

	dc.w	$FFDA,$0015 ;-0.290852,-0.206697

	dc.w	$FFD8,$0014 ;-0.296569,-0.213047

	dc.w	$FFD8,$000F ;-0.296569,-0.233198

	dc.w	$FFD8,$000B ;-0.296569,-0.253348

	dc.w	$FFD8,$0006 ;-0.296569,-0.273499

	dc.w	$FFD8,$0001 ;-0.296569,-0.293649

	dc.w	$FFD5,$0000 ;-0.311349,-0.299020

	dc.w	$FFD1,$0001 ;-0.325980,-0.293500

	dc.w	$FFD1,$0006 ;-0.325980,-0.273350

	dc.w	$FFD1,$000B ;-0.325980,-0.253199

	dc.w	$FFD1,$000F ;-0.325980,-0.233048

	dc.w	$FFD1,$0014 ;-0.325980,-0.212898

	dc.w	$FFD0,$0017 ;-0.334214,-0.200980

	dc.w	$FFCB,$0016 ;-0.352941,-0.202403

	dc.w	$FFCB,$0012 ;-0.352941,-0.222554

	dc.w	$FFCB,$000D ;-0.352941,-0.242705

	dc.w	$FFCB,$0008 ;-0.352941,-0.262855

	dc.w	$FFCB,$0004 ;-0.352941,-0.283006

	dc.w	$FFCA,$0000 ;-0.357078,-0.299020

	dc.w	$FFC7,$0001 ;-0.372549,-0.294340

	dc.w	$FFC7,$0006 ;-0.372549,-0.274190

	dc.w	$FFC7,$000A ;-0.372549,-0.254039

	dc.w	$FFC7,$000F ;-0.372549,-0.233888

	dc.w	$FFC7,$0014 ;-0.372549,-0.213738

	dc.w	$FFC5,$0017 ;-0.379942,-0.200980

	dc.w	$FFC1,$0016 ;-0.399510,-0.201563

	dc.w	$FFC1,$0012 ;-0.399510,-0.221714

	dc.w	$FFC1,$000D ;-0.399510,-0.241865

	dc.w	$FFC1,$0009 ;-0.399510,-0.262015

	dc.w	$FFC1,$0004 ;-0.399510,-0.282166

	dc.w	$FFC1,$0000 ;-0.399510,-0.302316

	dc.w	$FFC1,$FFFC ;-0.399510,-0.322467

	dc.w	$FFC1,$FFF7 ;-0.399510,-0.342618

	dc.w	$FFC1,$FFF2 ;-0.399510,-0.362768

	dc.w	$FFC1,$FFEE ;-0.399510,-0.382919

	dc.w	$FFEE,$FFEA ;-0.200980,-0.398401

	dc.w	$FFEE,$FFEF ;-0.200980,-0.378251

	dc.w	$FFEE,$FFF3 ;-0.200980,-0.358100

	dc.w	$FFEE,$FFF8 ;-0.200980,-0.337949

	dc.w	$FFEF,$FFFC ;-0.197701,-0.321078

	dc.w	$FFF4,$FFFC ;-0.177550,-0.321078

	dc.w	$FFF8,$FFFC ;-0.157400,-0.321078

	dc.w	$FFFA,$FFFF ;-0.149510,-0.308818

	dc.w	$FFF8,$0000 ;-0.159863,-0.299020

	dc.w	$FFF3,$0000 ;-0.180013,-0.299020

	dc.w	$FFEE,$0000 ;-0.200164,-0.299020

	dc.w	$FFEE,$0005 ;-0.200980,-0.279686

	dc.w	$FFEE,$0009 ;-0.200980,-0.259535

	dc.w	$FFEE,$000E ;-0.200980,-0.239385

	dc.w	$FFEE,$0012 ;-0.200980,-0.219234

	dc.w	$FFEF,$0017 ;-0.199083,-0.200980

	dc.w	$FFF3,$0017 ;-0.178933,-0.200980

	dc.w	$FFF8,$0017 ;-0.158782,-0.200980

	dc.w	$FFFD,$0017 ;-0.138632,-0.200980

	dc.w	$0000,$0017 ;-0.118481,-0.200980

	dc.w	$0005,$0017 ;-0.098330,-0.200980

	dc.w	$0009,$0017 ;-0.078180,-0.200980

	dc.w	$000E,$0017 ;-0.058029,-0.200980

	dc.w	$0011,$0015 ;-0.046569,-0.209671

	dc.w	$0011,$0010 ;-0.046569,-0.229821

	dc.w	$0011,$000B ;-0.046569,-0.249972

	dc.w	$0011,$0007 ;-0.046569,-0.270122

	dc.w	$0011,$0002 ;-0.046569,-0.290273

	dc.w	$0011,$FFFE ;-0.046569,-0.310424

	dc.w	$0011,$FFFA ;-0.046569,-0.330574

	dc.w	$0011,$FFF5 ;-0.046569,-0.350725

	dc.w	$000D,$FFF4 ;-0.062052,-0.355392

	dc.w	$0008,$FFF4 ;-0.082202,-0.355392

	dc.w	$0004,$FFF4 ;-0.102353,-0.355392

	dc.w	$0000,$FFF4 ;-0.122504,-0.355392

	dc.w	$FFFC,$FFF4 ;-0.142654,-0.355392

	dc.w	$FFF9,$FFF2 ;-0.151961,-0.366236

	dc.w	$FFFC,$FFEF ;-0.143025,-0.377451

	dc.w	$0000,$FFEF ;-0.122875,-0.377451

	dc.w	$0004,$FFEF ;-0.102724,-0.377451

	dc.w	$0008,$FFED ;-0.084205,-0.385073

	dc.w	$000C,$FFEB ;-0.065820,-0.393322

	dc.w	$0010,$FFE9 ;-0.047436,-0.401572

	dc.w	$000C,$FFE9 ;-0.065769,-0.401961

	dc.w	$0008,$FFE9 ;-0.085919,-0.401961

	dc.w	$0003,$FFE9 ;-0.106070,-0.401961

	dc.w	$FFFF,$FFE9 ;-0.126220,-0.401961

	dc.w	$FFFB,$FFE9 ;-0.146371,-0.401961

	dc.w	$FFF6,$FFE9 ;-0.166522,-0.401961

	dc.w	$FFF1,$FFE9 ;-0.186672,-0.401961

	dc.w	$001D,$FFE9 ;0.008293,-0.401961

	dc.w	$0022,$FFE9 ;0.028444,-0.401961

	dc.w	$0027,$FFE9 ;0.048595,-0.401961

	dc.w	$002B,$FFE9 ;0.068745,-0.401961

	dc.w	$0030,$FFE9 ;0.088896,-0.401961

	dc.w	$0034,$FFE9 ;0.109046,-0.401961

	dc.w	$0039,$FFE9 ;0.129197,-0.401961

	dc.w	$003E,$FFE9 ;0.149348,-0.401961

	dc.w	$003D,$FFEB ;0.145199,-0.397101

	dc.w	$0039,$FFEC ;0.126599,-0.389351

	dc.w	$0034,$FFEE ;0.107998,-0.381600

	dc.w	$0030,$FFEF ;0.088677,-0.377451

	dc.w	$002B,$FFEF ;0.068527,-0.377451

	dc.w	$0027,$FFEF ;0.048376,-0.377451

	dc.w	$0022,$FFEF ;0.029412,-0.376265

	dc.w	$0022,$FFF4 ;0.029412,-0.356114

	dc.w	$0022,$FFF9 ;0.029412,-0.335964

	dc.w	$0022,$FFFD ;0.029412,-0.315813

	dc.w	$0023,$0000 ;0.032769,-0.299020

	dc.w	$0028,$0000 ;0.052920,-0.299020

	dc.w	$002C,$0000 ;0.073070,-0.299020

	dc.w	$0031,$0000 ;0.093221,-0.299020

	dc.w	$0032,$FFFE ;0.098039,-0.314352

	dc.w	$002F,$FFFB ;0.087066,-0.323529

	dc.w	$002B,$FFFB ;0.066916,-0.323529

	dc.w	$0027,$FFFB ;0.049020,-0.325784

	dc.w	$0027,$FFF6 ;0.049020,-0.345935

	dc.w	$0029,$FFF4 ;0.059713,-0.355392

	dc.w	$002E,$FFF4 ;0.079863,-0.355392

	dc.w	$0032,$FFF4 ;0.100014,-0.355392

	dc.w	$0037,$FFF4 ;0.120165,-0.355392

	dc.w	$003C,$FFF4 ;0.140315,-0.355392

	dc.w	$003F,$FFF5 ;0.154412,-0.349338

	dc.w	$003F,$FFFA ;0.154412,-0.329188

	dc.w	$003F,$FFFF ;0.154412,-0.309037

	dc.w	$003F,$0002 ;0.154412,-0.288886

	dc.w	$003F,$0007 ;0.154412,-0.268736

	dc.w	$003F,$000C ;0.154412,-0.248585

	dc.w	$003F,$0010 ;0.154412,-0.228435

	dc.w	$003F,$0015 ;0.154412,-0.208284

	dc.w	$003C,$0017 ;0.141565,-0.200980

	dc.w	$0037,$0017 ;0.121414,-0.200980

	dc.w	$0033,$0017 ;0.101263,-0.200980

	dc.w	$002E,$0017 ;0.081113,-0.200980

	dc.w	$0029,$0017 ;0.060962,-0.200980

	dc.w	$0025,$0017 ;0.040812,-0.200980

	dc.w	$0020,$0017 ;0.020661,-0.200980

	dc.w	$001C,$0017 ;0.000511,-0.200980

	dc.w	$001B,$0012 ;0.000239,-0.220619

	dc.w	$001C,$000D ;0.000485,-0.240768

	dc.w	$001C,$0009 ;0.000731,-0.260917

	dc.w	$001C,$0004 ;0.000977,-0.281066

	dc.w	$001C,$0000 ;0.001222,-0.301215

	dc.w	$001C,$FFFC ;0.001468,-0.321364

	dc.w	$001C,$FFF7 ;0.001714,-0.341514

	dc.w	$001C,$FFF3 ;0.001960,-0.361663

	dc.w	$001C,$FFEE ;0.002205,-0.381812

