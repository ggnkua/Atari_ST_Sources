	dc.w	$FFE4,$FFF1 ;0.051006,-0.563991

	dc.w	$FFEA,$FFF1 ;0.076000,-0.563991

	dc.w	$FFEF,$FFF2 ;0.099322,-0.562318

	dc.w	$FFED,$FFF5 ;0.087150,-0.549496

	dc.w	$FFE7,$FFF5 ;0.062156,-0.549496

	dc.w	$FFE4,$FFF2 ;0.051006,-0.563340

	dc.w	$FFDE,$FFEA ;0.023811,-0.597812

	dc.w	$FFE4,$FFEA ;0.048806,-0.597812

	dc.w	$FFEA,$FFEA ;0.073800,-0.597812

	dc.w	$FFEF,$FFEA ;0.098794,-0.597812

	dc.w	$FFF4,$FFED ;0.117624,-0.582198

	dc.w	$FFF8,$FFF1 ;0.135877,-0.565123

	dc.w	$FFFB,$FFF5 ;0.150860,-0.546629

	dc.w	$FFFB,$FFFB ;0.150860,-0.521635

	dc.w	$FFFB,$0000 ;0.150860,-0.496640

	dc.w	$FFFB,$0006 ;0.150860,-0.471646

	dc.w	$FFFB,$000B ;0.148681,-0.447594

	dc.w	$FFF7,$000F ;0.130466,-0.430478

	dc.w	$FFF2,$0013 ;0.112252,-0.413362

	dc.w	$FFEF,$0015 ;0.097727,-0.404778

	dc.w	$FFEF,$000F ;0.097723,-0.429772

	dc.w	$FFEF,$000A ;0.097719,-0.454767

	dc.w	$FFEF,$0004 ;0.097715,-0.479761

	dc.w	$FFEE,$0000 ;0.092524,-0.499569

	dc.w	$FFE8,$0000 ;0.067530,-0.499569

	dc.w	$FFE5,$0002 ;0.052616,-0.489488

	dc.w	$FFE5,$0007 ;0.052616,-0.464494

	dc.w	$FFE5,$000D ;0.052616,-0.439499

	dc.w	$FFE5,$0013 ;0.052616,-0.414505

	dc.w	$FFE2,$0016 ;0.042412,-0.399714

	dc.w	$FFDD,$0016 ;0.017418,-0.399714

	dc.w	$FFD8,$0015 ;-0.000532,-0.406759

	dc.w	$FFD8,$000F ;-0.000532,-0.431753

	dc.w	$FFD8,$0009 ;-0.000532,-0.456748

	dc.w	$FFD8,$0003 ;-0.000532,-0.481742

	dc.w	$FFD8,$FFFF ;-0.000532,-0.506736

	dc.w	$FFD8,$FFF9 ;-0.000532,-0.531731

	dc.w	$FFD8,$FFF3 ;-0.000532,-0.556725

	dc.w	$FFD8,$FFED ;-0.000532,-0.581720

	dc.w	$FFAD,$FFEA ;-0.191339,-0.597812

	dc.w	$FFB2,$FFEA ;-0.166344,-0.597812

	dc.w	$FFB8,$FFEA ;-0.141350,-0.597812

	dc.w	$FFBE,$FFEA ;-0.116356,-0.597812

	dc.w	$FFC4,$FFEA ;-0.091361,-0.597812

	dc.w	$FFC9,$FFEA ;-0.066367,-0.597812

	dc.w	$FFCD,$FFEA ;-0.052305,-0.594857

	dc.w	$FFC8,$FFED ;-0.073894,-0.582263

	dc.w	$FFC3,$FFF0 ;-0.095484,-0.569669

	dc.w	$FFBD,$FFF1 ;-0.118944,-0.563991

	dc.w	$FFB7,$FFF1 ;-0.143938,-0.563991

	dc.w	$FFB8,$FFF5 ;-0.143322,-0.549496

	dc.w	$FFBD,$FFF5 ;-0.118328,-0.549496

	dc.w	$FFC3,$FFF5 ;-0.093333,-0.549496

	dc.w	$FFC9,$FFF5 ;-0.068339,-0.549496

	dc.w	$FFCD,$FFF6 ;-0.050487,-0.542349

	dc.w	$FFCC,$FFFB ;-0.053627,-0.520506

	dc.w	$FFC7,$FFFB ;-0.078621,-0.520506

	dc.w	$FFC1,$FFFB ;-0.103615,-0.520506

	dc.w	$FFBB,$FFFB ;-0.128610,-0.520506

	dc.w	$FFB6,$FFFC ;-0.151669,-0.518845

	dc.w	$FFB8,$0000 ;-0.143212,-0.499568

	dc.w	$FFBD,$0000 ;-0.118217,-0.499568

	dc.w	$FFC3,$0000 ;-0.093223,-0.499568

	dc.w	$FFC9,$0000 ;-0.068229,-0.499569

	dc.w	$FFCD,$0001 ;-0.050459,-0.492343

	dc.w	$FFCD,$0007 ;-0.050459,-0.467349

	dc.w	$FFCD,$000C ;-0.050459,-0.442355

	dc.w	$FFCD,$0012 ;-0.050459,-0.417360

	dc.w	$FFCB,$0016 ;-0.057808,-0.399714

	dc.w	$FFC6,$0016 ;-0.082802,-0.399714

	dc.w	$FFC0,$0016 ;-0.107796,-0.399714

	dc.w	$FFBA,$0016 ;-0.132791,-0.399714

	dc.w	$FFB4,$0016 ;-0.157785,-0.399714

	dc.w	$FFAF,$0016 ;-0.182780,-0.399714

	dc.w	$FFAB,$0015 ;-0.200241,-0.407248

	dc.w	$FFAB,$000F ;-0.200241,-0.432242

	dc.w	$FFAB,$0009 ;-0.200241,-0.457236

	dc.w	$FFAB,$0003 ;-0.200241,-0.482231

	dc.w	$FFAB,$FFFF ;-0.200241,-0.507225

	dc.w	$FFAB,$FFF9 ;-0.200241,-0.532220

	dc.w	$FFAB,$FFF3 ;-0.200241,-0.557214

	dc.w	$FFAB,$FFED ;-0.200241,-0.582208

	dc.w	$0036,$FFEA ;0.408343,-0.598144

	dc.w	$003B,$FFEA ;0.433337,-0.598144

	dc.w	$0040,$FFEB ;0.454441,-0.591851

	dc.w	$0043,$FFF0 ;0.465612,-0.569492

	dc.w	$0045,$FFF4 ;0.476429,-0.553341

	dc.w	$0047,$FFEF ;0.484978,-0.576828

	dc.w	$0049,$FFEA ;0.495047,-0.598144

	dc.w	$004F,$FFEA ;0.520041,-0.598144

	dc.w	$0055,$FFEA ;0.545035,-0.598144

	dc.w	$0053,$FFEE ;0.537986,-0.577354

	dc.w	$0051,$FFF4 ;0.527800,-0.554529

	dc.w	$004F,$FFF9 ;0.517614,-0.531704

	dc.w	$004E,$FFFE ;0.515690,-0.508313

	dc.w	$0050,$0003 ;0.522665,-0.484311

	dc.w	$0051,$0008 ;0.529640,-0.460310

	dc.w	$0053,$000E ;0.536615,-0.436308

	dc.w	$0055,$0013 ;0.543590,-0.412307

	dc.w	$0053,$0016 ;0.535430,-0.399669

	dc.w	$004D,$0016 ;0.510436,-0.399669

	dc.w	$0049,$0014 ;0.494332,-0.410993

	dc.w	$0048,$000E ;0.488399,-0.435273

	dc.w	$0047,$0008 ;0.482466,-0.459553

	dc.w	$0045,$0003 ;0.476533,-0.483833

	dc.w	$0044,$0002 ;0.470170,-0.487564

	dc.w	$0042,$0008 ;0.463227,-0.463553

	dc.w	$0041,$000D ;0.456284,-0.439542

	dc.w	$003F,$0013 ;0.449341,-0.415531

	dc.w	$003C,$0016 ;0.436272,-0.399669

	dc.w	$0036,$0016 ;0.411278,-0.399669

	dc.w	$0034,$0014 ;0.403082,-0.411645

	dc.w	$0036,$000E ;0.411229,-0.435274

	dc.w	$0038,$0009 ;0.419377,-0.458903

	dc.w	$003A,$0003 ;0.427524,-0.482533

	dc.w	$003C,$FFFF ;0.435672,-0.506162

	dc.w	$003C,$FFF9 ;0.435473,-0.529144

	dc.w	$0039,$FFF4 ;0.423780,-0.551235

	dc.w	$0036,$FFEF ;0.412088,-0.573326

	dc.w	$0034,$FFEA ;0.400396,-0.595416

	dc.w	$0016,$FFF1 ;0.269430,-0.563989

	dc.w	$001B,$FFF1 ;0.294425,-0.563989

	dc.w	$001B,$FFF4 ;0.291125,-0.550953

	dc.w	$0015,$FFF4 ;0.266131,-0.550953

	dc.w	$0011,$FFF3 ;0.248289,-0.559402

	dc.w	$0005,$FFEE ;0.199477,-0.577847

	dc.w	$0005,$FFF4 ;0.199477,-0.552853

	dc.w	$0005,$FFFA ;0.199477,-0.527858

	dc.w	$0005,$0000 ;0.199477,-0.502864

	dc.w	$0005,$0004 ;0.199477,-0.477870

	dc.w	$0005,$000A ;0.199477,-0.452875

	dc.w	$0005,$0010 ;0.199477,-0.427881

	dc.w	$0005,$0016 ;0.199477,-0.402886

	dc.w	$000A,$0016 ;0.220704,-0.399119

	dc.w	$0010,$0016 ;0.245698,-0.399119

	dc.w	$0011,$0012 ;0.251409,-0.418402

	dc.w	$0011,$000C ;0.251409,-0.443396

	dc.w	$0011,$0006 ;0.251409,-0.468391

	dc.w	$0011,$0001 ;0.251409,-0.493385

	dc.w	$0013,$0003 ;0.259396,-0.485178

	dc.w	$0016,$0008 ;0.270762,-0.462918

	dc.w	$0018,$000D ;0.282129,-0.440658

	dc.w	$001B,$0012 ;0.293496,-0.418398

	dc.w	$001E,$0016 ;0.306688,-0.399119

	dc.w	$0024,$0016 ;0.331682,-0.399119

	dc.w	$0028,$0015 ;0.348557,-0.404329

	dc.w	$0025,$0010 ;0.338143,-0.427051

	dc.w	$0023,$000B ;0.327729,-0.449772

	dc.w	$0021,$0006 ;0.317315,-0.472494

	dc.w	$001E,$0000 ;0.306901,-0.495215

	dc.w	$0020,$FFFD ;0.314973,-0.514614

	dc.w	$0024,$FFF9 ;0.332647,-0.532288

	dc.w	$0028,$FFF5 ;0.350321,-0.549962

	dc.w	$0028,$FFEF ;0.350945,-0.574697

	dc.w	$0028,$FFEA ;0.349444,-0.598191

	dc.w	$0022,$FFEA ;0.324449,-0.598191

	dc.w	$001C,$FFEA ;0.299455,-0.598191

	dc.w	$0017,$FFEA ;0.274460,-0.598191

	dc.w	$0011,$FFEA ;0.249466,-0.598191

	dc.w	$000B,$FFEA ;0.224472,-0.598191

