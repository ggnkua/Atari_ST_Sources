	dc.w	-1947
	dc.w	-1884
	dc.w	-1822
	dc.w	-1759
	dc.w	-1696
	dc.w	-1633
	dc.w	-1570
	dc.w	-1507
	dc.w	-1445
	dc.w	-1382
	dc.w	-1319
	dc.w	-1256
	dc.w	-1193
	dc.w	-1130
	dc.w	-1068
	dc.w	-1005
	dc.w	-942
	dc.w	-879
	dc.w	-816
	dc.w	-753
	dc.w	-691
	dc.w	-628
	dc.w	-565
	dc.w	-502
	dc.w	-439
	dc.w	-376
	dc.w	-314
	dc.w	-251
	dc.w	-188
	dc.w	-125
	dc.w	-62
	dc.w	0
	dc.w	119
	dc.w	227
	dc.w	318
	dc.w	386
	dc.w	429
	dc.w	445
	dc.w	434
	dc.w	398
	dc.w	339
	dc.w	263
	dc.w	173
	dc.w	77
	dc.w	-19
	dc.w	-111
	dc.w	-193
	dc.w	-261
	dc.w	-310
	dc.w	-340
	dc.w	-348
	dc.w	-335
	dc.w	-303
	dc.w	-254
	dc.w	-192
	dc.w	-121
	dc.w	-45
	dc.w	29
	dc.w	100
	dc.w	163
	dc.w	213
	dc.w	249
	dc.w	268
	dc.w	271
	dc.w	258
	dc.w	230
	dc.w	190
	dc.w	139
	dc.w	83
	dc.w	23
	dc.w	-34
	dc.w	-89
	dc.w	-136
	dc.w	-173
	dc.w	-199
	dc.w	-211
	dc.w	-211
	dc.w	-198
	dc.w	-174
	dc.w	-141
	dc.w	-100
	dc.w	-55
	dc.w	-9
	dc.w	36
	dc.w	77
	dc.w	113
	dc.w	140
	dc.w	158
	dc.w	166
	dc.w	164
	dc.w	152
	dc.w	132
	dc.w	104
	dc.w	72
	dc.w	36
	dc.w	0
	dc.w	-35
	dc.w	-66
	dc.w	-93
	dc.w	-113
	dc.w	-125
	dc.w	-130
	dc.w	-127
	dc.w	-116
	dc.w	-99
	dc.w	-77
	dc.w	-50
	dc.w	-22
	dc.w	5
	dc.w	32
	dc.w	56
	dc.w	76
	dc.w	91
	dc.w	99
	dc.w	102
	dc.w	98
	dc.w	88
	dc.w	74
	dc.w	56
	dc.w	35
	dc.w	13
	dc.w	-8
	dc.w	-29
	dc.w	-47
	dc.w	-62
	dc.w	-72
	dc.w	-78
	dc.w	-79
	dc.w	-75
	dc.w	-67
	dc.w	-55
	dc.w	-40
	dc.w	-24
	dc.w	-6
	dc.w	10
	dc.w	26
	dc.w	39
	dc.w	50
	dc.w	58
	dc.w	62
	dc.w	61
	dc.w	58
	dc.w	51
	dc.w	41
	dc.w	29
	dc.w	16
	dc.w	2
	dc.w	-10
	dc.w	-22
	dc.w	-33
	dc.w	-41
	dc.w	-46
	dc.w	-48
	dc.w	-48
	dc.w	-44
	dc.w	-38
	dc.w	-30
	dc.w	-21
	dc.w	-10
	dc.w	0
	dc.w	10
	dc.w	19
	dc.w	27
	dc.w	33
	dc.w	36
	dc.w	38
	dc.w	37
	dc.w	34
	dc.w	29
	dc.w	22
	dc.w	14
	dc.w	6
	dc.w	-1
	dc.w	-9
	dc.w	-16
	dc.w	-22
	dc.w	-26
	dc.w	-29
	dc.w	-29
	dc.w	-28
	dc.w	-26
	dc.w	-21
	dc.w	-16
	dc.w	-10
	dc.w	-3
	dc.w	2
	dc.w	8
	dc.w	13
	dc.w	18
	dc.w	21
	dc.w	23
	dc.w	23
	dc.w	22
	dc.w	19
	dc.w	16
	dc.w	12
	dc.w	7
	dc.w	2
	dc.w	-2
	dc.w	-7
	dc.w	-11
	dc.w	-14
	dc.w	-17
	dc.w	-18
	dc.w	-18
	dc.w	-17
	dc.w	-15
	dc.w	-12
	dc.w	-8
	dc.w	-4
	dc.w	0
	dc.w	3
	dc.w	6
	dc.w	9
	dc.w	12
	dc.w	13
	dc.w	14
	dc.w	14
	dc.w	13
	dc.w	11
	dc.w	8
	dc.w	6
	dc.w	3
	dc.w	0
	dc.w	-3
	dc.w	-5
	dc.w	-8
	dc.w	-9
	dc.w	-10
	dc.w	-11
	dc.w	-10
	dc.w	-10
	dc.w	-8
	dc.w	-6
	dc.w	-4
	dc.w	-1
	dc.w	0
	dc.w	2
	dc.w	4
	dc.w	6
	dc.w	7
	dc.w	8
	dc.w	8
	dc.w	8
	dc.w	7
	dc.w	6
	dc.w	4
	dc.w	3
	dc.w	1
	dc.w	0
	dc.w	-2
	dc.w	-4
	dc.w	-5
	dc.w	-6
	dc.w	-6
	dc.w	-6
	dc.w	-6
	dc.w	-5
	dc.w	-4
	dc.w	-3
	dc.w	-2
	dc.w	0
	dc.w	0
	dc.w	2
	dc.w	3
	dc.w	4
	dc.w	5
	dc.w	5
	dc.w	5
	dc.w	5
	dc.w	4
	dc.w	3
	dc.w	2
	dc.w	1
	dc.w	0
	dc.w	0
	dc.w	-1
	dc.w	-2
	dc.w	-3
	dc.w	-3
	dc.w	-4
	dc.w	-4
	dc.w	-3
	dc.w	-3
	dc.w	-2
	dc.w	-1
	dc.w	0
