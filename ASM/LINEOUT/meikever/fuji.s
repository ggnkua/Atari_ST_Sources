	dc.w	$FFE0,$FFDA,0 ;-0.126471,-0.150000
	dc.w	$FFE3,$FFDA,0 ;-0.114143,-0.150000
	dc.w	$FFE6,$FFDA,0 ;-0.101815,-0.150000
	dc.w	$FFEA,$FFDA,0 ;-0.089487,-0.150000
	dc.w	$FFED,$FFDA,0 ;-0.077159,-0.150000
	dc.w	$FFEE,$FFDC,0 ;-0.070588,-0.144243
	dc.w	$FFEE,$FFDF,0 ;-0.070588,-0.131915
	dc.w	$FFEE,$FFE2,0 ;-0.070588,-0.119587
	dc.w	$FFEE,$FFE5,0 ;-0.070588,-0.107259
	dc.w	$FFEE,$FFE8,0 ;-0.070588,-0.094931
	dc.w	$FFEE,$FFEB,0 ;-0.070588,-0.082604
	dc.w	$FFEE,$FFEE,0 ;-0.071564,-0.070315
	dc.w	$FFEE,$FFF2,0 ;-0.072561,-0.058028
	dc.w	$FFEE,$FFF5,0 ;-0.073557,-0.045740
	dc.w	$FFED,$FFF8,0 ;-0.074553,-0.033452
	dc.w	$FFED,$FFFB,0 ;-0.075549,-0.021165
	dc.w	$FFED,$FFFE,0 ;-0.076546,-0.008877
	dc.w	$FFED,$0000,0 ;-0.077542,0.003410
	dc.w	$FFEC,$0004,0 ;-0.078538,0.015698
	dc.w	$FFEC,$0007,0 ;-0.080457,0.027574
	dc.w	$FFEA,$0009,0 ;-0.088935,0.036523
	dc.w	$FFE8,$000B,0 ;-0.097414,0.045473
	dc.w	$FFE5,$000D,0 ;-0.105892,0.054422
	dc.w	$FFE3,$0010,0 ;-0.114371,0.063372
	dc.w	$FFE1,$0012,0 ;-0.122849,0.072321
	dc.w	$FFDF,$0014,0 ;-0.131328,0.081271
	dc.w	$FFDC,$0016,0 ;-0.142528,0.086084
	dc.w	$FFD9,$0017,0 ;-0.154102,0.090328
	dc.w	$FFD6,$0018,0 ;-0.165676,0.094571
	dc.w	$FFD3,$0019,0 ;-0.177251,0.098815
	dc.w	$FFD0,$001A,0 ;-0.188825,0.103059
	dc.w	$FFCD,$001B,0 ;-0.200399,0.107303
	dc.w	$FFCA,$001C,0 ;-0.211974,0.111547
	dc.w	$FFC7,$001D,0 ;-0.223741,0.114706
	dc.w	$FFC4,$001D,0 ;-0.236069,0.114706
	dc.w	$FFC1,$001D,0 ;-0.248397,0.114706
	dc.w	$FFBE,$001D,0 ;-0.260725,0.114706
	dc.w	$FFBB,$001D,0 ;-0.273052,0.114706
	dc.w	$FFB7,$001D,0 ;-0.285380,0.114706
	dc.w	$FFB4,$001D,0 ;-0.297708,0.114706
	dc.w	$FFB3,$001B,0 ;-0.302941,0.107611
	dc.w	$FFB3,$0018,0 ;-0.302941,0.095283
	dc.w	$FFB3,$0015,0 ;-0.302941,0.082955
	dc.w	$FFB3,$0012,0 ;-0.302941,0.070627
	dc.w	$FFB6,$0012,0 ;-0.290652,0.070588
	dc.w	$FFB9,$0012,0 ;-0.278324,0.070588
	dc.w	$FFBC,$0012,0 ;-0.265996,0.070588
	dc.w	$FFC0,$0011,0 ;-0.253730,0.070072
	dc.w	$FFC3,$0011,0 ;-0.241742,0.067195
	dc.w	$FFC6,$0010,0 ;-0.229755,0.064318
	dc.w	$FFC9,$000F,0 ;-0.217767,0.061441
	dc.w	$FFCC,$000E,0 ;-0.205780,0.058564
	dc.w	$FFCF,$000E,0 ;-0.193792,0.055687
	dc.w	$FFD2,$000D,0 ;-0.181942,0.052555
	dc.w	$FFD4,$000B,0 ;-0.172965,0.044106
	dc.w	$FFD7,$0009,0 ;-0.163988,0.035656
	dc.w	$FFD9,$0006,0 ;-0.155011,0.027207
	dc.w	$FFDB,$0004,0 ;-0.146034,0.018758
	dc.w	$FFDD,$0002,0 ;-0.137056,0.010309
	dc.w	$FFDF,$0000,0 ;-0.131949,0.000027
	dc.w	$FFDF,$FFFD,0 ;-0.131101,-0.012271
	dc.w	$FFDF,$FFFA,0 ;-0.130253,-0.024570
	dc.w	$FFDF,$FFF7,0 ;-0.129405,-0.036869
	dc.w	$FFE0,$FFF4,0 ;-0.128557,-0.049167
	dc.w	$FFE0,$FFF1,0 ;-0.127708,-0.061466
	dc.w	$FFE0,$FFEE,0 ;-0.126860,-0.073765
	dc.w	$FFE0,$FFEA,0 ;-0.126471,-0.086079
	dc.w	$FFE0,$FFE7,0 ;-0.126471,-0.098407
	dc.w	$FFE0,$FFE4,0 ;-0.126471,-0.110735
	dc.w	$FFE0,$FFE1,0 ;-0.126471,-0.123063
	dc.w	$FFE0,$FFDE,0 ;-0.126471,-0.135391
	dc.w	$FFE0,$FFDB,0 ;-0.126471,-0.147719
	dc.w	$FFFA,$FFDD,0 ;-0.026471,-0.139953
	dc.w	$FFFA,$FFE0,0 ;-0.026471,-0.127625
	dc.w	$FFFA,$FFE3,0 ;-0.026471,-0.115298
	dc.w	$FFFA,$FFE6,0 ;-0.026471,-0.102970
	dc.w	$FFFA,$FFE9,0 ;-0.026471,-0.090642
	dc.w	$FFFA,$FFEC,0 ;-0.026471,-0.078314
	dc.w	$FFFA,$FFF0,0 ;-0.026471,-0.065986
	dc.w	$FFFA,$FFF3,0 ;-0.026471,-0.053658
	dc.w	$FFFA,$FFF6,0 ;-0.026471,-0.041330
	dc.w	$FFFA,$FFF9,0 ;-0.026471,-0.029002
	dc.w	$FFFA,$FFFC,0 ;-0.026471,-0.016674
	dc.w	$FFFA,$FFFF,0 ;-0.026471,-0.004347
	dc.w	$FFFA,$0002,0 ;-0.026471,0.007981
	dc.w	$FFFA,$0005,0 ;-0.026471,0.020309
	dc.w	$FFFA,$0008,0 ;-0.026471,0.032637
	dc.w	$FFFA,$000B,0 ;-0.026471,0.044965
	dc.w	$FFFA,$000E,0 ;-0.026471,0.057293
	dc.w	$FFFA,$0011,0 ;-0.026471,0.069621
	dc.w	$FFFA,$0014,0 ;-0.026471,0.081949
	dc.w	$FFFA,$0018,0 ;-0.026471,0.094277
	dc.w	$FFFA,$001B,0 ;-0.026471,0.106604
	dc.w	$FFFC,$001B,0 ;-0.016362,0.108824
	dc.w	$FFFF,$001B,0 ;-0.004034,0.108824
	dc.w	$0002,$001B,0 ;0.008294,0.108824
	dc.w	$0005,$001B,0 ;0.020622,0.108824
	dc.w	$0006,$0019,0 ;0.023529,0.099403
	dc.w	$0006,$0016,0 ;0.023529,0.087075
	dc.w	$0006,$0013,0 ;0.023529,0.074747
	dc.w	$0006,$000F,0 ;0.023529,0.062419
	dc.w	$0006,$000C,0 ;0.023529,0.050092
	dc.w	$0006,$0009,0 ;0.023529,0.037764
	dc.w	$0006,$0006,0 ;0.023529,0.025436
	dc.w	$0006,$0003,0 ;0.023529,0.013108
	dc.w	$0006,$0000,0 ;0.023529,0.000780
	dc.w	$0006,$FFFE,0 ;0.023529,-0.011548
	dc.w	$0006,$FFFA,0 ;0.023529,-0.023876
	dc.w	$0006,$FFF7,0 ;0.023529,-0.036204
	dc.w	$0006,$FFF4,0 ;0.023529,-0.048532
	dc.w	$0006,$FFF1,0 ;0.023529,-0.060859
	dc.w	$0006,$FFEE,0 ;0.023529,-0.073187
	dc.w	$0006,$FFEB,0 ;0.023529,-0.085515
	dc.w	$0006,$FFE7,0 ;0.023529,-0.097843
	dc.w	$0006,$FFE4,0 ;0.023529,-0.110171
	dc.w	$0006,$FFE1,0 ;0.023529,-0.122499
	dc.w	$0006,$FFDE,0 ;0.023529,-0.134827
	dc.w	$0006,$FFDB,0 ;0.023529,-0.147155
	dc.w	$0003,$FFDA,0 ;0.014047,-0.150000
	dc.w	$0000,$FFDA,0 ;0.001719,-0.150000
	dc.w	$FFFE,$FFDA,0 ;-0.010609,-0.150000
	dc.w	$FFFB,$FFDA,0 ;-0.022937,-0.150000
	dc.w	$0012,$FFDC,0 ;0.070588,-0.141206
	dc.w	$0012,$FFE0,0 ;0.070588,-0.128878
	dc.w	$0012,$FFE3,0 ;0.070588,-0.116550
	dc.w	$0012,$FFE6,0 ;0.070588,-0.104222
	dc.w	$0012,$FFE9,0 ;0.070588,-0.091894
	dc.w	$0012,$FFEC,0 ;0.070813,-0.079575
	dc.w	$0012,$FFEF,0 ;0.071810,-0.067288
	dc.w	$0012,$FFF2,0 ;0.072806,-0.055000
	dc.w	$0012,$FFF6,0 ;0.073802,-0.042713
	dc.w	$0013,$FFF9,0 ;0.074799,-0.030425
	dc.w	$0013,$FFFC,0 ;0.075795,-0.018138
	dc.w	$0013,$FFFF,0 ;0.076791,-0.005850
	dc.w	$0013,$0001,0 ;0.077787,0.006438
	dc.w	$0014,$0004,0 ;0.078784,0.018725
	dc.w	$0015,$0007,0 ;0.082716,0.029609
	dc.w	$0017,$0009,0 ;0.091653,0.038100
	dc.w	$0019,$000B,0 ;0.100591,0.046591
	dc.w	$001C,$000E,0 ;0.109529,0.055082
	dc.w	$001E,$0010,0 ;0.118466,0.063573
	dc.w	$0020,$0012,0 ;0.127404,0.072063
	dc.w	$0022,$0014,0 ;0.136342,0.080554
	dc.w	$0025,$0015,0 ;0.147386,0.085621
	dc.w	$0028,$0016,0 ;0.158995,0.089767
	dc.w	$002B,$0018,0 ;0.170605,0.093914
	dc.w	$002E,$0019,0 ;0.182215,0.098060
	dc.w	$0031,$001A,0 ;0.193824,0.102206
	dc.w	$0034,$001B,0 ;0.205434,0.106352
	dc.w	$0037,$001C,0 ;0.217044,0.110499
	dc.w	$003A,$001C,0 ;0.229152,0.111765
	dc.w	$003D,$001C,0 ;0.241480,0.111765
	dc.w	$0040,$001C,0 ;0.253808,0.111765
	dc.w	$0044,$001C,0 ;0.266136,0.111765
	dc.w	$0047,$001C,0 ;0.278464,0.111765
	dc.w	$004A,$001C,0 ;0.290792,0.111765
	dc.w	$004D,$001C,0 ;0.302941,0.111586
	dc.w	$004D,$0019,0 ;0.302941,0.099259
	dc.w	$004D,$0016,0 ;0.302941,0.086931
	dc.w	$004D,$0013,0 ;0.302941,0.074603
	dc.w	$004C,$0011,0 ;0.297569,0.067647
	dc.w	$0049,$0011,0 ;0.285241,0.067647
	dc.w	$0045,$0011,0 ;0.272914,0.067647
	dc.w	$0042,$0011,0 ;0.260586,0.067647
	dc.w	$003F,$0010,0 ;0.248434,0.065723
	dc.w	$003C,$0010,0 ;0.236313,0.063478
	dc.w	$0039,$000F,0 ;0.224191,0.061234
	dc.w	$0036,$000F,0 ;0.212069,0.058989
	dc.w	$0033,$000E,0 ;0.199947,0.056744
	dc.w	$0030,$000D,0 ;0.187825,0.054499
	dc.w	$002D,$000C,0 ;0.176666,0.050357
	dc.w	$002A,$000A,0 ;0.167688,0.041907
	dc.w	$0028,$0008,0 ;0.158711,0.033458
	dc.w	$0026,$0006,0 ;0.149734,0.025009
	dc.w	$0024,$0004,0 ;0.140757,0.016560
	dc.w	$0021,$0002,0 ;0.131780,0.008111
	dc.w	$0020,$0000,0 ;0.128509,-0.003149
	dc.w	$0020,$FFFD,0 ;0.127282,-0.015415
	dc.w	$0020,$FFF9,0 ;0.126055,-0.027682
	dc.w	$001F,$FFF6,0 ;0.124829,-0.039949
	dc.w	$001F,$FFF3,0 ;0.123602,-0.052216
	dc.w	$001F,$FFF0,0 ;0.122375,-0.064482
	dc.w	$001F,$FFED,0 ;0.121149,-0.076749
	dc.w	$001E,$FFEA,0 ;0.120588,-0.089049
	dc.w	$001E,$FFE7,0 ;0.120588,-0.101377
	dc.w	$001E,$FFE3,0 ;0.120588,-0.113705
	dc.w	$001E,$FFE0,0 ;0.120588,-0.126033
	dc.w	$001E,$FFDD,0 ;0.120588,-0.138361
	dc.w	$001E,$FFDA,0 ;0.119900,-0.150000
	dc.w	$001B,$FFDA,0 ;0.107572,-0.150000
	dc.w	$0018,$FFDA,0 ;0.095244,-0.150000
	dc.w	$0015,$FFDA,0 ;0.082916,-0.150000
