	dc.b	-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,00,01,00,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1
	dc.b	-1,-1,-1,-1,-1,-1,-1,-1,03,04,05,06,06,06,05,04,03,-1,-1,-1,-1,-1,-1,-1,-1
	dc.b	-1,-1,-1,-1,-1,-1,03,05,06,07,08,08,08,08,08,07,06,05,03,-1,-1,-1,-1,-1,-1
	dc.b	-1,-1,-1,-1,00,04,06,08,08,09,09,10,10,10,09,09,08,08,06,04,00,-1,-1,-1,-1
	dc.b	-1,-1,-1,00,05,07,08,09,10,10,11,11,11,11,11,10,10,09,08,07,05,00,-1,-1,-1
	dc.b	-1,-1,-1,04,07,08,09,10,11,11,12,12,12,12,12,11,11,10,09,08,07,04,-1,-1,-1
	dc.b	-1,-1,03,06,08,09,10,11,12,12,13,13,13,13,13,12,12,11,10,09,08,06,03,-1,-1
	dc.b	-1,-1,05,08,09,10,11,12,13,13,13,13,14,13,13,13,13,12,11,10,09,08,05,-1,-1
	dc.b	-1,03,06,08,10,11,12,13,13,14,14,14,14,14,14,14,13,13,12,11,10,08,06,03,-1
	dc.b	-1,04,07,09,10,11,12,13,14,14,14,14,14,14,14,14,14,13,12,11,10,09,07,04,-1
	dc.b	-1,05,08,09,11,12,13,13,14,14,14,15,15,15,14,14,14,13,13,12,11,09,08,05,-1
	dc.b	00,06,08,10,11,12,13,13,14,14,15,15,15,15,15,14,14,13,13,12,11,10,08,06,00
	dc.b	01,06,08,10,11,12,13,14,14,14,15,15,15,15,15,14,14,14,13,12,11,10,08,06,01
	dc.b	00,06,08,10,11,12,13,13,14,14,15,15,15,15,15,14,14,13,13,12,11,10,08,06,00
	dc.b	-1,05,08,09,11,12,13,13,14,14,14,15,15,15,14,14,14,13,13,12,11,09,08,05,-1
	dc.b	-1,04,07,09,10,11,12,13,14,14,14,14,14,14,14,14,14,13,12,11,10,09,07,04,-1
	dc.b	-1,03,06,08,10,11,12,13,13,14,14,14,14,14,14,14,13,13,12,11,10,08,06,03,-1
	dc.b	-1,-1,05,08,09,10,11,12,13,13,13,13,14,13,13,13,13,12,11,10,09,08,05,-1,-1
	dc.b	-1,-1,03,06,08,09,10,11,12,12,13,13,13,13,13,12,12,11,10,09,08,06,03,-1,-1
	dc.b	-1,-1,-1,04,07,08,09,10,11,11,12,12,12,12,12,11,11,10,09,08,07,04,-1,-1,-1
	dc.b	-1,-1,-1,00,05,07,08,09,10,10,11,11,11,11,11,10,10,09,08,07,05,00,-1,-1,-1
	dc.b	-1,-1,-1,-1,00,04,06,08,08,09,09,10,10,10,09,09,08,08,06,04,00,-1,-1,-1,-1
	dc.b	-1,-1,-1,-1,-1,-1,03,05,06,07,08,08,08,08,08,07,06,05,03,-1,-1,-1,-1,-1,-1
	dc.b	-1,-1,-1,-1,-1,-1,-1,-1,03,04,05,06,06,06,05,04,03,-1,-1,-1,-1,-1,-1,-1,-1
	dc.b	-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,00,01,00,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1,-1
