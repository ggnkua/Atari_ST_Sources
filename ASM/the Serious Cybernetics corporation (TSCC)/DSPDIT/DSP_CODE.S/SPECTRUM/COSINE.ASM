;**************************************************************************
;*     Motorola Austin DSP Operation  June 06, 1991                       *
;*                                                                        *
;*       *  ALTHOUGH THE INFORMATION CONTAINED HEREIN,    *               *
;*       *  AS WELL AS ANY INFORMATION PROVIDED RELATIVE  *               *
;*       *  THERETO, HAS BEEN CAREFULLY REVIEWED AND IS   *               *
;*       *  BELIEVED ACCURATE, MOTOROLA ASSUMES NO        *               *
;*       *  LIABILITY ARISING OUT OF ITS APPLICATION OR   *               *
;*       *  USE, NEITHER DOES IT CONVEY ANY LICENSE UNDER *               *
;*       *  ITS PATENT RIGHTS NOR THE RIGHTS OF OTHERS.   *               *
;*                                                                        *
;*  This program originally available on the Motorola DSP bulletin board. *
;*  It is provided under a DISCLAMER OF WARRANTY available from           *
;*  Motorola DSP Operation, 6501 Wm. Cannon Drive W., Austin, Tx., 78735. *
;*                                                                        *

;  Cosine table with size N/2 =  512

  dc   0.999995     ; = cosine(  1  )
  dc   0.999995     ; = cosine(  2  )
  dc   0.999995     ; = cosine(  3  )
  dc   0.999995     ; = cosine(  4  )
  dc   0.999995     ; = cosine(  5  )
  dc   0.999994     ; = cosine(  6  )
  dc   0.999994     ; = cosine(  7  )
  dc   0.999994     ; = cosine(  8  )
  dc   0.999994     ; = cosine(  9  )
  dc   0.999994     ; = cosine(  10  )
  dc   0.999994     ; = cosine(  11  )
  dc   0.999993     ; = cosine(  12  )
  dc   0.999993     ; = cosine(  13  )
  dc   0.999993     ; = cosine(  14  )
  dc   0.999993     ; = cosine(  15  )
  dc   0.999993     ; = cosine(  16  )
  dc   0.999992     ; = cosine(  17  )
  dc   0.999992     ; = cosine(  18  )
  dc   0.999992     ; = cosine(  19  )
  dc   0.999992     ; = cosine(  20  )
  dc   0.999992     ; = cosine(  21  )
  dc   0.999991     ; = cosine(  22  )
  dc   0.999991     ; = cosine(  23  )
  dc   0.999991     ; = cosine(  24  )
  dc   0.999991     ; = cosine(  25  )
  dc   0.999990     ; = cosine(  26  )
  dc   0.999990     ; = cosine(  27  )
  dc   0.999990     ; = cosine(  28  )
  dc   0.999989     ; = cosine(  29  )
  dc   0.999989     ; = cosine(  30  )
  dc   0.999989     ; = cosine(  31  )
  dc   0.999989     ; = cosine(  32  )
  dc   0.999988     ; = cosine(  33  )
  dc   0.999988     ; = cosine(  34  )
  dc   0.999988     ; = cosine(  35  )
  dc   0.999987     ; = cosine(  36  )
  dc   0.999987     ; = cosine(  37  )
  dc   0.999987     ; = cosine(  38  )
  dc   0.999986     ; = cosine(  39  )
  dc   0.999986     ; = cosine(  40  )
  dc   0.999985     ; = cosine(  41  )
  dc   0.999985     ; = cosine(  42  )
  dc   0.999985     ; = cosine(  43  )
  dc   0.999984     ; = cosine(  44  )
  dc   0.999984     ; = cosine(  45  )
  dc   0.999983     ; = cosine(  46  )
  dc   0.999983     ; = cosine(  47  )
  dc   0.999982     ; = cosine(  48  )
  dc   0.999982     ; = cosine(  49  )
  dc   0.999981     ; = cosine(  50  )
  dc   0.999981     ; = cosine(  51  )
  dc   0.999980     ; = cosine(  52  )
  dc   0.999980     ; = cosine(  53  )
  dc   0.999979     ; = cosine(  54  )
  dc   0.999979     ; = cosine(  55  )
  dc   0.999978     ; = cosine(  56  )
  dc   0.999978     ; = cosine(  57  )
  dc   0.999977     ; = cosine(  58  )
  dc   0.999976     ; = cosine(  59  )
  dc   0.999976     ; = cosine(  60  )
  dc   0.999975     ; = cosine(  61  )
  dc   0.999974     ; = cosine(  62  )
  dc   0.999974     ; = cosine(  63  )
  dc   0.999973     ; = cosine(  64  )
  dc   0.999972     ; = cosine(  65  )
  dc   0.999971     ; = cosine(  66  )
  dc   0.999971     ; = cosine(  67  )
  dc   0.999970     ; = cosine(  68  )
  dc   0.999969     ; = cosine(  69  )
  dc   0.999968     ; = cosine(  70  )
  dc   0.999967     ; = cosine(  71  )
  dc   0.999966     ; = cosine(  72  )
  dc   0.999965     ; = cosine(  73  )
  dc   0.999964     ; = cosine(  74  )
  dc   0.999964     ; = cosine(  75  )
  dc   0.999963     ; = cosine(  76  )
  dc   0.999961     ; = cosine(  77  )
  dc   0.999960     ; = cosine(  78  )
  dc   0.999959     ; = cosine(  79  )
  dc   0.999958     ; = cosine(  80  )
  dc   0.999957     ; = cosine(  81  )
  dc   0.999956     ; = cosine(  82  )
  dc   0.999955     ; = cosine(  83  )
  dc   0.999953     ; = cosine(  84  )
  dc   0.999952     ; = cosine(  85  )
  dc   0.999951     ; = cosine(  86  )
  dc   0.999950     ; = cosine(  87  )
  dc   0.999948     ; = cosine(  88  )
  dc   0.999947     ; = cosine(  89  )
  dc   0.999945     ; = cosine(  90  )
  dc   0.999944     ; = cosine(  91  )
  dc   0.999942     ; = cosine(  92  )
  dc   0.999941     ; = cosine(  93  )
  dc   0.999939     ; = cosine(  94  )
  dc   0.999937     ; = cosine(  95  )
  dc   0.999936     ; = cosine(  96  )
  dc   0.999934     ; = cosine(  97  )
  dc   0.999932     ; = cosine(  98  )
  dc   0.999930     ; = cosine(  99  )
  dc   0.999928     ; = cosine(  100  )
  dc   0.999926     ; = cosine(  101  )
  dc   0.999924     ; = cosine(  102  )
  dc   0.999922     ; = cosine(  103  )
  dc   0.999920     ; = cosine(  104  )
  dc   0.999918     ; = cosine(  105  )
  dc   0.999916     ; = cosine(  106  )
  dc   0.999913     ; = cosine(  107  )
  dc   0.999911     ; = cosine(  108  )
  dc   0.999909     ; = cosine(  109  )
  dc   0.999906     ; = cosine(  110  )
  dc   0.999903     ; = cosine(  111  )
  dc   0.999901     ; = cosine(  112  )
  dc   0.999898     ; = cosine(  113  )
  dc   0.999895     ; = cosine(  114  )
  dc   0.999892     ; = cosine(  115  )
  dc   0.999889     ; = cosine(  116  )
  dc   0.999886     ; = cosine(  117  )
  dc   0.999883     ; = cosine(  118  )
  dc   0.999880     ; = cosine(  119  )
  dc   0.999877     ; = cosine(  120  )
  dc   0.999873     ; = cosine(  121  )
  dc   0.999870     ; = cosine(  122  )
  dc   0.999866     ; = cosine(  123  )
  dc   0.999863     ; = cosine(  124  )
  dc   0.999859     ; = cosine(  125  )
  dc   0.999855     ; = cosine(  126  )
  dc   0.999851     ; = cosine(  127  )
  dc   0.999847     ; = cosine(  128  )
  dc   0.999843     ; = cosine(  129  )
  dc   0.999839     ; = cosine(  130  )
  dc   0.999834     ; = cosine(  131  )
  dc   0.999830     ; = cosine(  132  )
  dc   0.999825     ; = cosine(  133  )
  dc   0.999820     ; = cosine(  134  )
  dc   0.999815     ; = cosine(  135  )
  dc   0.999810     ; = cosine(  136  )
  dc   0.999805     ; = cosine(  137  )
  dc   0.999800     ; = cosine(  138  )
  dc   0.999794     ; = cosine(  139  )
  dc   0.999788     ; = cosine(  140  )
  dc   0.999783     ; = cosine(  141  )
  dc   0.999777     ; = cosine(  142  )
  dc   0.999771     ; = cosine(  143  )
  dc   0.999764     ; = cosine(  144  )
  dc   0.999758     ; = cosine(  145  )
  dc   0.999751     ; = cosine(  146  )
  dc   0.999744     ; = cosine(  147  )
  dc   0.999737     ; = cosine(  148  )
  dc   0.999730     ; = cosine(  149  )
  dc   0.999723     ; = cosine(  150  )
  dc   0.999715     ; = cosine(  151  )
  dc   0.999707     ; = cosine(  152  )
  dc   0.999699     ; = cosine(  153  )
  dc   0.999691     ; = cosine(  154  )
  dc   0.999683     ; = cosine(  155  )
  dc   0.999674     ; = cosine(  156  )
  dc   0.999665     ; = cosine(  157  )
  dc   0.999656     ; = cosine(  158  )
  dc   0.999646     ; = cosine(  159  )
  dc   0.999637     ; = cosine(  160  )
  dc   0.999627     ; = cosine(  161  )
  dc   0.999617     ; = cosine(  162  )
  dc   0.999606     ; = cosine(  163  )
  dc   0.999595     ; = cosine(  164  )
  dc   0.999584     ; = cosine(  165  )
  dc   0.999573     ; = cosine(  166  )
  dc   0.999561     ; = cosine(  167  )
  dc   0.999549     ; = cosine(  168  )
  dc   0.999537     ; = cosine(  169  )
  dc   0.999524     ; = cosine(  170  )
  dc   0.999511     ; = cosine(  171  )
  dc   0.999498     ; = cosine(  172  )
  dc   0.999484     ; = cosine(  173  )
  dc   0.999470     ; = cosine(  174  )
  dc   0.999455     ; = cosine(  175  )
  dc   0.999440     ; = cosine(  176  )
  dc   0.999425     ; = cosine(  177  )
  dc   0.999409     ; = cosine(  178  )
  dc   0.999393     ; = cosine(  179  )
  dc   0.999376     ; = cosine(  180  )
  dc   0.999359     ; = cosine(  181  )
  dc   0.999342     ; = cosine(  182  )
  dc   0.999324     ; = cosine(  183  )
  dc   0.999305     ; = cosine(  184  )
  dc   0.999286     ; = cosine(  185  )
  dc   0.999266     ; = cosine(  186  )
  dc   0.999246     ; = cosine(  187  )
  dc   0.999226     ; = cosine(  188  )
  dc   0.999204     ; = cosine(  189  )
  dc   0.999183     ; = cosine(  190  )
  dc   0.999160     ; = cosine(  191  )
  dc   0.999137     ; = cosine(  192  )
  dc   0.999114     ; = cosine(  193  )
  dc   0.999089     ; = cosine(  194  )
  dc   0.999064     ; = cosine(  195  )
  dc   0.999039     ; = cosine(  196  )
  dc   0.999012     ; = cosine(  197  )
  dc   0.998985     ; = cosine(  198  )
  dc   0.998958     ; = cosine(  199  )
  dc   0.998929     ; = cosine(  200  )
  dc   0.998900     ; = cosine(  201  )
  dc   0.998870     ; = cosine(  202  )
  dc   0.998839     ; = cosine(  203  )
  dc   0.998807     ; = cosine(  204  )
  dc   0.998774     ; = cosine(  205  )
  dc   0.998740     ; = cosine(  206  )
  dc   0.998706     ; = cosine(  207  )
  dc   0.998670     ; = cosine(  208  )
  dc   0.998634     ; = cosine(  209  )
  dc   0.998597     ; = cosine(  210  )
  dc   0.998558     ; = cosine(  211  )
  dc   0.998519     ; = cosine(  212  )
  dc   0.998478     ; = cosine(  213  )
  dc   0.998436     ; = cosine(  214  )
  dc   0.998394     ; = cosine(  215  )
  dc   0.998349     ; = cosine(  216  )
  dc   0.998304     ; = cosine(  217  )
  dc   0.998258     ; = cosine(  218  )
  dc   0.998210     ; = cosine(  219  )
  dc   0.998161     ; = cosine(  220  )
  dc   0.998111     ; = cosine(  221  )
  dc   0.998059     ; = cosine(  222  )
  dc   0.998006     ; = cosine(  223  )
  dc   0.997951     ; = cosine(  224  )
  dc   0.997895     ; = cosine(  225  )
  dc   0.997837     ; = cosine(  226  )
  dc   0.997778     ; = cosine(  227  )
  dc   0.997717     ; = cosine(  228  )
  dc   0.997655     ; = cosine(  229  )
  dc   0.997590     ; = cosine(  230  )
  dc   0.997524     ; = cosine(  231  )
  dc   0.997457     ; = cosine(  232  )
  dc   0.997387     ; = cosine(  233  )
  dc   0.997315     ; = cosine(  234  )
  dc   0.997242     ; = cosine(  235  )
  dc   0.997166     ; = cosine(  236  )
  dc   0.997089     ; = cosine(  237  )
  dc   0.997009     ; = cosine(  238  )
  dc   0.996927     ; = cosine(  239  )
  dc   0.996843     ; = cosine(  240  )
  dc   0.996756     ; = cosine(  241  )
  dc   0.996667     ; = cosine(  242  )
  dc   0.996576     ; = cosine(  243  )
  dc   0.996482     ; = cosine(  244  )
  dc   0.996386     ; = cosine(  245  )
  dc   0.996287     ; = cosine(  246  )
  dc   0.996185     ; = cosine(  247  )
  dc   0.996081     ; = cosine(  248  )
  dc   0.995974     ; = cosine(  249  )
  dc   0.995863     ; = cosine(  250  )
  dc   0.995750     ; = cosine(  251  )
  dc   0.995634     ; = cosine(  252  )
  dc   0.995514     ; = cosine(  253  )
  dc   0.995391     ; = cosine(  254  )
  dc   0.995265     ; = cosine(  255  )
  dc   0.995135     ; = cosine(  256  )
  dc   0.995002     ; = cosine(  257  )
  dc   0.994865     ; = cosine(  258  )
  dc   0.994725     ; = cosine(  259  )
  dc   0.994580     ; = cosine(  260  )
  dc   0.994432     ; = cosine(  261  )
  dc   0.994280     ; = cosine(  262  )
  dc   0.994123     ; = cosine(  263  )
  dc   0.993962     ; = cosine(  264  )
  dc   0.993797     ; = cosine(  265  )
  dc   0.993627     ; = cosine(  266  )
  dc   0.993452     ; = cosine(  267  )
  dc   0.993273     ; = cosine(  268  )
  dc   0.993089     ; = cosine(  269  )
  dc   0.992900     ; = cosine(  270  )
  dc   0.992706     ; = cosine(  271  )
  dc   0.992506     ; = cosine(  272  )
  dc   0.992301     ; = cosine(  273  )
  dc   0.992090     ; = cosine(  274  )
  dc   0.991874     ; = cosine(  275  )
  dc   0.991651     ; = cosine(  276  )
  dc   0.991423     ; = cosine(  277  )
  dc   0.991188     ; = cosine(  278  )
  dc   0.990947     ; = cosine(  279  )
  dc   0.990699     ; = cosine(  280  )
  dc   0.990445     ; = cosine(  281  )
  dc   0.990183     ; = cosine(  282  )
  dc   0.989915     ; = cosine(  283  )
  dc   0.989639     ; = cosine(  284  )
  dc   0.989355     ; = cosine(  285  )
  dc   0.989064     ; = cosine(  286  )
  dc   0.988765     ; = cosine(  287  )
  dc   0.988458     ; = cosine(  288  )
  dc   0.988142     ; = cosine(  289  )
  dc   0.987818     ; = cosine(  290  )
  dc   0.987484     ; = cosine(  291  )
  dc   0.987142     ; = cosine(  292  )
  dc   0.986791     ; = cosine(  293  )
  dc   0.986429     ; = cosine(  294  )
  dc   0.986058     ; = cosine(  295  )
  dc   0.985677     ; = cosine(  296  )
  dc   0.985286     ; = cosine(  297  )
  dc   0.984883     ; = cosine(  298  )
  dc   0.984470     ; = cosine(  299  )
  dc   0.984046     ; = cosine(  300  )
  dc   0.983610     ; = cosine(  301  )
  dc   0.983162     ; = cosine(  302  )
  dc   0.982702     ; = cosine(  303  )
  dc   0.982229     ; = cosine(  304  )
  dc   0.981744     ; = cosine(  305  )
  dc   0.981245     ; = cosine(  306  )
  dc   0.980733     ; = cosine(  307  )
  dc   0.980206     ; = cosine(  308  )
  dc   0.979666     ; = cosine(  309  )
  dc   0.979110     ; = cosine(  310  )
  dc   0.978540     ; = cosine(  311  )
  dc   0.977954     ; = cosine(  312  )
  dc   0.977352     ; = cosine(  313  )
  dc   0.976734     ; = cosine(  314  )
  dc   0.976099     ; = cosine(  315  )
  dc   0.975446     ; = cosine(  316  )
  dc   0.974776     ; = cosine(  317  )
  dc   0.974088     ; = cosine(  318  )
  dc   0.973381     ; = cosine(  319  )
  dc   0.972655     ; = cosine(  320  )
  dc   0.971909     ; = cosine(  321  )
  dc   0.971143     ; = cosine(  322  )
  dc   0.970356     ; = cosine(  323  )
  dc   0.969548     ; = cosine(  324  )
  dc   0.968718     ; = cosine(  325  )
  dc   0.967865     ; = cosine(  326  )
  dc   0.966989     ; = cosine(  327  )
  dc   0.966090     ; = cosine(  328  )
  dc   0.965166     ; = cosine(  329  )
  dc   0.964217     ; = cosine(  330  )
  dc   0.963242     ; = cosine(  331  )
  dc   0.962242     ; = cosine(  332  )
  dc   0.961213     ; = cosine(  333  )
  dc   0.960158     ; = cosine(  334  )
  dc   0.959073     ; = cosine(  335  )
  dc   0.957960     ; = cosine(  336  )
  dc   0.956816     ; = cosine(  337  )
  dc   0.955641     ; = cosine(  338  )
  dc   0.954435     ; = cosine(  339  )
  dc   0.953196     ; = cosine(  340  )
  dc   0.951924     ; = cosine(  341  )
  dc   0.950617     ; = cosine(  342  )
  dc   0.949275     ; = cosine(  343  )
  dc   0.947897     ; = cosine(  344  )
  dc   0.946482     ; = cosine(  345  )
  dc   0.945029     ; = cosine(  346  )
  dc   0.943537     ; = cosine(  347  )
  dc   0.942005     ; = cosine(  348  )
  dc   0.940432     ; = cosine(  349  )
  dc   0.938816     ; = cosine(  350  )
  dc   0.937157     ; = cosine(  351  )
  dc   0.935454     ; = cosine(  352  )
  dc   0.933704     ; = cosine(  353  )
  dc   0.931909     ; = cosine(  354  )
  dc   0.930065     ; = cosine(  355  )
  dc   0.928171     ; = cosine(  356  )
  dc   0.926227     ; = cosine(  357  )
  dc   0.924232     ; = cosine(  358  )
  dc   0.922182     ; = cosine(  359  )
  dc   0.920079     ; = cosine(  360  )
  dc   0.917919     ; = cosine(  361  )
  dc   0.915702     ; = cosine(  362  )
  dc   0.913425     ; = cosine(  363  )
  dc   0.911089     ; = cosine(  364  )
  dc   0.908690     ; = cosine(  365  )
  dc   0.906227     ; = cosine(  366  )
  dc   0.903699     ; = cosine(  367  )
  dc   0.901105     ; = cosine(  368  )
  dc   0.898441     ; = cosine(  369  )
  dc   0.895707     ; = cosine(  370  )
  dc   0.892901     ; = cosine(  371  )
  dc   0.890021     ; = cosine(  372  )
  dc   0.887065     ; = cosine(  373  )
  dc   0.884032     ; = cosine(  374  )
  dc   0.880918     ; = cosine(  375  )
  dc   0.877723     ; = cosine(  376  )
  dc   0.874444     ; = cosine(  377  )
  dc   0.871079     ; = cosine(  378  )
  dc   0.867626     ; = cosine(  379  )
  dc   0.864083     ; = cosine(  380  )
  dc   0.860447     ; = cosine(  381  )
  dc   0.856717     ; = cosine(  382  )
  dc   0.852889     ; = cosine(  383  )
  dc   0.848962     ; = cosine(  384  )
  dc   0.844933     ; = cosine(  385  )
  dc   0.840800     ; = cosine(  386  )
  dc   0.836560     ; = cosine(  387  )
  dc   0.832211     ; = cosine(  388  )
  dc   0.827749     ; = cosine(  389  )
  dc   0.823173     ; = cosine(  390  )
  dc   0.818479     ; = cosine(  391  )
  dc   0.813665     ; = cosine(  392  )
  dc   0.808728     ; = cosine(  393  )
  dc   0.803665     ; = cosine(  394  )
  dc   0.798472     ; = cosine(  395  )
  dc   0.793148     ; = cosine(  396  )
  dc   0.787689     ; = cosine(  397  )
  dc   0.782091     ; = cosine(  398  )
  dc   0.776353     ; = cosine(  399  )
  dc   0.770470     ; = cosine(  400  )
  dc   0.764439     ; = cosine(  401  )
  dc   0.758256     ; = cosine(  402  )
  dc   0.751920     ; = cosine(  403  )
  dc   0.745425     ; = cosine(  404  )
  dc   0.738769     ; = cosine(  405  )
  dc   0.731948     ; = cosine(  406  )
  dc   0.724959     ; = cosine(  407  )
  dc   0.717798     ; = cosine(  408  )
  dc   0.710460     ; = cosine(  409  )
  dc   0.702944     ; = cosine(  410  )
  dc   0.695243     ; = cosine(  411  )
  dc   0.687356     ; = cosine(  412  )
  dc   0.679278     ; = cosine(  413  )
  dc   0.671005     ; = cosine(  414  )
  dc   0.662534     ; = cosine(  415  )
  dc   0.653859     ; = cosine(  416  )
  dc   0.644979     ; = cosine(  417  )
  dc   0.635887     ; = cosine(  418  )
  dc   0.626581     ; = cosine(  419  )
  dc   0.617056     ; = cosine(  420  )
  dc   0.607308     ; = cosine(  421  )
  dc   0.597334     ; = cosine(  422  )
  dc   0.587128     ; = cosine(  423  )
  dc   0.576688     ; = cosine(  424  )
  dc   0.566009     ; = cosine(  425  )
  dc   0.555086     ; = cosine(  426  )
  dc   0.543916     ; = cosine(  427  )
  dc   0.532495     ; = cosine(  428  )
  dc   0.520819     ; = cosine(  429  )
  dc   0.508883     ; = cosine(  430  )
  dc   0.496685     ; = cosine(  431  )
  dc   0.484219     ; = cosine(  432  )
  dc   0.471483     ; = cosine(  433  )
  dc   0.458472     ; = cosine(  434  )
  dc   0.445183     ; = cosine(  435  )
  dc   0.431613     ; = cosine(  436  )
  dc   0.417757     ; = cosine(  437  )
  dc   0.403613     ; = cosine(  438  )
  dc   0.389177     ; = cosine(  439  )
  dc   0.374447     ; = cosine(  440  )
  dc   0.359419     ; = cosine(  441  )
  dc   0.344091     ; = cosine(  442  )
  dc   0.328460     ; = cosine(  443  )
  dc   0.312524     ; = cosine(  444  )
  dc   0.296282     ; = cosine(  445  )
  dc   0.279730     ; = cosine(  446  )
  dc   0.262867     ; = cosine(  447  )
  dc   0.245693     ; = cosine(  448  )
  dc   0.228206     ; = cosine(  449  )
  dc   0.210405     ; = cosine(  450  )
  dc   0.192291     ; = cosine(  451  )
  dc   0.173863     ; = cosine(  452  )
  dc   0.155122     ; = cosine(  453  )
  dc   0.136069     ; = cosine(  454  )
  dc   0.116706     ; = cosine(  455  )
  dc    9.70328e-02     ; = cosine(  456  )
  dc    7.70536e-02     ; = cosine(  457  )
  dc    5.67709e-02     ; = cosine(  458  )
  dc    3.61882e-02     ; = cosine(  459  )
  dc    1.53098e-02     ; = cosine(  460  )
  dc   -5.85962e-03     ; = cosine(  461  )
  dc   -2.73144e-02     ; = cosine(  462  )
  dc   -4.90482e-02     ; = cosine(  463  )
  dc   -7.10542e-02     ; = cosine(  464  )
  dc   -9.33244e-02     ; = cosine(  465  )
  dc  -0.115850     ; = cosine(  466  )
  dc  -0.138622     ; = cosine(  467  )
  dc  -0.161628     ; = cosine(  468  )
  dc  -0.184859     ; = cosine(  469  )
  dc  -0.208301     ; = cosine(  470  )
  dc  -0.231940     ; = cosine(  471  )
  dc  -0.255762     ; = cosine(  472  )
  dc  -0.279750     ; = cosine(  473  )
  dc  -0.303888     ; = cosine(  474  )
  dc  -0.328157     ; = cosine(  475  )
  dc  -0.352537     ; = cosine(  476  )
  dc  -0.377007     ; = cosine(  477  )
  dc  -0.401544     ; = cosine(  478  )
  dc  -0.426124     ; = cosine(  479  )
  dc  -0.450721     ; = cosine(  480  )
  dc  -0.475309     ; = cosine(  481  )
  dc  -0.499858     ; = cosine(  482  )
  dc  -0.524338     ; = cosine(  483  )
  dc  -0.548716     ; = cosine(  484  )
  dc  -0.572958     ; = cosine(  485  )
  dc  -0.597029     ; = cosine(  486  )
  dc  -0.620891     ; = cosine(  487  )
  dc  -0.644504     ; = cosine(  488  )
  dc  -0.667826     ; = cosine(  489  )
  dc  -0.690815     ; = cosine(  490  )
  dc  -0.713424     ; = cosine(  491  )
  dc  -0.735607     ; = cosine(  492  )
  dc  -0.757314     ; = cosine(  493  )
  dc  -0.778494     ; = cosine(  494  )
  dc  -0.799092     ; = cosine(  495  )
  dc  -0.819055     ; = cosine(  496  )
  dc  -0.838325     ; = cosine(  497  )
  dc  -0.856842     ; = cosine(  498  )
  dc  -0.874545     ; = cosine(  499  )
  dc  -0.891372     ; = cosine(  500  )
  dc  -0.907258     ; = cosine(  501  )
  dc  -0.922136     ; = cosine(  502  )
  dc  -0.935939     ; = cosine(  503  )
  dc  -0.948598     ; = cosine(  504  )
  dc  -0.960041     ; = cosine(  505  )
  dc  -0.970198     ; = cosine(  506  )
  dc  -0.978995     ; = cosine(  507  )
  dc  -0.986359     ; = cosine(  508  )
  dc  -0.992216     ; = cosine(  509  )
  dc  -0.996491     ; = cosine(  510  )
  dc  -0.999110     ; = cosine(  511  )
  dc  -1.000000     ; = cosine(  512  )
