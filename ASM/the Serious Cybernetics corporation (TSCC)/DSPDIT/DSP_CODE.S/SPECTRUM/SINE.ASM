;**************************************************************************
;*     Motorola Austin DSP Operation  June 06, 1991                       *
;*                                                                        *
;*       *  ALTHOUGH THE INFORMATION CONTAINED HEREIN,    *               *
;*       *  AS WELL AS ANY INFORMATION PROVIDED RELATIVE  *               *
;*       *  THERETO, HAS BEEN CAREFULLY REVIEWED AND IS   *               *
;*       *  BELIEVED ACCURATE, MOTOROLA ASSUMES NO        *               *
;*       *  LIABILITY ARISING OUT OF ITS APPLICATION OR   *               *
;*       *  USE, NEITHER DOES IT CONVEY ANY LICENSE UNDER *               *
;*       *  ITS PATENT RIGHTS NOR THE RIGHTS OF OTHERS.   *               *
;*                                                                        *
;*  This program originally available on the Motorola DSP bulletin board. *
;*  It is provided under a DISCLAMER OF WARRANTY available from           *
;*  Motorola DSP Operation, 6501 Wm. Cannon Drive W., Austin, Tx., 78735. *
;*                                                                        *

;  Sine table with size N/2 =  512
  dc    3.14159e-03     ; = sine(  1  )
  dc    3.18434e-03     ; = sine(  2  )
  dc    3.22768e-03     ; = sine(  3  )
  dc    3.27161e-03     ; = sine(  4  )
  dc    3.31614e-03     ; = sine(  5  )
  dc    3.36127e-03     ; = sine(  6  )
  dc    3.40702e-03     ; = sine(  7  )
  dc    3.45339e-03     ; = sine(  8  )
  dc    3.50038e-03     ; = sine(  9  )
  dc    3.54802e-03     ; = sine(  10  )
  dc    3.59631e-03     ; = sine(  11  )
  dc    3.64526e-03     ; = sine(  12  )
  dc    3.69487e-03     ; = sine(  13  )
  dc    3.74515e-03     ; = sine(  14  )
  dc    3.79613e-03     ; = sine(  15  )
  dc    3.84779e-03     ; = sine(  16  )
  dc    3.90016e-03     ; = sine(  17  )
  dc    3.95324e-03     ; = sine(  18  )
  dc    4.00704e-03     ; = sine(  19  )
  dc    4.06158e-03     ; = sine(  20  )
  dc    4.11685e-03     ; = sine(  21  )
  dc    4.17288e-03     ; = sine(  22  )
  dc    4.22968e-03     ; = sine(  23  )
  dc    4.28724e-03     ; = sine(  24  )
  dc    4.34559e-03     ; = sine(  25  )
  dc    4.40473e-03     ; = sine(  26  )
  dc    4.46468e-03     ; = sine(  27  )
  dc    4.52544e-03     ; = sine(  28  )
  dc    4.58703e-03     ; = sine(  29  )
  dc    4.64946e-03     ; = sine(  30  )
  dc    4.71274e-03     ; = sine(  31  )
  dc    4.77688e-03     ; = sine(  32  )
  dc    4.84189e-03     ; = sine(  33  )
  dc    4.90779e-03     ; = sine(  34  )
  dc    4.97458e-03     ; = sine(  35  )
  dc    5.04229e-03     ; = sine(  36  )
  dc    5.11091e-03     ; = sine(  37  )
  dc    5.18047e-03     ; = sine(  38  )
  dc    5.25098e-03     ; = sine(  39  )
  dc    5.32244e-03     ; = sine(  40  )
  dc    5.39488e-03     ; = sine(  41  )
  dc    5.46830e-03     ; = sine(  42  )
  dc    5.54272e-03     ; = sine(  43  )
  dc    5.61816e-03     ; = sine(  44  )
  dc    5.69462e-03     ; = sine(  45  )
  dc    5.77212e-03     ; = sine(  46  )
  dc    5.85068e-03     ; = sine(  47  )
  dc    5.93030e-03     ; = sine(  48  )
  dc    6.01101e-03     ; = sine(  49  )
  dc    6.09282e-03     ; = sine(  50  )
  dc    6.17574e-03     ; = sine(  51  )
  dc    6.25979e-03     ; = sine(  52  )
  dc    6.34499e-03     ; = sine(  53  )
  dc    6.43134e-03     ; = sine(  54  )
  dc    6.51887e-03     ; = sine(  55  )
  dc    6.60759e-03     ; = sine(  56  )
  dc    6.69752e-03     ; = sine(  57  )
  dc    6.78867e-03     ; = sine(  58  )
  dc    6.88106e-03     ; = sine(  59  )
  dc    6.97471e-03     ; = sine(  60  )
  dc    7.06963e-03     ; = sine(  61  )
  dc    7.16585e-03     ; = sine(  62  )
  dc    7.26337e-03     ; = sine(  63  )
  dc    7.36222e-03     ; = sine(  64  )
  dc    7.46242e-03     ; = sine(  65  )
  dc    7.56398e-03     ; = sine(  66  )
  dc    7.66692e-03     ; = sine(  67  )
  dc    7.77127e-03     ; = sine(  68  )
  dc    7.87703e-03     ; = sine(  69  )
  dc    7.98423e-03     ; = sine(  70  )
  dc    8.09290e-03     ; = sine(  71  )
  dc    8.20304e-03     ; = sine(  72  )
  dc    8.31468e-03     ; = sine(  73  )
  dc    8.42784e-03     ; = sine(  74  )
  dc    8.54254e-03     ; = sine(  75  )
  dc    8.65880e-03     ; = sine(  76  )
  dc    8.77664e-03     ; = sine(  77  )
  dc    8.89608e-03     ; = sine(  78  )
  dc    9.01716e-03     ; = sine(  79  )
  dc    9.13987e-03     ; = sine(  80  )
  dc    9.26427e-03     ; = sine(  81  )
  dc    9.39035e-03     ; = sine(  82  )
  dc    9.51815e-03     ; = sine(  83  )
  dc    9.64768e-03     ; = sine(  84  )
  dc    9.77898e-03     ; = sine(  85  )
  dc    9.91207e-03     ; = sine(  86  )
  dc    1.00470e-02     ; = sine(  87  )
  dc    1.01837e-02     ; = sine(  88  )
  dc    1.03223e-02     ; = sine(  89  )
  dc    1.04628e-02     ; = sine(  90  )
  dc    1.06052e-02     ; = sine(  91  )
  dc    1.07495e-02     ; = sine(  92  )
  dc    1.08958e-02     ; = sine(  93  )
  dc    1.10441e-02     ; = sine(  94  )
  dc    1.11944e-02     ; = sine(  95  )
  dc    1.13467e-02     ; = sine(  96  )
  dc    1.15011e-02     ; = sine(  97  )
  dc    1.16577e-02     ; = sine(  98  )
  dc    1.18163e-02     ; = sine(  99  )
  dc    1.19771e-02     ; = sine(  100  )
  dc    1.21401e-02     ; = sine(  101  )
  dc    1.23053e-02     ; = sine(  102  )
  dc    1.24728e-02     ; = sine(  103  )
  dc    1.26426e-02     ; = sine(  104  )
  dc    1.28146e-02     ; = sine(  105  )
  dc    1.29890e-02     ; = sine(  106  )
  dc    1.31658e-02     ; = sine(  107  )
  dc    1.33450e-02     ; = sine(  108  )
  dc    1.35266e-02     ; = sine(  109  )
  dc    1.37106e-02     ; = sine(  110  )
  dc    1.38972e-02     ; = sine(  111  )
  dc    1.40864e-02     ; = sine(  112  )
  dc    1.42781e-02     ; = sine(  113  )
  dc    1.44724e-02     ; = sine(  114  )
  dc    1.46693e-02     ; = sine(  115  )
  dc    1.48690e-02     ; = sine(  116  )
  dc    1.50713e-02     ; = sine(  117  )
  dc    1.52764e-02     ; = sine(  118  )
  dc    1.54843e-02     ; = sine(  119  )
  dc    1.56950e-02     ; = sine(  120  )
  dc    1.59086e-02     ; = sine(  121  )
  dc    1.61251e-02     ; = sine(  122  )
  dc    1.63446e-02     ; = sine(  123  )
  dc    1.65670e-02     ; = sine(  124  )
  dc    1.67924e-02     ; = sine(  125  )
  dc    1.70210e-02     ; = sine(  126  )
  dc    1.72526e-02     ; = sine(  127  )
  dc    1.74874e-02     ; = sine(  128  )
  dc    1.77254e-02     ; = sine(  129  )
  dc    1.79666e-02     ; = sine(  130  )
  dc    1.82111e-02     ; = sine(  131  )
  dc    1.84589e-02     ; = sine(  132  )
  dc    1.87101e-02     ; = sine(  133  )
  dc    1.89647e-02     ; = sine(  134  )
  dc    1.92228e-02     ; = sine(  135  )
  dc    1.94844e-02     ; = sine(  136  )
  dc    1.97495e-02     ; = sine(  137  )
  dc    2.00183e-02     ; = sine(  138  )
  dc    2.02907e-02     ; = sine(  139  )
  dc    2.05668e-02     ; = sine(  140  )
  dc    2.08466e-02     ; = sine(  141  )
  dc    2.11303e-02     ; = sine(  142  )
  dc    2.14179e-02     ; = sine(  143  )
  dc    2.17093e-02     ; = sine(  144  )
  dc    2.20047e-02     ; = sine(  145  )
  dc    2.23042e-02     ; = sine(  146  )
  dc    2.26077e-02     ; = sine(  147  )
  dc    2.29153e-02     ; = sine(  148  )
  dc    2.32271e-02     ; = sine(  149  )
  dc    2.35432e-02     ; = sine(  150  )
  dc    2.38635e-02     ; = sine(  151  )
  dc    2.41883e-02     ; = sine(  152  )
  dc    2.45174e-02     ; = sine(  153  )
  dc    2.48510e-02     ; = sine(  154  )
  dc    2.51891e-02     ; = sine(  155  )
  dc    2.55319e-02     ; = sine(  156  )
  dc    2.58793e-02     ; = sine(  157  )
  dc    2.62314e-02     ; = sine(  158  )
  dc    2.65884e-02     ; = sine(  159  )
  dc    2.69501e-02     ; = sine(  160  )
  dc    2.73168e-02     ; = sine(  161  )
  dc    2.76885e-02     ; = sine(  162  )
  dc    2.80653e-02     ; = sine(  163  )
  dc    2.84471e-02     ; = sine(  164  )
  dc    2.88342e-02     ; = sine(  165  )
  dc    2.92265e-02     ; = sine(  166  )
  dc    2.96242e-02     ; = sine(  167  )
  dc    3.00272e-02     ; = sine(  168  )
  dc    3.04358e-02     ; = sine(  169  )
  dc    3.08499e-02     ; = sine(  170  )
  dc    3.12696e-02     ; = sine(  171  )
  dc    3.16950e-02     ; = sine(  172  )
  dc    3.21262e-02     ; = sine(  173  )
  dc    3.25633e-02     ; = sine(  174  )
  dc    3.30063e-02     ; = sine(  175  )
  dc    3.34554e-02     ; = sine(  176  )
  dc    3.39105e-02     ; = sine(  177  )
  dc    3.43719e-02     ; = sine(  178  )
  dc    3.48395e-02     ; = sine(  179  )
  dc    3.53135e-02     ; = sine(  180  )
  dc    3.57939e-02     ; = sine(  181  )
  dc    3.62808e-02     ; = sine(  182  )
  dc    3.67744e-02     ; = sine(  183  )
  dc    3.72746e-02     ; = sine(  184  )
  dc    3.77817e-02     ; = sine(  185  )
  dc    3.82956e-02     ; = sine(  186  )
  dc    3.88166e-02     ; = sine(  187  )
  dc    3.93446e-02     ; = sine(  188  )
  dc    3.98798e-02     ; = sine(  189  )
  dc    4.04223e-02     ; = sine(  190  )
  dc    4.09721e-02     ; = sine(  191  )
  dc    4.15294e-02     ; = sine(  192  )
  dc    4.20943e-02     ; = sine(  193  )
  dc    4.26668e-02     ; = sine(  194  )
  dc    4.32472e-02     ; = sine(  195  )
  dc    4.38354e-02     ; = sine(  196  )
  dc    4.44316e-02     ; = sine(  197  )
  dc    4.50359e-02     ; = sine(  198  )
  dc    4.56484e-02     ; = sine(  199  )
  dc    4.62692e-02     ; = sine(  200  )
  dc    4.68985e-02     ; = sine(  201  )
  dc    4.75363e-02     ; = sine(  202  )
  dc    4.81828e-02     ; = sine(  203  )
  dc    4.88380e-02     ; = sine(  204  )
  dc    4.95021e-02     ; = sine(  205  )
  dc    5.01753e-02     ; = sine(  206  )
  dc    5.08576e-02     ; = sine(  207  )
  dc    5.15492e-02     ; = sine(  208  )
  dc    5.22501e-02     ; = sine(  209  )
  dc    5.29606e-02     ; = sine(  210  )
  dc    5.36806e-02     ; = sine(  211  )
  dc    5.44105e-02     ; = sine(  212  )
  dc    5.51503e-02     ; = sine(  213  )
  dc    5.59001e-02     ; = sine(  214  )
  dc    5.66601e-02     ; = sine(  215  )
  dc    5.74304e-02     ; = sine(  216  )
  dc    5.82111e-02     ; = sine(  217  )
  dc    5.90025e-02     ; = sine(  218  )
  dc    5.98045e-02     ; = sine(  219  )
  dc    6.06175e-02     ; = sine(  220  )
  dc    6.14414e-02     ; = sine(  221  )
  dc    6.22766e-02     ; = sine(  222  )
  dc    6.31230e-02     ; = sine(  223  )
  dc    6.39810e-02     ; = sine(  224  )
  dc    6.48505e-02     ; = sine(  225  )
  dc    6.57319e-02     ; = sine(  226  )
  dc    6.66251e-02     ; = sine(  227  )
  dc    6.75306e-02     ; = sine(  228  )
  dc    6.84482e-02     ; = sine(  229  )
  dc    6.93783e-02     ; = sine(  230  )
  dc    7.03210e-02     ; = sine(  231  )
  dc    7.12764e-02     ; = sine(  232  )
  dc    7.22448e-02     ; = sine(  233  )
  dc    7.32263e-02     ; = sine(  234  )
  dc    7.42211e-02     ; = sine(  235  )
  dc    7.52293e-02     ; = sine(  236  )
  dc    7.62512e-02     ; = sine(  237  )
  dc    7.72869e-02     ; = sine(  238  )
  dc    7.83367e-02     ; = sine(  239  )
  dc    7.94006e-02     ; = sine(  240  )
  dc    8.04789e-02     ; = sine(  241  )
  dc    8.15718e-02     ; = sine(  242  )
  dc    8.26794e-02     ; = sine(  243  )
  dc    8.38021e-02     ; = sine(  244  )
  dc    8.49399e-02     ; = sine(  245  )
  dc    8.60931e-02     ; = sine(  246  )
  dc    8.72618e-02     ; = sine(  247  )
  dc    8.84463e-02     ; = sine(  248  )
  dc    8.96469e-02     ; = sine(  249  )
  dc    9.08636e-02     ; = sine(  250  )
  dc    9.20968e-02     ; = sine(  251  )
  dc    9.33466e-02     ; = sine(  252  )
  dc    9.46132e-02     ; = sine(  253  )
  dc    9.58970e-02     ; = sine(  254  )
  dc    9.71980e-02     ; = sine(  255  )
  dc    9.85166e-02     ; = sine(  256  )
  dc    9.98530e-02     ; = sine(  257  )
  dc   0.101207     ; = sine(  258  )
  dc   0.102580     ; = sine(  259  )
  dc   0.103971     ; = sine(  260  )
  dc   0.105381     ; = sine(  261  )
  dc   0.106810     ; = sine(  262  )
  dc   0.108258     ; = sine(  263  )
  dc   0.109725     ; = sine(  264  )
  dc   0.111212     ; = sine(  265  )
  dc   0.112719     ; = sine(  266  )
  dc   0.114247     ; = sine(  267  )
  dc   0.115795     ; = sine(  268  )
  dc   0.117364     ; = sine(  269  )
  dc   0.118953     ; = sine(  270  )
  dc   0.120564     ; = sine(  271  )
  dc   0.122197     ; = sine(  272  )
  dc   0.123852     ; = sine(  273  )
  dc   0.125529     ; = sine(  274  )
  dc   0.127228     ; = sine(  275  )
  dc   0.128950     ; = sine(  276  )
  dc   0.130695     ; = sine(  277  )
  dc   0.132463     ; = sine(  278  )
  dc   0.134255     ; = sine(  279  )
  dc   0.136071     ; = sine(  280  )
  dc   0.137911     ; = sine(  281  )
  dc   0.139776     ; = sine(  282  )
  dc   0.141665     ; = sine(  283  )
  dc   0.143580     ; = sine(  284  )
  dc   0.145520     ; = sine(  285  )
  dc   0.147487     ; = sine(  286  )
  dc   0.149479     ; = sine(  287  )
  dc   0.151498     ; = sine(  288  )
  dc   0.153543     ; = sine(  289  )
  dc   0.155616     ; = sine(  290  )
  dc   0.157716     ; = sine(  291  )
  dc   0.159845     ; = sine(  292  )
  dc   0.162001     ; = sine(  293  )
  dc   0.164186     ; = sine(  294  )
  dc   0.166400     ; = sine(  295  )
  dc   0.168643     ; = sine(  296  )
  dc   0.170916     ; = sine(  297  )
  dc   0.173218     ; = sine(  298  )
  dc   0.175551     ; = sine(  299  )
  dc   0.177915     ; = sine(  300  )
  dc   0.180310     ; = sine(  301  )
  dc   0.182737     ; = sine(  302  )
  dc   0.185195     ; = sine(  303  )
  dc   0.187686     ; = sine(  304  )
  dc   0.190209     ; = sine(  305  )
  dc   0.192766     ; = sine(  306  )
  dc   0.195355     ; = sine(  307  )
  dc   0.197979     ; = sine(  308  )
  dc   0.200637     ; = sine(  309  )
  dc   0.203330     ; = sine(  310  )
  dc   0.206057     ; = sine(  311  )
  dc   0.208821     ; = sine(  312  )
  dc   0.211620     ; = sine(  313  )
  dc   0.214455     ; = sine(  314  )
  dc   0.217327     ; = sine(  315  )
  dc   0.220237     ; = sine(  316  )
  dc   0.223184     ; = sine(  317  )
  dc   0.226169     ; = sine(  318  )
  dc   0.229192     ; = sine(  319  )
  dc   0.232255     ; = sine(  320  )
  dc   0.235356     ; = sine(  321  )
  dc   0.238498     ; = sine(  322  )
  dc   0.241679     ; = sine(  323  )
  dc   0.244902     ; = sine(  324  )
  dc   0.248165     ; = sine(  325  )
  dc   0.251470     ; = sine(  326  )
  dc   0.254817     ; = sine(  327  )
  dc   0.258206     ; = sine(  328  )
  dc   0.261639     ; = sine(  329  )
  dc   0.265114     ; = sine(  330  )
  dc   0.268634     ; = sine(  331  )
  dc   0.272197     ; = sine(  332  )
  dc   0.275805     ; = sine(  333  )
  dc   0.279459     ; = sine(  334  )
  dc   0.283158     ; = sine(  335  )
  dc   0.286903     ; = sine(  336  )
  dc   0.290695     ; = sine(  337  )
  dc   0.294533     ; = sine(  338  )
  dc   0.298419     ; = sine(  339  )
  dc   0.302353     ; = sine(  340  )
  dc   0.306335     ; = sine(  341  )
  dc   0.310366     ; = sine(  342  )
  dc   0.314446     ; = sine(  343  )
  dc   0.318576     ; = sine(  344  )
  dc   0.322755     ; = sine(  345  )
  dc   0.326985     ; = sine(  346  )
  dc   0.331267     ; = sine(  347  )
  dc   0.335599     ; = sine(  348  )
  dc   0.339983     ; = sine(  349  )
  dc   0.344419     ; = sine(  350  )
  dc   0.348908     ; = sine(  351  )
  dc   0.353450     ; = sine(  352  )
  dc   0.358045     ; = sine(  353  )
  dc   0.362693     ; = sine(  354  )
  dc   0.367396     ; = sine(  355  )
  dc   0.372153     ; = sine(  356  )
  dc   0.376965     ; = sine(  357  )
  dc   0.381833     ; = sine(  358  )
  dc   0.386755     ; = sine(  359  )
  dc   0.391734     ; = sine(  360  )
  dc   0.396768     ; = sine(  361  )
  dc   0.401859     ; = sine(  362  )
  dc   0.407006     ; = sine(  363  )
  dc   0.412211     ; = sine(  364  )
  dc   0.417472     ; = sine(  365  )
  dc   0.422791     ; = sine(  366  )
  dc   0.428167     ; = sine(  367  )
  dc   0.433602     ; = sine(  368  )
  dc   0.439094     ; = sine(  369  )
  dc   0.444644     ; = sine(  370  )
  dc   0.450252     ; = sine(  371  )
  dc   0.455919     ; = sine(  372  )
  dc   0.461644     ; = sine(  373  )
  dc   0.467427     ; = sine(  374  )
  dc   0.473268     ; = sine(  375  )
  dc   0.479168     ; = sine(  376  )
  dc   0.485127     ; = sine(  377  )
  dc   0.491143     ; = sine(  378  )
  dc   0.497218     ; = sine(  379  )
  dc   0.503350     ; = sine(  380  )
  dc   0.509540     ; = sine(  381  )
  dc   0.515788     ; = sine(  382  )
  dc   0.522092     ; = sine(  383  )
  dc   0.528454     ; = sine(  384  )
  dc   0.534872     ; = sine(  385  )
  dc   0.541346     ; = sine(  386  )
  dc   0.547875     ; = sine(  387  )
  dc   0.554459     ; = sine(  388  )
  dc   0.561098     ; = sine(  389  )
  dc   0.567791     ; = sine(  390  )
  dc   0.574536     ; = sine(  391  )
  dc   0.581334     ; = sine(  392  )
  dc   0.588183     ; = sine(  393  )
  dc   0.595083     ; = sine(  394  )
  dc   0.602032     ; = sine(  395  )
  dc   0.609029     ; = sine(  396  )
  dc   0.616073     ; = sine(  397  )
  dc   0.623164     ; = sine(  398  )
  dc   0.630299     ; = sine(  399  )
  dc   0.637477     ; = sine(  400  )
  dc   0.644697     ; = sine(  401  )
  dc   0.651956     ; = sine(  402  )
  dc   0.659255     ; = sine(  403  )
  dc   0.666589     ; = sine(  404  )
  dc   0.673958     ; = sine(  405  )
  dc   0.681360     ; = sine(  406  )
  dc   0.688792     ; = sine(  407  )
  dc   0.696252     ; = sine(  408  )
  dc   0.703737     ; = sine(  409  )
  dc   0.711246     ; = sine(  410  )
  dc   0.718774     ; = sine(  411  )
  dc   0.726320     ; = sine(  412  )
  dc   0.733881     ; = sine(  413  )
  dc   0.741453     ; = sine(  414  )
  dc   0.749032     ; = sine(  415  )
  dc   0.756616     ; = sine(  416  )
  dc   0.764201     ; = sine(  417  )
  dc   0.771782     ; = sine(  418  )
  dc   0.779356     ; = sine(  419  )
  dc   0.786919     ; = sine(  420  )
  dc   0.794466     ; = sine(  421  )
  dc   0.801993     ; = sine(  422  )
  dc   0.809494     ; = sine(  423  )
  dc   0.816965     ; = sine(  424  )
  dc   0.824399     ; = sine(  425  )
  dc   0.831793     ; = sine(  426  )
  dc   0.839140     ; = sine(  427  )
  dc   0.846433     ; = sine(  428  )
  dc   0.853667     ; = sine(  429  )
  dc   0.860836     ; = sine(  430  )
  dc   0.867931     ; = sine(  431  )
  dc   0.874947     ; = sine(  432  )
  dc   0.881875     ; = sine(  433  )
  dc   0.888709     ; = sine(  434  )
  dc   0.895440     ; = sine(  435  )
  dc   0.902059     ; = sine(  436  )
  dc   0.908559     ; = sine(  437  )
  dc   0.914930     ; = sine(  438  )
  dc   0.921163     ; = sine(  439  )
  dc   0.927248     ; = sine(  440  )
  dc   0.933176     ; = sine(  441  )
  dc   0.938936     ; = sine(  442  )
  dc   0.944518     ; = sine(  443  )
  dc   0.949910     ; = sine(  444  )
  dc   0.955101     ; = sine(  445  )
  dc   0.960079     ; = sine(  446  )
  dc   0.964832     ; = sine(  447  )
  dc   0.969348     ; = sine(  448  )
  dc   0.973613     ; = sine(  449  )
  dc   0.977614     ; = sine(  450  )
  dc   0.981338     ; = sine(  451  )
  dc   0.984770     ; = sine(  452  )
  dc   0.987895     ; = sine(  453  )
  dc   0.990699     ; = sine(  454  )
  dc   0.993167     ; = sine(  455  )
  dc   0.995281     ; = sine(  456  )
  dc   0.997027     ; = sine(  457  )
  dc   0.998387     ; = sine(  458  )
  dc   0.999345     ; = sine(  459  )
  dc   0.999883     ; = sine(  460  )
  dc   0.999983     ; = sine(  461  )
  dc   0.999627     ; = sine(  462  )
  dc   0.998796     ; = sine(  463  )
  dc   0.997472     ; = sine(  464  )
  dc   0.995636     ; = sine(  465  )
  dc   0.993267     ; = sine(  466  )
  dc   0.990345     ; = sine(  467  )
  dc   0.986852     ; = sine(  468  )
  dc   0.982765     ; = sine(  469  )
  dc   0.978065     ; = sine(  470  )
  dc   0.972730     ; = sine(  471  )
  dc   0.966740     ; = sine(  472  )
  dc   0.960073     ; = sine(  473  )
  dc   0.952708     ; = sine(  474  )
  dc   0.944623     ; = sine(  475  )
  dc   0.935798     ; = sine(  476  )
  dc   0.926211     ; = sine(  477  )
  dc   0.915840     ; = sine(  478  )
  dc   0.904665     ; = sine(  479  )
  dc   0.892665     ; = sine(  480  )
  dc   0.879819     ; = sine(  481  )
  dc   0.866107     ; = sine(  482  )
  dc   0.851510     ; = sine(  483  )
  dc   0.836009     ; = sine(  484  )
  dc   0.819585     ; = sine(  485  )
  dc   0.802220     ; = sine(  486  )
  dc   0.783897     ; = sine(  487  )
  dc   0.764601     ; = sine(  488  )
  dc   0.744317     ; = sine(  489  )
  dc   0.723032     ; = sine(  490  )
  dc   0.700732     ; = sine(  491  )
  dc   0.677408     ; = sine(  492  )
  dc   0.653051     ; = sine(  493  )
  dc   0.627653     ; = sine(  494  )
  dc   0.601208     ; = sine(  495  )
  dc   0.573715     ; = sine(  496  )
  dc   0.545171     ; = sine(  497  )
  dc   0.515580     ; = sine(  498  )
  dc   0.484944     ; = sine(  499  )
  dc   0.453273     ; = sine(  500  )
  dc   0.420575     ; = sine(  501  )
  dc   0.386866     ; = sine(  502  )
  dc   0.352162     ; = sine(  503  )
  dc   0.316484     ; = sine(  504  )
  dc   0.279859     ; = sine(  505  )
  dc   0.242314     ; = sine(  506  )
  dc   0.203885     ; = sine(  507  )
  dc   0.164610     ; = sine(  508  )
  dc   0.124532     ; = sine(  509  )
  dc    8.37010e-02     ; = sine(  510  )
  dc    4.21703e-02     ; = sine(  511  )
  dc    1.50996e-07     ; = sine(  512  )
