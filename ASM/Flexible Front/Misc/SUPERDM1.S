 MOVE.L A7,A5
 MOVE.L 4(A5),A5
 MOVE.L $C(A5),D0
 ADD.L $14(A5),D0
 ADD.L $1C(A5),D0
 ADD.L #$500,D0

 MOVE.L D0,D1
 ADD.L A5,D1
 AND.L #-2,D1
 MOVE.L D1,A7
 MOVE.L D0,-(SP)
 MOVE.L A5,-(SP)
 CLR.W -(SP)
 MOVE.W #$4A,-(SP)
 TRAP #1
 ADD.L #12,SP

 JMP START
BUFFER: DS.B 2690,0
BUFFR1: DS.B 640,0
START:
 PEA STR1
 MOVE.W #1,-(SP)
 MOVE.W #25,-(SP)
 TRAP #14
 ADDQ.L #8,SP
 CLR.W -(SP)
 MOVE.L #SCR,-(SP)
 MOVE.L #SCR,-(SP)
 MOVE.W #5,-(SP)
 TRAP #14
 ADD.L #12,SP
 CLR.L -(SP)
 MOVE.W #$20,-(SP)
 TRAP #1
 ADDQ.L #6,SP
 MOVE.L D0,SSSP
 LEA BUFFER,A0
 MOVE.W #3329,D0
RS99:
 CLR.B (A0)+
 DBRA D0,RS99
 LEA SAMPLE,A2
AGAIN2:
 CMP.L #SMPSLUT,A2
 BEQ FINI
 MOVE.B (A2),D1
 AND.W #$00FF,D1
 ADD.B #$80,D1
 MOVE.B D1,(A2)+
 BRA AGAIN2
FINI:
 MOVE.W SR,SPAR5
 MOVE.L $70,SPAR1
 MOVE.L $120,SPAR2
 MOVE.L $118,SPAR3
 MOVE.B $FFFA09,SPAR4
 MOVE.B $FFFA07,SPAR4+1
 MOVE.B $FFFA13,SPAR4+2
 LEA PAMC,A0
 LEA $FF8240,A1
 MOVEQ #15,D0
PICPL:
 MOVE.W (A0)+,(A1)+
 DBRA D0,PICPL
 JSR CALER
 LEA PICT,A0
 LEA SCR,A1
 MOVE.W #7999,D0
PICTF:
 MOVE.L (A0)+,(A1)+
 DBRA D0,PICTF
 LEA SCR+(48*160),A0
 MOVEQ #52,D0
PCLR1:
 MOVEQ #21,D1
PCLR:
 CLR.L (A0)+
 DBRA D1,PCLR
 ADD.W #72,A0
 DBRA D0,PCLR1
 MOVE.L #RASTER3,$118
 ANDI.B #-$21,$FFFA09
 ANDI.B #-2,$FFFA07
 MOVE.L #RASTER1,$120
 ORI.B #1,$FFFA07
 ORI.B #1,$FFFA13
 MOVE.W #1,D0
 JSR MUSIC
 MOVE.L #RASTER2,$70
; MOVE.L #REST,$42A
; MOVE.L #$31415926,$426
 JSR PRINT
 JSR MOONR
NOEXIT:
 MOVE.B $FFFC02,D0
 CMP.B #$3B,D0
 BEQ MUSIC1
 CMP.B #$3C,D0
 BEQ MUSIC2
 CMP.B #$3D,D0
 BEQ MUSIC3
 CMP.B #$66,D0
 BEQ EXIT
; BEQ REST
TOMB6:
 LEA BUFFR1,A0
 LEA BUFFR1+8,A1
 MOVEQ #40,D0
TOMB1:
 MOVE.L (A1)+,(A0)+
 MOVE.L (A1)+,(A0)+
 MOVE.L (A1)+,(A0)+
 MOVE.L (A1)+,(A0)+
 DBRA D0,TOMB1
 ADDQ.B #1,TOMR
 CMP.B #15,TOMR
 BLS TOMB2
 CLR.W TOMR
 MOVE.L TOMPK,A0
 CMP.L #TOMTX1,A0
 BNE TOMB3
 LEA TOMTX,A0
TOMB3:
 CLR.W D0
 MOVE.B (A0)+,D0
 MOVE.L A0,TOMPK
 SUB.B #32,D0
 MULU #128,D0
 LEA FONT,A0
 ADD.W D0,A0
 LEA BUFFR1+512,A1
 MOVEQ #15,D0
TOMB4:
 MOVE.W (A0),D1
 MOVE.W D1,(A1)+
 MOVE.W D1,(A1)+
 MOVE.W D1,(A1)+
 NOT.W D1
 MOVE.W D1,(A1)+
 ADD.W #8,A0
 DBRA D0,TOMB4
TOMB2:
 LEA BUFFR1,A0
 LEA SCR+(160*36)+152,A1
 LEA TOMTAB,A2
TOMB7:
 MOVE.W (A2)+,D0
 CMP.W #$FFFF,D0
 BEQ TOMFN2
 CMP.W #$FFFE,D0
 BEQ TOMFN3
TOMB5:
 MOVE.L (A0),(A1)+
 MOVE.L 4(A0),(A1)
 ADD.L #156,A1
 DBRA D0,TOMB5
TOMFN3:
 ADDQ.W #8,A0
 JMP TOMB7
TOMFN2:
 JMP NOEXIT
LGFG: DC.B 0,$FF
TOMTX: DC.B 'PRESS KEYS F1 TO F3 TO CHOOSE MUSIC   '
TOMTX1:
 ALIGN.W
TOMPK: DC.L TOMTX
TOMR: DC.B 0,0
TOMTAB:
 DC.W $FFFE,0,$FFFE,0,$FFFE,0,$FFFE,0,0,0,0,01,1,1,1,1,1,1,1
 DC.W 2,3,4,5,6,7,7,6,5,4,3,2
 DC.W 1,1,1,1,1,1,1,1,0,0,0,0,0,$FFFE,0,$FFFE,0,$FFFE,0,$FFFE,$FFFF
EXIT:
 PEA STR2
 MOVE.W #1,-(SP)
 MOVE.W #25,-(SP)
 TRAP #14
 ADDQ.L #8,SP
 MOVE.B SPAR4,$FFFA09
 MOVE.B SPAR4+1,$FFFA07
 MOVE.B SPAR4+2,$FFFA13
 MOVE.L SPAR1,$70
 MOVE.L SPAR2,$120
 MOVE.L SPAR3,$118
 MOVE.W #$777,$FF8240
 MOVE.W SPAR5,SR
 MOVE.L SSSP,-(SP)
 MOVE.W #$20,-(SP)
 TRAP #1
 ADDQ.L #6,SP
 MOVE.W #1,-(SP)
 MOVE.L #$78000,-(SP)
 MOVE.L #$78000,-(SP)
 MOVE.W #5,-(SP)
 TRAP #14
 ADD.L #12,SP
 ILLEGAL
STR1: DC.B $12,$1A
STR2: DC.B $08,0
MUSNR: DC.B 0,0
MUSIC1:
 CMP.B #0,MUSNR
 BEQ TOMB6
 MOVE.W #0,D0
 MOVE.B D0,MUSNR
 JSR MUSIC
 BRA NOEXIT
MUSIC2:
 CMP.B #1,MUSNR
 BEQ TOMB6
 MOVE.W #1,D0
 MOVE.B D0,MUSNR
 JSR MUSIC
 BRA NOEXIT
MUSIC3:
 CMP.B #2,MUSNR
 BEQ TOMB6
 MOVE.W #2,D0
 MOVE.B D0,MUSNR
 JSR MUSIC
 BRA NOEXIT
PRINT:
 LEA SCR+(200*160),A0
 LEA SCR+(228*160),A3
PRINT1:
 MOVE.W #60*40,D0
PRLOP2:
 CLR.L (A0)+
 DBRA D0,PRLOP2
 LEA TXPEK1,A2
PRLOP1:
 CLR.W D0
 MOVE.B (A2)+,D0
 CMP.B #$FF,D0
 BEQ PRFIN
 SUB.B #32,D0
 MULU #128,D0
 LEA FONT,A0
 ADD.L D0,A0
 MOVE.L A3,A1
 MOVEQ #15,D0
PRLOP:
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 ADD.L #152,A1
 DBRA D0,PRLOP
 ADDQ.W #8,A3
 JMP PRLOP1
PRFIN:
 RTS
TXPEK1: DC.B '   ZZAPGAMES & CCK ',$FF
 ALIGN.W
MOONR:
 LEA MOON,A0
 LEA SCR+(160*40)+16,A1
 MOVEQ #63,D0
MONLOP:
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 ADD.L #128,A1
 DBRA D0,MONLOP
 LEA GURU,A0
 LEA SCR+(160*76),A1
 MOVEQ #31,D0
 JSR GURLOP
 LEA GURU+1024,A0
 MOVEQ #31,D0
 JSR GURLOP
 JSR GURSCR
 RTS
GURLOP:
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 MOVE.L 496(A0),(A1)+
 MOVE.L 500(A0),(A1)+
 MOVE.L 504(A0),(A1)+
 MOVE.L 508(A0),(A1)+
 ADD.L #128,A1
 DBRA D0,GURLOP
 RTS
GURSCR:
 MOVEQ #7,D2
GURLP5:
 LEA SCR+(160*76),A0
 MOVEQ #63,D1
GURLP4:
 MOVEQ #3,D0
GURLP3:
 MOVE #0,CCR
 ROXR.W (A0)
 ROXR.W 8(A0)
 ROXR.W 16(A0)
 ROXR.W 24(A0)
 ROXR.W 32(A0)
 ADDQ.W #2,A0
 DBRA D0,GURLP3
 ADD.W #152,A0
 DBRA D1,GURLP4
 DBRA D2,GURLP5
 ST GURFG
 RTS
GURFG: DC.W 0
RASTER1:
 CMP.W #197,LINE
 BGE.S SKIP1
 MOVE.L D0,-(SP)
PEKAR:
 MOVE.W COLTAB,$FF8240
 CMP.W #134,LINE
 BGE.S SKIWP1
NYPEK1:
 MOVE.W COLTAB3,D0
 MOVE.W D0,$FF8242
 ADDQ.L #2,NYPEK1+2
 ADDQ.L #2,PEKAR+2
 ADDQ.W #1,LINE
 MOVE.L (SP)+,D0
 BCLR #0,$FFFA0F
 RTE
SKIP1:
 CMP.W #198,LINE
 BEQ.S SKIWP
PEKAR1:
 MOVE.L COLTAB1,$FF8240
 ADDQ.L #4,PEKAR1+2
 ADDQ.W #1,LINE
 BCLR #0,$FFFA0F
 RTE
SKIWP1:
NYPEK2:
 MOVE.W COLTAB2,$FF8242
 ADDQ.L #2,PEKAR+2
 ADDQ.L #2,NYPEK2+2
 ADDQ.W #1,LINE
 MOVE.L (SP)+,D0
 BCLR #0,$FFFA0F
 RTE
SKIWP:
 DS.W 100,$4E71    ;104
 BCLR #1,$FF820A
 DS.W 16,$4E71     ;14
 BSET #1,$FF820A
 ADDQ.W #1,LINE
 BCLR #0,$FFFA0F
 RTE
RASTER2:
 CLR.B $FFFA1B
 MOVEM.L A0-A6/D0-D7,-(SP)
 MOVEQ #1,D0
 MOVE.B D0,$FFFA21
 MOVE.B #8,$FFFA1B
 CLR.W LINE
 MOVE.W #$004,$FF8240
 JSR MUSIC+274
 LEA COLTAB3,A0
 MOVE.L A0,NYPEK1+2
 LEA COLTAB,A0
 MOVE.W ADDER,D0
 CMP.W #396,D0
 BNE.S SKIP
 MOVEQ #-2,D0
SKIP:
 ADDQ.W #2,D0
 MOVE.W D0,ADDER
 ADD.W D0,A0
 MOVE.L A0,PEKAR+2
 LEA COLTAB2,A0
 MOVE.W SUBBER,D0
 CMP.W #132,D0
 BNE.S SKIP14
 MOVEQ #0,D0
SKIP14:
 ADDQ.W #2,D0
 MOVE.W D0,SUBBER
 SUB.W D0,A0
 MOVE.L A0,NYPEK2+2
 MOVE.L SCPEK,A0
 CMP.L #LINESLUT,A0
 BNE SKIP7
 MOVE.L #LINESTART,A0
SKIP7:
 MOVE.L (A0)+,PEKAR5+2
 MOVE.L #COLTAB1,PEKAR1+2
 MOVE.L A0,SCPEK
 JSR PACMAN
 JSR SCROLL
 MOVE.L STUDSPEK,A0
 CMP.L #STUDSX,A0
 BNE SKIP11
 MOVE.L #STUDS,A0
SKIP11:
 MOVE.L (A0)+,PEKAR7+2
 MOVE.L A0,STUDSPEK
 TST.B ANFG
 BPL NOANI1
 CLR.B ANFG
 MOVE.L PACPEK,A0
 CMP.L #PACSLUT,A0
 BNE.S SKIP10
 MOVE.L #PACADS,A0
SKIP10:
 MOVE.L (A0)+,PEKAR6+2
 MOVE.L A0,PACPEK
 MOVE.L PEKAR8+2,D0
 CMP.L #MOON-512,D0
 BNE.S SKIP12
 MOVE.L #BALL-512,D0
SKIP12:
 ADD.L #512,D0
 MOVE.L D0,PEKAR8+2
 MOVE.L PEKAR9+2,D0
 CMP.L #COKE-512,D0
 BNE.S GURAN
 MOVE.L #GURU+(512*3),D0
GURAN:
 ADD.L #512,D0
 MOVE.L D0,PEKAR9+2
 CMP.B #4,COKFG
 BLS NOANI2
 CLR.B COKFG
 MOVE.L COKEPEK,A0
 CMP.L #COKSLUT,A0
 BNE.S SKIP13
 LEA COKADS,A0
SKIP13:
 MOVE.L (A0)+,COKPEK+2
 MOVE.L A0,COKEPEK
NOANI2:
 ADDQ.B #1,COKFG
TEXI:
 MOVEM.L (SP)+,A0-A6/D0-D7
 RTE
NOANI1:
 MOVE.B #-1,ANFG
 JMP TEXI
ANFG: DC.W 0
COKFG: DC.W 0
PACMAN:
PEKAR6:
 LEA PACADS,A0
PEKAR7:
 LEA SCR2,A1
 MOVEQ #10,D0
PACLOP:
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 ADDQ.W #8,A0
 ADD.W #152,A1
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 ADDQ.W #8,A0
 ADD.W #152,A1
 DBRA D0,PACLOP
 TST.B GURFG
 BEQ GRPIKS
PEKAR8:
 LEA BALL,A0
 LEA SCR3,A1
 LEA SCR3+128,A2
PEKAR9:
 LEA GURU+(512*4),A3
 LEA SCR+(160*76)+16,A4
 MOVEQ #31,D0
BALLOP:
 MOVE.L (A3)+,(A4)+
 MOVE.L (A3)+,(A4)+
 MOVE.L (A3)+,(A4)+
 MOVE.L (A3)+,(A4)+
 MOVE.L (A0),(A2)+
 MOVE.L 4(A0),(A2)+
 MOVE.L 8(A0),(A2)+
 MOVE.L 12(A0),(A2)+
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 ADD.W #144,A1
 ADD.W #144,A2
 ADD.W #144,A4
 DBRA D0,BALLOP
GRPIKS:
COKPEK:
 LEA COKE,A0
 ADD.W #10*32,A0
 LEA SCR+(80*160)+40,A1
 MOVEQ #53,D0
COKLOP:
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 ADD.W #128,A1
 DBRA D0,COKLOP
LOGPEK1:
 LEA LOGO,A0
LOGPEK2:
 LEA SCR+(115*160)+72,A1
 MOVEQ #24,D0
LOGLOP:
 CLR.L -8(A1)
 CLR.L -4(A1)
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 CLR.L (A1)
 CLR.L 4(A1)
 ADD.W #128,A1
 DBRA D0,LOGLOP
LOGSPEK:
 MOVE.L #LOGO,D0
 TST.B LOGFG
 BEQ LOGLEFT
 CMP.L #LOGO+(1024*16),D0
 BLO SKIP511
 CMP.L #SCR+(115*160)+112,LOGPEK2+2
 BEQ SKIP514
 MOVE.L #LOGO,LOGSPEK+2
 ADDQ.L #8,LOGPEK2+2
 MOVE.L #LOGO,D0
SKIP511:
 MOVE.L D0,LOGPEK1+2
 ADD.L #1024,LOGSPEK+2
 RTS
LOGLEFT:
 CMP.L #LOGO-1024,D0
 BGT SKIP512
 CMP.L #SCR+(115*160)+72,LOGPEK2+2
 BEQ SKIP513
 MOVE.L #LOGO+(1024*15),LOGSPEK+2
 SUBQ.L #8,LOGPEK2+2
 MOVE.L #LOGO+(1024*15),D0
SKIP512:
 MOVE.L D0,LOGPEK1+2
 SUB.L #1024,LOGSPEK+2
 RTS
SKIP513:
 MOVE.B #$FF,LOGFG
 MOVE.L #LOGO,LOGSPEK+2
 RTS
SKIP514:
 MOVE.L #LOGO+(1024*15),LOGSPEK+2
 CLR.B LOGFG
 RTS
LOGFG: DC.B $FF,0
PACPEK: DC.L PACADS
PACADS:
 DC.L PAMC+32,PAMC+392,PAMC+752,PAMC+1112,PAMC+1472,PAMC+1832
 DC.L PAMC+2192,PAMC+2552,PAMC+2912,PAMC+3272,PAMC+3632,PAMC+3992
 DC.L PAMC+4352,PAMC+4712,PAMC+5072,PAMC+5432,PAMC+5792,PAMC+6152
 DC.L PAMC+6512,PAMC+6872,PAMC+7232,PAMC+7592
PACSLUT:
COKEPEK: DC.L COKADS
COKADS:
 DC.L COKE,COKE+2048,COKE+4096,COKE+6144,COKE+8192,COKE+10240
 DC.L COKE+12288,COKE+14336,COKE+16384,COKE+18432,COKE+20480
 DC.L COKE+22528,COKE+24576,COKE+26624
COKSLUT:
STUDSPEK: DC.L STUDS
STUDS:
 DC.L SCR2,SCR2,SCR2+160,SCR2+160,SCR2+160,SCR2+320,SCR2+320
 DC.L SCR2+480,SCR2+640,SCR2+800,SCR2+960
 DC.L SCR2+1120,SCR2+1280,SCR2+1440
 DC.L SCR2+1600,SCR2+1760,SCR2+1920
 DC.L SCR2+2080,SCR2+2240,SCR2+2400
 DC.L SCR2+2560,SCR2+2560,SCR2+2720,SCR2+2720,SCR2+2720,SCR2+2880,SCR2+2880

 DC.L SCR2+2880,SCR2+2880,SCR2+2720,SCR2+2720,SCR2+2720,SCR2+2560,SCR2+2560,SCR2+2400
 DC.L SCR2+2240,SCR2+2080
 DC.L SCR2+1920,SCR2+1760,SCR2+1600
 DC.L SCR2+1440,SCR2+1280,SCR2+1120
 DC.L SCR2+960,SCR2+800,SCR2+640,SCR2+480
 DC.L SCR2+320,SCR2+320,SCR2+160,SCR2+160,SCR2+160,SCR2,SCR2
STUDSX:
SCROLL:
 MOVE.W ROTS,D1
 CMP.W #16,D1
 BNE SKIP3
 CLR.W D0
TXPEK:
 MOVE.B TXSTART,D0
 ADDQ.L #1,TXPEK+2
 CMP.B #$FF,D0
 BNE SKIP2
 MOVE.L #TXSTART+1,TXPEK+2
 MOVE.B TXSTART,D0
SKIP2:
 SUB.B #32,D0
 MULU #128,D0
 LEA FONT,A0
 ADD.L D0,A0
 LEA BUFFER+160,A1
 MOVEQ #7,D0
LOP6:
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 ADD.W #160,A1
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 ADD.W #160,A1
 DBRA D0,LOP6
 CLR.W D1
SKIP3:
 ADDQ.W #1,D1
 MOVE.W D1,ROTS
 LEA BUFFER+166,A0
 MOVEQ #15,D1
LOP4:
 MOVEQ #3,D0
LOP2:
 MOVE #0,CCR
 ROXL.W (A0)
 ROXL.W -8(A0)
 ROXL.W -16(A0)
 ROXL.W -24(A0)
 ROXL.W -32(A0)
 ROXL.W -40(A0)
 ROXL.W -48(A0)
 ROXL.W -56(A0)
 ROXL.W -64(A0)
 ROXL.W -72(A0)
 ROXL.W -80(A0)
 ROXL.W -88(A0)
 ROXL.W -96(A0)
 ROXL.W -104(A0)
 ROXL.W -112(A0)
 ROXL.W -120(A0)
 ROXL.W -128(A0)
 ROXL.W -136(A0)
 ROXL.W -144(A0)
 ROXL.W -152(A0)
 ROXL.W -160(A0)
 SUBQ.W #2,A0
 DBRA D0,LOP2
 ADD.L #176,A0
 DBRA D1,LOP4
PEKAR5:
 LEA 0,A1
 LEA BUFFER,A0
 MOVE.W #15,D0
LOP5:
 MOVE.W #4,D1
LOP7:
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 DBRA D1,LOP7
 ADDQ.W #8,A0
 DBRA D0,LOP5
 RTS
RASTER3:
 MOVE.W #$2500,SR
 JMP $FC281C
RASTER5:
 clr.b $ff820a     ;60 HZ
 CLR.B $FFFA1B
 CLR.W R441+2
 MOVE.L #RASTER44,$120
 MOVEM.L A0-A1/D0,-(SP)
 CLR.L D0
 LEA $FF8209,A0
 LEA SPTAB1,A1
SPLOP1:              ;WAIT FOR SCREEN TO BEGIN
 TST.B (A0)
 BEQ.S SPLOP1        ;NOT YET
 MOVE.B (A0),D0
 ADDA.L D0,A1
 JMP (A1)
SPTAB1:
 DS.W 118,$4E71
SPLOP2:
 DS.W 10,$4E71
 move.b #2,$ff820a ;50 HZ. VOILA! LARGER SCREEN!
 MOVEQ #1,D0
 MOVE.B D0,$FFFA21
 MOVE.B #8,$FFFA1B
 CLR.W $FF8240
 MOVE.L #RSTCOL,RASTER4+2
 CMP.B #$1,$FFFC02
 BEQ EXIT
 ADDQ.W #1,LINE
 MOVEM.L (SP)+,A0-A1/D0
 RTE
RASTER44:
 MOVE.W R44CL,$FF8242
 MOVE.W D0,-(SP)
R441:
 MOVE.W #0,D0
 CMP.W #20,D0
 BNE R44X
 MOVE.L #R44CL,RASTER44+2
 MOVE.L #RASTER4,$120
R44X:
 ADDQ.W #1,R441+2
 ADDQ.L #2,RASTER44+2
 MOVE.W (SP)+,D0
 BCLR #0,$FFFA0F
 RTE
RASTER4:
 MOVE.W RSTCOL,$FF8240
 ADDQ.L #2,RASTER4+2
 BCLR #0,$FFFA0F
 RTE
REST:
 MOVE.W #$2700,SR
 MOVE.B #2,$FFFF820A
 LEA $D50,A7
 CLR.W $FF8240
 LEA SCR,A0
 MOVE.W #7999,D0
RS9:
 CLR.L (A0)+
 DBRA D0,RS9
MFP=$FFFA00
IERA=$07
IERB=$09
IPRA=$0B
ISRA=$0F
IMRA=$13
IMRB=$15
VECTOR=$17
TACR=$19
TADR=$1F
ISRVEC=$134
SCREG=$FF8800
SCDATA=$FF8802
 MOVE.B #0,SCREG ;CHANNEL A
 MOVE.B #0,SCDATA
 MOVE.B #1,SCREG
 MOVE.B #0,SCDATA
 MOVE.B #2,SCREG ;CHANNEL B
 MOVE.B #0,SCDATA
 MOVE.B #3,SCREG
 MOVE.B #0,SCDATA
 MOVE.B #4,SCREG ;CHANNEL C
 MOVE.B #0,SCDATA
 MOVE.B #5,SCREG
 MOVE.B #0,SCDATA
 MOVE.B #7,SCREG ;SET UP CHANNEL MIXING & PORT 'A' I/O
 MOVE.B #$FF,SCDATA
 MOVE.B #8,SCREG ;SET ALL VOLUMES TO ZERO
 MOVE.B #0,SCDATA
 MOVE.B #9,SCREG
 MOVE.B #0,SCDATA
 MOVE.B #10,SCREG
 MOVE.B #0,SCDATA
SAMPLAY:
 LEA SCREG,A1
 LEA SND_OUT,A0
IREPLAY:
 CLR.W D0
SAMPEK:
 MOVE.B SAMPLE,D0 ;READ FROM RAM
 LSL.W #3,D0      ;DOUBLE LONG WORD OFFSET
 CMP.L #SMPSLUT,SAMPEK+2     ;EXCEDED END STOP
 BGT.S HALTREP    ;BRANCH IF SO
SAMBACK:
INTOUTP:
 ADD.W D0,A0
 MOVE.L (A0)+,D0   ;GET DATA #1
 MOVEP.L D0,0(A1)       ;PLAY #1
 MOVE.W (A0),D0   ;GET DATA #2
 MOVEP.W D0,0(A1)       ;PLAY #2
 ADDQ.L #1,SAMPEK+2
 CMP.B #$39,$FFFC02
 BEQ EXIT
 MOVEQ #26,D0
SAMPAS:
 DBRA D0,SAMPAS
 JMP SAMPLAY
HALTREP:
 MOVE.L #SAMPLE,SAMPEK+2
 JMP SAMBACK
SND_OUT:
 dc.w $80c,$90b,$a09,0,$80c,$90b,$a09,0
 dc.w $80d,$908,$a08,0,$80b,$90b,$a0b,0
 dc.w $80d,$909,$a05,0,$80c,$90b,$a08,0
 dc.w $80d,$909,$a02,0,$80d,$908,$a06,0
 dc.w $80c,$90b,$a07,0,$80d,$907,$a07,0
 dc.w $80c,$90b,$a06,0,$80c,$90a,$a09,0
 dc.w $80b,$90b,$a0a,0,$80c,$90b,$a02,0
 dc.w $80c,$90b,$a00,0,$80c,$90a,$a08,0

 dc.w $80d,$906,$a04,0,$80d,$905,$a05,0
 dc.w $80d,$905,$a04,0,$80c,$909,$a09,0
 dc.w $80d,$904,$a03,0,$80b,$90b,$a09,0
 dc.w $80c,$90a,$a05,0,$80b,$90a,$a0a,0
 dc.w $80c,$909,$a08,0,$80b,$90b,$a08,0
 dc.w $80c,$90a,$a00,0,$80c,$90a,$a00,0
 dc.w $80c,$909,$a07,0,$80b,$90b,$a07,0
 dc.w $80c,$909,$a06,0,$80b,$90b,$a06,0

 dc.w $80b,$90a,$a09,0,$80b,$90b,$a05,0
 dc.w $80a,$90a,$a0a,0,$80b,$90b,$a02,0
 dc.w $80b,$90a,$a08,0,$80c,$907,$a07,0
 dc.w $80c,$908,$a04,0,$80c,$907,$a06,0
 dc.w $80b,$909,$a09,0,$80c,$906,$a06,0
 dc.w $80a,$90a,$a09,0,$80c,$907,$a03,0
 dc.w $80b,$90a,$a05,0,$80b,$909,$a08,0
 dc.w $80b,$90a,$a03,0,$80a,$90a,$a08,0

 dc.w $80b,$90a,$a00,0,$80b,$909,$a07,0
 dc.w $80b,$908,$a08,0,$80a,$90a,$a07,0
 dc.w $80a,$909,$a09,0,$80c,$901,$a01,0
 dc.w $80a,$90a,$a06,0,$80b,$908,$a07,0
 dc.w $80a,$90a,$a05,0,$80a,$909,$a08,0
 dc.w $80a,$90a,$a02,0,$80a,$90a,$a01,0
 dc.w $80a,$90a,$a00,0,$809,$909,$a09,0
 dc.w $80a,$908,$a08,0,$80b,$908,$a01,0

 dc.w $80a,$909,$a06,0,$80b,$907,$a04,0
 dc.w $80a,$909,$a05,0,$809,$909,$a08,0
 dc.w $80a,$909,$a03,0,$80a,$908,$a06,0
 dc.w $80a,$909,$a00,0,$809,$909,$a07,0
 dc.w $809,$908,$a08,0,$80a,$908,$a04,0
 dc.w $809,$909,$a06,0,$80a,$908,$a01,0
 dc.w $809,$909,$a05,0,$809,$908,$a07,0
 dc.w $808,$908,$a08,0,$809,$909,$a02,0

 dc.w $809,$908,$a06,0,$809,$909,$a00,0
 dc.w $809,$907,$a07,0,$808,$908,$a07,0
 dc.w $809,$907,$a06,0,$809,$908,$a02,0
 dc.w $808,$908,$a06,0,$809,$906,$a06,0
 dc.w $808,$907,$a07,0,$808,$908,$a04,0
 dc.w $808,$907,$a06,0,$808,$908,$a02,0
 dc.w $807,$907,$a07,0,$808,$906,$a06,0
 dc.w $808,$907,$a04,0,$807,$907,$a06,0

 dc.w $808,$906,$a05,0,$808,$906,$a04,0
 dc.w $807,$906,$a06,0,$807,$907,$a04,0
 dc.w $808,$905,$a04,0,$806,$906,$a06,0
 dc.w $807,$906,$a04,0,$807,$905,$a05,0
 dc.w $806,$906,$a05,0,$806,$906,$a04,0
 dc.w $806,$905,$a05,0,$806,$906,$a02,0
 dc.w $806,$905,$a04,0,$805,$905,$a05,0
 dc.w $806,$905,$a02,0,$805,$905,$a04,0

 dc.w $805,$904,$a04,0,$805,$905,$a02,0
 dc.w $804,$904,$a04,0,$804,$904,$a03,0
 dc.w $804,$904,$a02,0,$804,$903,$a03,0
 dc.w $803,$903,$a03,0,$803,$903,$a02,0
 dc.w $803,$902,$a02,0,$802,$902,$a02,0
 dc.w $802,$902,$a01,0,$801,$901,$a01,0
 dc.w $802,$901,$a00,0,$801,$901,$a00,0
 dc.w $801,$900,$a00,0,$800,$900,$a00,0

 dc.w $80e,$90d,$a0c,0,$80f,$903,$a00,0
 dc.w $80f,$903,$a00,0,$80f,$903,$a00,0
 dc.w $80f,$903,$a00,0,$80f,$903,$a00,0
 dc.w $80f,$903,$a00,0,$80e,$90d,$a0b,0
 dc.w $80e,$90d,$a0b,0,$80e,$90d,$a0b,0
 dc.w $80e,$90d,$a0b,0,$80e,$90d,$a0b,0
 dc.w $80e,$90d,$a0b,0,$80e,$90d,$a0b,0
 dc.w $80e,$90d,$a0a,0,$80e,$90d,$a0a,0

 dc.w $80e,$90d,$a0a,0,$80e,$90d,$a0a,0
 dc.w $80e,$90c,$a0c,0,$80e,$90d,$a00,0
 dc.w $80d,$90d,$a0d,0,$80d,$90d,$a0d,0
 dc.w $80d,$90d,$a0d,0,$80d,$90d,$a0d,0
 dc.w $80d,$90d,$a0d,0,$80d,$90d,$a0d,0
 dc.w $80e,$90c,$a0b,0,$80e,$90c,$a0b,0
 dc.w $80e,$90c,$a0b,0,$80e,$90c,$a0b,0
 dc.w $80e,$90c,$a0b,0,$80e,$90c,$a0b,0

 dc.w $80e,$90c,$a0b,0,$80e,$90c,$a0b,0
 dc.w $80e,$90c,$a0a,0,$80e,$90c,$a0a,0
 dc.w $80e,$90c,$a0a,0,$80e,$90c,$a0a,0
 dc.w $80d,$90d,$a0c,0,$80d,$90d,$a0c,0
 dc.w $80e,$90c,$a09,0,$80e,$90c,$a09,0
 dc.w $80e,$90c,$a05,0,$80e,$90c,$a00,0
 dc.w $80e,$90c,$a00,0,$80e,$90b,$a0b,0
 dc.w $80e,$90b,$a0b,0,$80e,$90b,$a0b,0

 dc.w $80e,$90b,$a0b,0,$80e,$90b,$a0a,0
 dc.w $80e,$90b,$a0a,0,$80e,$90b,$a0a,0
 dc.w $80d,$90d,$a0b,0,$80d,$90d,$a0b,0
 dc.w $80d,$90d,$a0b,0,$80e,$90b,$a09,0
 dc.w $80e,$90b,$a09,0,$80e,$90b,$a09,0
 dc.w $80d,$90c,$a0c,0,$80d,$90d,$a0a,0
 dc.w $80e,$90b,$a07,0,$80e,$90b,$a00,0
 dc.w $80e,$90b,$a00,0,$80d,$90d,$a09,0

 dc.w $80d,$90d,$a09,0,$80e,$90a,$a09,0
 dc.w $80d,$90d,$a08,0,$80d,$90d,$a07,0
 dc.w $80d,$90d,$a04,0,$80d,$90d,$a00,0
 dc.w $80e,$90a,$a04,0,$80e,$909,$a09,0
 dc.w $80e,$909,$a09,0,$80d,$90c,$a0b,0
 dc.w $80e,$909,$a08,0,$80e,$909,$a08,0
 dc.w $80e,$909,$a07,0,$80e,$908,$a08,0
 dc.w $80e,$909,$a01,0,$80c,$90c,$a0c,0

 dc.w $80d,$90c,$a0a,0,$80e,$908,$a06,0
 dc.w $80e,$907,$a07,0,$80e,$908,$a00,0
 dc.w $80e,$907,$a05,0,$80e,$906,$a06,0
 dc.w $80d,$90c,$a09,0,$80e,$905,$a05,0
 dc.w $80e,$904,$a04,0,$80d,$90c,$a08,0
 dc.w $80d,$90b,$a0b,0,$80e,$900,$a00,0
 dc.w $80d,$90c,$a06,0,$80d,$90c,$a05,0
 dc.w $80d,$90c,$a02,0,$80c,$90c,$a0b,0

 dc.w $80c,$90c,$a0b,0,$80d,$90b,$a0a,0
 dc.w $80d,$90b,$a0a,0,$80d,$90b,$a0a,0
 dc.w $80d,$90b,$a0a,0,$80c,$90c,$a0a,0
 dc.w $80c,$90c,$a0a,0,$80c,$90c,$a0a,0
 dc.w $80d,$90b,$a09,0,$80d,$90b,$a09,0
 dc.w $80d,$90a,$a0a,0,$80d,$90a,$a0a,0
 dc.w $80d,$90a,$a0a,0,$80c,$90c,$a09,0
 dc.w $80c,$90c,$a09,0,$80c,$90c,$a09,0

 dc.w $80d,$90b,$a06,0,$80c,$90b,$a0b,0
 dc.w $80c,$90c,$a08,0,$80d,$90b,$a00,0
 dc.w $80d,$90b,$a00,0,$80c,$90c,$a07,0
 dc.w $80c,$90c,$a06,0,$80c,$90c,$a05,0
 dc.w $80c,$90c,$a03,0,$80c,$90c,$a01,0
 dc.w $80c,$90b,$a0a,0,$80d,$90a,$a05,0
 dc.w $80d,$90a,$a04,0,$80d,$90a,$a02,0
 dc.w $80d,$909,$a08,0,$80d,$909,$a08,0
CALER:
 LEA RSTB1,A0
 MOVE.L A0,A1
RS7:
 MOVE.W -(A0),(A1)+
 CMP.L #RSTAB,A0
 BHI RS7
 LEA SCR,A0
 MOVE.W #40000,D0
SPCL:
 CLR.B (A0)+
 DBRA D0,SPCL
 LEA SCR,A0
 MOVE.W #1000,D0
SPCL1:
 MOVE.L #$FFFF0000,(A0)+
 DBRA D0,SPCL1
 LEA SCR+(10*160),A0
 LEA SCR+(10*160),A3
 JSR PRINT1
 MOVE.L #RASTER3,$118
 ANDI.B #-$21,$FFFA09
 ANDI.B #-2,$FFFA07
 MOVE.L #RASTER4,$120
 ORI.B #1,$FFFA07
 ORI.B #1,$FFFA13
 MOVE.L #RASTER5,$70
 MOVE.W #$2300,SR
 CLR.B $FFFC02
 LEA RSTAB,A2
 LEA RSTAB+32,A3
 LEA RSTAB+64,A4
 LEA RSTAB+96,A5
 LEA RSTAB+128,A6
 CLR.W D7
AGAIN1:
 LEA RSTCOL-16,A0
 ADD.W D7,A0
 MOVEQ #25,D0
RS6:
 MOVE.L #$00000002,(A0)+
 MOVE.L #$00030003,(A0)+
 MOVE.L #$00030003,(A0)+
 MOVE.L #$00020000,(A0)+
 DBRA D0,RS6
 CLR.W RSTCOL+398
 CMP.B #$39,$FFFC02
 BEQ EXITC
 MOVE.W (A2)+,D0
 LEA RSTCOL,A0
 ADD.W D0,D0
 ADD.W D0,A0
 LEA RST1,A1
 BSR RSSUB
 LEA RSTCOL,A0
 MOVE.W (A3)+,D0
 ADD.W D0,D0
 ADD.W D0,A0
 LEA RST2,A1
 BSR RSSUB
 LEA RSTCOL,A0
 MOVE.W (A4)+,D0
 ADD.W D0,D0
 ADD.W D0,A0
 LEA RST3,A1
 BSR RSSUB
 LEA RSTCOL,A0
 MOVE.W (A5)+,D0
 ADD.W D0,D0
 ADD.W D0,A0
 LEA RST4,A1
 BSR RSSUB
 LEA RSTCOL,A0
 MOVE.W (A6)+,D0
 ADD.W D0,D0
 ADD.W D0,A0
 LEA RST5,A1
 BSR RSSUB
 CMP.L #RSFIN,A2
 BLT RS1
 LEA RSTAB,A2
RS1:
 CMP.L #RSFIN,A3
 BLT RS2
 LEA RSTAB,A3
RS2:
 CMP.L #RSFIN,A4
 BLT RS3
 LEA RSTAB,A4
RS3:
 CMP.L #RSFIN,A5
 BLT RS4
 LEA RSTAB,A5
RS4:
 CMP.L #RSFIN,A6
 BLT RS8
 LEA RSTAB,A6
RS8:
 TST.B RSFG
 BEQ RS11
 CLR.B RSFG
 TST.W DRAD
 BEQ DRSK
 SUB.W #160,DRAD
DRSK:
 CMP.W #16,D7
 BNE RS10
 CLR.W D7
RS10:
 ADDQ.W #2,D7
 BRA RS12
RS11:
 ST RSFG
RS12:
 LEA PICT+(48*160),A0
 LEA SCR+(80*160)+40,A1
 ADD.W DRAD,A1
 MOVEQ #52,D0
DRL1:
 MOVEQ #21,D1
DRL2:
 MOVE.L (A0)+,(A1)+
 DBRA D1,DRL2
 ADD.W #72,A1
 ADD.W #72,A0
 DBRA D0,DRL1
 MOVE.W LINE,D0
RS5:
 CMP.W LINE,D0
 BEQ RS5
 BRA AGAIN1
RSSUB:
 MOVEQ #6,D1
RSLOP:
 MOVE.L (A1)+,(A0)+
 DBRA D1,RSLOP
 LEA RSTCOL+398,A0
 SUB.W D0,A0
 MOVEQ #6,D1
RSLOP11:
 MOVE.L -(A1),-(A0)
 DBRA D1,RSLOP11
EXITC:
 RTS
DRAD: DC.W 160*150
RSFG: DC.W 0
SCR=$76000
RSTAB:
 DC.W 0,0,0,0,1,1,1,1,2,2,2,2,3,3,3,4,4,4,5,5,5,6,6,6,7,7,8,8,9,9
 DC.W 10,10,11,11,12,13,14,15,16,17,18,19
 DC.W 20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40
 DC.W 41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62
 DC.W 63,64,65,66,67,68,69,70,71,72,73,74
 DC.W 75,75,76,76,77,77,78,78,79,79,80,80,80,81,81,81,82,82,82,83,83,83
 DC.W 84,84,84,84,85,85,85,85,86,86,86,86
RSTB1: DS.W 138,0
RSFIN:
LINE: DC.W 0
ADDER: DC.W 0
SUBBER: DC.W 0
SPAR1: DC.L 0
SPAR2: DC.L 0
SPAR3: DC.L 0
SPAR4: DC.L 0
SPAR5: DC.W 0
SSSP:  DC.L 0
RST1:
 DC.W $001,$002,$003,$004,$005,$006,$007,$007,$006,$005,$004,$003,$002,$001
RST2:
 DC.W $010,$020,$030,$040,$050,$060,$070,$070,$060,$050,$040,$030,$020,$010
RST3:
 DC.W $100,$200,$300,$400,$500,$600,$700,$700,$600,$500,$400,$300,$200,$100
RST4:
 DC.W $111,$222,$333,$444,$555,$666,$777,$777,$666,$555,$444,$333,$222,$111
RST5:
 DC.W $110,$220,$330,$440,$550,$660,$770,$770,$660,$550,$440,$330,$220,$110

 DS.W 8
RSTCOL:
 DS.W 100,$070
 DS.W 130,$700

COLTAB:
 DC.W  $111,$222,$333,$444
 DC.W  $555,$666,$777,$777,$667,$667,$557,$557,$447,$447,$337
 DC.W  $337,$227,$227,$117,$117,$007
 DC.W  $006,$005,$004,$003,$002,$001,$000,$000,$001,$002,$003,$004,$005
 DC.W  $006,$007,$107,$107,$207,$207,$307,$307,$407,$407
 DC.W  $507,$507,$607,$607,$707,$606
 DC.W  $505,$404,$303,$202,$101,$000,$000,$101,$202,$303,$404,$505,$606
 DC.W  $707,$706,$706,$705,$705,$704,$704,$703,$703,$702
 DC.W  $702,$701,$701,$700,$600,$500
 DC.W  $400,$300,$200,$100,$000,$000,$100,$200,$300,$400,$500,$600,$700
 DC.W  $710,$710,$720,$720,$730,$730,$740,$740,$750,$750
 DC.W  $760,$760,$770,$660,$550,$440
 DC.W  $330,$220,$110,$000,$000,$110,$220,$330,$440,$550,$660,$770,$670
 DC.W  $670,$570
 DC.W  $570,$470,$470,$370,$370,$270,$270,$170,$170,$070
 DC.W  $060,$050,$040,$030
 DC.W  $020,$010,$000,$000,$010,$020,$030,$040,$050,$060,$070,$071,$071
 DC.W  $072,$072,$073
 DC.W  $073,$074,$074,$075,$075,$076,$076,$077,$066,$055
 DC.W  $044,$033,$022
 DC.W  $011,$000,$000,$011,$022,$033,$044,$055,$066,$077,$177,$177,$277
 DC.W  $277,$377,$377,$477,$477,$577,$577,$677,$677,$777
 DC.W  $666,$555,$444,$333,$222,$111

 DS.W  4,$000

 ;**********

 DC.W  $111,$222,$333,$444
 DC.W  $555,$666,$777,$777,$667,$667,$557,$557,$447,$447,$337
 DC.W  $337,$227,$227,$117,$117,$007
 DC.W  $006,$005,$004,$003,$002,$001,$000,$000,$001,$002,$003,$004,$005
 DC.W  $006,$007,$107,$107,$207,$207,$307,$307,$407,$407
 DC.W  $507,$507,$607,$607,$707,$606
 DC.W  $505,$404,$303,$202,$101,$000,$000,$101,$202,$303,$404,$505,$606
 DC.W  $707,$706,$706,$705,$705,$704,$704,$703,$703,$702
 DC.W  $702,$701,$701,$700,$600,$500
 DC.W  $400,$300,$200,$100,$000,$000,$100,$200,$300,$400,$500,$600,$700
 DC.W  $710,$710,$720,$720,$730,$730,$740,$740,$750,$750
 DC.W  $760,$760,$770,$660,$550,$440
 DC.W  $330,$220,$110,$000,$000,$110,$220,$330,$440,$550,$660,$770,$670
 DC.W  $670,$570
 DC.W  $570,$470,$470,$370,$370,$270,$270,$170,$170,$070
 DC.W  $060,$050,$040,$030
 DC.W  $020,$010,$000,$000,$010,$020,$030,$040,$050,$060,$070,$071,$071
 DC.W  $072,$072,$073
 DC.W  $073,$074,$074,$075,$075,$076,$076,$077,$066,$055
 DC.W  $044,$033,$022
 DC.W  $011,$000,$000,$011,$022,$033,$044,$055,$066,$077,$177,$177,$277
 DC.W  $277,$377,$377,$477,$477,$577,$577,$677,$677,$777
 DC.W  $666,$555,$444,$333,$222,$111
 DS.W  4,$000
ROTS: DC.W 0
TXSTART:
 DC.B 'THIS DEMO WILL SOON BE FINISHED!!!!!!!...HOPEFULLY?'
 DC.B $FF
 ALIGN.W
SCR1=SCR+(160*197)
SCR2=SCR+(160*44)+80
SCR3=SCR+(160*150)+8
SCPEK: DC.L LINESTART
LINESTART:
 DC.L SCR1+480,SCR1+640,SCR1+800,SCR1+960
 DC.L SCR1+1120,SCR1+1280,SCR1+1440
 DC.L SCR1+1600,SCR1+1760,SCR1+1920
 DC.L SCR1+2080
 DC.L SCR1+2080
 DC.L SCR1+1920,SCR1+1760,SCR1+1600
 DC.L SCR1+1440,SCR1+1280,SCR1+1120
 DC.L SCR1+960,SCR1+800,SCR1+640,SCR1+480
LINESLUT: DC.L 0
R44CL:
 DC.W $020,$030,$040,$050,$060,$070,$070,$060,$050,$040,$030,$020
 DC.W $020,$030,$040,$050,$060,$070,$070,$060,$050,$040,$030,$020
COLTAB1:          ;* backround,foreground *
 DC.W $000,$001 ,$000,$002 ,$010,$003 ,$010,$004, $020,$005, $020,$006
 DC.W $030,$007 ,$030,$117 ,$040,$227 ,$040,$337, $050,$447, $050,$557
 DC.W $060,$667 ,$060,$777 ,$070,$766 ,$070,$755, $171,$744, $272,$733
 DC.W $373,$722 ,$474,$711 ,$575,$700 ,$676,$600, $777,$500, $767,$400
 DC.W $757,$300 ,$747,$200 ,$737,$100 ,$727,$000
 DC.W $717,$111 ,$707,$222 ,$606,$333 ,$606,$444, $505,$555, $505,$666
 DC.W $404,$777 ,$404,$677 ,$303,$577 ,$303,$477, $202,$377, $202,$277
 DC.W $101,$177 ,$101,$077 ,$000,$066 ,$000,$055,0,0,0,0,0,0,0,0,0,0
 ;COLTAB2 ALSO.
 DC.W $777,$776,$775,$774,$773,$772,$771,$770,$770
 DC.W $771,$772,$773
 DC.W $774,$775,$776,$777,$667,$557,$447,$337,$227,$117
 DC.W $007,$007,$007,$007,$117,$227,$337,$447,$557,$667,$777
 DC.W $777,$776,$775,$774,$773,$772,$771,$770,$770
 DC.W $771,$772,$773
 DC.W $774,$775,$776,$777,$667,$557,$447,$337,$227,$117
 DC.W $007,$007,$007,$007,$117,$227,$337,$447,$557,$667,$777
COLTAB2:
 DC.W $777,$776,$775,$774,$773,$772,$771,$770,$770
 DC.W $771,$772,$773
 DC.W $774,$775,$776,$777,$667,$557,$447,$337,$227,$117
 DC.W $007,$007,$007,$007,$117,$227,$337,$447,$557,$667,$777
 DC.W $777,$776,$775,$774,$773,$772,$771,$770,$770
 DC.W $771,$772,$773
 DC.W $774,$775,$776,$777,$667,$557,$447,$337,$227,$117
 DC.W $007,$007,$007,$007,$117,$227,$337,$447,$557,$667,$777
COLTAB3:
 DS.W 2,$000
 DC.W $777,$777,$766,$755,$744,$733,$722,$711,$700,$700,$700
 DC.W $611,$522,$433,$344,$255,$166,$077,$077,$077
 DC.W $167,$257,$347,$437,$527,$617,$707,$707,$707
 DS.W 16,$000
 DC.W $777,$667,$557,$446,$335,$335
 DC.W $224,$224,$113,$113,$002,$000,$001,$001,$002,$002
 DC.W $003,$003,$004,$004,$005,$005,$006,$006,$007
 DC.W $007,$007,$006,$006,$005,$005,$004,$004,$003,$003
 DC.W $002,$002,$001,$001,$000,$002,$113,$113,$224,$224
 DC.W $335,$335,$446,$557,$667,$777
 DS.W 28,$000
PAMC: IBYTES PACMAN.SPR
FONT: IBYTES FATFONT.DAT
PICT: IBYTES DEMO.ART
BALL: IBYTES BALL.SPR
MOON: IBYTES MOON.DAT
GURU: DS.B 1000 ;IBYTES CP_JAN.DAT
COKE: IBYTES COKE.DAT
LOGO: IBYTES LOGO2.DAT
MUSIC: IBYTES XEMUSIC.BIN
SSRR: DC.W 0
MFPMEM: DS.W 20
SAMPLE:
 DS.B 1000 ;IBYTES PUSH.SPL
SMPSLUT:
 END

