SCR=$78000
 BRA START

LOADER:
 MOVE.L #$15000,D0
 MOVE.L #$D000,-(SP)
 MOVE.W #0,-(SP)
 MOVE.W #$4A,-(SP)
 TRAP #1
 ADD.L #12,SP
 CLR.W $FF8240

 PEA DIR
 MOVE.W #$3B,-(SP)
 TRAP #1
 ADDQ.L #6,SP

 LEA RUT,A0
 LEA $76000,A1
 MOVE.W #100,D0
LOP:
 MOVE.L (A0)+,(A1)+
 DBRA D0,LOP
 JMP $76000
DIR:
 DC.B '\LEDSTORM._FF',0
 ALIGN.W
RUT:
 LEA $75000,A7
 MOVE.W #$007,$FF8240
 MOVE.W #$2,-(SP)
 PEA NAME
 MOVE.W #$3D,-(SP)
 TRAP #1
 ADDQ.L #8,SP
 MOVE.W D0,D7
 MOVE.L #$D000,-(SP)
 MOVE.L #$15000,-(SP)
 MOVE.W D7,-(SP)
 MOVE.W #$3F,-(SP)
 TRAP #1
 ADD.L #12,SP
 MOVE.W #$700,$FF8240
 MOVE.W D7,-(SP)
 MOVE.W #$3E,-(SP)
 TRAP #1
 ADDQ.L #4,SP
 MOVE.W #$070,$FF8240
TRAINPEK:   ;NOP OUT IF NO TRAINER
 BSR TRAIN
 JMP $D000
TRAIN:
 MOVE.L #$4E714E71,D0
 MOVE.L D0,$D000+$83F4
 MOVE.W D0,$D000+$83F8
 MOVE.L D0,$D000+$128
 MOVE.W D0,$D000+$12C
 MOVE.W #1,$D000+$770
 RTS
NAME:
 DC.B 'LED.DAT',0
 ALIGN.W

BUFF: DS.B 3000
START:
 CLR.L -(SP)
 MOVE.W #$20,-(SP)
 TRAP #1
 ADDQ.L #6,SP
 MOVE.L D0,SSP
 MOVE.W #0,-(SP)
 PEA SCR
 PEA SCR
 MOVE.W #5,-(SP)
 TRAP #14
 ADD.L #12,SP
 PEA STR1
 MOVE.W #1,-(SP)
 MOVE.W #25,-(SP)
 TRAP #14
 ADDQ.L #8,SP
; MOVE.W #6,-(SP)
; MOVE.W #26,-(SP)
; TRAP #14
; ADDQ.L #4,SP
 MOVE.W #5,-(SP)
 MOVE.W #26,-(SP)
 TRAP #14
 ADDQ.L #4,SP
 MOVE.W SR,SPAR5
 MOVE.W #$2700,SR
 MOVE.B $FF820A,SPAR4+3
 MOVE.L $70,SPAR1
 MOVE.L $68,SPAR2
 MOVE.L #RASTER2,$70
 MOVE.L #RASTER1,$68

 BSR MAKESCROLL

 LEA $FF8240,A0
 LEA OLPAL,A1
 MOVEQ #7,D0
 BSR COPY
 LEA PIC+2,A0
 LEA $FF8240,A1
 MOVEQ #7,D0
 BSR COPY

 LEA PIC+66,A0
 LEA SCR+32+(25*160),A1
 MOVE.W #(22000/4)-80,D0
 BSR COPY

 LEA SAMPLE,A2          ;PREPARE SAMPLE
AGAIN1:
 CMP.L #SAMPLESLUT,A2
 BEQ FINI
 MOVE.B (A2),D1
 AND.W #$00FF,D1        ;MASK OFF RUBBISH
 ADD.B #$80,D1          ;COMPLENT VALUE
 MOVE.B D1,(A2)+
 BRA AGAIN1
FINI:
 BSR SETSND

 LEA TEXTBUFF,A0   ;CONSTANTS
 LEA SCR,A1
 LEA SAMPLE,A5     ;SAMPLE
 LEA $FF8800,A4
 CLR.L D7
 LEA PACMAN+128,A2
 CLR.W D6
 LEA SCR+(159*160)+72,A6
 MOVE.W #30*50,D5  ;WAIT FOR PACMAN

 MOVE.W #$2100,SR
NOSTAR:
 CMP.B #02,$FFFC02
 BLO NOSTAR
 CMP.B #$80,$FFFC02
 BHI NOSTAR
 CMP.B #$14,$FFFC02
 BEQ EXIT

 MOVE.L #$4E714E71,TRAINPEK

EXIT:
 MOVE.W #$2700,SR
 MOVE.L SPAR1,$70
 MOVE.L SPAR2,$68

 MOVE.B SPAR4+3,$FF820A
 LEA OLPAL,A0
 LEA $FF8240,A1
 MOVEQ #7,D0
 BSR COPY

 MOVE.W SPAR5,SR

 MOVE.W #5,-(SP)
 MOVE.W #27,-(SP)
 TRAP #14
 ADDQ.L #4,SP

 PEA STR2
 MOVE.W #0,-(SP)
 MOVE.W #25,-(SP)
 TRAP #14
 ADDQ.L #8,SP

 LEA SCR,A0
 MOVE.W #7999,D0
CLS:
 CLR.L (A0)+
 DBRA D0,CLS

 JMP LOADER
COPY:
 MOVE.L (A0)+,(A1)+
 DBRA D0,COPY
 RTS
STR1: DC.B $1A,$12
STR2: DC.B $08,0
RASTER1:

 BSR SAMPLAY

 MOVE.W (A0)+,(A1)  ;DRAW SCROLLER
 ADD.W #160,A1

 MOVE.W (A2)+,D0    ;DRAW PACMAN
 CMP.W #-1,D0
 BEQ FINPAC
 MOVE.W D0,(A6)+
 MOVE.W D0,(A6)+
 MOVE.W D0,(A6)+
 MOVE.W D0,(A6)+
 MOVE.W (A2)+,D0
 MOVE.W D0,(A6)+
 MOVE.W D0,(A6)+
 MOVE.W D0,(A6)+
 MOVE.W D0,(A6)+
 ADD.W #144,A6

RSPEK:
 MOVE.W COLTAB,$FF8240
 ADDQ.L #2,RSPEK+2
 RTE
FINPAC:
 MOVE.L #HBL2,$68
PACPEK:
 MOVE.W PACTAB,D6
 BNE PAC2
 MOVE.L #PACTAB-2,PACPEK+2
 MOVE.W PACTAB,D6
PAC2:
 ADDQ.L #2,PACPEK+2

PACPEK2:
 MOVE.L PACAD,A2
 CMP.L #0,A2
 BNE PAC3
 MOVE.L #PACAD-4,PACPEK2+2
 MOVE.L PACAD,A2
PAC3:
 ADDQ.L #4,PACPEK2+2
 ADD.W D6,A2
 LEA SCR+(159*160)+72,A6
 RTE

HBL2:            ;ALTERNATIVE HBL
 JSR SAMPLAY

 MOVE.W (A0)+,(A1)  ;DRAW SCROLLER
 ADD.W #160,A1

 DS.W 45,$4E71
 BRA RSPEK

SAMPLAY:
 LEA SND_OUT,A3
 CLR.W D0
 MOVE.B (A5)+,D0
 LSL.W #3,D0
 ADD.W D0,A3
 MOVE.L (A3)+,D0
 MOVEP.L D0,0(A4)
 MOVE.W (A3),D0
 MOVEP.W D0,0(A4)
 RTS

RASTER2:  ;VBL
 MOVE.L #CTAB1,RSPEK+2
 MOVE.L #RASTER1,$68

 LEA TEXTBUFF,A0
 ADD.L D7,A0
 LEA SCR,A1

 CMP.L #COLTAB,RASTER2+2
 BNE RSTSK
 MOVE.L #CTAB1,RASTER2+2
RSTSK:
 SUBQ.L #2,RASTER2+2



BACK1:

 CMP.L #SAMPLESLUT,A5
 BLO NOPE
 LEA SAMPLE,A5   ;RESET SAMPLE
NOPE:
 ADDQ.L #2,D7
 CMP.L #(32*1000),D7
 BEQ YESS
 RTE
YESS:
 CLR.L D7
 RTE

SCREG=$FF8800
SCDATA=$FF8802
SETSND:
 MOVE.B #0,SCREG ;CHANNEL A
 MOVE.B #0,SCDATA
 MOVE.B #1,SCREG
 MOVE.B #0,SCDATA

 MOVE.B #2,SCREG ;CHANNEL B
 MOVE.B #0,SCDATA
 MOVE.B #3,SCREG
 MOVE.B #0,SCDATA

 MOVE.B #4,SCREG ;CHANNEL C
 MOVE.B #0,SCDATA
 MOVE.B #5,SCREG
 MOVE.B #0,SCDATA

 MOVE.B #7,SCREG ;SET UP CHANNEL MIXING & PORT 'A' I/O
 MOVE.B #$FF,SCDATA

 MOVE.B #8,SCREG ;SET ALL VOLUMES TO ZERO
 MOVE.B #0,SCDATA
 MOVE.B #9,SCREG
 MOVE.B #0,SCDATA
 MOVE.B #10,SCREG
 MOVE.B #0,SCDATA
 RTS

MAKESCROLL:
 LEA TEXTBUFF+32,A2
 LEA ASCCI,A1
MAKELOP:
 CLR.W D0
 MOVE.B (A1)+,D0
 BEQ MAKEFIN
 SUB.B #32,D0
 LSL.W #5,D0
 LEA FONT,A0
 ADD.W D0,A0
 MOVEM.L (A0)+,D0-D7
 MOVEM.L D0-D7,-(A2)
 ADD.W #64,A2
 BRA MAKELOP
MAKEFIN:
 RTS

SSP: DC.L 0
LINE: DC.W 0
ADDER: DC.W 0
SPAR1: DC.L 0
SPAR2: DC.L 0
SPAR3: DC.L 0
SPAR4: DC.L 0
SPAR5: DC.W 0
COLTAB:
 DC.W $400,$400,$400,$500,$500,$500,$600,$600,$600,$700,$700,$700,$600,$600,$600,$500,$500,$500,$400,$400,$400
 DC.W $040,$040,$040,$050,$050,$050,$060,$060,$060,$070,$070,$070,$060,$060,$060,$050,$050,$050,$040,$040,$040
 DC.W $440,$440,$440,$550,$550,$550,$660,$660,$660,$770,$770,$770,$660,$660,$660,$550,$550,$550,$440,$440,$440
 DC.W $044,$044,$044,$055,$055,$055,$066,$066,$066,$077,$077,$077,$066,$066,$066,$055,$055,$055,$044,$044,$044
 DC.W $404,$404,$404,$505,$505,$505,$606,$606,$606,$707,$707,$707,$606,$606,$606,$505,$505,$505,$404,$404,$404
 DC.W $004,$004,$004,$005,$005,$005,$006,$006,$006,$007,$007,$007,$006,$006,$006,$005,$005,$005,$004,$004,$004
CTAB1:
 DC.W $400,$400,$400,$500,$500,$500,$600,$600,$600,$700,$700,$700,$600,$600,$600,$500,$500,$500,$400,$400,$400
 DC.W $040,$040,$040,$050,$050,$050,$060,$060,$060,$070,$070,$070,$060,$060,$060,$050,$050,$050,$040,$040,$040
 DC.W $440,$440,$440,$550,$550,$550,$660,$660,$660,$770,$770,$770,$660,$660,$660,$550,$550,$550,$440,$440,$440
 DC.W $044,$044,$044,$055,$055,$055,$066,$066,$066,$077,$077,$077,$066,$066,$066,$055,$055,$055,$044,$044,$044
 DC.W $404,$404,$404,$505,$505,$505,$606,$606,$606,$707,$707,$707,$606,$606,$606,$505,$505,$505,$404,$404,$404
 DC.W $004,$004,$004,$005,$005,$005,$006,$006,$006,$007,$007,$007,$006,$006,$006,$005,$005,$005,$004,$004,$004
 DC.W $400,$400,$400,$500,$500,$500,$600,$600,$600,$700,$700,$700,$600,$600,$600,$500,$500,$500,$400,$400,$400
 DC.W $040,$040,$040,$050,$050,$050,$060,$060,$060,$070,$070,$070,$060,$060,$060,$050,$050,$050,$040,$040,$040
 DC.W $440,$440,$440,$550,$550,$550,$660,$660,$660,$770,$770,$770,$660,$660,$660,$550,$550,$550,$440,$440,$440
 DC.W $044,$044,$044,$055,$055,$055,$066,$066,$066,$077,$077,$077,$066,$066,$066,$055,$055,$055,$044,$044,$044
 DC.W $404,$404,$404,$505,$505,$505,$606,$606,$606,$707,$707,$707,$606,$606,$606,$505,$505,$505,$404,$404,$404
 DC.W $004,$004,$004,$005,$005,$005,$006,$006,$006,$007,$007,$007,$006,$006,$006,$005,$005,$005,$004,$004,$004
 DC.W $400,$400,$400,$500,$500,$500,$600,$600,$600,$700,$700,$700,$600,$600,$600,$500,$500,$500,$400,$400,$400
 DC.W $040,$040,$040,$050,$050,$050,$060,$060,$060,$070,$070,$070,$060,$060,$060,$050,$050,$050,$040,$040,$040
 DC.W $440,$440,$440,$550,$550,$550,$660,$660,$660,$770,$770,$770,$660,$660,$660,$550,$550,$550,$440,$440,$440
 DC.W $044,$044,$044,$055,$055,$055,$066,$066,$066,$077,$077,$077,$066,$066,$066,$055,$055,$055,$044,$044,$044
 DC.W $404,$404,$404,$505,$505,$505,$606,$606,$606,$707,$707,$707,$606,$606,$606,$505,$505,$505,$404,$404,$404
 DC.W $004,$004,$004,$005,$005,$005,$006,$006,$006,$007,$007,$007,$006,$006,$006,$005,$005,$005,$004,$004,$004

SND_OUT:
 dc.w $80c,$90b,$a09,0,$80c,$90b,$a09,0
 dc.w $80d,$908,$a08,0,$80b,$90b,$a0b,0
 dc.w $80d,$909,$a05,0,$80c,$90b,$a08,0
 dc.w $80d,$909,$a02,0,$80d,$908,$a06,0
 dc.w $80c,$90b,$a07,0,$80d,$907,$a07,0
 dc.w $80c,$90b,$a06,0,$80c,$90a,$a09,0
 dc.w $80b,$90b,$a0a,0,$80c,$90b,$a02,0
 dc.w $80c,$90b,$a00,0,$80c,$90a,$a08,0

 dc.w $80d,$906,$a04,0,$80d,$905,$a05,0
 dc.w $80d,$905,$a04,0,$80c,$909,$a09,0
 dc.w $80d,$904,$a03,0,$80b,$90b,$a09,0
 dc.w $80c,$90a,$a05,0,$80b,$90a,$a0a,0
 dc.w $80c,$909,$a08,0,$80b,$90b,$a08,0
 dc.w $80c,$90a,$a00,0,$80c,$90a,$a00,0
 dc.w $80c,$909,$a07,0,$80b,$90b,$a07,0
 dc.w $80c,$909,$a06,0,$80b,$90b,$a06,0

 dc.w $80b,$90a,$a09,0,$80b,$90b,$a05,0
 dc.w $80a,$90a,$a0a,0,$80b,$90b,$a02,0
 dc.w $80b,$90a,$a08,0,$80c,$907,$a07,0
 dc.w $80c,$908,$a04,0,$80c,$907,$a06,0
 dc.w $80b,$909,$a09,0,$80c,$906,$a06,0
 dc.w $80a,$90a,$a09,0,$80c,$907,$a03,0
 dc.w $80b,$90a,$a05,0,$80b,$909,$a08,0
 dc.w $80b,$90a,$a03,0,$80a,$90a,$a08,0

 dc.w $80b,$90a,$a00,0,$80b,$909,$a07,0
 dc.w $80b,$908,$a08,0,$80a,$90a,$a07,0
 dc.w $80a,$909,$a09,0,$80c,$901,$a01,0
 dc.w $80a,$90a,$a06,0,$80b,$908,$a07,0
 dc.w $80a,$90a,$a05,0,$80a,$909,$a08,0
 dc.w $80a,$90a,$a02,0,$80a,$90a,$a01,0
 dc.w $80a,$90a,$a00,0,$809,$909,$a09,0
 dc.w $80a,$908,$a08,0,$80b,$908,$a01,0

 dc.w $80a,$909,$a06,0,$80b,$907,$a04,0
 dc.w $80a,$909,$a05,0,$809,$909,$a08,0
 dc.w $80a,$909,$a03,0,$80a,$908,$a06,0
 dc.w $80a,$909,$a00,0,$809,$909,$a07,0
 dc.w $809,$908,$a08,0,$80a,$908,$a04,0
 dc.w $809,$909,$a06,0,$80a,$908,$a01,0
 dc.w $809,$909,$a05,0,$809,$908,$a07,0
 dc.w $808,$908,$a08,0,$809,$909,$a02,0

 dc.w $809,$908,$a06,0,$809,$909,$a00,0
 dc.w $809,$907,$a07,0,$808,$908,$a07,0
 dc.w $809,$907,$a06,0,$809,$908,$a02,0
 dc.w $808,$908,$a06,0,$809,$906,$a06,0
 dc.w $808,$907,$a07,0,$808,$908,$a04,0
 dc.w $808,$907,$a06,0,$808,$908,$a02,0
 dc.w $807,$907,$a07,0,$808,$906,$a06,0
 dc.w $808,$907,$a04,0,$807,$907,$a06,0

 dc.w $808,$906,$a05,0,$808,$906,$a04,0
 dc.w $807,$906,$a06,0,$807,$907,$a04,0
 dc.w $808,$905,$a04,0,$806,$906,$a06,0
 dc.w $807,$906,$a04,0,$807,$905,$a05,0
 dc.w $806,$906,$a05,0,$806,$906,$a04,0
 dc.w $806,$905,$a05,0,$806,$906,$a02,0
 dc.w $806,$905,$a04,0,$805,$905,$a05,0
 dc.w $806,$905,$a02,0,$805,$905,$a04,0

 dc.w $805,$904,$a04,0,$805,$905,$a02,0
 dc.w $804,$904,$a04,0,$804,$904,$a03,0
 dc.w $804,$904,$a02,0,$804,$903,$a03,0
 dc.w $803,$903,$a03,0,$803,$903,$a02,0
 dc.w $803,$902,$a02,0,$802,$902,$a02,0
 dc.w $802,$902,$a01,0,$801,$901,$a01,0
 dc.w $802,$901,$a00,0,$801,$901,$a00,0
 dc.w $801,$900,$a00,0,$800,$900,$a00,0

 dc.w $80e,$90d,$a0c,0,$80f,$903,$a00,0
 dc.w $80f,$903,$a00,0,$80f,$903,$a00,0
 dc.w $80f,$903,$a00,0,$80f,$903,$a00,0
 dc.w $80f,$903,$a00,0,$80e,$90d,$a0b,0
 dc.w $80e,$90d,$a0b,0,$80e,$90d,$a0b,0
 dc.w $80e,$90d,$a0b,0,$80e,$90d,$a0b,0
 dc.w $80e,$90d,$a0b,0,$80e,$90d,$a0b,0
 dc.w $80e,$90d,$a0a,0,$80e,$90d,$a0a,0

 dc.w $80e,$90d,$a0a,0,$80e,$90d,$a0a,0
 dc.w $80e,$90c,$a0c,0,$80e,$90d,$a00,0
 dc.w $80d,$90d,$a0d,0,$80d,$90d,$a0d,0
 dc.w $80d,$90d,$a0d,0,$80d,$90d,$a0d,0
 dc.w $80d,$90d,$a0d,0,$80d,$90d,$a0d,0
 dc.w $80e,$90c,$a0b,0,$80e,$90c,$a0b,0
 dc.w $80e,$90c,$a0b,0,$80e,$90c,$a0b,0
 dc.w $80e,$90c,$a0b,0,$80e,$90c,$a0b,0

 dc.w $80e,$90c,$a0b,0,$80e,$90c,$a0b,0
 dc.w $80e,$90c,$a0a,0,$80e,$90c,$a0a,0
 dc.w $80e,$90c,$a0a,0,$80e,$90c,$a0a,0
 dc.w $80d,$90d,$a0c,0,$80d,$90d,$a0c,0
 dc.w $80e,$90c,$a09,0,$80e,$90c,$a09,0
 dc.w $80e,$90c,$a05,0,$80e,$90c,$a00,0
 dc.w $80e,$90c,$a00,0,$80e,$90b,$a0b,0
 dc.w $80e,$90b,$a0b,0,$80e,$90b,$a0b,0

 dc.w $80e,$90b,$a0b,0,$80e,$90b,$a0a,0
 dc.w $80e,$90b,$a0a,0,$80e,$90b,$a0a,0
 dc.w $80d,$90d,$a0b,0,$80d,$90d,$a0b,0
 dc.w $80d,$90d,$a0b,0,$80e,$90b,$a09,0
 dc.w $80e,$90b,$a09,0,$80e,$90b,$a09,0
 dc.w $80d,$90c,$a0c,0,$80d,$90d,$a0a,0
 dc.w $80e,$90b,$a07,0,$80e,$90b,$a00,0
 dc.w $80e,$90b,$a00,0,$80d,$90d,$a09,0

 dc.w $80d,$90d,$a09,0,$80e,$90a,$a09,0
 dc.w $80d,$90d,$a08,0,$80d,$90d,$a07,0
 dc.w $80d,$90d,$a04,0,$80d,$90d,$a00,0
 dc.w $80e,$90a,$a04,0,$80e,$909,$a09,0
 dc.w $80e,$909,$a09,0,$80d,$90c,$a0b,0
 dc.w $80e,$909,$a08,0,$80e,$909,$a08,0
 dc.w $80e,$909,$a07,0,$80e,$908,$a08,0
 dc.w $80e,$909,$a01,0,$80c,$90c,$a0c,0

 dc.w $80d,$90c,$a0a,0,$80e,$908,$a06,0
 dc.w $80e,$907,$a07,0,$80e,$908,$a00,0
 dc.w $80e,$907,$a05,0,$80e,$906,$a06,0
 dc.w $80d,$90c,$a09,0,$80e,$905,$a05,0
 dc.w $80e,$904,$a04,0,$80d,$90c,$a08,0
 dc.w $80d,$90b,$a0b,0,$80e,$900,$a00,0
 dc.w $80d,$90c,$a06,0,$80d,$90c,$a05,0
 dc.w $80d,$90c,$a02,0,$80c,$90c,$a0b,0

 dc.w $80c,$90c,$a0b,0,$80d,$90b,$a0a,0
 dc.w $80d,$90b,$a0a,0,$80d,$90b,$a0a,0
 dc.w $80d,$90b,$a0a,0,$80c,$90c,$a0a,0
 dc.w $80c,$90c,$a0a,0,$80c,$90c,$a0a,0
 dc.w $80d,$90b,$a09,0,$80d,$90b,$a09,0
 dc.w $80d,$90a,$a0a,0,$80d,$90a,$a0a,0
 dc.w $80d,$90a,$a0a,0,$80c,$90c,$a09,0
 dc.w $80c,$90c,$a09,0,$80c,$90c,$a09,0

 dc.w $80d,$90b,$a06,0,$80c,$90b,$a0b,0
 dc.w $80c,$90c,$a08,0,$80d,$90b,$a00,0
 dc.w $80d,$90b,$a00,0,$80c,$90c,$a07,0
 dc.w $80c,$90c,$a06,0,$80c,$90c,$a05,0
 dc.w $80c,$90c,$a03,0,$80c,$90c,$a01,0
 dc.w $80c,$90b,$a0a,0,$80d,$90a,$a05,0
 dc.w $80d,$90a,$a04,0,$80d,$90a,$a02,0
 dc.w $80d,$909,$a08,0,$80d,$909,$a08,0

ASCCI:
 DC.B '             HI THERE...      FLEXIBLE FRONT BRINGS YOU LED STORM. PRESS T FOR TRAINER. THIS INTRO WAS CODED BY STALIN'
 DC.B ' WITH GRAPHICS BY EARTHLIGHT. SORRY THAT THIS INTRO IS A BIT BORING BUT WE HAVE SOOO LITTLE TIME AT THE MOMENT FOR'
 DC.B ' WRITING NEW STUFF. WE ARE WORKING ON A NEW DEMO BUT NOONE KNOWS WHEN IT WILL BE FINISHED, PROBABLY NOT UNTIL AUGUST-89'
 DC.B ' AT THE EARLIEST. (WE SAID THAT WE HAD LITTLE TIME!) THIS GAME IS FUN, DONT USE THE TRAINER UNLESS YOU HAVE TO, BECAUSE'
 DC.B ' IT REALLY SPOILS THE GAME. OK, NO MORE TIME FOR WRITING SCROLLTEXT, GREETINGS TIME.'
 DC.B ' GREETINGS TO: TEX, TCB, REPLICANTS+REST OF UNION, THE BLADE RUNNERS, WAS(NOT WAS), MCA, BEAR OF BLOCKBUSTERS'
 DC.B ', LIGHT TEAM, SYNC, OMEGA. '
 DC.B '            NO MORE TEXT.      OH, IF YOURE INTO SYNTH MUSIC, THEN DONT HESITATE TO BUY FRONT LINE ASSEMBLYS NEW MAXI'
 DC.B ' SIINGLE: DIGITAL TENSION DEMENTIA.          LOOK OUT FOR OUR DEMO, WE WILL TRY TO FINISH IT!'
 DC.B '           TCB, ARE YOU STILL PLANNING A COPY PARTY IN STOCKHOLM? WE HOPE SO!                       '
 DC.B 0
ASCCIFIN:
 ALIGN.W

PACTAB:
 DS.W 50,124
 DC.W 124,124,120,120,116,116,112,112,108,108,104,104,100,100,96,96
 DC.W 92,92,88,88,84,84,80,80,76,76,72,72,68,68,64,64,60,60,56,56,52,52,48,48
 DC.W 44,44,40,40,36,36,32,32,28,28,24,24,20,20,16,16,12,12,8,8,4,4

 DS.W 50,4

 DC.W 4,4,8,8,12,12,16,16,20,20,24,24,28,28,32,32,36,36,40,40,44,44,48,48,52,52,56,56
 DC.W 60,60,64,64,68,68,72,72,76,76,80,80,84,84,88,88,92,92,96,96,100,100,104,104,108,112,112
 DC.W 116,116,120,120,124,124,0

PACAD:
 DC.L PACMAN+4,PACMAN+4,PACMAN+132,PACMAN+132,PACMAN+260,PACMAN+260
 DC.L PACMAN+388,PACMAN+388,PACMAN+516,PACMAN+516
 DC.L PACMAN+388,PACMAN+388,PACMAN+260,PACMAN+260,PACMAN+132,PACMAN+132
 DC.L 0

OLPAL:
 DS.W 16
FONT:
 IBYTES SMALLFNT.DAT
PACMAN:
 IBYTES PACMAN.DAT
 DC.W $FFFF
PIC:
 IBYTES FLEXBEST.PI1,22000

SAMPLE:
 IBYTES BODYC.SPL
SAMPLESLUT:
TEXTBUFF:
 END

