 TEXT
 MOVE.L A7,A5
 MOVE.L 4(A5),A5
 MOVE.L $C(A5),D0
 ADD.L $14(A5),D0
 ADD.L $1C(A5),D0
 ADD.L #$500,D0
 MOVE.L D0,D1
 ADD.L A5,D1
 AND.L #-2,D1
 MOVE.L D1,A7
 MOVE.L D0,-(SP)
 MOVE.L A5,-(SP)
 CLR.W -(SP)
 MOVE.W #$4A,-(SP)
 TRAP #1
 ADD.L #12,SP

 PEA FDTA
 MOVE.W #$1A,-(SP)
 TRAP #1
 ADDQ.L #6,SP

 LEA INRTX,A0
 BSR PRLN
AGAIN:
 LEA MPRG,A0
 BSR DIR
 LEA MTOS,A0
 BSR DIR
 LEA MTTP,A0
 BSR DIR
 LEA RETU,A0
 BSR PRLN
 LEA INBF,A0
 BSR RDLN
 CMP.B #'*',INBF+2
 BEQ AGAIN
 LEA INBF+2,A0
 BSR EXEC
 MOVE.W #7,-(SP)
 TRAP #1
 ADDQ.L #2,SP
 CLR.W -(SP)
 TRAP #1
DIR:
 CLR.B TABF
 CLR.W FINR
 MOVE.W #7,-(SP)
 MOVE.L A0,-(SP)
 MOVE.W #$4E,-(SP)
 TRAP #1
 ADDQ.L #8,SP
 TST.W D0
 BNE NOFI
 BSR PRFI
DMORE:
 MOVE.W #$4F,-(SP)
 TRAP #1
 ADDQ.L #2,SP
 TST.L D0
 BNE NOFI
 ADDQ.W #1,FINR
 BSR PRFI
 BRA DMORE
NOFI:
 LEA RETU,A0
 BSR PRLN
 RTS
PRFI:
 TST.B TABF
 BEQ PRF3
 LEA TABB,A0
 BSR PRLN
 CLR.B TABF
 LEA FDTA+30,A0
 BRA PRF2
PRF3:
 LEA RETU,A0
 BSR PRLN
 ST TABF
 LEA FDTA+30,A0
PRF2:
 CLR.W D0
 MOVE.B (A0)+,D0
 TST.B D0
 BEQ PFI1
 BSR CNOUT
 BRA PRF2
PFI1:
 RTS
EXEC:
 PEA NULL
 PEA NULL
 MOVE.L A0,-(SP)
 MOVE.W #0,-(SP)
 MOVE.W #$4B,-(SP)
 TRAP #1
 ADD.L #16,SP
 RTS
PRLN:
 MOVE.L A0,-(SP)
 MOVE.W #$09,-(SP)
 TRAP #1
 ADDQ.L #6,SP
 RTS
RDLN:
 MOVE.L A0,-(SP)
 MOVE.W #$0A,-(SP)
 TRAP #1
 ADDQ.L #6,SP
 RTS
CNOUT:
 MOVEM.L D1-D7/A0-A6,-(SP)
 MOVE.W D0,-(SP)
 MOVE.W #2,-(SP)
 TRAP #1
 ADDQ.L #4,SP
 MOVEM.L (SP)+,D1-D7/A0-A6
 RTS

 DATA
INRTX:
 DC.B 27,'Y',32,32,'ZZAP-DOS Version 0.50  24/7-1988',13,10
 DC.B 'Written by STalin of ZZAP GAMES.',13,10,0
 ALIGN.W
MPRG:
 DC.B '*.PRG',0
MTOS:
 DC.B '*.TOS',0
MTTP:
 DC.B '*.TTP',0
 ALIGN.W
FINR:
 DC.W 0
RETU:
 DC.B 10,13,0,0
TABB:
 DC.B 9,16,0,0
TABF:
 DC.W 0
INBF:
 DC.B 20,0
 DS.B 20

 BSS
NULL:
 DC.W 0
FDTA:
 DS.B 100*44
 END

