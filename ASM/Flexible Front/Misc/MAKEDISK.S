; SWITCH DISK!!!!
 LEA CODE,A0
 MOVE.W #19999,D0
DCRY:
 EOR.L #'ZZAP',(A0)+
 DBRA D0,DCRY
 BRA NEXT
 DS.B 3000
NEXT:
 MOVE.W #9,-(SP)
 CLR.W -(SP)
 MOVE.W TRACK,-(SP)
 MOVE.W #1,-(SP)
 MOVE.W #0,-(SP)
 CLR.L -(SP)
 MOVE.L BUFFER,-(SP)
 MOVE.W #9,-(SP)
 TRAP #14
 ADD.L #20,SP
 ADD.L #5120-512,BUFFER
 ADDQ.W #1,TRACK
 CMP.W #21,TRACK
 BEQ EXIT
 BRA NEXT
EXIT:
 ILLEGAL
BUFFER: DC.L CODE
TRACK: DC.W 1
CODE:
 IBYTES ZDEMO3.B
 END

