 MOVE.L A7,A5         ;SETBLOCK
 LEA NEWSTACK(PC),A7
 MOVE.L 4(A5),A5
 MOVE.L $C(A5),D0
 ADD.L #$100,D0
 MOVE.L D0,-(SP)
 MOVE.L A5,-(SP)
 CLR.W -(SP)
 MOVE.W #$4A,-(SP)
 TRAP #1
 ADD.L #12,SP


MAINMENU:          ;MAIN LOOP
 PEA NUL(PC)       ;EXECUTE MAINMENU
 PEA NUL(PC)
 PEA MAINFILE(PC)
 CLR.W -(SP)
 MOVE.W #$4B,-(SP)
 TRAP #1
 ADD.L #16,SP

 MOVE.W D0,-(SP)
 BSR KILLSOUND
 MOVE.W (SP)+,D0

 BSR EXECUTE       ;SCREEN NO IN D0
 BSR KILLSOUND
 BRA MAINMENU



EXECUTE:
 MOVEQ #0,D1
 MOVE.B D0,D1
 LSL.W #4,D1
; ADD.W D1,A0
 LEA FILES(PC,D1.W),A0
 PEA NUL            ;LOAD & EXECUTE
 PEA NUL
 PEA (A0)
 CLR.W -(SP)
 MOVE.W #$4B,-(SP)
 TRAP #1
 ADD.L #16,SP
 RTS

KILLSOUND:
 PEA OFF(PC)
 MOVE.W #32,-(SP)
 TRAP #14
 ADDQ.L #6,SP
 RTS

OFF:
 DC.B 8,0,9,0,10,0,$FF,0

NUL: DC.W 0
MAINFILE:
 DC.B 'MAINMENU._FF',0
 ALIGN.W
FILES:
 DC.B 'SCRSCROL._FF',0,'   '
 DC.B 'MEGAFF._FF',0,'     '
 DC.B 'FLEXSCR._FF',0,'    '
 DC.B 'NEWLIFE._FF',0,'    '
 ALIGN.W

 DS.L 50,0
NEWSTACK:
 END

