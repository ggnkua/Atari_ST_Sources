 MOVE.L A7,A5
 MOVE.L 4(A5),A5
 MOVE.L $C(A5),D0
 ADD.L $14(A5),D0
 ADD.L $1C(A5),D0
 ADD.L #$500+6000,D0

 MOVE.L D0,D1
 ADD.L A5,D1
 AND.L #-2,D1
 MOVE.L D1,A7
 MOVE.L D0,-(SP)
 MOVE.L A5,-(SP)
 CLR.W -(SP)
 MOVE.W #$4A,-(SP)
 TRAP #1
 ADD.L #12,SP
SCR=$76000
 JMP START
START:
 MOVE.W #0,-(SP)
 PEA SCR
 PEA SCR
 MOVE.W #5,-(SP)
 TRAP #14
 ADD.L #12,SP
 PEA STRI
 MOVE.W #0,-(SP)
 MOVE.W #25,-(SP)
 TRAP #14
 ADDQ.L #8,SP
 PEA START1
 MOVE.W #38,-(SP)
 TRAP #14
 ADDQ.L #6,SP
EXIT:
 PEA STOPP
 MOVE.W #38,-(SP)
 TRAP #14
 ADDQ.L #6,SP
 PEA COME
 PEA COME
 PEA PROG
 MOVE.W #0,-(SP)
 MOVE.W #$4B,-(SP)
 TRAP #1
 ADD.L #16,SP

 ILLEGAL
CALP:
 MOVEQ #7,D0
CAL1:
 MOVE.L (A0)+,(A1)+
 DBRA D0,CAL1
 RTS
START1:
 LEA $FF8240,A0
 LEA OLPAL,A1
 BSR CALP
 MOVE.L $70,SPAR1
 MOVE.L #RASTER,$70
MAIN:
 JSR SCROL1
 LEA SCR,A1
 JSR DUMP1
 CMP.B #$39,$FFFC02
 BNE MAIN
 RTS
STOPP:
 MOVE.L SPAR1,$70
 RTS
RASTER:
 MOVEM.L A0-A6/D0-D7,-(SP)
 ADDQ.W #1,VCLOC
SLUT:
 MOVEM.L (SP)+,A0-A6/D0-D7
 RTE
SCROL1:
 MOVE.W #1,D1
 CMP.W #8,D1
 BNE SCIP3
 CLR.W D0
TXPEK:
 MOVE.B TXSTART,D0
 ADDQ.L #1,TXPEK+2
 CMP.B #$FF,D0
 BNE SCIP2
 ST D6
 RTS
SCIP2:
 SUB.B #32,D0
 LSL.W #7,D0
 LEA FONT,A0
 ADD.L D0,A0
 LEA BUFF+160,A1
 MOVEQ #15,D0
LLOP6:
 MOVE.W (A0)+,(A1)
 MOVE.W (A0)+,8(A1)
 ADD.W #160+16,A1
 MOVE.W (A0)+,(A1)
 MOVE.W (A0)+,8(A1)
 ADD.W #160+16,A1
 DBRA D0,LLOP6
 CLR.W D1
SCIP3:
 ADDQ.W #1,D1
 MOVE.W D1,SCROL1+2
 LEA BUFF+168,A0
 MOVEQ #31,D1
LOP4:
 MOVEQ #3,D0
LLOP2:
 MOVE #0,CCR
 ROXL.W (A0)
 ROXL.W -8(A0)
 ROXL.W -16(A0)
 ROXL.W -24(A0)
 ROXL.W -32(A0)
 ROXL.W -40(A0)
 ROXL.W -48(A0)
 ROXL.W -56(A0)
 ROXL.W -64(A0)
 ROXL.W -72(A0)
 ROXL.W -80(A0)
 ROXL.W -88(A0)
 ROXL.W -96(A0)
 ROXL.W -104(A0)
 ROXL.W -112(A0)
 ROXL.W -120(A0)
 ROXL.W -128(A0)
 ROXL.W -136(A0)
 ROXL.W -144(A0)
 ROXL.W -152(A0)
 ROXL.W -160(A0)
 ROXL.W -168(A0)
 DBRA D0,LLOP2
 ADD.L #176,A0
 DBRA D1,LOP4
 CLR.B D6
 RTS
SYNC:
 MOVE.W VCLOC,D0
SYNC1:
 CMP.W VCLOC,D0
 BEQ SYNC1
 RTS
DUMP1:
 BSR SYNC
 LEA BUFF,A0
 MOVE.W #31,D0
LOP5:
 MOVE.W #1,D1
LOP7:
 MOVE.W (A0),(A1)
 MOVE.W 8(A0),8(A1)
 MOVE.W 16(A0),16(A1)
 MOVE.W 24(A0),24(A1)
 MOVE.W 32(A0),32(A1)
 MOVE.W 40(A0),40(A1)
 MOVE.W 48(A0),48(A1)
 MOVE.W 56(A0),56(A1)
 MOVE.W 64(A0),64(A1)
 MOVE.W 72(A0),72(A1)
 ADD.W #80,A0
 ADD.W #80,A1
 DBRA D1,LOP7
 ADD.W #16,A0
 DBRA D0,LOP5
 RTS
PROG:
 DC.B 'BOOT.PRG',0
 ALIGN.W
COME:
 DC.W 0
OLPAL: DS.W 16
SPAR1: DC.L 0
STRI: DC.B $12,0
TXSTART:
 DC.B 'ZZAPGAMES PRESENTS BIONIC COMMANDOS. CRACKED BY STALIN 28/7-88.'
 DC.B 'HAVE YOU SEEN OUR NEW DEMOS? THE LAZER DEMO AND DEMO3. IF NOT '
 DC.B "TRY TO GET A COPY AS SOON AS POSSIBLE! THIS GAME WAS SO EASY TO CRACK, THAT I ALMOST FEEL ASHAMED. "
 DC.B 'STILL, IT GIVES ME THE OPPURTI'
 DC.B ' PRESS SPACE TO CONTINUE...........'
 DC.B $FF
 ALIGN.W
IKBW: DC.B $12,$15, 8,0
VCLOC: DC.W 0
SPAR: DS.L 10
FONT: IBYTES FONT1.DAT
BUFF:
 END

