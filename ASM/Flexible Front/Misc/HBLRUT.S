SCR=$78000
 CLR.L -(SP)
 MOVE.W #$20,-(SP)
 TRAP #1
 ADDQ.L #6,SP
 MOVE.L D0,SSP
 MOVE.W #0,-(SP)
 PEA SCR
 PEA SCR
 MOVE.W #5,-(SP)
 TRAP #14
 ADD.L #12,SP
 PEA STR1
 MOVE.W #1,-(SP)
 MOVE.W #25,-(SP)
 TRAP #14
 ADDQ.L #8,SP
 MOVE.W #6,-(SP)
 MOVE.W #26,-(SP)
 TRAP #14
 ADDQ.L #4,SP
 MOVE.W #5,-(SP)
 MOVE.W #26,-(SP)
 TRAP #14
 ADDQ.L #4,SP
 MOVE.W SR,SPAR5
 MOVE.B $FF820A,SPAR4+3
 MOVE.L $70,SPAR1
 MOVE.L $68,SPAR2
 MOVE.L #RASTER2,$70
 MOVE.L #RASTER1,$68
 MOVE.W #$8240,A0
 LEA OLPAL+32,A1
 MOVEM.L (A0)+,D0-D7
 MOVEM.L D0-D7,-(A1)
 MOVE.W #$2100,SR
 MOVE.W #$777,$FF8242
 BSR PRNT
 BSR MKANI
NOSTAR:
 BSR ANIM2
 BSR ANIM1
 CMP.B #$66,$FFFC02
 BNE NOSTAR
EXIT:
 MOVE.W #$2700,SR
 MOVE.L SPAR1,$70
 MOVE.L SPAR2,$68
 MOVE.B SPAR4+3,$FF820A
 MOVE.W #5,-(SP)
 MOVE.W #27,-(SP)
 TRAP #14
 ADDQ.L #4,SP
 MOVE.W #1,-(SP)
 PEA $78000
 PEA $78000
 MOVE.W #5,-(SP)
 TRAP #14
 ADD.L #12,SP
 PEA STR2
 MOVE.W #0,-(SP)
 MOVE.W #25,-(SP)
 TRAP #14
 ADDQ.L #8,SP
 MOVE.W #6,-(SP)
 MOVE.W #27,-(SP)
 TRAP #14
 ADDQ.L #4,SP
 MOVE.W #$8240+32,A0
 LEA OLPAL,A1
 MOVEM.L (A1)+,D0-D7
 MOVEM.L D0-D7,-(A0)
 MOVE.W SPAR5,SR
 MOVE.L SSP,-(SP)
 MOVE.W #$20,-(SP)
 TRAP #1
 ADDQ.L #6,SP
 ILLEGAL
STR1: DC.B $1A,$12
STR2: DC.B $08,0
ANIM1:
 LEA TXBUF,A0
 MOVEQ #5,D7
AN1L:
 BSR SYNC
 BSR BLIT
 DBRA D7,AN1L
 RTS
ANIM2:
 LEA TXBUF+4*(16*40),A0
 MOVEQ #3,D7
AN2L:
 BSR SYNC
 BSR BLIT
 SUB.W #(16*40)*2,A0
 DBRA D7,AN2L
 RTS
KEYS:
 CLR.B $FFFC02
KEY1:
 CMP.B #$39,$FFFC02
 BNE KEY1
 RTS
RASTER1:
 MOVE.L D0,-(SP)
 MOVEQ #27,D0
RSLP:
 DBRA D0,RSLP
 MOVE.L (SP)+,D0
RSPEK:
 MOVE.W COLTAB,$FF8240
 ADDQ.L #2,RSPEK+2
 RTE
RASTER2:
 MOVE.L #CTAB1,RSPEK+2
 CMP.L #COLTAB,RASTER2+2
 BNE RSTSK
 MOVE.L #CTAB1,RASTER2+2
RSTSK:
 SUBQ.L #2,RASTER2+2
 CLR.W LINE
 CMP.B #$66,$FFFC02
 BEQ EXIT
 ADDQ.W #1,VBLCL
 RTE
SPRT:  ;A0=GRAPHICS A1=SCREEN D1=X-CORD
 LEA FONT+(32*20),A0
 LEA SCR,A1
 MOVE.W D1,D3
 AND.B #%00001111,D3
 AND.B #%11110000,D1
 LSR.W #1,D1
 ADD.W D1,A1
 MOVEQ #15,D2
SPRLOP:
 CLR.L D0
 MOVE.W (A0)+,D0
 SWAP D0
 LSR.L D3,D0
 MOVE.W #0,-8(A1)
 MOVE.W D0,8(A1)
 SWAP D0
 MOVE.W D0,(A1)
 MOVE.W #0,16(A1)
 ADD.W #160,A1
 DBRA D2,SPRLOP
 RTS
SYNC:
 MOVE.W VBLCL,D0
SYN1:
 CMP.W VBLCL,D0
 BEQ SYN1
 RTS
PRNT:
 LEA TXTS,A0
 LEA TXBUF,A2
LPRT2:
 LEA FONT,A1
 CLR.W D0
 MOVE.B (A0)+,D0
 TST.B D0
 BEQ LPRT3
 SUB.B #32,D0
 LSL.W #5,D0
 ADD.W D0,A1
 MOVE.L A2,A3
 MOVEQ #15,D0
LPRT1:
 MOVE.W (A1),(A3)
 MOVE.W (A1),640(A3)
 MOVE.W (A1),640*2(A3)
 MOVE.W (A1),640*3(A3)
 MOVE.W (A1),640*4(A3)
 MOVE.W (A1),640*5(A3)
 MOVE.W (A1),640*6(A3)
 MOVE.W (A1)+,640*7(A3)
 ADD.W #40,A3
 DBRA D0,LPRT1
 ADDQ.W #2,A2
 BRA LPRT2
LPRT3:
 RTS
SCRLR:
 MOVE.L A1,A0
 MOVEQ #19,D0
SCRR:
 ROXR.W (A0)+
 DBRA D0,SCRR
 DBRA D1,SCRLR
 RTS
SCRLL:
 MOVE.L A1,A0
 ADD.W #40,A0
 MOVEQ #19,D0
SCRL:
 ROXL.W -(A0)
 DBRA D0,SCRL
 DBRA D1,SCRLL
 RTS
BLIT:
 LEA SCR+(170*160),A1
 MOVE.W #79,D0
BLT1:
 MOVE.W (A0)+,(A1)
 ADDQ.W #8,A1
 MOVE.W (A0)+,(A1)
 ADDQ.W #8,A1
 MOVE.W (A0)+,(A1)
 ADDQ.W #8,A1
 MOVE.W (A0)+,(A1)
 ADDQ.W #8,A1
 DBRA D0,BLT1
 RTS
MKANI:
 LEA TXBUF,A1
 LEA SCAN1,A6
 BSR MKSUB
 LEA SCAN2,A6
 BSR MKSUB
 LEA SCAN3,A6
 BSR MKSUB
 LEA SCAN4,A6
 BSR MKSUB
 LEA SCAN6,A6
 BSR MKSUB
 LEA SCAN7,A6
 BSR MKSUB
 RTS
MKSUB:
 MOVE.L A6,A2
 MOVE.W #15,D2
MK4:
 CLR.W D1
 MOVE.B (A2)+,D1
 CMP.B #$FF,D1
 BNE MK1
 MOVE.L A6,A2
 MOVE.B (A2)+,D1
MK1:
 TST.B D1
 BEQ MK3
 BTST #7,D1
 BEQ MK2
 BCLR #7,D1
 SUBQ.W #1,D1
 BSR SCRLL
 BRA MK3
MK2:
 SUBQ.W #1,D1
 BSR SCRLR
MK3:
 ADD.W #40,A1
 DBRA D2,MK4
 RTS
TXTS:
 DC.B ' **** ROBOCOP **** ',0
 ALIGN.W
FONT:
 IBYTES SMALLFNT.DAT
COLTAB:
 DC.W $400,$400,$400,$500,$500,$500,$600,$600,$600,$700,$700,$700,$600,$600,$600,$500,$500,$500,$400,$400,$400
 DC.W $040,$040,$040,$050,$050,$050,$060,$060,$060,$070,$070,$070,$060,$060,$060,$050,$050,$050,$040,$040,$040
 DC.W $440,$440,$440,$550,$550,$550,$660,$660,$660,$770,$770,$770,$660,$660,$660,$550,$550,$550,$440,$440,$440
 DC.W $044,$044,$044,$055,$055,$055,$066,$066,$066,$077,$077,$077,$066,$066,$066,$055,$055,$055,$044,$044,$044
 DC.W $404,$404,$404,$505,$505,$505,$606,$606,$606,$707,$707,$707,$606,$606,$606,$505,$505,$505,$404,$404,$404
 DC.W $004,$004,$004,$005,$005,$005,$006,$006,$006,$007,$007,$007,$006,$006,$006,$005,$005,$005,$004,$004,$004
CTAB1:
 DC.W $400,$400,$400,$500,$500,$500,$600,$600,$600,$700,$700,$700,$600,$600,$600,$500,$500,$500,$400,$400,$400
 DC.W $040,$040,$040,$050,$050,$050,$060,$060,$060,$070,$070,$070,$060,$060,$060,$050,$050,$050,$040,$040,$040
 DC.W $440,$440,$440,$550,$550,$550,$660,$660,$660,$770,$770,$770,$660,$660,$660,$550,$550,$550,$440,$440,$440
 DC.W $044,$044,$044,$055,$055,$055,$066,$066,$066,$077,$077,$077,$066,$066,$066,$055,$055,$055,$044,$044,$044
 DC.W $404,$404,$404,$505,$505,$505,$606,$606,$606,$707,$707,$707,$606,$606,$606,$505,$505,$505,$404,$404,$404
 DC.W $004,$004,$004,$005,$005,$005,$006,$006,$006,$007,$007,$007,$006,$006,$006,$005,$005,$005,$004,$004,$004
 DC.W $400,$400,$400,$500,$500,$500,$600,$600,$600,$700,$700,$700,$600,$600,$600,$500,$500,$500,$400,$400,$400
 DC.W $040,$040,$040,$050,$050,$050,$060,$060,$060,$070,$070,$070,$060,$060,$060,$050,$050,$050,$040,$040,$040
 DC.W $440,$440,$440,$550,$550,$550,$660,$660,$660,$770,$770,$770,$660,$660,$660,$550,$550,$550,$440,$440,$440
 DC.W $044,$044,$044,$055,$055,$055,$066,$066,$066,$077,$077,$077,$066,$066,$066,$055,$055,$055,$044,$044,$044
 DC.W $404,$404,$404,$505,$505,$505,$606,$606,$606,$707,$707,$707,$606,$606,$606,$505,$505,$505,$404,$404,$404
 DC.W $004,$004,$004,$005,$005,$005,$006,$006,$006,$007,$007,$007,$006,$006,$006,$005,$005,$005,$004,$004,$004
 DC.W $400,$400,$400,$500,$500,$500,$600,$600,$600,$700,$700,$700,$600,$600,$600,$500,$500,$500,$400,$400,$400
 DC.W $040,$040,$040,$050,$050,$050,$060,$060,$060,$070,$070,$070,$060,$060,$060,$050,$050,$050,$040,$040,$040
 DC.W $440,$440,$440,$550,$550,$550,$660,$660,$660,$770,$770,$770,$660,$660,$660,$550,$550,$550,$440,$440,$440
 DC.W $044,$044,$044,$055,$055,$055,$066,$066,$066,$077,$077,$077,$066,$066,$066,$055,$055,$055,$044,$044,$044
 DC.W $404,$404,$404,$505,$505,$505,$606,$606,$606,$707,$707,$707,$606,$606,$606,$505,$505,$505,$404,$404,$404
 DC.W $004,$004,$004,$005,$005,$005,$006,$006,$006,$007,$007,$007,$006,$006,$006,$005,$005,$005,$004,$004,$004
I=128
SCAN1:
 DC.B 1,3,4,5,5,5,5,4,3,1,1+I,3+I,4+I,5+I,5+I,5+I,5+I,4+I,3+I,1+I,$FF
SCAN2:
 DC.B 1,2,2,3,3,3,3,2,2,1,1+I,2+I,2+I,3+I,3+I,3+I,3+I,2+I,2+I,1+I,$FF
SCAN3:
 DC.B 0,0,1,1,1,1,1,1,0,0,0,0,1+I,1+I,1+I,1+I,1+I,1+I,0,0,$FF
SCAN4:
 DC.B 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,$FF
SCAN5:
 DC.B 0,0,1+I,1+I,1+I,1+I,1+I,1+I,0,0,0,0,1,1,1,1,1,1,0,0,0,0,$FF
SCAN6:
 DC.B 1+I,2+I,2+I,3+I,3+I,3+I,3+I,2+I,2+I,1+I,1,2,2,3,3,3,3,2,2,1,$FF
SCAN7:
 DC.B 1+I,3+I,4+I,5+I,5+I,5+I,5+I,4+I,3+I,1+I,1,3,4,5,5,5,5,4,3,1,$FF
 ALIGN.W
SSP: DC.L 0
LINE: DC.W 0
ADDER: DC.W 0
SPAR1: DC.L 0
SPAR2: DC.L 0
SPAR3: DC.L 0
SPAR4: DC.L 0
SPAR5: DC.W 0
VBLCL: DC.W 0
OLPAL: DS.W 16
TXBUF: DS.B (16*40)*8
 END

