SCR=$78000
SCR1=SCR ;-32000

 BRA MAIN
GRAF: DS.W 5000,%1111000000001111

MAIN:
 BSR STARTUP
 BSR PREGRAF
 BSR INITRAST

 MOVE.W #$2300,SR
NOTYET:
 CMP.B #$39,$FFFC02
 BNE NOTYET

 BSR RESETT

 ILLEGAL


VBL:
 CLR.W $FF8240

 CLR.B $FFFA1B
 MOVEQ #1,D0
 MOVE.B D0,$FFFA21
 MOVE.B #8,$FFFA1B
 LEA COLTAB,A5

 MOVE.L SCREEN,D0
 MOVE.L SCREEN1,D1
 EXG.L D0,D1
 MOVE.L D0,SCREEN
 MOVE.L D1,SCREEN1
 MOVE.L D0,A6       ;SCREEN TO PRINT ON

 BSR WOBRUT
 BSR SCROLL

 BSR MUSIC+246

; MOVE.L #VBL1,$70
 MOVE.W #$777,$FF8240
 RTE

VBL1:
 CLR.B $FFFA1B
 MOVEQ #1,D0
 MOVE.B D0,$FFFA21
 MOVE.B #8,$FFFA1B
 LEA COLTAB,A5
 MOVE.L #VBL,$70
 RTE

UPDAT:
 CMP.L #WOBEND-162,PEK1+2
 BNE UPDAT1
 MOVE.L #WOBTAB-2,PEK1+2
UPDAT1:
 ADDQ.L #2,PEK1+2

 CMP.L #WOBEND1-256,PEK2+2
 BNE UPDAT2
 MOVE.L #SIDEWOB-4,PEK2+2
UPDAT2:
 ADDQ.L #4,PEK2+2

 MOVE.B SCREEN+1,$FF8201
 MOVE.B SCREEN+2,$FF8203
 RTS


SCROLL:
 MOVE.W #160*4,D1
 LEA 6(A6),A1
 LEA SCBUF,A0
 MOVEQ #31,D0
SCLOP:
 MOVEM.L (A0)+,D2-D5
 MOVE.W D2,8(A1)
 SWAP D2
 MOVE.W D2,(A1)
 MOVE.W D3,168(A1)
 SWAP D3
 MOVE.W D3,160(A1)
 MOVE.W D4,328(A1)
 SWAP D4
 MOVE.W D4,320(A1)
 MOVE.W D5,488(A1)
 SWAP D5
 MOVE.W D5,480(A1)
 ADD.W D1,A1
 DBRA D0,SCLOP
 RTS

WOBRUT:
 BSR SETLINE
 MOVEQ #0,D2
 MOVEQ #24,D0
PEK1:
 MOVE.L #WOBTAB,A2
 LEA GRAF,A0

 MOVEQ #11,D1
DOWN1:

 MOVE.L A6,A1
 ADD.W (A2)+,A1
 ADD.W D0,A1
 JSR PUT1

 ADDQ.W #2,D0
 MOVE.L A6,A1
 ADD.W (A2)+,A1
 ADD.W D0,A1
 JSR PUT1

 SUBQ.W #1,D0
 MOVE.L A6,A1
 ADD.W (A2)+,A1
 ADD.W D0,A1
 JSR PUT1

 ADDQ.W #2,D0
 MOVE.L A6,A1
 ADD.W (A2)+,A1
 ADD.W D0,A1
 JSR PUT1

 ADDQ.W #5,D0
 DBRA D1,DOWN1

 BSR UPDAT
 RTS
PUT1:
 MOVE.B D2,-800(A1)
 MOVE.B D2,-640(A1)
 MOVE.B D2,-480(A1)
 MOVE.B D2,-320(A1)
 MOVE.B D2,-160(A1)
 MOVE.B (A0)+,(A1)
 MOVE.B (A0)+,160(A1)
 MOVE.B (A0)+,320(A1)
 MOVE.B (A0)+,480(A1)
 MOVE.B (A0)+,640(A1)
 MOVE.B (A0)+,800(A1)
 MOVE.B (A0)+,960(A1)
 MOVE.B (A0)+,1120(A1)
 MOVE.B (A0)+,1280(A1)
 MOVE.B (A0)+,1440(A1)
 MOVE.B (A0)+,1600(A1)
 MOVE.B (A0)+,1760(A1)
 MOVE.B (A0)+,1920(A1)
 MOVE.B (A0)+,2080(A1)
 MOVE.B (A0)+,2240(A1)
 MOVE.B (A0)+,2400(A1)
 MOVE.B (A0)+,2560(A1)
 MOVE.B (A0)+,2720(A1)
 MOVE.B (A0)+,2880(A1)
 MOVE.B (A0)+,3040(A1)
 MOVE.B (A0)+,3200(A1)
 MOVE.B (A0)+,3360(A1)
 MOVE.B (A0)+,3520(A1)
 MOVE.B (A0)+,3680(A1)
 MOVE.B (A0)+,3840(A1)
 MOVE.B (A0)+,4000(A1)
 MOVE.B (A0)+,4160(A1)
 MOVE.B (A0)+,4320(A1)
 MOVE.B (A0)+,4480(A1)
 MOVE.B (A0)+,4640(A1)
 MOVE.B (A0)+,4800(A1)
 MOVE.B (A0)+,4960(A1)
 MOVE.B (A0)+,5120(A1)
 MOVE.B (A0)+,5280(A1)
 MOVE.B (A0)+,5440(A1)
 MOVE.B (A0)+,5600(A1)
 MOVE.B (A0)+,5760(A1)
 MOVE.B (A0)+,5920(A1)
 MOVE.B (A0)+,6080(A1)
 MOVE.B (A0)+,6240(A1)
 MOVE.B (A0)+,6400(A1)
 MOVE.B (A0)+,6560(A1)
 MOVE.B (A0)+,6720(A1)
 MOVE.B (A0)+,6880(A1)
 MOVE.B (A0)+,7040(A1)
 MOVE.B (A0)+,7200(A1)
 MOVE.B (A0)+,7360(A1)
 MOVE.B (A0)+,7520(A1)
 MOVE.B (A0)+,7680(A1)
 MOVE.B (A0)+,7840(A1)
 MOVE.B (A0)+,8000(A1)
 MOVE.B (A0)+,8160(A1)
 MOVE.B (A0)+,8320(A1)
 MOVE.B (A0)+,8480(A1)
 MOVE.B (A0)+,8640(A1)
 MOVE.B (A0)+,8800(A1)
 MOVE.B (A0)+,8960(A1)
 MOVE.B (A0)+,9120(A1)
 MOVE.B (A0)+,9280(A1)
 MOVE.B (A0)+,9440(A1)
 MOVE.B (A0)+,9600(A1)
 MOVE.B (A0)+,9760(A1)
 MOVE.B (A0)+,9920(A1)
 MOVE.B (A0)+,10080(A1)
 MOVE.B D2,10240(A1)
 MOVE.B D2,10400(A1)
 MOVE.B D2,10560(A1)
 MOVE.B D2,10720(A1)
 MOVE.B D2,10880(A1)
 RTS

SETLINE:
 LEA FLEX,A2
 LEA GRAF,A1
PEK2:
 MOVE.L #SIDEWOB,A3
 MOVEQ #0,D1
 MOVEQ #48,D2

 MOVEQ #63,D0
SET1:

  LEA (A2,D1.W),A0
  ADD.L (A3)+,A0

 MOVE.B (A0)+,(A1)
 MOVE.B (A0)+,64(A1)
 MOVE.B (A0)+,128(A1)
 MOVE.B (A0)+,192(A1)
 MOVE.B (A0)+,256(A1)
 MOVE.B (A0)+,320(A1)
 MOVE.B (A0)+,384(A1)
 MOVE.B (A0)+,448(A1)
 MOVE.B (A0)+,512(A1)
 MOVE.B (A0)+,576(A1)
 MOVE.B (A0)+,640(A1)
 MOVE.B (A0)+,704(A1)
 MOVE.B (A0)+,768(A1)
 MOVE.B (A0)+,832(A1)
 MOVE.B (A0)+,896(A1)
 MOVE.B (A0)+,960(A1)
 MOVE.B (A0)+,1024(A1)
 MOVE.B (A0)+,1088(A1)
 MOVE.B (A0)+,1152(A1)
 MOVE.B (A0)+,1216(A1)
 MOVE.B (A0)+,1280(A1)
 MOVE.B (A0)+,1344(A1)
 MOVE.B (A0)+,1408(A1)
 MOVE.B (A0)+,1472(A1)
 MOVE.B (A0)+,1536(A1)
 MOVE.B (A0)+,1600(A1)
 MOVE.B (A0)+,1664(A1)
 MOVE.B (A0)+,1728(A1)
 MOVE.B (A0)+,1792(A1)
 MOVE.B (A0)+,1856(A1)
 MOVE.B (A0)+,1920(A1)
 MOVE.B (A0)+,1984(A1)
 MOVE.B (A0)+,2048(A1)
 MOVE.B (A0)+,2112(A1)
 MOVE.B (A0)+,2176(A1)
 MOVE.B (A0)+,2240(A1)
 MOVE.B (A0)+,2304(A1)
 MOVE.B (A0)+,2368(A1)
 MOVE.B (A0)+,2432(A1)
 MOVE.B (A0)+,2496(A1)
 MOVE.B (A0)+,2560(A1)
 MOVE.B (A0)+,2624(A1)
 MOVE.B (A0)+,2688(A1)
 MOVE.B (A0)+,2752(A1)
 MOVE.B (A0)+,2816(A1)
 MOVE.B (A0)+,2880(A1)
 MOVE.B (A0)+,2944(A1)
 MOVE.B (A0)+,3008(A1)

  ADD.W D2,D1
  ADDQ.W #1,A1

 DBRA D0,SET1

 RTS

 RTS

STARTUP:
 CLR.L -(SP)
 MOVE.W #$20,-(SP)
 TRAP #1
 ADDQ.L #6,SP
 MOVE.L D0,SSP

 PEA MOUSEOFF
 MOVE.W #1,-(SP)
 MOVE.W #25,-(SP)
 TRAP #14
 ADDQ.L #8,SP

 MOVEQ #0,D0
 BSR MUSIC

 LEA $FF8240,A0
 MOVEM.L (A0)+,D0-D7
 LEA OLPAL+32,A1
 MOVEM.L D0-D7,-(A1)
 LEA PAL,A0
 LEA $FF8240+32,A1
 MOVEM.L (A0)+,D0-D7
 MOVEM.L D0-D7,-(A1)

 CLR.W -(SP)
 PEA SCR
 PEA SCR
 MOVE.W #5,-(SP)
 TRAP #14
 ADD.W #12,SP

 LEA SCR,A0
 LEA SCR1,A1
 MOVE.W #7999,D0
 BSR COPY

 MOVE.W #$2700,SR
 MOVE.L $70,OVBL
 MOVE.L #VBL,$70  ;SET $2300 LATER

 RTS


RESETT:
 MOVE.W #$2700,SR
 BSR REMOVERAST
 MOVE.L OVBL,$70
 MOVE.W #$2300,SR

 PEA MOUSEON
 MOVE.W #1,-(SP)
 MOVE.W #25,-(SP)
 TRAP #14
 ADDQ.L #8,SP

 LEA OLPAL,A0
 LEA $FF8240+32,A1
 MOVEM.L (A0)+,D0-D7
 MOVEM.L D0-D7,-(A1)

 MOVE.L SSP,-(SP)
 MOVE.W #$20,-(SP)
 TRAP #1
 ADDQ.L #6,SP

 MOVE.W #1,-(SP)
 PEA SCR
 PEA SCR
 MOVE.W #5,-(SP)
 TRAP #14
 ADD.W #12,SP

 RTS


PRESCROLL:
 LEA SCBUF,A1
 LEA ASCCI,A2
 LEA SCWOBTB,A3
PRES1:
 LEA FONT,A0
 CLR.W D0
 MOVE.B (A2)+,D0
 CMP.B #$FF,D0
 BEQ PRESFIN
 SUB.B #32,D0
 LSL.W #5,D0
 ADD.W D0,A0
 MOVEQ #15,D2
PRES2:
 CLR.L D1
 MOVE.W (A0)+,D1
 NOT.W D1
  MOVE.W (A3)+,D3
  CMP.W #-1,D3
  BNE PRES3
  LEA SCWOBTB,A3
  MOVE.W (A3)+,D3
PRES3:
 LSL.L D3,D1
 MOVE.L D1,(A1)+
 DBRA D2,PRES2
 BRA PRES1
PRESFIN:
 RTS
SCWOBTB: DC.W 0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,14,13,12,11,10,9,8,7,6,5,4,3,2,1,$FFFF

PREGRAF:
 BSR PRESCROLL
 LEA FLEX,A0
 LEA TEMP,A1
 MOVE.W #383,D0
 BSR COPY

 LEA TEMP,A0
 LEA FLEX,A1
 MOVEQ #63,D0
PRE1:
 MOVE.L (A0),(A1)+
 MOVE.L 4(A0),(A1)+
 MOVE.L 512(A0),(A1)+
 MOVE.L 516(A0),(A1)+
 MOVE.L 1024(A0),(A1)+
 MOVE.L 1028(A0),(A1)+
 ADDQ.W #8,A0
 DBRA D0,PRE1

 LEA FLEX,A0
 LEA FLEXNORM,A1
 MOVE.W #383,D0
 BSR COPY

 LEA FLEX,A0
 LEA TEMP,A1
 MOVE.W #383,D0
 BSR COPY

 BSR BYTE       ;MAKE BYTE WOB
 BSR ROTT       ;MAKE 16 ROTATIONS

 LEA FLEX,A0    ;START NIBBLING
 CLR.L D3

 MOVEQ #15,D4
NIB1:

  LEA FLEX,A0
  ADD.L D3,A0
  LEA TEMP,A1
  MOVE.W #767,D0
  BSR COPY
  LEA TEMP,A0
  LEA FLEX,A1
  ADD.L D3,A1
  BSR NIBB
  ADD.L #3072,D3

 DBRA D4,NIB1

 RTS

NIBB:
 MOVE.W #1535,D0
PRE2:
 MOVE.B (A0)+,D1
 MOVE.B D1,D2
 AND.B #%11110000,D2
 MOVE.B D2,(A1)+

 MOVE.B D1,D2
 AND.B #%00001111,D2
 MOVE.B D2,(A1)+
 DBRA D0,PRE2

 RTS


ROTT:
 LEA FLEX+1536,A0
 LEA FLEX+3072,A1

 MOVEQ #14,D1
ROTT1:
 MOVE.W #767,D0
 SUB.W #1536,A0
 BSR COPY
 BSR ROT
 DBRA D1,ROTT1

 RTS

ROT:
 MOVEQ #63,D0
ROT1:
 MOVE.W #0,CCR
 ROXR.W (A0)
 ROXR.W 2(A0)
 ROXR.W 4(A0)
 ROXR.W 6(A0)
 ROXR.W 8(A0)
 ROXR.W 10(A0)
 ROXR.W 12(A0)
 ROXR.W 14(A0)
 ROXR.W 16(A0)
 ROXR.W 18(A0)
 ROXR.W 20(A0)
 ROXR.W 22(A0)
 ADD.W #24,A0
 DBRA D0,ROT1
 RTS

BYTE:
 LEA FLEX,A0
 LEA FLEXBYTE,A1

 MOVEQ #23,D1
BYT2:

 MOVEQ #63,D0
BYT1:
 MOVE.B (A0),(A1)+
 ADD.W #24,A0
 DBRA D0,BYT1

 SUB.W #(64*24)-1,A0
 DBRA D1,BYT2

 LEA FLEXBYTE,A0    ;MAKE MIRROR IMAGE
 LEA FLEXBYTE1,A1

 MOVE.W #1535,D0
MIRROR:
 CLR.B D2
 MOVE.B (A0)+,D1
 MOVE.W #0,CCR
 ROXR.B #1,D1
 ROXL.B #1,D2
 ROXR.B #1,D1
 ROXL.B #1,D2
 ROXR.B #1,D1
 ROXL.B #1,D2
 ROXR.B #1,D1
 ROXL.B #1,D2
 ROXR.B #1,D1
 ROXL.B #1,D2
 ROXR.B #1,D1
 ROXL.B #1,D2
 ROXR.B #1,D1
 ROXL.B #1,D2
 ROXR.B #1,D1
 ROXL.B #1,D2
 MOVE.B D2,(A1)+
 DBRA D0,MIRROR

 RTS

SPINRUT:
 MOVE.L A6,A1
 MOVE.L #SPINTAB,A2

 MOVE.W #63,D0
SPIN1:
 LEA FLEXNORM,A0
 ADD.W (A2)+,A0

 MOVE.W (A0)+,(A1)
 MOVE.W (A0)+,8(A1)
 MOVE.W (A0)+,16(A1)
 MOVE.W (A0)+,24(A1)

 MOVE.W (A0)+,32(A1)
 MOVE.W (A0)+,40(A1)
 MOVE.W (A0)+,48(A1)
 MOVE.W (A0)+,56(A1)

 MOVE.W (A0)+,64(A1)
 MOVE.W (A0)+,72(A1)
 MOVE.W (A0)+,80(A1)
 MOVE.W (A0)+,88(A1)

 ADD.W #160,A1
 DBRA D0,SPIN1
 RTS

TURNRUT:
 ADD.W #100*160,A6
 MOVE.L #TURNTAB,A2
 MOVEQ #0,D1
 MOVEQ #0,D2
 MOVE.L (A2)+,A3  ;GRAFX

 MOVEQ #11,D0
TURN1:
 MOVE.L A3,A0
 ADD.W (A2)+,A0
 MOVE.L A6,A1
 ADD.W D1,A1
 BSR PUT1
 ADDQ.W #1,D1

 MOVE.L A3,A0
 ADD.W (A2)+,A0
 MOVE.L A6,A1
 ADD.W D1,A1
 BSR PUT1
 ADDQ.W #7,D1

 DBRA D0,TURN1

 RTS


SLIMERUT:
 LEA FLEXNORM,A0
 MOVE.L A6,A1
SLPEK:
 MOVE.L #SLIMETAB,A2  ;PEK

 MOVE.W #63,D0
SLIME1:

 CLR.W D1
 MOVE.B (A2)+,D1
SLIME2:
 MOVE.W (A0)+,(A1)
 MOVE.W (A0)+,8(A1)
 MOVE.W (A0)+,16(A1)
 MOVE.W (A0)+,24(A1)

 MOVE.W (A0)+,32(A1)
 MOVE.W (A0)+,40(A1)
 MOVE.W (A0)+,48(A1)
 MOVE.W (A0)+,56(A1)

 MOVE.W (A0)+,64(A1)
 MOVE.W (A0)+,72(A1)
 MOVE.W (A0)+,80(A1)
 MOVE.W (A0)+,88(A1)
 ADD.W #160,A1
 SUB.W #24,A0
 DBRA D1,SLIME2

 ADD.W #24,A0
 DBRA D0,SLIME1

 MOVEQ #0,D0
 MOVEQ #4,D1
CLEER:
 MOVE.W D0,(A1)
 MOVE.W D0,8(A1)
 MOVE.W D0,16(A1)
 MOVE.W D0,24(A1)
 MOVE.W D0,32(A1)
 MOVE.W D0,40(A1)
 MOVE.W D0,48(A1)
 MOVE.W D0,56(A1)
 MOVE.W D0,64(A1)
 MOVE.W D0,72(A1)
 MOVE.W D0,80(A1)
 MOVE.W D0,88(A1)
 ADD.W #160,A1
 DBRA D1,CLEER

 MOVE.L SLPEK+2,A0  ;UPDATE
 CMP.L #SLIMETAB+128,A0
 BNE SLU1
 LEA SLIMETAB-1,A0
SLU1:
 ADDQ.W #1,A0
 MOVE.L A0,SLPEK+2

 RTS

RASTER1:
 MOVE.W (A5)+,$FF8240
 BCLR #0,$FFFA0F
 RTE

RASTER3:
SPAR3:
 JMP 0

INITRAST:
 MOVE.L $120,SPAR2
 MOVE.L $118,SPAR3+2
 MOVE.B $FFFA09,SPAR4
 MOVE.B $FFFA07,SPAR4+1
 MOVE.B $FFFA13,SPAR4+2
 MOVE.L #RASTER3,$118
 ANDI.B #-$21,$FFFA09
 ANDI.B #-2,$FFFA07
 MOVE.L #RASTER1,$120
 ORI.B #1,$FFFA07
 ORI.B #1,$FFFA13
 RTS

REMOVERAST:
 MOVE.B SPAR4,$FFFA09
 MOVE.B SPAR4+1,$FFFA07
 MOVE.B SPAR4+2,$FFFA13
 MOVE.L SPAR2,$120
 MOVE.L SPAR3+2,$118
 RTS

COPY:
 MOVE.L (A0)+,(A1)+
 DBRA D0,COPY
 RTS

SSP:
 DC.L 0
OVBL:
 DC.L 0
SCREEN:
 DC.L SCR
SCREEN1:
 DC.L SCR1
MOUSEOFF:
 DC.B $12,$1A
MOUSEON:
 DC.B $14,$08
OLPAL:
 DS.W 16,0
PAL:
 DC.W $000,$700,$700,$700,0,0,0,0,$555,0,0,0,0,0,0,0

SPAR1: DC.L 0
SPAR2: DC.L 0
SPAR4: DC.L 0
SPAR5: DC.W 0
COLTAB:
 DC.W  $111,$222,$333,$444
 DC.W  $555,$666,$777,$777,$667,$667,$557,$557,$447,$447,$337
 DC.W  $337,$227,$227,$117,$117,$007
 DC.W  $006,$005,$004,$003,$002,$001,$000,$000,$001,$002,$003,$004,$005
 DC.W  $006,$007,$107,$107,$207,$207,$307,$307,$407,$407
 DC.W  $507,$507,$607,$607,$707,$606
 DC.W  $505,$404,$303,$202,$101,$000,$000,$101,$202,$303,$404,$505,$606
 DC.W  $707,$706,$706,$705,$705,$704,$704,$703,$703,$702
 DC.W  $702,$701,$701,$700,$600,$500
 DC.W  $400,$300,$200,$100,$000,$000,$100,$200,$300,$400,$500,$600,$700
 DC.W  $710,$710,$720,$720,$730,$730,$740,$740,$750,$750
 DC.W  $760,$760,$770,$660,$550,$440
 DS.W 100,$005

L=160

WOBTAB:
; DS.W 96,160*100
 IBYTES SIN2.DAT
 IBYTES SIN2.DAT
 IBYTES SIN2.DAT
WOBEND:

MUSIC:
 IBYTES BMXMUS.DAT

SIDEWOB:
 DS.L 4,0
 DS.L 4,3072
 DS.L 4,3072*2
 DS.L 4,3072*3
 DS.L 4,3072*4
 DS.L 4,3072*5
 DS.L 4,3072*6
 DS.L 4,3072*7
 DS.L 4,3072*8
 DS.L 4,3072*9
 DS.L 4,3072*10
 DS.L 4,3072*11
 DS.L 4,3072*12
 DS.L 4,3072*13
 DS.L 4,3072*14
 DS.L 4,3072*15

 DS.L 4,3072*15
 DS.L 4,3072*14
 DS.L 4,3072*13
 DS.L 4,3072*12
 DS.L 4,3072*11
 DS.L 4,3072*10
 DS.L 4,3072*9
 DS.L 4,3072*8
 DS.L 4,3072*7
 DS.L 4,3072*6
 DS.L 4,3072*5
 DS.L 4,3072*4
 DS.L 4,3072*3
 DS.L 4,3072*2
 DS.L 4,3072*1
 DS.L 4,0

 DS.L 4,0
 DS.L 4,3072
 DS.L 4,3072*2
 DS.L 4,3072*3
 DS.L 4,3072*4
 DS.L 4,3072*5
 DS.L 4,3072*6
 DS.L 4,3072*7
 DS.L 4,3072*8
 DS.L 4,3072*9
 DS.L 4,3072*10
 DS.L 4,3072*11
 DS.L 4,3072*12
 DS.L 4,3072*13
 DS.L 4,3072*14
 DS.L 4,3072*15
WOBEND1:

X=24
SPINTAB:
 DC.W 63*X,62*X,61*X,60*X,59*X,58*X,57*X,56*X
 DC.W 55*X,54*X,53*X,52*X,51*X,50*X,49*X,48*X
 DC.W 47*X,46*X,45*X,44*X,43*X,42*X,41*X,40*X
 DC.W 39*X,38*X,37*X,36*X,35*X,34*X,33*X,32*X
 DC.W 31*X,30*X,29*X,28*X,27*X,26*X,25*X,24*X
 DC.W 23*X,22*X,21*X,20*X,19*X,18*X,17*X,16*X
 DC.W 15*X,14*X,13*X,12*X,11*X,10*X,09*X,08*X
 DC.W 07*X,06*X,05*X,04*X,03*X,02*X,01*X,00*X

Y=64
TURNTAB:
 DC.L FLEXBYTE1
 DC.W 23*Y,22*Y,21*Y,20*Y,19*Y,18*Y,17*Y,16*Y
 DC.W 15*Y,14*Y,13*Y,12*Y,11*Y,10*Y,09*Y,08*Y
 DC.W 07*Y,06*Y,05*Y,04*Y,03*Y,02*Y,01*Y,00*Y

SLIMETAB:
 DS.B 64,0
 DS.B 64,1
 DS.B 64,0

ASCCI:
 DC.B 'VILLE TESTING',$FF
 ALIGN.W

FONT:
 IBYTES SMALLFNT.DAT
FLEX:
 IBYTES FLEX.WOB
 DS.B 1536,0
 DS.B 15*3072
FLEXNORM:
 DS.B 1536,0
FLEXBYTE:
 DS.B 1536,0
FLEXBYTE1:    ;MIRRORED
 DS.B 1536,0
SCBUF:
 DS.B 5000
TEMP:
 END

