SCR=$78000
 JMP START
START:
 MOVE.W #0,-(SP)
 PEA SCR
 PEA SCR
 MOVE.W #5,-(SP)
 TRAP #14
 ADD.L #12,SP
 MOVE.W #7999,D0
 LEA $78000,A0
LOP6:
 CLR.L (A0)+
 DBRA D0,LOP6
 PEA STRI
 MOVE.W #0,-(SP)
 MOVE.W #25,-(SP)
 TRAP #14
 ADDQ.L #8,SP
 PEA START1
 MOVE.W #38,-(SP)
 TRAP #14
 ADDQ.L #6,SP
EXIT:
 PEA STOPP
 MOVE.W #38,-(SP)
 TRAP #14
 ADDQ.L #6,SP
 JMP START2
CALP:
 MOVEQ #7,D0
CAL1:
 MOVE.L (A0)+,(A1)+
 DBRA D0,CAL1
 RTS
START1:
 LEA $FF8240,A0
 LEA OLPAL,A1
 BSR CALP
 LEA $FF8240,A0
 MOVEQ #7,D0
STAR1:
 CLR.L (A0)+
 DBRA D0,STAR1
 MOVE.L $70,SPAR1
 MOVE.L #RASTER,$70
MAIN:
 JSR SCROL1
 LEA SCR,A1
 JSR DUMP1
 CMP.B #$66,$FFFC02
 BNE MAIN
 RTS
STOPP:
 LEA OLPAL,A0
 LEA $FF8240,A1
 BSR CALP
 MOVE.L SPAR1,$70
 RTS
RASTER:
 clr.b $ff820a
 MOVEM.L A0-A6/D0-D7,-(SP)
 MOVE.W #$700,$FF8242
 MOVE.W SR,-(A7)
 ORI.W #$700,SR
 LEA $FF8242,A4
 LEA $FF8209,A5
 LEA (A4),A0
; LEA (A4),A1
; LEA (A4),A2
 LEA TAB1,A6
 LEA TAB2,A3

 MOVE.W #31,D7
 CLR.L D0
LOP1:
 TST.B (A5)
 BEQ.S LOP1
 MOVE.B (A5),D0
 ADDA.L D0,A6
 JMP (A6)
TAB1:
 DS.W 118,$4E71
LOP2:
 MOVE.W (A3)+,(A0)
 MOVE.W #24,D6
LOP3:
 NOP
 DBRA D6,LOP3
 DS.W 19,$4E71
 DBRA D7,LOP2
 MOVE.W (A7)+,SR
 ADDQ.W #1,VCLOC
SLUT:
 CLR.L $FF8240
 move.b #2,$ff820a
 MOVEM.L (SP)+,A0-A6/D0-D7
 RTE
SCROL1:
 MOVE.W #1,D1
 CMP.W #8,D1
 BNE SCIP3
 CLR.W D0
TXPEK:
 MOVE.B TXSTART,D0
 ADDQ.L #1,TXPEK+2
 CMP.B #$FF,D0
 BNE SCIP2
 MOVE.L #TXSTART+1,TXPEK+2
 MOVE.B TXSTART,D0
SCIP2:
 SUB.B #32,D0
 LSL.W #7,D0
 LSL.W #2,D0
 LEA FONT,A0
 ADD.L D0,A0
 LEA BUFF+160,A1
 MOVEQ #31,D0
LLOP6:
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 ADD.W #160,A1
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 MOVE.L (A0)+,(A1)+
 ADD.W #160,A1
 DBRA D0,LLOP6
 CLR.W D1
SCIP3:
 ADDQ.W #1,D1
 MOVE.W D1,SCROL1+2
 LEA BUFF+168,A0
 MOVEQ #31,D1
LOP4:
 MOVEQ #3,D0
LLOP2:
 MOVE #0,CCR
 ROXL.W (A0)
 ROXL.W -8(A0)
 ROXL.W -16(A0)
 ROXL.W -24(A0)
 ROXL.W -32(A0)
 ROXL.W -40(A0)
 ROXL.W -48(A0)
 ROXL.W -56(A0)
 ROXL.W -64(A0)
 ROXL.W -72(A0)
 ROXL.W -80(A0)
 ROXL.W -88(A0)
 ROXL.W -96(A0)
 ROXL.W -104(A0)
 ROXL.W -112(A0)
 ROXL.W -120(A0)
 ROXL.W -128(A0)
 ROXL.W -136(A0)
 ROXL.W -144(A0)
 ROXL.W -152(A0)
 ROXL.W -160(A0)
 ROXL.W -168(A0)
 DBRA D0,LLOP2
 ADD.L #176,A0
 DBRA D1,LOP4
 RTS
SYNC:
 MOVE.W VCLOC,D0
SYNC1:
 CMP.W VCLOC,D0
 BEQ SYNC1
 RTS
DUMP1:
 JSR SYNC
 LEA BUFF,A0
 MOVE.W #31,D0
LOP5:
 MOVE.W #1,D1
LOP7:
 MOVE.W (A0),(A1)
 MOVE.W 8(A0),8(A1)
 MOVE.W 16(A0),16(A1)
 MOVE.W 24(A0),24(A1)
 MOVE.W 32(A0),32(A1)
 MOVE.W 40(A0),40(A1)
 MOVE.W 48(A0),48(A1)
 MOVE.W 56(A0),56(A1)
 MOVE.W 64(A0),64(A1)
 MOVE.W 72(A0),72(A1)
 ADD.W #80,A0
 ADD.W #80,A1
 DBRA D1,LOP7
 ADD.W #16,A0
 DBRA D0,LOP5
 RTS
START2:
 LEA STUDS,A0
NFERD:
 MOVE.W (A0),D0
 CMP.W #$FFFF,D0
 BEQ FERD
 MULU #160,D0
 MOVE.W D0,(A0)+
 BRA NFERD
FERD:
 CLR.L -(SP)     ;SV MODE
 MOVE.W #$20,-(SP)
 TRAP #1
 ADDQ.L #6,SP
 MOVE.L D0,SPAR+4
 MOVE.W #$2700,SR
 CLR.W -(SP)     ;SETSCR
 PEA SCR
 PEA SCR
 MOVE.W #5,-(SP)
 TRAP #14
 ADD.L #12,SP
 PEA IKBW       ;IKDBWS
 MOVE.W #1,-(SP)
 MOVE.W #25,-(SP)
 TRAP #14
 ADDQ.L #8,SP
 MOVE.L $70,SPAR+8 ;SET EXCEPTIONS
 MOVE.L #VBLR,$70
; MOVE.L $120,SPAR+16
; MOVE.L #RASTER1,$120
; MOVE.L $118,SPAR+12
; MOVE.L #RASTER2,$118
; MOVE.B $FFFA07,SPAR+20
; MOVE.B $FFFA09,SPAR+21
; MOVE.B $FFFA13,SPAR+22
 MOVE.W #$2300,SR
MAIN1:
 JSR SCROL1
PEKAR5:
 LEA SCR,A1
 JSR DUMP1
PEKAR6:
 LEA STUDS,A1
 LEA SCR,A2
 MOVE.W (A1)+,D0
 BTST #15,D0
 BEQ SKIP9
 LEA STUDS,A1
 MOVE.W STUDS,D0
SKIP9:
 ADD.W D0,A2
 MOVE.L A1,PEKAR6+2
 MOVE.L A2,PEKAR5+2
 CMP.B #$66,$FFFC02
 BNE MAIN1
EXIT1:
 PEA IKBW+2      ;IKDBWS
 CLR.W -(SP)
 MOVE.W #25,-(SP)
 TRAP #14
 ADDQ.L #8,SP
; MOVE.B SPAR+20,$FFFA07
; MOVE.B SPAR+21,$FFFA09
; MOVE.B SPAR+22,$FFFA13
; MOVE.L SPAR+16,$120
; MOVE.L SPAR+12,$118
 MOVE.L SPAR+8,$70
 MOVE.W #$777,$FF8240
 MOVE.W #1,-(SP)
 PEA -1
 PEA -1
 MOVE.W #5,-(SP)
 TRAP #14
 ADD.L #12,SP
 MOVE.L SPAR+4,-(SP)
 MOVE.W #$20,-(SP)
 TRAP #1
 ADDQ.L #6,SP
 ILLEGAL
 CLR.W -(SP)
 TRAP #1
VBLR:
 ADDQ.W #1,VCLOC
 RTE
STUDS: DC.W 0,2,4,6,8,12,16,20,24,28,32,$FFFF
OLPAL: DS.W 16
SPAR1: DC.L 0
STRI: DC.B $12,0
TAB2: DC.W $520,$520,$011,$122,$233,$344,$455,$566,$677,$677,$566,$455,$344
      DC.W $233,$122,$011
      DS.W 35,$520
TXSTART: DC.B 'WELCOME TO THE SKINNY PUPPY DEMO.........',$FF
 ALIGN.W
IKBW: DC.B $12,$15, 8,0
VCLOC: DC.W 0
SPAR: DS.L 10
FONT: IBYTES FONT.DAT
BUFF: DS.B 5632
 END

