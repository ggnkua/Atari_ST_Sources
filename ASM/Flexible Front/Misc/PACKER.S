;FORMAT: 0 TO 128=NR OF DATA
;        -1 TO -127=REPEAT DATA +1

START:
 BSR PACKER

 BSR CLEAR
 BSR UNPACK

 BSR GETCHECK
 CMP.L SAVECHECK,D1
 BEQ YES
 LEA MESS3,A6
 BSR PRINT
 BRA FINITO

YES:
 LEA MESS4,A6
 BSR PRINT
FINITO:
 MOVE.W #7,-(SP)
 TRAP #1
 ADDQ.L #2,SP
 ILLEGAL
BOOM:
 MOVE.L A0,SAVESIZE
 ILLEGAL
SAVESIZE:
 DC.L 0
SAVECHECK:
 DC.L 0
SAVESIZE2:
 DC.L 0

GETCHECK:
 MOVE.L #(USLUT-UNPACKDAT)-1,D0
 LEA UNPACKDAT,A0
 CLR.L D1
CHECK1:
 CLR.L D2
 MOVE.B (A0)+,D2
 ADD.L D2,D1
 DBRA D0,CHECK1
 RTS
CLEAR:
 LEA UNPACKDAT,A0
 MOVE.L #(USLUT-UNPACKDAT)-1,D0
CLEAR1:
 CLR.B (A0)+
 DBRA D0,CLEAR1
 RTS


UNPACK:
 LEA PACKDAT,A0   ;SOURCE
 LEA UNPACKDAT,A1 ;DESTINY

UPACK:
 CLR.W D0
 MOVE.B (A0)+,D0
 TST.B D0
 BMI UREP   ;REPEAT

 TST.W D0
 BEQ BOOM
 SUBQ.W #1,D0
USTREAM:    ;STREAMDATA
 MOVE.B (A0)+,(A1)+
 DBRA D0,USTREAM
 JMP UPACK

UREP:
 BCLR #7,D0
 TST.B D0
 BEQ UFIN
 MOVE.B (A0)+,D1
UREP2:
 MOVE.B D1,(A1)+
 DBRA D0,UREP2
 JMP UPACK

UFIN:
 MOVE.L A0,SAVESIZE
 MOVE.L A1,D7
 SUB.L #UNPACKDAT,D7
 RTS



PACKER:
 LEA MESS1,A6
 BSR PRINT
 MOVE.L #(USLUT-UNPACKDAT)-1,D0
 BSR DCIP

 BSR GETCHECK
 MOVE.L D1,SAVECHECK

 LEA UNPACKDAT,A0    ;SOURCE
 LEA PACKDAT,A1      ;DESTINY
 MOVE.L #USLUT-UNPACKDAT,D6    ;COUNT
 CLR.L D5

STREAM:
 SUBQ.L #1,D6
 BMI PACKFIN3
 MOVE.B (A0)+,D0
 CMP.B (A0),D0
 BNE SKIP1
 CMP.B 1(A0),D0
 BNE SKIP1
PACK:
 TST.B D5
 BEQ SKIP6
 MOVE.L A1,A2
 SUB.L D5,A2
 SUBQ.W #1,A2
 MOVE.B D5,(A2)
 CLR.L D5
SKIP6:

 MOVEQ #2,D2
 ADDQ.W #2,A0
PCLOP:
 CMP.B (A0),D0
 BNE SKIP3
 CMP.B #127,D2
 BEQ SKIP3
 ADD.B #1,D2
 ADDQ.W #1,A0
 BRA PCLOP
SKIP3:
 SUB.L D2,D6
 BMI PACKFIN2
 BSET #7,D2

 MOVE.B D2,(A1)+  ;COUNT
 MOVE.B D0,(A1)+  ;VALUE TO REPEAT
 BRA STREAM
PACKFIN2:
 BSET #7,D2

 MOVE.B D2,(A1)+
 MOVE.B D0,(A1)+
 BRA PACKFIN

SKIP1:
 TST.B D5
 BNE SKIP5
 ADDQ.W #1,A1
SKIP5:
 CMP.B #127,D5
 BNE SKIP2
 MOVE.L A1,A2
 SUB.L D5,A2
 SUBQ.W #1,A2

 MOVE.B D5,(A2)  ;COUNT
 CLR.L D5
 MOVE.B #0,D5
 ADDQ.W #1,A1
SKIP2:
 MOVE.B D0,(A1)+
 ADDQ.B #1,D5
 BRA STREAM

PACKFIN3:
 MOVE.L A1,A2
 SUB.L D5,A2
 SUBQ.W #1,A2
 TST.B D5
 BEQ PACKFIN
 MOVE.B D5,(A2)
PACKFIN:
 MOVE.B #128,(A1)+
 MOVE.L A1,D7
 SUB.L #PACKDAT,D7

 MOVE.L D7,SAVESIZE2
 LEA MESS2,A6
 BSR PRINT
 MOVE.L D7,D0     ;PRINT NEW LENGHT
 BSR DCIP
 LEA MESS6,A6
 BSR PRINT
 MOVE.W #7,-(SP)
 TRAP #1
 ADDQ.L #2,SP

 CMP.B #'Y',D0
 BEQ SAVE
 CMP.B #'y',D0
 BEQ SAVE
 RTS

PRINT:
 PEA (A6)
 MOVE.W #9,-(SP)
 TRAP #1
 ADDQ.L #6,SP
 RTS
DCIP:
 LEA TBUF,A0
 MOVE.L #'    ',D1
 MOVE.W #$0914,(A0)+
 MOVE.L D1,(A0)+
 MOVE.L D1,(A0)+
DCI1:
 CMP.L #10,D0
 BLO DCI2
 DIVU #10,D0
 SWAP D0
 ADD.W #$30,D0
 MOVE.B D0,-(A0)
 CLR.W D0
 SWAP D0
 BRA DCI1
DCI2:
 ADD.W #$30,D0
 MOVE.B D0,-(A0)
 LEA TBUF,A6
 BSR PRINT
 RTS
TBUF:
 DS.B 20,0

SAVE:
 LEA MESS5,A6
 BSR PRINT
 PEA READBUF
 MOVE.W #$0A,-(SP)
 TRAP #1
 ADDQ.L #6,SP

 MOVE.W #0,-(SP)
 PEA READBUF+2
 MOVE.W #$3C,-(SP)
 TRAP #1
 ADDQ.L #8,SP
 MOVE.W D0,HAND

 PEA PACKDAT
 MOVE.L SAVESIZE2,-(SP)
 MOVE.W HAND,-(SP)
 MOVE.W #$40,-(SP)
 TRAP #1
 ADD.L #12,SP

 MOVE.W HAND,-(SP)
 MOVE.W #$3E,-(SP)
 TRAP #1
 ADDQ.L #4,SP
 RTS
HAND:
 DC.W 0
READBUF:
 DC.B 15,0
 DS.B 16,0

MESS0:
 DC.B $0D,$0A,0
MESS1:
 DC.B 27,'E','FF PACKER V1.0  -89',10,13,'*******************'
 DC.B 10,10,13,'  OLD LENGHT: ',0
MESS2:
 DC.B 10,10,13,'  NEW LENGHT: ',0
MESS3:
 DC.B 10,10,13,'  UNPACK ERROR!!!',0
MESS4:
 DC.B 10,10,13,'  CHECKSUM OK.',0
MESS5:
 DC.B 10,10,13,'  INPUT FILENAME: ',0
MESS6:
 DC.B 10,10,13,'  SAVE Y/N?',0
 ALIGN.W

UNPACKDAT:
 IBYTES \MASK.TLB\DIGITAL.TOS
USLUT:

PACKDAT:
 END

