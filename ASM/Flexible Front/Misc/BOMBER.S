SCR=$78000
SCR1=$70000-(20*256)

 BRA START
BUFF:
 DS.B 3000,0

START:
 CLR.L -(SP)     ;SV MODE
 MOVE.W #$20,-(SP)
 TRAP #1
 ADDQ.L #6,SP
 MOVE.L D0,SPAR+4

 PEA MOUSE2
 MOVE.W #3,-(SP)
 MOVE.W #25,-(SP)
 TRAP #14
 ADDQ.L #8,SP

 CLR.W -(SP)     ;SETSCR
 PEA SCR
 PEA SCR
 MOVE.W #5,-(SP)
 TRAP #14
 ADD.L #12,SP

 MOVE.W #34,-(SP)
 TRAP #14
 ADDQ.L #2,SP
 MOVE.L D0,A0
 MOVE.L A0,SPARK+4
 MOVE.L 16(A0),SPARK
 MOVE.L #MOUSEINT,16(A0)

 AND.B #%11111110,$484
 LEA $FF8240,A0
 LEA OPAL,A1
 MOVEQ #7,D0
 BSR COPY
 LEA PAL,A0
 LEA $FF8240,A1
 MOVEQ #7,D0
 BSR COPY

 LEA SCR1,A0
 MOVE.W #15999,D0
CLS:
 CLR.L (A0)+
 DBRA D0,CLS

 MOVE.W #$2700,SR
 MOVE.L $70,OVBL
 MOVE.L #VBL,$70
 MOVE.W #$2300,SR

DEADLOP:
 CMP.B #$66,$FFFC02
 BNE DEADLOP

EXIT:
 MOVE.W #$2700,SR
 MOVE.L OVBL,$70
 MOVE.W #$2300,SR

 MOVE.W #1,-(SP)
 PEA SCR
 PEA SCR
 MOVE.W #5,-(SP)
 TRAP #14
 ADD.L #12,SP

 MOVE.L SPARK+4,A0
 MOVE.L SPARK,16(A0)

 LEA OPAL,A0
 LEA $FF8240,A1
 MOVEQ #7,D0
 BSR COPY

 MOVE.L SPAR+4,-(SP)
 MOVE.W #$20,-(SP)
 TRAP #1
 ADDQ.L #6,SP

 PEA MOUSE+2
 MOVE.W #1,-(SP)
 MOVE.W #25,-(SP)
 TRAP #14
 ADDQ.L #8,SP
 ILLEGAL
COPY:
 MOVE.L (A0)+,(A1)+
 DBRA D0,COPY
 RTS


VBL:
; MOVE.W #$0,$FF8240
 LEA SCREENS,A0
 MOVE.L (A0),D0
 MOVE.L 4(A0),D1
 EXG.L D0,D1
 MOVE.L D0,(A0)
 MOVE.L D1,4(A0)
 MOVE.L D0,A6

 JSR BOMBMAN
 JSR HERO
 JSR BOMBS
 JSR CONTROL
 JSR COLLISION
 JSR SCORE

 MOVE.B SCREENS+1,$FF8201
 MOVE.B SCREENS+2,$FF8203
 ADDQ.W #1,CLOCK
; MOVE.W #$777,$FF8240
 RTE

COLLISION:
 LEA BOMBTAB+2,A0
 MOVE.W HEROX+2,D0

 MOVEQ #15,D1
COLL1:
 CMP.W (A0),D0
 BEQ YESCOLL
COBACK:
 ADDQ.W #4,A0
 DBRA D1,COLL1
 RTS
YESCOLL:
 CMP.W #32000-(64*160),-2(A0)
 BGE YESCOLL2
 BRA COBACK
YESCOLL2:
 BSET #15,(A0)
 BSET #14,(A0)
 ADDQ.L #1,SCORE+2
 BRA COBACK

CONTROL:
; TST.B READFLAG
; BEQ NOWAY
 CLR.B READFLAG
 MOVE.W HEROX+2,D0
; MOVE.B READOUT,D1
; BTST #7,D1
; BNE LEFT
; BRA RIGHT

 MOVE.B $FFFC02,D1
 CMP.B #$4D,D1
 BEQ RIGHT
 CMP.B #$4B,D1
 BEQ LEFT
NOWAY:
 RTS
RIGHT:
 CMP.W #144,D0
 BEQ NOWAY
 ADD.W #8,D0
 MOVE.W HEROX+2,OLDX2+2
 MOVE.W D0,HEROX+2
 RTS
LEFT:
 TST.W D0
 BEQ NOWAY
 SUB.W #8,D0
 MOVE.W HEROX+2,OLDX2+2
 MOVE.W D0,HEROX+2
 RTS

HERO:
 MOVE.L A6,A1
OLDX2:         ;PEK!
 ADD.W #0,A1
 ADD.W #(168*160)+32,A1
 MOVEQ #7,D6 ;CLEAR OLD POSITION
 MOVEQ #0,D0
 MOVE.L D0,D1
 MOVE.L D1,D2
 MOVE.L D2,D3
 MOVE.W #208,D4
HERO2:
 MOVEM.L D0-D3,-(A1)
 MOVEM.L D0-D3,-(A1)
 MOVEM.L D0-D3,-(A1)
 ADD.W D4,A1
 MOVEM.L D0-D3,-(A1)
 MOVEM.L D0-D3,-(A1)
 MOVEM.L D0-D3,-(A1)
 ADD.W D4,A1
 MOVEM.L D0-D3,-(A1)
 MOVEM.L D0-D3,-(A1)
 MOVEM.L D0-D3,-(A1)
 ADD.W D4,A1
 MOVEM.L D0-D3,-(A1)
 MOVEM.L D0-D3,-(A1)
 MOVEM.L D0-D3,-(A1)
 ADD.W D4,A1
 DBRA D6,HERO2

 LEA BOMBGRAF+384,A0
 MOVE.L A6,A1
 ADD.W #168*160,A1
HEROX:
 ADD.W #0,A1
 MOVE.W #156,D7
 MOVEQ #31,D6
HERO1:
 MOVEM.W (A0)+,D0-D5
 MOVE.W D0,(A1)+
 MOVE.W D1,(A1)+
 MOVE.W D2,(A1)
 MOVE.W D3,4(A1)
 MOVE.W D4,6(A1)
 MOVE.W D5,8(A1)
 ADD.W D7,A1
 DBRA D6,HERO1

 RTS

BOMBMAN:
 MOVE.L A6,A1
OLDX:         ;PEK!
 ADD.W #0,A1
 ADD.W #16,A1
 MOVEQ #49,D6 ;CLEAR OLD POSITION
 MOVEQ #0,D0
 MOVE.L D0,D1
 MOVE.L D1,D2
 MOVE.L D2,D3
 MOVE.W #176,D4
BOMB9:
 MOVEM.L D0-D3,-(A1)
 ADD.W D4,A1
 DBRA D6,BOMB9

 LEA BOMBGRAF+768,A0
 MOVE.L A6,A1
BOMBX:  ;PEK!
 ADD.W #0,A1
 MOVE.W #156,D7
 MOVEQ #49,D6
BOMB1:
 MOVEM.W (A0)+,D0-D5
 MOVE.W D0,(A1)+
 MOVE.W D1,(A1)+
 MOVE.W D2,(A1)
 MOVE.W D3,4(A1)
 MOVE.W D4,6(A1)
 MOVE.W D5,8(A1)
 ADD.W D7,A1
 DBRA D6,BOMB1
 RTS


BOMBS:
 LEA BOMBTAB,A2
 MOVEQ #15,D0
BOMB3:
 MOVE.W D0,A3
BPEK1:        ;PEK!
 LEA BOMBGRAF,A0
 MOVE.L A6,A1
 ADD.W (A2)+,A1
 MOVE.W (A2)+,D0
 BTST #15,D0
 BNE SPECIAL      ;CLEAR BOMB
 ADD.W D0,A1
 MOVE.W #156,D7
 MOVEQ #31,D6

 MOVEQ #0,D0
 MOVE.L D0,-160(A1)
 MOVE.W D0,-156(A1)
 MOVE.L D0,-152(A1)
 MOVE.W D0,-148(A1)
 MOVE.L D0,-320(A1)
 MOVE.W D0,-316(A1)
 MOVE.L D0,-312(A1)
 MOVE.W D0,-308(A1)

BOMB2:
 MOVEM.W (A0)+,D0-D5
 MOVE.W D0,(A1)+
 MOVE.W D1,(A1)+
 MOVE.W D2,(A1)
 MOVE.W D3,4(A1)
 MOVE.W D4,6(A1)
 MOVE.W D5,8(A1)
 ADD.W D7,A1
 DBRA D6,BOMB2
BBACK:
 MOVE.W A3,D0
 DBRA D0,BOMB3

 JSR MOVBOMB
 JSR NEWBOMB
 RTS
SPECIAL:
 BTST #14,D0
 BEQ SPEC2

 BCLR #14,D0
 MOVE.W D0,-2(A2)
 JMP SPEC3
SPEC2:
 MOVE.W #32000,-4(A2)
SPEC3:
 BCLR #15,D0
 SUB.W #320,A1
 ADD.W D0,A1
 MOVEQ #0,D2
 MOVEQ #8,D3
SPEC1:
 MOVE.L D2,(A1)
 MOVE.W D2,4(A1)
 MOVE.L D2,8(A1)
 MOVE.W D2,12(A1)

 MOVE.L D2,160(A1)
 MOVE.W D2,164(A1)
 MOVE.L D2,168(A1)
 MOVE.W D2,172(A1)

 MOVE.L D2,320(A1)
 MOVE.W D2,324(A1)
 MOVE.L D2,328(A1)
 MOVE.W D2,332(A1)

 MOVE.L D2,480(A1)
 MOVE.W D2,484(A1)
 MOVE.L D2,488(A1)
 MOVE.W D2,492(A1)

 ADD.W #640,A1
 DBRA D3,SPEC1
 BRA BBACK

MOVBOMB:
 LEA BOMBTAB+64,A0
 MOVEQ #15,D0
BOMB7:
 SUBQ.W #2,A0
 CMP.W #32000,-(A0)
 BGE BOMB8
 ADD.W #160,(A0)
 DBRA D0,BOMB7
 RTS
BOMB8:
 MOVE.W #32000,(A0)
 DBRA D0,BOMB7
 RTS

NEWBOMB:
 SUBQ.W #1,NEWSPEED
 BNE NONEW

 MOVE.W #5,NEWSPEED

 LEA BOMBTAB+64,A0
 MOVEQ #15,D0
BOMB4:
 SUBQ.W #2,A0
 CMP.W #32000,-(A0)
 BEQ BOMB5
 DBRA D0,BOMB4
NONEW:
 RTS         ;NO NEW BOMB
BOMB5:  ;PEK!
 MOVE.B BOMBRAND,D0
 CMP.B #$FF,D0
 BNE BOMB6
 MOVE.L #BOMBRAND,BOMB5+2
 MOVE.B #144,D0
BOMB6:
 ADDQ.L #1,BOMB5+2

 LEA BOMBTAB+2,A1
 MOVEQ #15,D1
BOMB11:
 CMP.W (A1),D0
 BNE BOMB12
 CMP.W #160*82,-2(A1)
 BLO NONEW
BOMB12:
 ADDQ.W #4,A1
 DBRA D1,BOMB11

 MOVE.W BOMBX+2,OLDX+2
 MOVE.W D0,BOMBX+2
 MOVE.W #50*160,(A0)+
 MOVE.W D0,(A0)+
 RTS

SCORE:          ;PEK!
 MOVE.L #0,D0   ;SCORE VARIABEL
 MOVEQ #10,D2
 LEA TBUF,A0
 MOVE.L #0,D1
 MOVE.W D1,(A0)+
 MOVE.L D1,(A0)+
 MOVE.L D1,(A0)+
DCI1:
 CMP.L D2,D0
 BLO DCI2
 DIVU D2,D0
 SWAP D0
 MOVE.B D0,-(A0)
 CLR.W D0
 SWAP D0
 JMP DCI1
DCI2:
 MOVE.B D0,-(A0)

 MOVE.L A6,A1
 ADD.W #(64*160)+64+6,A1
 LEA TBUF+2,A2
 MOVEQ #7,D3
DCI3:
 LEA FONT+(16*32),A0
 CLR.W D0
 MOVE.B (A2)+,D0
 LSL.W #5,D0
 ADD.W D0,A0
 MOVE.W (A0)+,(A1)
 MOVE.W (A0)+,160(A1)
 MOVE.W (A0)+,320(A1)
 MOVE.W (A0)+,480(A1)
 MOVE.W (A0)+,640(A1)
 MOVE.W (A0)+,800(A1)
 MOVE.W (A0)+,960(A1)
 MOVE.W (A0)+,1120(A1)
 MOVE.W (A0)+,1280(A1)
 MOVE.W (A0)+,1440(A1)
 MOVE.W (A0)+,1600(A1)
 MOVE.W (A0)+,1760(A1)
 MOVE.W (A0)+,1920(A1)
 MOVE.W (A0)+,2080(A1)
 MOVE.W (A0)+,2240(A1)
 MOVE.W (A0)+,2400(A1)
 ADDQ.W #8,A1
 DBRA D3,DCI3
 RTS



MOUSEINT:
 TST.B READFLAG
 BNE MOUS2
 MOVE.B 1(A0),D0
 TST.B D0
 BEQ MOUS2
; CMP.B READOUT+1,D0
; BEQ MOUS2
; MOVE.B READOUT,READOUT+1
 MOVE.B D0,READOUT
 ST.B READFLAG
MOUS2:
 RTS
READFLAG:
 DC.W 0
READOUT:
 DC.W 0

SPARK:
 DC.L 0,0

NEWSPEED:
 DC.W 20

SPAR: DS.L 10

PAL:
 DC.W $007,$777,$733,$770,$000,$040,$445,$420
 DC.W $700,$777,$733,$770,$000,$040,$445,$420
OPAL:
 DS.W 16,0
OVBL:
 DC.L 0

MOUSE:
 DC.B $08,$14,$14,8
MOUSE2:
 DC.B $08,$0B,1,1,0,0

TBUF:
 DS.B 10,' '

SCREENS:
 DC.L SCR1,SCR

CLOCK:
 DC.W 0

FONT:
 IBYTES SMALLFNT.DAT
BOMBRAND:
 IBYTES BOMBRAND.DAT
 DC.B $FF
 ALIGN.W
BOMBTAB:
 DS.L 32,$7D000000
BOMBGRAF:
 IBYTES BOMBER.DAT
 END

