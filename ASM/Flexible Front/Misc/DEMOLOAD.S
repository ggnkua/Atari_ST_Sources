 CLR.L -(SP)
 MOVE.W #$20,-(SP)
 TRAP #1
 ADDQ.L #6,SP

 MOVE.L #450000,-(SP)
 MOVE.L #40000,-(SP)
 CLR.W -(SP)
 MOVE.W #$4A,-(SP)
 TRAP #1
 ADD.L #12,SP

 LEA START,A0
 LEA 50000,A1
 MOVE.W #THEEND-START,D0
MOVEIT:
 MOVE.B (A0)+,(A1)+
 DBRA D0,MOVEIT

 JMP 50000



START:
 LEA 50000,SP
 LEA FILES(PC),A6
 BRA LOAD_AND_EXECUTE


LOAD_AND_EXECUTE:
 CLR.W -(SP)     ;OPEN
 PEA 8(A6)
 MOVE.W #$3D,-(SP)
 TRAP #1
 ADDQ.L #8,SP
 TST.L D0
 BMI ERROR
 MOVE.W D0,D6

 MOVE.L (A6)+,-(SP)  ;READ
 MOVE.L #300000,-(SP)
 MOVE.W D6,-(SP)
 MOVE.W #$3F,-(SP)
 TRAP #1
 ADD.L #12,SP

 MOVE.W D6,-(SP)     ;CLOSE
 MOVE.W #$3E,-(SP)
 TRAP #1
 ADDQ.L #4,SP

 MOVE.L (A6),A0     ;EXECUTE
 JMP (A0)
 RTS
ERROR:
 ADDQ.W #1,$FF8240
 BRA.S ERROR

FILES:
 DC.L $10000,$10000
 DC.B 'SCRSCROL.B',0,'   '

 ds.b 10,0
THEEND:
 END

