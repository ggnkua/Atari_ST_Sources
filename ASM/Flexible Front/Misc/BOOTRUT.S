; LEA BOOT1+4,A0
; MOVE.W #254,D0
;DCRY:
; EOR.L #'ZZAP',(A0)+
; DBRA D0,DCRY
; MOVE.W #2,-(SP)
; MOVE.W #0,-(SP)
; MOVE.W #0,-(SP)
; MOVE.W #8,-(SP)
; MOVE.W #0,-(SP)
; CLR.L -(SP)
; PEA BOOT1
; MOVE.W #9,-(SP)
; TRAP #14
; ADD.L #20,SP
; ILLEGAL
;BOOT1:
; IBYTES BOOTRUT.B
; END

 ORG 50000
SCR=$76000
 BRA.S GO
NR:
 DC.W 0
GO:
 CMP.L #'ZZAP',TEST
 BEQ.S ROUT
CRASH:
 BRA.S CRASH
ROUT:
 MOVE.B #07,$FF8201
 MOVE.B #$60,$FF8203
 CLR.B $FF8260
 MOVE.L #$00000740,$FF8240
 MOVE.L #$06660770,$FF8240+4
 MOVE.L #SCR,$44E
 BSR CLS
 LEA GRAF,A0
 LEA SCR+(20*160)+72,A1
 BSR SPRT
 LEA SCR+(184*160),A1
 BSR SPRT
 LEA TXT,A0
 BSR PRINT
LOAD:
 MOVE.W #1,D7
 LEA $24576,A6
NEXT:
 MOVEM.L D7/A6,-(SP)
 MOVE.W #9,-(SP)
 CLR.W -(SP)
 MOVE.W D7,-(SP)
 MOVE.W #1,-(SP)
 MOVE.W #0,-(SP)
 CLR.L -(SP)
 MOVE.L A6,-(SP)
 MOVE.W #8,-(SP)
 TRAP #14
 ADD.L #20,SP
 MOVEM.L (SP)+,D7/A6
 ADD.L #5120-512,A6
 ADDQ.W #1,D7
 CMP.W #21,D7
 BEQ EXIT
 CMP.B #$2E,$FFFC02
 BEQ COPY
 BRA NEXT
EXIT:
 LEA $24576,A0
 MOVE.W #19999,D0
DCRY:
 EOR.L #'ZZAP',(A0)+
 DBRA D0,DCRY
 JMP $24576
COPY:
 BSR CLS
 LEA TXT1,A0
 BSR PRINT
 CLR.W D7
 LEA 51024,A6
NEXT1:
 MOVEM.L D7/A6,-(SP)
 MOVE.W #9,-(SP)
 CLR.W -(SP)
 MOVE.W D7,-(SP)
 MOVE.W #1,-(SP)
 MOVE.W #0,-(SP)
 CLR.L -(SP)
 MOVE.L A6,-(SP)
 MOVE.W #8,-(SP)
 TRAP #14
 ADD.L #20,SP
 MOVEM.L (SP)+,D7/A6
 ADD.L #5120-512,A6
 ADDQ.W #1,D7
 CMP.W #81,D7
 BNE NEXT1
 LEA TXT2,A0
 BSR PRINT
 CLR.W $444
 BSR SPACE
 LEA TXT3,A0
 BSR PRINT
 ADDQ.W #1,51024+(7*512)+2
 LEA 51024,A6
 CLR.W D7
NEXT2:
 MOVEM.L D7/A6,-(SP)
 MOVE.W #$E5E5,-(SP)
 MOVE.L #$87654321,-(SP)
 MOVE.W #1,-(SP)
 MOVE.W #0,-(SP)
 MOVE.W D7,-(SP)
 MOVE.W #9,-(SP)
 MOVE.W #0,-(SP)
 CLR.L -(SP)
 PEA 30000
 MOVE.W #10,-(SP)
 TRAP #14
 ADD.L #26,SP
 MOVEM.L (SP)+,D7/A6

 MOVEM.L D7/A6,-(SP)
 MOVE.W #9,-(SP)
 MOVE.W #0,-(SP)
 MOVE.W D7,-(SP)
 MOVE.W #1,-(SP)
 MOVE.W #0,-(SP)
 CLR.L -(SP)
 MOVE.L A6,-(SP)
 MOVE.W #9,-(SP)
 TRAP #14
 ADD.L #20,SP
 MOVEM.L (SP)+,D7/A6
 ADD.W #5120-512,A6
 ADDQ.W #1,D7
 CMP.W #81,D7
 BNE NEXT2
 LEA TXT4,A0
 BSR PRINT
 BSR SPACE
 JMP $FC0000
SPACE:
 LEA $FFFC02,A0
 CLR.B (A0)
SP1:
 CMP.B #$39,(A0)
 BNE SP1
 CLR.B (A0)
 RTS
SPRT:
 MOVEQ #15,D0
SAP1:
 MOVE.W (A0)+,(A1)
 MOVE.W (A0)+,8(A1)
 ADD.W #160,A1
 DBRA D0,SAP1
 RTS
PRINT:
 MOVE.L A0,-(SP)
 MOVE.W #9,-(SP)
 TRAP #1
 ADDQ.L #6,SP
 RTS
CLS:
 LEA SCR,A0
 MOVE.W #7999,D0
CLS1:
 CLR.L (A0)+
 DBRA D0,CLS1
 RTS
TXT:
 DC.B 27,'Y',32,42,27,'b',2,'ZZAP GAMES PRESENT:'
 DC.B 27,'Y',39,35,'THIS DEMO IS SHARE WARE SOFT AND'
 DC.B 27,'Y',40,35,'DESIGNED TO PROVIDE YOU WITH SOME'
 DC.B 27,'Y',41,35,'MEANINGLESS FUN.'
 DC.B 27,'Y',43,49,'ENJOY!!!'
 DC.B 27,'Y',45,38,'LOADING DEMO3. PLEASE WAIT.'
 DC.B 27,'Y',48,40,27,'b',3,"PRESS 'C' TO COPY DISK."
 DC.B 27,'Y',57,35,'ALIN...'
 DC.B 0
 ALIGN.W
TXT1:
 DC.B 27,'Y',32,32,'DEMO3 COPIER.',10,13
 DC.B 'READING DEMO DISK...',10,13,0
TXT2:
 DC.B 'INSERT DESTINATION DISK AND PRESS SPACE',10,13,0
TXT3:
 DC.B 'FORMATTING AND WRITING...',10,13,0
TXT4:
 DC.B 'FINISHED. PRESS SPACE FOR RESET.',0
 ALIGN.W
GRAF:
 IBYTES BOOTGX.DAT
TEST: DC.B 'ZZAP'
 END

