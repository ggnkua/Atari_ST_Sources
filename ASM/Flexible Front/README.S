A short message from STalin of Flexible Front... 24/7-1989
Here are the sources for my whattaheck screens, maybe
some soon-to-be-demo-programmers can find them interesting.
They aren't very well commented, so I guess that they look
quite messy sometimes...

The repeat-until commands works simular to the 'rept' function
in Devpac.
The align.w command is equal to the 'even' function in other
assemblers.
Ds.b x,y fills a block of x bytes with the y value.
Ibytes includes a binary file, just like incbin in devpac.

These sources are public domain, but I hardly have to say
that anyone that rewrites the scrolltext and re-releases
the screens under their names are real suckers and will
always be recognized as mega-lamers.

Bye, bye!
