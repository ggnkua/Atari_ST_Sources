 LEA BILD,A0
 LEA BUFF,A1

 MOVE.W #149,D1
CONV1:
 MOVE.L A0,A2
 MOVE.W #15,D0
CONV:
 MOVE.W (A2),(A1)+
 ADDQ.W #8,A2
 DBRA D0,CONV
 ADD.W #160,A0
 DBRA D1,CONV1

 MOVE.W #0,-(SP)
 PEA FILE
 MOVE.W #$3C,-(SP)
 TRAP #1
 ADDQ.L #8,SP
 MOVE.W D0,HAND

 PEA BUFF
 MOVE.L #4800,-(SP)
 MOVE.W HAND,-(SP)
 MOVE.W #$40,-(SP)
 TRAP #1
 ADD.L #12,SP

 MOVE.W HAND,-(SP)
 MOVE.W #$3E,-(SP)
 TRAP #1
 ADDQ.L #4,SP
 ILLEGAL
HAND:
 DC.W 0
FILE:
 DC.B 'BIFF.PIC',0
 ALIGN.W
BILD:
 IBYTES BIGFF.ART
BUFF:
 DS.B 8000
 END

