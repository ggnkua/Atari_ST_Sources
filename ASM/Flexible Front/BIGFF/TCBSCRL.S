SCR=$F8000
SCR1=$F0000 ;-(32*256)

 BRA START
BUFF:
 DS.B 3000,0

START:
 CLR.L -(SP)     ;SV MODE
 MOVE.W #$20,-(SP)
 TRAP #1
 ADDQ.L #6,SP
 MOVE.L D0,SPAR+4

 MOVE.W #5,-(SP)
 MOVE.W #26,-(SP)
 TRAP #14
 ADDQ.L #4,SP

 PEA MOUSE
 MOVE.W #1,-(SP)
 MOVE.W #25,-(SP)
 TRAP #14
 ADDQ.L #8,SP

 CLR.W -(SP)     ;SETSCR
 PEA SCR
 PEA SCR
 MOVE.W #5,-(SP)
 TRAP #14
 ADD.L #12,SP

 LEA $FF8240,A0
 LEA OPAL,A1
 MOVEQ #7,D0
 BSR COPY
 LEA PAL,A0
 LEA $FF8240,A1
 MOVEQ #7,D0
 BSR COPY

 LEA $FC0000,A0
 LEA SCR1,A1
 MOVE.W #15999,D0
FILL:
 MOVE.L (A0)+,(A1)+
 DBRA D0,FILL

 MOVE.W #$2700,SR
 JSR INITRAST
 MOVE.L $70,OVBL
 MOVE.L #VBL,$70
 MOVE.W #$2300,SR

DEADLOP:
 CMP.B #$66,$FFFC02
 BNE DEADLOP

EXIT:
 BCLR #0,$FF820A
 MOVE.W #$2700,SR
 MOVE.L OVBL,$70
 JSR REMOVERAST
 MOVE.W #$2300,SR

 MOVE.W #1,-(SP)
 PEA SCR
 PEA SCR
 MOVE.W #5,-(SP)
 TRAP #14
 ADD.L #12,SP

 LEA OPAL,A0
 LEA $FF8240,A1
 MOVEQ #7,D0
 BSR COPY

 MOVE.W #5,-(SP)
 MOVE.W #27,-(SP)
 TRAP #14
 ADDQ.L #4,SP

 MOVE.L SPAR+4,-(SP)
 MOVE.W #$20,-(SP)
 TRAP #1
 ADDQ.L #6,SP

 PEA MOUSE+2
 MOVE.W #1,-(SP)
 MOVE.W #25,-(SP)
 TRAP #14
 ADDQ.L #8,SP
 ILLEGAL
COPY:
 MOVE.L (A0)+,(A1)+
 DBRA D0,COPY
 RTS


VBL:
 MOVE.W #$0,$FF8240
 CLR.B $FFFA1B
 MOVE.B #1,D0
 MOVE.B D0,$FFFA21
 MOVE.B #8,$FFFA1B

 MOVE.L #HBL1,$120

;WAIT:
; TST.B $FF8209
; BEQ WAIT

; BSET #0,$FF820A

 LEA SCREENS,A0
 MOVE.L (A0),D0
 MOVE.L 4(A0),D1
 EXG.L D0,D1
 MOVE.L D0,(A0)
 MOVE.L D1,4(A0)
 MOVE.L D0,A6

 CMP.B #$39,$FFFC02
 BNE NOKEY
 CMP.B #7,SC
 BNE NK2
 MOVE.B #0,SC
NK2:
 ADDQ.B #1,SC
NOKEY:
; MOVE.B SCREENS+1,$FF8201
; MOVE.B SCREENS+2,$FF8203
 ADDQ.W #1,CLOCK
 RTE
SC: DC.B 5,0

INITRAST:
 MOVE.L $120,SPAR2
 MOVE.B $FFFA09,SPAR4
 MOVE.B $FFFA07,SPAR4+1
 MOVE.B $FFFA13,SPAR4+2
 MOVE.L #HBL1,$120
 ORI.B #1,$FFFA07
 ORI.B #1,$FFFA13
 RTS

REMOVERAST:
 MOVE.B SPAR4,$FFFA09
 MOVE.B SPAR4+1,$FFFA07
 MOVE.B SPAR4+2,$FFFA13
 MOVE.L SPAR2,$120
 RTS

HBL1:
  MOVE.B $FF8209,D0
WAIT2:
  CMP.B $FF8209,D0
  BEQ WAIT2
 BSET #0,$FF820A
 MOVE.L #HBL2,$120
 CLR.B $FFFA1B
 MOVE.B SC,D0
 MOVE.B D0,$FFFA21
 MOVE.B #8,$FFFA1B
 BCLR #0,$FFFA0F
 RTE

HBL2:
  MOVE.B $FF8209,D0
WAIT3:
  CMP.B $FF8209,D0
  BEQ WAIT3
 BCLR #0,$FF820A
 CLR.B $FFFA1B
 MOVE.B #200,D0
 MOVE.B D0,$FFFA21
 MOVE.B #8,$FFFA1B
 BCLR #0,$FFFA0F
 RTE

HBLCOUNT:
 DC.W 1
SPAR1: DC.L 0
SPAR2: DC.L 0
SPAR3: DC.L 0
SPAR4: DC.L 0
SPAR5: DC.W 0
SPAR: DS.L 10

PAL:
 DC.W $000,$117,$770,$006,$040,$006,$040,$006
 DC.W $000,$117,$000,$115,$040,$006,$040,$006
OPAL:
 DS.W 16,0
OVBL:
 DC.L 0

MOUSE:
 DC.B $12,$1A,$14,8

SCREENS:
 DC.L SCR1,SCR

CLOCK:
 DC.W 0
 END

