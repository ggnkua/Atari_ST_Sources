	.export	swap
	
swap:	swap d0
		rts
		