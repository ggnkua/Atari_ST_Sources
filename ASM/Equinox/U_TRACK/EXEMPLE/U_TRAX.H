/* ~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~ */
/* Defines des numВros des fonctions APPL_WRITE */
/* ~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~ */

/* Commands sent to the player */

#define		T_LOAD			900
#define		T_PLAY			901
#define		T_FORWARD		902
#define		T_REWIND		903
#define		T_PAUSE			904
#define		T_STOP			905
#define		T_ABOUT			906
#define		T_OPEN			907
#define		T_CLOSE			908
#define		T_FREQ			909
#define		T_LOOP			910
#define		T_IDENT			911
#define		T_FIDENT		912
#define		T_INFOS			913
#define		T_OPN_OSCILLO	914
#define		T_CLS_OSCILLO	915

/* Message received from the player */

#define		R_LOAD			950
#define		R_PLAY			951
#define		R_FORWARD		952
#define		R_REWIND		953
#define		R_PAUSE_ON		954
#define		R_PAUSE_OFF		955
#define		R_STOP			956
#define		R_OPEN			957
#define		R_CLOSE			958
#define		R_FREQ			959
#define		R_LOOP_OFF		960
#define		R_LOOP_ON		961
#define		R_BEGLOAD		962
#define		R_ENDLOAD		963
#define		R_FAILOAD		964
#define		R_MOVE			965
#define		R_INFOS			966
#define		R_POSIT			967
#define		R_QUIT			968
#define		R_ENDMOD		969
#define		R_PROTECMOD		970
#define		R_OPN_OSCILLO	971
#define		R_CLS_OSCILLO	972
#define		R_MOVE_OSCILLO	973

#define		ID_TRACK		999	
#define		ID_REPONSE		998

