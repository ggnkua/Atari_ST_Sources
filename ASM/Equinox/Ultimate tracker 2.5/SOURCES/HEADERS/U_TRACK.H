
#define MENU               0 	/* TREE - MENU   */
#define MABOUT             8 	/* G_STRING in (#0) MENU */
#define MLOAD             17 	/* G_STRING in (#0) MENU */
#define MQUIT1            19 	/* G_STRING in (#0) MENU */
#define WCYCLE            21 	/* G_STRING in (#0) MENU */
#define WTRACK            23 	/* G_STRING in (#0) MENU */
#define WOSCILLO          24 	/* G_STRING in (#0) MENU */
#define WVUMETRE          25 	/* G_STRING in (#0) MENU */
#define WCONFIGURE        27 	/* G_STRING in (#0) MENU */
#define WLISTE            28 	/* G_STRING in (#0) MENU */

#define FENLOW16           1 	/* TREE - DIALOG */

#define FENLOWM            2 	/* TREE - DIALOG */

#define ABLOW16            3 	/* TREE - DIALOG */

#define ABLOWMON           4 	/* TREE - DIALOG */

#define RQLOW16            5 	/* TREE - DIALOG */

#define RQLOWM             6 	/* TREE - DIALOG */

#define STATLW16           7 	/* TREE - DIALOG */

#define STLOWMON           8 	/* TREE - DIALOG */

#define LISTLOW16          9 	/* TREE - DIALOG */

#define LISTLOWM          10 	/* TREE - DIALOG */

#define FEN16             11 	/* TREE - DIALOG */
#define INFOS              1 	/* G_BUTTON in (#11) FEN16 */
#define PH1                2 	/* G_TEXT in (#11) FEN16 */
#define INFOS2             3 	/* G_BUTTON in (#11) FEN16 */
#define PH2                4 	/* G_TEXT in (#11) FEN16 */
#define BSPEKTRU           5 	/* G_BOXCHAR in (#11) FEN16 */
#define ICSPEKTR           6 	/* G_IMAGE in (#11) FEN16 */
#define BOSCILLO           7 	/* G_BOXCHAR in (#11) FEN16 */
#define ICOSCILL           8 	/* G_IMAGE in (#11) FEN16 */
#define INFOS3             9 	/* G_BOX in (#11) FEN16 */
#define PREV_MOD          13 	/* G_BOXCHAR in (#11) FEN16 */
#define ASC               14 	/* G_BOX in (#11) FEN16 */
#define BITONIO           15 	/* G_BOX in (#11) FEN16 */
#define TPREV_MOD         16 	/* G_STRING in (#11) FEN16 */
#define PLAYLIST          17 	/* G_BUTTON in (#11) FEN16 */
#define NOM               18 	/* G_FTEXT in (#11) FEN16 */
#define NEXT_MOD          19 	/* G_BOXCHAR in (#11) FEN16 */
#define TNEXT_MOD         20 	/* G_STRING in (#11) FEN16 */
#define LOAD              22 	/* G_BUTTON in (#11) FEN16 */
#define ICLOAD            23 	/* G_IMAGE in (#11) FEN16 */
#define REWIND            24 	/* G_BUTTON in (#11) FEN16 */
#define ICREWIND          25 	/* G_IMAGE in (#11) FEN16 */
#define BPLAY             26 	/* G_BUTTON in (#11) FEN16 */
#define ICPLAY            27 	/* G_IMAGE in (#11) FEN16 */
#define FORWARD           28 	/* G_BUTTON in (#11) FEN16 */
#define ICFORWRD          29 	/* G_IMAGE in (#11) FEN16 */
#define PAUSE             30 	/* G_BUTTON in (#11) FEN16 */
#define ICPAUSE           31 	/* G_IMAGE in (#11) FEN16 */
#define STOP              32 	/* G_BUTTON in (#11) FEN16 */
#define ICSTOP            33 	/* G_IMAGE in (#11) FEN16 */
#define F625              37 	/* G_BUTTON in (#11) FEN16 */
#define F125              38 	/* G_BUTTON in (#11) FEN16 */
#define F25               39 	/* G_BUTTON in (#11) FEN16 */
#define F50               40 	/* G_BUTTON in (#11) FEN16 */
#define LOOP              41 	/* G_BUTTON in (#11) FEN16 */
#define QUIT              43 	/* G_BUTTON in (#11) FEN16 */
#define CONFIG            44 	/* G_BUTTON in (#11) FEN16 */
#define FLUSH             45 	/* G_BUTTON in (#11) FEN16 */

#define AB16              12 	/* TREE - DIALOG */
#define AB_PH1             4 	/* G_TEXT in (#12) AB16 */

#define FENMONO           13 	/* TREE - DIALOG */

#define ABMON             14 	/* TREE - DIALOG */

#define RQ16              15 	/* TREE - DIALOG */
#define MSIZE              3 	/* G_FTEXT in (#15) RQ16 */
#define CSIZE              5 	/* G_FTEXT in (#15) RQ16 */
#define OKSIZE             6 	/* G_BUTTON in (#15) RQ16 */
#define CANCSIZE           7 	/* G_BUTTON in (#15) RQ16 */
#define LEFTMOD           10 	/* G_BUTTON in (#15) RQ16 */
#define PATHMOD           11 	/* G_FBOXTEXT in (#15) RQ16 */
#define RIGHTMOD          12 	/* G_BUTTON in (#15) RQ16 */
#define CHPATH            13 	/* G_BUTTON in (#15) RQ16 */
#define R68000_8          16 	/* G_BUTTON in (#15) RQ16 */
#define R68000_16         17 	/* G_BUTTON in (#15) RQ16 */
#define RDSP_16           18 	/* G_BUTTON in (#15) RQ16 */

#define RQMONO            16 	/* TREE - DIALOG */

#define STAT16            17 	/* TREE - DIALOG */
#define LGSTAT             3 	/* G_FTEXT in (#17) STAT16 */

#define STATMONO          18 	/* TREE - DIALOG */

#define LIST16            19 	/* TREE - DIALOG */
#define NBTOTAL            4 	/* G_TEXT in (#19) LIST16 */
#define PLAYING            6 	/* G_TEXT in (#19) LIST16 */
#define SORT               8 	/* G_BOXCHAR in (#19) LIST16 */
#define LIG1               9 	/* G_TEXT in (#19) LIST16 */
#define LIG2              10 	/* G_TEXT in (#19) LIST16 */
#define LIG3              11 	/* G_TEXT in (#19) LIST16 */
#define LIG4              12 	/* G_TEXT in (#19) LIST16 */
#define LIG5              13 	/* G_TEXT in (#19) LIST16 */
#define LIG6              14 	/* G_TEXT in (#19) LIST16 */
#define LIG7              15 	/* G_TEXT in (#19) LIST16 */
#define UP_LIST           16 	/* G_BOXCHAR in (#19) LIST16 */
#define DOWN_LIST         17 	/* G_BOXCHAR in (#19) LIST16 */
#define UP_LIST10         18 	/* G_BOXCHAR in (#19) LIST16 */
#define DOWN_LIST10       19 	/* G_BOXCHAR in (#19) LIST16 */
#define COMPTEUR          21 	/* G_TEXT in (#19) LIST16 */
#define BSAVE             23 	/* G_BUTTON in (#19) LIST16 */
#define ICSAVE            24 	/* G_IMAGE in (#19) LIST16 */
#define TSAVE             25 	/* G_TEXT in (#19) LIST16 */
#define BREPEAT           26 	/* G_BUTTON in (#19) LIST16 */
#define ICREPEAT          27 	/* G_IMAGE in (#19) LIST16 */
#define TREPEAT           28 	/* G_TEXT in (#19) LIST16 */
#define BLOAD             29 	/* G_BUTTON in (#19) LIST16 */
#define ICLLOAD           30 	/* G_IMAGE in (#19) LIST16 */
#define TLOAD             31 	/* G_TEXT in (#19) LIST16 */
#define BNEW              32 	/* G_BUTTON in (#19) LIST16 */
#define ICNEW             33 	/* G_IMAGE in (#19) LIST16 */
#define TNEW              34 	/* G_TEXT in (#19) LIST16 */
#define BADD              35 	/* G_BUTTON in (#19) LIST16 */
#define ICADD             36 	/* G_IMAGE in (#19) LIST16 */
#define TADD              37 	/* G_TEXT in (#19) LIST16 */
#define BREMOVE           38 	/* G_BUTTON in (#19) LIST16 */
#define ICREMOVE          39 	/* G_IMAGE in (#19) LIST16 */
#define TREMOVE           40 	/* G_TEXT in (#19) LIST16 */
#define TIME_PLAY         42 	/* G_FBOXTEXT in (#19) LIST16 */

#define LISTMONO          20 	/* TREE - DIALOG */

#define OSC16             21 	/* TREE - DIALOG */
#define OSC_FOND           1 	/* G_BOX in (#21) OSC16 */

#define OSCMONO           22 	/* TREE - DIALOG */
