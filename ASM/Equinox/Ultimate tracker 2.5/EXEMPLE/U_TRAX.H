/* ~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~ */
/* Defines des numВros des fonctions APPL_WRITE */
/* ~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~ */

/* Commands sent to the player */

#define		T_LOAD			900
#define		T_PLAY			901
#define		T_FORWARD		902
#define		T_REWIND		903
#define		T_PAUSE			904
#define		T_STOP			905
#define		T_ABOUT			906
#define		T_OPEN			907
#define		T_CLOSE			908
#define		T_FREQ			909
#define		T_LOOP			910
#define		T_IDENT			911
#define		T_FIDENT		912
#define		T_INFOS			913
#define		T_OPN_OSCILLO	914
#define		T_CLS_OSCILLO	915
#define		T_OPN_PLAYLIST	916
#define		T_CLS_PLAYLIST	917
#define		T_NEXT_MOD		918
#define		T_PREV_MOD		919
#define		T_OPN_VUM		920
#define		T_CLS_VUM		921
#define		T_SEL_PLST		922
#define		T_REMOVE_PLST	923
#define		T_ADD_PLST		924
#define		T_NEW_PLST		925
#define		T_LOAD_PLST		926
#define		T_SAVE_PLST		927
#define		T_LOOP_PLST		928
#define		T_TIME_PLST		929
#define		T_CYCLE_WIN		930
#define		T_PLAYLIST		931

/* Message received from the player */

#define		R_LOAD			950
#define		R_PLAY			951
#define		R_FORWARD		952
#define		R_REWIND		953
#define		R_PAUSE_ON		954
#define		R_PAUSE_OFF		955
#define		R_STOP			956
#define		R_OPEN			957
#define		R_CLOSE			958
#define		R_FREQ			959
#define		R_LOOP_OFF		960
#define		R_LOOP_ON		961
#define		R_BEGLOAD		962
#define		R_ENDLOAD		963
#define		R_FAILOAD		964
#define		R_MOVE			965
#define		R_INFOS			966
#define		R_POSIT			967
#define		R_QUIT			968
#define		R_ENDMOD		969
#define		R_PROTECMOD		970
#define		R_OPN_OSCILLO	971
#define		R_CLS_OSCILLO	972
#define		R_MOVE_OSCILLO	973
#define		R_OPN_PLAYLIST	974
#define		R_CLS_PLAYLIST	975
#define		R_MOVE_PLAYLIST	976
#define		R_NEXT_MOD		977
#define		R_PREV_MOD		978
#define		R_OPN_VUM		979
#define		R_CLS_VUM		980
#define		R_MOVE_VUM		981
#define		R_PLAYLIST		982
#define		R_SEL_PLST		983
#define		R_REMOVE_PLST	984
#define		R_ADD_PLST		985
#define		R_NEW_PLST		986
#define		R_BEG_LOAD_PLST	987
#define		R_BEG_SAVE_PLST	988
#define		R_LOOP_PLST_ON	989
#define		R_LOOP_PLST_OFF	990
#define		R_TIME_PLST		991
#define		R_CUR_TIME		992
#define		R_CYCLE_WIN		993
#define		R_DEL_PLST		994
#define		R_END_SAVE_PLST	995
#define		R_END_LOAD_PLST	996
#define		R_FAIL_LOAD_PLST 997
#define		R_FAIL_SAVE_PLST 998



