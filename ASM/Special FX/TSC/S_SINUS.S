 DC.W  395,394,394,393,392,391,390,389,388,387
 DC.W  386,385,384,383,382,381,380,378,377,376
 DC.W  375,373,372,371,369,368,367,365,364,362
 DC.W  361,360,358,357,355,354,352,351,350,348
 DC.W  347,345,344,343,341,340,338,337,336,334
 DC.W  333,332,331,329,328,327,326,324,323,322
 DC.W  321,320,319,318,317,316,315,314,313,312
 DC.W  312,311,310,309,309,308,307,307,306,306
 DC.W  305,305,305,304,304,304,304,303,303,303
 DC.W  303,303,303,303,303,304,304,304,304,305
 DC.W  305,305,306,306,307,308,308,309,310,310
 DC.W  311,312,313,314,315,316,317,318,319,320
 DC.W  321,322,323,325,326,327,329,330,331,333
 DC.W  334,336,337,339,340,342,343,345,347,348
 DC.W  350,352,353,355,357,359,360,362,364,366
 DC.W  367,369,371,373,375,376,378,380,382,384
 DC.W  385,387,389,391,392,394,396,398,399,401
 DC.W  403,404,406,407,409,411,412,414,415,417
 DC.W  418,419,421,422,423,425,426,427,428,429
 DC.W  430,431,432,433,434,435,436,437,438,438
 DC.W  439,439,440,440,441,441,442,442,442,442
 DC.W  442,443,443,442,442,442,442,442,441,441
 DC.W  441,440,439,439,438,437,437,436,435,434
 DC.W  433,432,430,429,428,427,425,424,422,421
 DC.W  419,417,415,414,412,410,408,406,404,401
 DC.W  399,397,395,392,390,387,385,382,380,377
 DC.W  374,371,369,366,363,360,357,354,351,348
 DC.W  344,341,338,335,331,328,325,321,318,314
 DC.W  311,307,304,300,297,293,289,286,282,278
 DC.W  274,271,267,263,259,256,252,248,244,240
 DC.W  237,233,229,225,221,217,214,210,206,202
 DC.W  198,194,191,187,183,179,176,172,168,165
 DC.W  161,157,154,150,146,143,139,136,132,129
 DC.W  126,122,119,116,112,109,106,103,100,96
 DC.W  93,90,87,84,81,79,76,73,70,68
 DC.W  65,62,60,57,55,52,50,48,45,43
 DC.W  41,39,37,35,33,31,29,27,25,24
 DC.W  22,20,19,17,16,14,13,11,10,9
 DC.W  8,6,5,4,3,2,1,0,0,-1
 DC.W  -2,-3,-3,-4,-5,-5,-6,-6,-7,-7
 DC.W  -8,-8,-8,-9,-9,-9,-9,-9,-9,-10
 DC.W  -10,-10,-10,-10,-10,-10,-10,-10,-9,-9
 DC.W  -9,-9,-9,-9,-9,-8,-8,-8,-8,-8
 DC.W  -7,-7,-7,-7,-6,-6,-6,-6,-6,-5
 DC.W  -5,-5,-5,-5,-4,-4,-4,-4,-4,-4
 DC.W  -4,-4,-4,-4,-4,-4,-4,-4,-4,-4
 DC.W  -4,-4,-5,-5,-5,-6,-6,-6,-7,-7
 DC.W  -8,-8,-9,-9,-10,-11,-11,-12,-13,-14
 DC.W  -15,-16,-17,-18,-19,-20,-21,-22,-24,-25
 DC.W  -26,-28,-29,-31,-32,-34,-35,-37,-39,-41
 DC.W  -43,-44,-46,-48,-50,-52,-55,-57,-59,-61
 DC.W  -64,-66,-68,-71,-73,-76,-78,-81,-84,-87
 DC.W  -89,-92,-95,-98,-101,-104,-107,-110,-113,-116
 DC.W  -119,-122,-126,-129,-132,-136,-139,-142,-146,-149
 DC.W  -153,-156,-160,-163,-167,-170,-174,-178,-181,-185
 DC.W  -189,-192,-196,-200,-204,-207,-211,-215,-219,-222
 DC.W  -226,-230,-234,-238,-241,-245,-249,-253,-257,-260
 DC.W  -264,-268,-272,-275,-279,-283,-286,-290,-294,-297
 DC.W  -301,-305,-308,-312,-315,-319,-322,-326,-329,-333
 DC.W  -336,-339,-343,-346,-349,-352,-355,-358,-361,-365
 DC.W  -367,-370,-373,-376,-379,-382,-384,-387,-390,-392
 DC.W  -395,-397,-400,-402,-404,-407,-409,-411,-413,-415
 DC.W  -417,-419,-421,-423,-424,-426,-428,-429,-431,-432
 DC.W  -434,-435,-436,-437,-439,-440,-441,-442,-443,-444
 DC.W  -444,-445,-446,-446,-447,-447,-448,-448,-448,-449
 DC.W  -449,-449,-449,-449,-449,-449,-449,-449,-448,-448
 DC.W  -448,-447,-447,-446,-446,-445,-445,-444,-443,-442
 DC.W  -441,-440,-440,-439,-438,-436,-435,-434,-433,-432
 DC.W  -430,-429,-428,-426,-425,-424,-422,-421,-419,-418
 DC.W  -416,-414,-413,-411,-409,-408,-406,-404,-403,-401
 DC.W  -399,-397,-395,-394,-392,-390,-388,-386,-384,-383
 DC.W  -381,-379,-377,-375,-373,-371,-370,-368,-366,-364
 DC.W  -362,-360,-359,-357,-355,-353,-352,-350,-348,-347
 DC.W  -345,-343,-342,-340,-338,-337,-335,-334,-332,-331
 DC.W  -329,-328,-327,-325,-324,-323,-322,-320,-319,-318
 DC.W  -317,-316,-315,-314,-313,-312,-311,-310,-310,-309
 DC.W  -308,-308,-307,-306,-306,-305,-305,-304,-304,-304
 DC.W  -303,-303,-303,-303,-303,-303,-302,-302,-302,-303
 DC.W  -303,-303,-303,-303,-304,-304,-304,-305,-305,-306
 DC.W  -306,-307,-307,-308,-309,-309,-310,-311,-312,-312
 DC.W  -313,-314,-315,-316,-317,-318,-319,-320,-321,-322
 DC.W  -323,-324,-326,-327,-328,-329,-330,-332,-333,-334
 DC.W  -336,-337,-338,-340,-341,-342,-344,-345,-346,-348
 DC.W  -349,-350,-352,-353,-355,-356,-357,-359,-360,-361
 DC.W  -363,-364,-365,-366,-368,-369,-370,-371,-373,-374
 DC.W  -375,-376,-377,-378,-379,-380,-381,-382,-383,-384
 DC.W  -385,-386,-387,-388,-388,-389,-390,-390,-391,-391
 DC.W  -392,-392,-393,-393,-393,-394,-394,-394,-394,-394
 DC.W  -394,-394,-394,-394,-394,-394,-393,-393,-393,-392
 DC.W  -392,-391,-390,-390,-389,-388,-387,-386,-385,-384
 DC.W  -383,-382,-381,-380,-378,-377,-376,-374,-373,-371
 DC.W  -369,-368,-366,-364,-362,-360,-358,-356,-354,-352
 DC.W  -349,-347,-345,-342,-340,-337,-335,-332,-329,-327
 DC.W  -324,-321,-318,-315,-312,-309,-306,-303,-300,-297
 DC.W  -294,-290,-287,-284,-280,-277,-273,-270,-266,-263
 DC.W  -259,-255,-252,-248,-244,-241,-237,-233,-229,-225
 DC.W  -221,-217,-214,-210,-206,-202,-198,-194,-190,-186
 DC.W  -182,-178,-174,-170,-165,-161,-157,-153,-149,-145
 DC.W  -141,-137,-133,-129,-125,-121,-117,-113,-109,-105
 DC.W  -101,-97,-93,-89,-85,-82,-78,-74,-70,-66
 DC.W  -63,-59,-55,-52,-48,-44,-41,-37,-34,-30
 DC.W  -27,-24,-20,-17,-14,-10,-7,-4,-1,2
 DC.W  5,8,11,14,17,19,22,25,28,30
 DC.W  33,35,38,40,42,45,47,49,51,53
 DC.W  55,57,59,61,63,65,67,68,70,72
 DC.W  73,75,76,78,79,80,81,83,84,85
 DC.W  86,87,88,89,90,90,91,92,93,93
 DC.W  94,95,95,96,96,96,97,97,97,98
 DC.W  98,98,98,98,99,99,99,99,99,99
 DC.W  99,99,99,98,98,98,98,98,98,97
 DC.W  97,97,97,96,96,96,96,95,95,95
 DC.W  94,94,94,94,93,93,93,93,92,92
 DC.W  92,92,91,91,91,91,91,90,90,90
 DC.W  90,90,90,90,90,90,90,90,90,91
 DC.W  91,91,91,91,92,92,93,93,93,94
 DC.W  94,95,96,96,97,98,98,99,100,101
 DC.W  102,103,104,105,106,107,109,110,111,112
 DC.W  114,115,117,118,120,122,123,125,127,128
 DC.W  130,132,134,136,138,140,142,145,147,149
 DC.W  151,154,156,159,161,164,166,169,171,174
 DC.W  177,180,182,185,188,191,194,197,200,203
 DC.W  206,209,212,215,218,222,225,228,231,235
 DC.W  238,241,245,248,251,255,258,261,265,268
 DC.W  272,275,279,282,286,289,293,296,300,303
 DC.W  307,310,313,317,320,324,327,331,334,338
 DC.W  341,344,348,351,354,358,361,364,367,370
 DC.W  374,377,380,383,386,389,392,395,398,401
 DC.W  404,406,409,412,415,417,420,422,425,427
 DC.W  430,432,434,437,439,441,443,445,447,449
 DC.W  451,453,454,456,458,459,461,463,464,465
 DC.W  467,468,469,470,471,472,473,474,475,476
 DC.W  476,477,478,478,479,479,479,480,480,480
 DC.W  480,480,480,480,480,480,480,479,479,478
 DC.W  478,477,477,476,475,475,474,473,472,471
 DC.W  470,469,468,467,465,464,463,461,460,459
 DC.W  457,455,454,452,451,449,447,445,444,442
 DC.W  440,438,436,434,432,430,428,426,424,422
 DC.W  420,418,415,413,411,409,407,404,402,400
 DC.W  398,395,393,391,388,386,384,381,379,377
 DC.W  375,372,370,368,365,363,361,359,356,354
 DC.W  352,350,348,345,343,341,339,337,335,333
 DC.W  331,329,327,325,323,321,319,318,316,314
 DC.W  312,311,309,307,306,304,303,301,300,298
 DC.W  297,296,294,293,292,291,290,289,288,287
 DC.W  286,285,284,283,282,281,281,280,279,279
 DC.W  278,278,277,277,277,276,276,276,276,275
 DC.W  275,275,275,275,275,275,275,276,276,276
 DC.W  276,277,277,277,278,278,279,279,280,280
 DC.W  281,281,282,283,283,284,285,285,286,287
 DC.W  288,289,290,290,291,292,293,294,295,296
 DC.W  297,298,299,300,301,302,303,304,305,306
 DC.W  307,308,309,310,311,311,312,313,314,315
 DC.W  316,317,318,319,319,320,321,322,323,323
 DC.W  324,325,325,326,326,327,327,328,328,329
 DC.W  329,329,330,330,330,330,330,331,331,331
 DC.W  331,330,330,330,330,330,329,329,329,328
 DC.W  328,327,326,326,325,324,323,322,321,320
 DC.W  319,318,317,316,315,313,312,310,309,307
 DC.W  306,304,302,300,298,297,295,293,290,288
 DC.W  286,284,282,279,277,274,272,269,267,264
 DC.W  261,258,255,253,250,247,244,240,237,234
 DC.W  231,228,224,221,218,214,211,207,204,200
 DC.W  196,193,189,185,182,178,174,170,166,162
 DC.W  158,154,150,146,142,138,134,130,126,122
 DC.W  118,114,110,105,101,97,93,89,85,80
 DC.W  76,72,68,64,59,55,51,47,43,39
 DC.W  34,30,26,22,18,14,10,6,2,-2
 DC.W  -6,-10,-14,-18,-22,-25,-29,-33,-37,-41
 DC.W  -44,-48,-51,-55,-59,-62,-65,-69,-72,-76
 DC.W  -79,-82,-85,-89,-92,-95,-98,-101,-104,-107
 DC.W  -109,-112,-115,-118,-120,-123,-125,-128,-130,-133
 DC.W  -135,-137,-139,-142,-144,-146,-148,-150,-152,-154
 DC.W  -155,-157,-159,-160,-162,-164,-165,-166,-168,-169
 DC.W  -170,-172,-173,-174,-175,-176,-177,-178,-179,-180
 DC.W  -180,-181,-182,-182,-183,-184,-184,-185,-185,-185
 DC.W  -186,-186,-186,-187,-187,-187,-187,-187,-187,-187
 DC.W  -187,-187,-187,-187,-187,-187,-187,-186,-186,-186
 DC.W  -186,-185,-185,-185,-184,-184,-184,-183,-183,-182
 DC.W  -182,-182,-181,-181,-180,-180,-179,-179,-178,-178
 DC.W  -178,-177,-177,-176,-176,-175,-175,-175,-174,-174
 DC.W  -173,-173,-173,-172,-172,-172,-172,-171,-171,-171
 DC.W  -171,-171,-171,-170,-170,-170,-170,-170,-170,-170
 DC.W  -171,-171,-171,-171,-171,-172,-172,-172,-173,-173
 DC.W  -174,-174,-175,-175,-176,-176,-177,-178,-179,-180
 DC.W  -180,-181,-182,-183,-184,-186,-187,-188,-189,-190
 DC.W  -192,-193,-195,-196,-197,-199,-201,-202,-204,-206
 DC.W  -207,-209,-211,-213,-215,-217,-219,-221,-223,-225
 DC.W  -227,-230,-232,-234,-237,-239,-241,-244,-246,-249
 DC.W  -251,-254,-257,-259,-262,-265,-267,-270,-273,-276
 DC.W  -279,-281,-284,-287,-290,-293,-296,-299,-302,-305
 DC.W  -308,-311,-314,-317,-320,-323,-326,-330,-333,-336
 DC.W  -339,-342,-345,-348,-351,-354,-358,-361,-364,-367
 DC.W  -370,-373,-376,-379,-382,-385,-388,-391,-394,-397
 DC.W  -400,-403,-405,-408,-411,-414,-417,-419,-422,-425
 DC.W  -427,-430,-432,-435,-437,-440,-442,-445,-447,-449
 DC.W  -451,-454,-456,-458,-460,-462,-464,-466,-468,-469
 DC.W  -471,-473,-474,-476,-478,-479,-480,-482,-483,-484
 DC.W  -486,-487,-488,-489,-490,-491,-492,-492,-493,-494
 DC.W  -494,-495,-495,-496,-496,-496,-497,-497,-497,-497
 DC.W  -497,-497,-497,-496,-496,-496,-496,-495,-495,-494
 DC.W  -493,-493,-492,-491,-490,-489,-488,-487,-486,-485
 DC.W  -484,-483,-481,-480,-479,-477,-476,-474,-472,-471
 DC.W  -469,-467,-466,-464,-462,-460,-458,-456,-454,-452
 DC.W  -450,-447,-445,-443,-441,-438,-436,-434,-431,-429
 DC.W  -426,-424,-421,-419,-416,-414,-411,-409,-406,-403
 DC.W  -401,-398,-395,-393,-390,-387,-384,-382,-379,-376
 DC.W  -374,-371,-368,-365,-363,-360,-357,-354,-352,-349
 DC.W  -346,-343,-341,-338,-335,-333,-330,-328,-325,-322
 DC.W  -320,-317,-315,-312,-310,-307,-305,-302,-300,-298
 DC.W  -295,-293,-291,-289,-287,-284,-282,-280,-278,-276
 DC.W  -274,-272,-270,-268,-267,-265,-263,-261,-260,-258
 DC.W  -256,-255,-253,-252,-250,-249,-248,-246,-245,-244
 DC.W  -243,-242,-241,-240,-239,-238,-237,-236,-235,-234
 DC.W  -234,-233,-232,-232,-231,-231,-230,-230,-229,-229
 DC.W  -229,-228,-228,-228,-228,-228,-227,-227,-227,-227
 DC.W  -227,-228,-228,-228,-228,-228,-228,-229,-229,-229
 DC.W  -230,-230,-230,-231,-231,-232,-232,-233,-233,-234
 DC.W  -234,-235,-235,-236,-237,-237,-238,-239,-239,-240
 DC.W  -241,-241,-242,-243,-243,-244,-244,-245,-246,-246
 DC.W  -247,-248,-248,-249,-250,-250,-251,-251,-252,-252
 DC.W  -253,-253,-254,-254,-255,-255,-256,-256,-256,-257
 DC.W  -257,-257,-257,-257,-258,-258,-258,-258,-258,-258
 DC.W  -258,-258,-257,-257,-257,-257,-256,-256,-256,-255
 DC.W  -255,-254,-254,-253,-252,-251,-251,-250,-249,-248
 DC.W  -247,-246,-245,-244,-243,-241,-240,-239,-237,-236
 DC.W  -234,-233,-231,-229,-227,-226,-224,-222,-220,-218
 DC.W  -216,-214,-211,-209,-207,-205,-202,-200,-197,-195
 DC.W  -192,-189,-187,-184,-181,-178,-175,-172,-169,-166
 DC.W  -163,-160,-157,-153,-150,-147,-143,-140,-137,-133
 DC.W  -130,-126,-122,-119,-115,-111,-107,-104,-100,-96
 DC.W  -92,-88,-84,-80,-76,-72,-68,-64,-60,-56
 DC.W  -52,-48,-44,-40,-35,-31,-27,-23,-19,-14
 DC.W  -10,-6,-2,3,7,11,15,19,24,28
 DC.W  32,36,41,45,49,53,57,61,65,70
 DC.W  74,78,82,86,90,94,98,102,105,109
 DC.W  113,117,121,124,128,132,135,139,143,146
 DC.W  150,153,156,160,163,166,169,173,176,179
 DC.W  182,185,188,191,194,196,199,202,204,207
 DC.W  209,212,214,217,219,221,223,226,228,230
 DC.W  232,234,235,237,239,241,242,244,246,247
 DC.W  248,250,251,252,254,255,256,257,258,259
 DC.W  260,261,261,262,263,263,264,265,265,266
 DC.W  266,266,267,267,267,267,267,267,268,268
 DC.W  268,268,267,267,267,267,267,266,266,266
 DC.W  265,265,265,264,264,263,263,262,262,261
 DC.W  261,260,259,259,258,258,257,256,256,255
 DC.W  254,253,253,252,251,251,250,249,249,248
 DC.W  247,247,246,245,245,244,243,243,242,241
 DC.W  241,240,240,239,239,238,238,237,237,237
 DC.W  236,236,236,235,235,235,235,235,234,234
 DC.W  234,234,234,234,235,235,235,235,235,236
 DC.W  236,236,237,237,238,238,239,239,240,241
 DC.W  241,242,243,244,245,246,247,248,249,250
 DC.W  251,252,254,255,256,258,259,261,262,264
 DC.W  265,267,269,270,272,274,276,278,280,281
 DC.W  283,285,288,290,292,294,296,298,301,303
 DC.W  305,307,310,312,315,317,319,322,324,327
 DC.W  329,332,335,337,340,342,345,348,350,353
 DC.W  356,358,361,364,366,369,372,374,377,380
 DC.W  382,385,388,390,393,396,398,401,404,406
 DC.W  409,411,414,416,419,421,424,426,429,431
 DC.W  433,436,438,440,442,445,447,449,451,453
 DC.W  455,457,459,461,463,464,466,468,470,471
 DC.W  473,474,476,477,479,480,481,482,484,485
 DC.W  486,487,488,489,489,490,491,492,492,493
 DC.W  493,494,494,494,494,495,495,495,495,495
 DC.W  495,494,494,494,493,493,492,492,491,491
 DC.W  490,489,488,487,486,485,484,483,482,480
 DC.W  479,478,476,475,473,471,470,468,466,464
 DC.W  462,461,459,457,454,452,450,448,446,443
 DC.W  441,439,436,434,431,429,426,423,421,418
 DC.W  415,413,410,407,404,401,398,395,392,389
 DC.W  386,383,380,377,374,371,368,365,362,359
 DC.W  356,353,349,346,343,340,337,334,330,327
 DC.W  324,321,318,315,312,308,305,302,299,296
 DC.W  293,290,287,284,281,278,275,272,269,266
 DC.W  263,261,258,255,252,250,247,244,242,239
 DC.W  237,234,232,229,227,224,222,220,217,215
 DC.W  213,211,209,207,205,203,201,199,197,195
 DC.W  194,192,190,189,187,186,184,183,181,180
 DC.W  179,177,176,175,174,173,172,171,170,169
 DC.W  168,167,166,166,165,164,164,163,163,162
 DC.W  162,161,161,161,160,160,160,160,159,159
 DC.W  159,159,159,159,159,159,159,159,159,160
 DC.W  160,160,160,160,161,161,161,162,162,162
 DC.W  163,163,163,164,164,165,165,165,166,166
 DC.W  167,167,167,168,168,169,169,170,170,170
 DC.W  171,171,171,172,172,172,173,173,173,173
 DC.W  174,174,174,174,174,174,174,174,174,174
 DC.W  174,174,174,174,174,174,173,173,173,172
 DC.W  172,171,171,170,170,169,168,168,167,166
 DC.W  165,164,163,162,161,160,159,158,157,155
 DC.W  154,152,151,149,148,146,145,143,141,139
 DC.W  137,135,133,131,129,127,125,123,120,118
 DC.W  116,113,111,108,105,103,100,97,94,92
 DC.W  89,86,83,80,77,73,70,67,64,60
 DC.W  57,54,50,47,43,40,36,33,29,25
 DC.W  22,18,14,10,6,2,-1,-5,-9,-13
 DC.W  -17,-21,-25,-29,-33,-37,-42,-46,-50,-54
 DC.W  -58,-62,-66,-71,-75,-79,-83,-87,-91,-96
 DC.W  -100,-104,-108,-112,-116,-121,-125,-129,-133,-137
 DC.W  -141,-145,-149,-153,-157,-161,-165,-169,-173,-177
 DC.W  -181,-185,-189,-192,-196,-200,-204,-207,-211,-214
 DC.W  -218,-222,-225,-228,-232,-235,-238,-242,-245,-248
 DC.W  -251,-254,-257,-260,-263,-266,-269,-272,-275,-277
 DC.W  -280,-282,-285,-287,-290,-292,-295,-297,-299,-301
 DC.W  -303,-305,-307,-309,-311,-313,-315,-316,-318,-319
 DC.W  -321,-322,-324,-325,-326,-328,-329,-330,-331,-332
 DC.W  -333,-334,-335,-335,-336,-337,-338,-338,-339,-339
 DC.W  -339,-340,-340,-340,-341,-341,-341,-341,-341,-341
 DC.W  -341,-341,-341,-340,-340,-340,-340,-339,-339,-338
 DC.W  -338,-337,-337,-336,-336,-335,-334,-334,-333,-332
 DC.W  -332,-331,-330,-329,-328,-327,-326,-326,-325,-324
 DC.W  -323,-322,-321,-320,-319,-318,-317,-316,-315,-314
 DC.W  -313,-312,-311,-310,-309,-307,-306,-305,-304,-303
 DC.W  -302,-301,-301,-300,-299,-298,-297,-296,-295,-294
 DC.W  -293,-292,-292,-291,-290,-289,-289,-288,-287,-287
 DC.W  -286,-286,-285,-285,-284,-284,-283,-283,-283,-282
 DC.W  -282,-282,-282,-281,-281,-281,-281,-281,-281,-281
 DC.W  -281,-282,-282,-282,-282,-283,-283,-283,-284,-284
 DC.W  -285,-286,-286,-287,-288,-288,-289,-290,-291,-292
 DC.W  -293,-294,-295,-296,-297,-298,-299,-301,-302,-303
 DC.W  -304,-306,-307,-309,-310,-312,-313,-315,-317,-318
 DC.W  -320,-322,-324,-325,-327,-329,-331,-333,-335,-337
 DC.W  -339,-341,-343,-345,-347,-349,-351,-353,-355,-358
 DC.W  -360,-362,-364,-366,-368,-371,-373,-375,-377,-380
 DC.W  -382,-384,-386,-389,-391,-393,-395,-398,-400,-402
 DC.W  -404,-406,-409,-411,-413,-415,-417,-419,-421,-423
 DC.W  -425,-427,-429,-431,-433,-435,-437,-439,-441,-442
 DC.W  -444,-446,-448,-449,-451,-453,-454,-456,-457,-458
 DC.W  -460,-461,-462,-464,-465,-466,-467,-468,-469,-470
 DC.W  -471,-472,-473,-473,-474,-475,-475,-476,-476,-477
 DC.W  -477,-477,-477,-478,-478,-478,-478,-478,-478,-477
 DC.W  -477,-477,-476,-476,-476,-475,-474,-474,-473,-472
 DC.W  -471,-470,-469,-468,-467,-466,-465,-464,-462,-461
 DC.W  -459,-458,-456,-455,-453,-451,-449,-448,-446,-444
 DC.W  -442,-440,-437,-435,-433,-431,-428,-426,-424,-421
 DC.W  -419,-416,-413,-411,-408,-405,-402,-400,-397,-394
 DC.W  -391,-388,-385,-382,-379,-376,-372,-369,-366,-363
 DC.W  -360,-356,-353,-350,-346,-343,-340,-336,-333,-329
 DC.W  -326,-322,-319,-315,-312,-308,-305,-301,-298,-294
 DC.W  -291,-287,-284,-280,-277,-273,-270,-266,-263,-259
 DC.W  -256,-252,-249,-245,-242,-238,-235,-232,-228,-225
 DC.W  -222,-218,-215,-212,-209,-205,-202,-199,-196,-193
 DC.W  -190,-187,-184,-181,-178,-175,-172,-169,-167,-164
 DC.W  -161,-159,-156,-153,-151,-148,-146,-144,-141,-139
 DC.W  -137,-134,-132,-130,-128,-126,-124,-122,-120,-118
 DC.W  -116,-115,-113,-111,-109,-108,-106,-105,-103,-102
 DC.W  -101,-99,-98,-97,-96,-95,-93,-92,-91,-90
 DC.W  -90,-89,-88,-87,-86,-86,-85,-84,-84,-83
 DC.W  -83,-82,-82,-82,-81,-81,-81,-80,-80,-80
 DC.W  -80,-80,-80,-79,-79,-79,-79,-79,-79,-80
 DC.W  -80,-80,-80,-80,-80,-80,-81,-81,-81,-81
 DC.W  -81,-82,-82,-82,-82,-83,-83,-83,-83,-84
 DC.W  -84,-84,-85,-85,-85,-85,-86,-86,-86,-86
 DC.W  -86,-87,-87,-87,-87,-87,-87,-87,-87,-87
 DC.W  -87,-87,-87,-87,-87,-87,-87,-87,-86,-86
 DC.W  -86,-86,-85,-85,-84,-84,-83,-83,-82,-82
 DC.W  -81,-80,-79,-79,-78,-77,-76,-75,-74,-73
 DC.W  -72,-71,-69,-68,-67,-65,-64,-63,-61,-59
 DC.W  -58,-56,-54,-53,-51,-49,-47,-45,-43,-41
 DC.W  -39,-37,-35,-32,-30,-28,-25,-23,-20,-18
 DC.W  -15,-12,-10,-7,-4,-1,2,5,8,11
 DC.W  14,17,20,23,26,30,33,36,40,43
 DC.W  47,50,54,57,61,64,68,72,75,79
 DC.W  83,87,90,94,98,102,106,110,114,118
 DC.W  122,126,130,134,138,142,146,150,154,158
 DC.W  162,166,170,174,178,182,186,190,194,198
 DC.W  202,206,210,214,218,222,225,229,233,237
 DC.W  241,245,248,252,256,260,263,267,270,274
 DC.W  278,281,284,288,291,295,298,301,304,308
 DC.W  311,314,317,320,323,326,329,331,334,337
 DC.W  340,342,345,347,350,352,354,357,359,361
 DC.W  363,365,367,369,371,373,375,376,378,380
 DC.W  381,383,384,386,387,388,389,390,391,392
 DC.W  393,394,395,396,397,397,398,398,399,399
 DC.W  400,400,400,401,401,401,401,401,401,401
 DC.W  401,400,400,400,400,399,399,398,398,397
 DC.W  397,396,395,394,394,393,392,391,390,389
 DC.W  388,387,386,385,384,383,382,381,379,378
 DC.W  377,376,374,373,372,371,369,368,366,365
 DC.W  364,362,361,359,358,357,355,354,352,351
 DC.W  349,348,347,345,344,342,341,340,338,337
 DC.W  336,334,333,332,330,329,328,327,325,324
 DC.W  323,322,321,320,319,318,317,316,315,314
 DC.W  313,312,312,311,310,309,309,308,307,307
 DC.W  306,306,305,305,305,304,304,304,304,303
 DC.W  303,303,303,303,303,303,303,304,304,304
 DC.W  304,305,305,306,306,306,307,308,308,309
 DC.W  310,310,311,312,313,314,315,316,317,318
 DC.W  319,320,321,322,323,325,326,327,329,330
 DC.W  331,333,334,336,337,339,340,342,344,345
 DC.W  347,348,350,352,354,355,357,359,360,362
 DC.W  364,366,368,369,371,373,375,376,378,380
 DC.W  382,384,385,387,389,391,392,394,396,398
 DC.W  399,401,403,404,406,408,409,411,412,414
 DC.W  415,417,418,419,421,422,423,425,426,427
 DC.W  428,429,431,432,433,433,434,435,436,437
 DC.W  438,438,439,439,440,441,441,441,442,442
 DC.W  442,442,442,443,443,442,442,442,442,442
 DC.W  441,441,440,439,439,438,437,437,436,435,434
 DC.W  433,432,430,429,428,427,425,424,422,421
 DC.W  419,417,415,414,412,410,408,406,404,401
 DC.W  399,397,395