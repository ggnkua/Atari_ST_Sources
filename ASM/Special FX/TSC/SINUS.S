 DC.W  62,63,64,64,65,65,65,65,64,64
 DC.W  63,63,63,62,62,62,63,63,64,65
 DC.W  66,68,70,72,74,77,79,82,85,88
 DC.W  91,94,96,99,101,104,106,107,109,110
 DC.W  110,111,111,110,110,109,107,106,104,103
 DC.W  101,99,97,96,94,92,91,90,89,88
 DC.W  88,88,88,88,89,89,90,91,92,94
 DC.W  95,96,97,98,99,99,100,100,99,99
 DC.W  98,97,95,93,91,89,86,83,80,77
 DC.W  74,70,67,64,61,58,55,52,50,48
 DC.W  46,44,43,42,42,41,41,41,41,42
 DC.W  42,42,43,43,43,43,43,43,42,42
 DC.W  41,39,38,36,34,31,29,26,23,20
 DC.W  17,14,11,8,5,2,0,0,0,0
 DC.W  0,0,2,3,5,6,7,8,9
 DC.W  10,10,10,10,10,9,8,7,6,4
 DC.W  3,2,0
 DC.W  0,0,0,0,0,2,4,7,9,12
 DC.W  15,18,22,25,28,31,34,37,39,42
 DC.W  44,46,47,49,50,50,51,51,51,51
 DC.W  51,50,50,50,49,49,49,49,49,50
 DC.W  50,51,53,54,56,58,61,63,66,69
 DC.W  72,76,79,82,85,88,91,94,96,98
 DC.W  100,102,103,104,104,104,104,104,103,102
 DC.W  101,100,99,97,96,95,93,92,91,90
 DC.W  89,89,89,89,89,90,91,92,93,94
 DC.W  96,97,99,100,102,103,105,106,107,107
 DC.W  107,107,107,106,105,104,102,100,98,96
 DC.W  93,90,87,84,81,78,75,72,69,66
 DC.W  64,62,60,59,57,56,56,55,55,55
 DC.W  55,55,56,57,57,57,58,58,58,58,58,59
 DC.W  59,59,59,60,60,60,61,61,61,62,62,62