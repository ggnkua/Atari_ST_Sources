	dc.l	RC_none		; FirstWindow
	dc.l	RC_none		; WinActivate
	dc.l	RC_none		; WinAttr
	dc.l	RC_none		; WinBackupToScr
	dc.l	RC_none		; WinBackground
	dc.l	RC_none		; WinBegin
	dc.l	RC_none		; WinBitmapGet
	dc.l	RC_none		; WinBitmapPut
	dc.l	RC_none		; WinBitmapSize
	dc.l	RC_none		; WinCharXY
	dc.l	RC_none		; WinChar
	dc.l	RC_none		; WinClose
	dc.l	RC_none		; WinClr
	dc.l	RC_none		; WinDeactivate
	dc.l	RC_none		; WinDupStat
	dc.l	RC_none		; WinEllipse
	dc.l	RC_none		; WinFill
	dc.l	RC_none		; WinFillLines2
	dc.l	RC_none		; WinFillTriangle
	dc.l	RC_none		; WinFont
	dc.l	RC_none		; WinGetCursor
	dc.l	RC_none		; WinHide
	dc.l	RC_none		; WinHome
	dc.l	RC_none		; WinLine
	dc.l	RC_none		; WinLineNC
	dc.l	RC_none		; WinLineTo
	dc.l	RC_none		; WinLineRel
	dc.l	RC_none		; WinMoveCursor
	dc.l	RC_none		; WinMoveTo
	dc.l	RC_none		; WinMoveRel
	dc.l	RC_none		; WinOpen
	dc.l	RC_none		; WinPixGet
	dc.l	RC_none		; WinPixSet
	dc.l	RC_none		; WinRect
	dc.l	RC_none		; WinReOpen
	dc.l	RC_none		; WinScrollH
	dc.l	RC_none		; WinScrollV
	dc.l	RC_none		; WinStr
	dc.l	RC_none		; WinStrXY
	dc.l	RC_none		; DrawWinBorder
	dc.l	RC_none		; ScrRectDivide
	dc.l	RC_none		; RectWinToWin
	dc.l	RC_none		; RectWinToScr
	dc.l	RC_none		; UpdateWindows
	dc.l	RC_none		; MakeWinRect
	dc.l	RC_none		; ScrToWin
	dc.l	RC_none		; ScrToHome
	dc.l	RC_none		; ScrRect
	dc.l	RC_none		; Dialog
	dc.l	RC_none		; NoCallBack
	dc.l	RC_none		; DialogDo
	dc.l	RC_none		; DialogAdd
	dc.l	RC_none		; DialogNew
	dc.l	RC_none		; DrawStaticButton
	dc.l	RC_none		; MenuBegin
	dc.l	RC_none		; MenuCheck
	dc.l	RC_none		; MenuEnd
	dc.l	RC_none		; MenuKey
	dc.l	RC_none		; MenuOn
	dc.l	RC_none		; MenuPopup
	dc.l	RC_none		; MenuSubStat
	dc.l	RC_none		; MenuTopStat
	dc.l	RC_none		; MenuTopSelect
	dc.l	RC_none		; MenuTopRedef
	dc.l	RC_none		; MenuGetTopRedef
	dc.l	RC_none		; MenuAddText
	dc.l	RC_none		; MenuAddIcon
	dc.l	RC_none		; MenuNew
	dc.l	RC_none		; PopupAddText
	dc.l	RC_none		; PopupNew
	dc.l	RC_none		; PopupClear
	dc.l	RC_none		; PopupDo
	dc.l	RC_none		; PopupText
	dc.l	RC_none		; MenuUpdate
	dc.l	RC_none		; Parse2DExpr
	dc.l	RC_none		; Parse2DMultiExpr
	dc.l	RC_none		; Print2DExpr
	dc.l	RC_none		; Parms2D
	dc.l	RC_none		; display_statements
	dc.l	RC_none		; Parse1DExpr
	dc.l	RC_none		; pushkey
	dc.l	RC_ngetchx	; ngetchx
	dc.l	RC_kbhit	; kbhit
	dc.l	RC_none		; sprintf
	dc.l	RC_none		; getcalc
	dc.l	RC_none		; sendcalc
	dc.l	RC_none		; LIO_Send
	dc.l	RC_none		; LIO_Get
	dc.l	RC_none		; LIO_Receive
	dc.l	RC_none		; LIO_GetMultiple
	dc.l	RC_none		; LIO_SendData
	dc.l	RC_none		; LIO_RecvData
	dc.l	RC_none		; SymAdd
	dc.l	RC_none		; SymAddMain
	dc.l	RC_none		; SymDel
	dc.l	RC_none		; HSymDel
	dc.l	RC_none		; SymFind
	dc.l	RC_none		; SymFindMain
	dc.l	RC_none		; SymFindHome
	dc.l	RC_none		; SymMove
	dc.l	RC_none		; FolderAdd
	dc.l	RC_none		; FolderCur
	dc.l	RC_none		; FolderDel
	dc.l	RC_none		; FolderFind
	dc.l	RC_none		; FolderGetCur
	dc.l	RC_none		; FolderOp
	dc.l	RC_none		; FolderRename
	dc.l	RC_none		; FolderCount
	dc.l	RC_none		; SymFindFirst
	dc.l	RC_none		; SymFindNext
	dc.l	RC_none		; SymFindPrev
	dc.l	RC_none		; SymFindFoldername
	dc.l	RC_none		; AddSymToFolder
	dc.l	RC_none		; FindSymInFolder
	dc.l	RC_none		; FolderCurTemp
	dc.l	RC_none		; FolderAddTemp
	dc.l	RC_none		; FolderDelTemp
	dc.l	RC_none		; FolderDelAllTemp
	dc.l	RC_none		; TempFolderName
	dc.l	RC_none		; IsMainFolderStr
	dc.l	RC_none		; ParseSymName
	dc.l	RC_none		; DerefSym
	dc.l	RC_none		; HSYMtoName
	dc.l	RC_none		; StrToTokN
	dc.l	RC_none		; TokToStrN
	dc.l	RC_none		; CheckGraphRef
	dc.l	RC_none		; ClearUserDef
	dc.l	RC_none		; CheckLinkLockFlag
	dc.l	RC_none		; TokenizeSymName
	dc.l	RC_none		; SymCmp
	dc.l	RC_none		; SymCpy
	dc.l	RC_none		; SymCpy0
	dc.l	RC_none		; ValidateSymName
	dc.l	RC_none		; VarRecall
	dc.l	RC_none		; VarStore
	dc.l	RC_none		; VarStoreLink
	dc.l	RC_none		; QSysProtected
	dc.l	RC_none		; CheckSysFunc
	dc.l	RC_none		; GetSysGraphRef
	dc.l	RC_none		; CheckReservedName
	dc.l	RC_none		; SymSysVar
	dc.l	RC_none		; ValidateStore
	dc.l	RC_none		; ResetSymFlags
	dc.l	HeapAvail
	dc.l	HeapAlloc
	dc.l	HeapAllocESTACK
	dc.l	HeapAllocHigh
	dc.l	HeapAllocThrow
	dc.l	HeapAllocHighThrow
	dc.l	HeapCompress
	dc.l	HeapDeref
	dc.l	HeapFree
	dc.l	HeapFreeIndir
	dc.l	HLock
	dc.l	HeapLock
	dc.l	HeapGetLock
	dc.l	HeapMax
	dc.l	HeapRealloc
	dc.l	HeapSize
	dc.l	HeapUnlock
	dc.l	HeapMoveHigh
	dc.l	HeapEnd
	dc.l	HeapAllocPtr
	dc.l	HeapFreePtr
	dc.l	RC_none		; NeedStack
	dc.l	RC_none		; TE_close
	dc.l	RC_none		; TE_checkSlack
	dc.l	RC_none		; TE_empty
	dc.l	RC_none		; TE_focus
	dc.l	RC_none		; TE_handleEvent
	dc.l	RC_none		; TE_indicateReadOnly
	dc.l	RC_none		; TE_isBlank
	dc.l	RC_none		; TE_open
	dc.l	RC_none		; TE_openFixed
	dc.l	RC_none		; TE_pasteText
	dc.l	RC_none		; TE_reopen
	dc.l	RC_none		; TE_reopenPlain
	dc.l	RC_none		; TE_select
	dc.l	RC_none		; TE_shrinkWrap
	dc.l	RC_none		; TE_unfocus
	dc.l	RC_none		; TE_updateCommand
	dc.l	RC_none		; _bcd_math
	dc.l	RC_none		; bcdadd
	dc.l	RC_none		; bcdsub
	dc.l	RC_none		; bcdmul
	dc.l	RC_none		; bcddiv
	dc.l	RC_none		; bcdneg
	dc.l	RC_none		; bcdcmp
	dc.l	RC_none		; bcdlong
	dc.l	RC_none		; bcdbcd
	dc.l	RC_none		; EX_getArg
	dc.l	RC_none		; EX_getBCD
	dc.l	RC_none		; EX_stoBCD
	dc.l	RC_none		; CB_replaceTEXT
	dc.l	RC_none		; CB_fetchTEXT
	dc.l	RC_none		; CU_restore
	dc.l	RC_none		; CU_start
	dc.l	RC_none		; CU_stop
	dc.l	RC_none		; EV_captureEvents
	dc.l	RC_none		; EV_clearPasteString
	dc.l	RC_none		; EV_getc
	dc.l	RC_none		; EV_getSplitRect
	dc.l	RC_none		; EV_notifySwitchGraph
	dc.l	RC_none		; EV_paintOneWindow
	dc.l	RC_none		; EV_paintWindows
	dc.l	RC_none		; EV_restorePainting
	dc.l	RC_none		; EV_sendEvent
	dc.l	RC_none		; EV_sendEventSide
	dc.l	RC_none		; EV_sendString
	dc.l	RC_none		; EV_setCmdCheck
	dc.l	RC_none		; EV_setCmdState
	dc.l	RC_none		; EV_setFKeyState
	dc.l	RC_none		; EV_startApp
	dc.l	RC_none		; EV_startSide
	dc.l	RC_none		; EV_startTask
	dc.l	RC_none		; EV_suspendPainting
	dc.l	RC_none		; EV_switch
	dc.l	RC_none		; MO_currentOptions
	dc.l	RC_none		; MO_defaults
	dc.l	RC_none		; MO_digestOptions
	dc.l	RC_none		; MO_isMultigraphTask
	dc.l	RC_none		; MO_modeDialog
	dc.l	RC_none		; MO_notifyModeChange
	dc.l	RC_none		; MO_sendQuit
	dc.l	RC_none		; ST_angle
	dc.l	RC_none		; ST_batt
	dc.l	RC_none		; ST_busy
	dc.l	RC_none		; ST_eraseHelp
	dc.l	RC_none		; ST_folder
	dc.l	RC_none		; ST_graph
	dc.l	RC_none		; ST_helpMsg
	dc.l	RC_none		; ST_modKey
	dc.l	RC_none		; ST_precision
	dc.l	RC_none		; ST_readOnly
	dc.l	RC_none		; ST_stack
	dc.l	RC_none		; ST_refDsp
	dc.l	RC_none		; OSCheckBreak
	dc.l	RC_none		; OSClearBreak
	dc.l	RC_none		; OSEnableBreak
	dc.l	RC_none		; OSDisableBreak
	dc.l	RC_none		; OSRegisterTimer
	dc.l	RC_none		; OSFreeTimer
	dc.l	RC_none		; OSTimerCurVal
	dc.l	RC_none		; OSTimerExpired
	dc.l	RC_none		; OSTimerRestart
	dc.l	acos
	dc.l	asin
	dc.l	atan
	dc.l	atan2
	dc.l	cos
	dc.l	sin
	dc.l	tan
	dc.l	cosh
	dc.l	sinh
	dc.l	tanh
	dc.l	exp
	dc.l	log
	dc.l	log10
	dc.l	RC_none		; modf
	dc.l	pow
	dc.l	sqrt
	dc.l	ceil
	dc.l	fabs
	dc.l	floor
	dc.l	fmod
	dc.l	RC_none		; top_estack
	dc.l	RC_none		; next_expression_index
	dc.l	RC_none		; gr_active
	dc.l	RC_none		; gr_other
	dc.l	RC_none		; ABT_dialog
	dc.l	RC_none		; HomeExecute
	dc.l	RC_none		; HomePushEStack
	dc.l	RC_none		; SP_Define
	dc.l	RC_none		; store_data_var
	dc.l	RC_none		; recall_data_var
	dc.l	RC_none		; CharNumber
	dc.l	RC_none		; spike_optionD
	dc.l	RC_none		; spike_geo_titles
	dc.l	RC_none		; spike_in_editor
	dc.l	RC_none		; dv_create_graph_titles
	dc.l	RC_none		; spike_titles_in_editor
	dc.l	RC_none		; dv_findColumn
	dc.l	RC_none		; spike_chk_gr_dirty
	dc.l	RC_none		; GetStatValue
	dc.l	RC_none		; partial_len
	dc.l	RC_none		; paint_all_except
	dc.l	RC_none		; EQU_select
	dc.l	RC_none		; EQU_setStyle
	dc.l	RC_none		; EQU_getNameInfo
	dc.l	RC_none		; checkCurrent
	dc.l	RC_none		; BN_power17Mod
	dc.l	RC_none		; BN_powerMod
	dc.l	RC_none		; BN_prodMod
	dc.l	RC_none		; CAT_dialog
	dc.l	RC_none		; caddcert
	dc.l	RC_none		; cdecrypt
	dc.l	RC_none		; ceof
	dc.l	RC_none		; cfindcertfield
	dc.l	RC_none		; cfindfield
	dc.l	RC_none		; cgetc
	dc.l	RC_none		; cgetcert
	dc.l	RC_none		; cgetflen
	dc.l	RC_none		; cgetfnl
	dc.l	RC_none		; cgetnl
	dc.l	RC_none		; cgetns
	dc.l	RC_none		; cgetvernum
	dc.l	RC_none		; copen
	dc.l	RC_none		; copensub
	dc.l	RC_none		; cputhdr
	dc.l	RC_none		; cputnl
	dc.l	RC_none		; cputns
	dc.l	RC_none		; cread
	dc.l	RC_none		; ctell
	dc.l	RC_none		; cwrite
	dc.l	RC_none		; cacos
	dc.l	RC_none		; casin
	dc.l	RC_none		; catan
	dc.l	RC_none		; cacosh
	dc.l	RC_none		; casinh
	dc.l	RC_none		; catanh
	dc.l	RC_none		; ccos
	dc.l	RC_none		; csin
	dc.l	RC_none		; ctan
	dc.l	RC_none		; ccosh
	dc.l	RC_none		; csinh
	dc.l	RC_none		; ctanh
	dc.l	RC_none		; csqrt
	dc.l	RC_none		; cln
	dc.l	RC_none		; clog10
	dc.l	RC_none		; cexp
	dc.l	RC_none		; CustomBegin
	dc.l	RC_none		; CustomMenuItem
	dc.l	RC_none		; CustomEnd
	dc.l	RC_none		; ReallocExprStruct
	dc.l	RC_none		; SearchExprStruct
	dc.l	RC_none		; handleRclKey
	dc.l	RC_none		; CustomFree
	dc.l	RC_none		; ERD_dialog
	dc.l	RC_none		; ERD_process
	dc.l	RC_none		; ER_throwVar
	dc.l	RC_none		; ER_catch
	dc.l	RC_none		; ER_success
	dc.l	RC_none		; EV_centralDispatcher
	dc.l	RC_none		; EV_defaultHandler
	dc.l	RC_none		; EV_eventLoop
	dc.l	RC_none		; EV_registerMenu
	dc.l	RC_none		; EX_patch
	dc.l	RC_none		; EM_abandon
	dc.l	RC_none		; EM_blockErase
	dc.l	RC_none		; EM_blockVerifyErase
	dc.l	RC_none		; EM_delete
	dc.l	RC_none		; EM_findEmptySlot
	dc.l	RC_none		; EM_GC
	dc.l	RC_none		; EM_moveSymFromExtMem
	dc.l	RC_none		; EM_moveSymToExtMem
	dc.l	RC_none		; EM_open
	dc.l	RC_none		; EM_put
	dc.l	RC_none		; EM_survey
	dc.l	RC_none		; EM_twinSymFromExtMem
	dc.l	RC_none		; EM_write
	dc.l	RC_none		; EM_writeToExtMem
	dc.l	RC_none		; FL_addCert
	dc.l	RC_none		; FL_download
	dc.l	RC_none		; FL_getHardwareParmBlock
	dc.l	RC_none		; FL_getCert
	dc.l	RC_none		; FL_getVerNum
	dc.l	RC_none		; EQU_deStatus
	dc.l	RC_none		; cmpstri
	dc.l	RC_none		; fix_loop_displacements
	dc.l	RC_none		; FL_write
	dc.l	RC_none		; fpisanint
	dc.l	RC_none		; fpisodd
	dc.l	RC_none		; round12
	dc.l	RC_none		; round14
	dc.l	RC_none		; GD_Circle
	dc.l	RC_none		; GD_Line
	dc.l	RC_none		; GD_HVLine
	dc.l	RC_none		; GD_Pen
	dc.l	RC_none		; GD_Eraser
	dc.l	RC_none		; GD_Text
	dc.l	RC_none		; GD_Select
	dc.l	RC_none		; GD_Contour
	dc.l	RC_none		; GKeyIn
	dc.l	RC_none		; GKeyDown
	dc.l	RC_none		; GKeyFlush
	dc.l	RC_none		; HelpKeys
	dc.l	RC_none		; QModeKey
	dc.l	RC_none		; QSysKey
	dc.l	RC_none		; WordInList
	dc.l	RC_none		; BitmapGet
	dc.l	RC_none		; BitmapInit
	dc.l	RC_none		; BitmapPut
	dc.l	RC_none		; BitmapSize
	dc.l	RC_none		; ScrRectFill
	dc.l	RC_none		; ScrRectOverlap
	dc.l	RC_none		; ScrRectScroll
	dc.l	RC_none		; ScrRectShift
	dc.l	RC_none		; QScrRectOverlap
	dc.l	FontGetSys
	dc.l	FontSetSys
	dc.l	FontCharWidth
	dc.l	DrawClipChar
	dc.l	RC_none		; DrawClipEllipse
	dc.l	RC_none		; DrawClipLine
	dc.l	RC_none		; DrawClipPix
	dc.l	RC_none		; DrawClipRect
	dc.l	RC_none		; DrawMultiLines
	dc.l	DrawStrWidth
	dc.l	RC_none		; FillTriangle
	dc.l	RC_none		; FillLines2
	dc.l	SetCurAttr
	dc.l	SetCurClip
	dc.l	LineTo
	dc.l	MoveTo
	dc.l	ScreenClear
	dc.l	GetPix
	dc.l	SaveScrState
	dc.l	RestoreScrState
	dc.l	PortSet
	dc.l	PortRestore
	dc.l	DrawChar
	dc.l	RC_none		; DrawFkey
	dc.l	RC_none		; DrawIcon
	dc.l	DrawLine
	dc.l	DrawPix
	dc.l	DrawStr
	dc.l	RC_none		; GM_Value
	dc.l	RC_none		; GM_Intersect
	dc.l	RC_none		; GM_Integrate
	dc.l	RC_none		; GM_Inflection
	dc.l	RC_none		; GM_TanLine
	dc.l	RC_none		; GM_Math1
	dc.l	RC_none		; GM_Derivative
	dc.l	RC_none		; GM_DistArc
	dc.l	RC_none		; GM_Shade
	dc.l	RC_none		; YCvtFtoWin
	dc.l	RC_none		; DlgMessage
	dc.l	RC_none		; SetGraphMode
	dc.l	RC_none		; Regraph
	dc.l	RC_none		; GrAxes
	dc.l	RC_none		; gr_xres_pixel
	dc.l	RC_none		; CptFuncX
	dc.l	RC_none		; XCvtPtoF
	dc.l	RC_none		; YCvtPtoF
	dc.l	RC_none		; YCvtFtoP
	dc.l	RC_none		; XCvtFtoP
	dc.l	RC_none		; GrLineFlt
	dc.l	RC_none		; FuncLineFlt
	dc.l	RC_none		; GrClipLine
	dc.l	RC_none		; CptDeltax
	dc.l	RC_none		; CptDeltay
	dc.l	RC_none		; CkValidDelta
	dc.l	RC_none		; GR_Pan
	dc.l	RC_none		; FindFunc
	dc.l	RC_none		; FindGrFunc
	dc.l	RC_none		; grFuncName
	dc.l	RC_none		; gr_initCondName
	dc.l	RC_none		; CptIndep
	dc.l	RC_none		; gr_CptIndepInc
	dc.l	RC_none		; gr_del_locals
	dc.l	RC_none		; gr_DelFolder
	dc.l	RC_none		; gr_openFolder
	dc.l	RC_none		; setup_more_graph_fun
	dc.l	RC_none		; unlock_more_graph_fun
	dc.l	RC_none		; execute_graph_func
	dc.l	RC_none		; cpt_gr_fun
	dc.l	RC_none		; cpt_gr_param
	dc.l	RC_none		; cpt_gr_polar
	dc.l	RC_none		; gr_execute_seq
	dc.l	RC_none		; CountGrFunc
	dc.l	RC_none		; FirstSeqPlot
	dc.l	RC_none		; cleanup_seq_mem
	dc.l	RC_none		; time_loop
	dc.l	RC_none		; InitTimeSeq
	dc.l	RC_none		; seqWebInit
	dc.l	RC_none		; run_one_seq
	dc.l	RC_none		; gr_seq_value
	dc.l	RC_none		; StepCk
	dc.l	RC_none		; seqStepCk
	dc.l	RC_none		; rngLen
	dc.l	RC_none		; gdb_len
	dc.l	RC_none		; gdb_store
	dc.l	RC_none		; gdb_recall
	dc.l	RC_none		; gr_DispLabels
	dc.l	RC_none		; GraphOrTableCmd
	dc.l	RC_none		; ck_valid_float
	dc.l	RC_none		; CreateEmptyList
	dc.l	RC_none		; QSkipGraphErr
	dc.l	RC_none		; gr_find_de_result
	dc.l	RC_none		; InitDEAxesRng
	dc.l	RC_none		; InitDEMem
	dc.l	RC_none		; de_loop
	dc.l	RC_none		; cleanup_de_mem
	dc.l	RC_none		; gr_de_value
	dc.l	RC_none		; gr_find_func_index
	dc.l	RC_none		; CptLastIndepDE
	dc.l	RC_none		; de_initRes
	dc.l	RC_none		; gr_del_vars_in_folder
	dc.l	RC_none		; gr_de_axes_lbl
	dc.l	RC_none		; gr_execute_de
	dc.l	RC_none		; gr_delete_fldpic
	dc.l	RC_none		; gr_remove_fldpic
	dc.l	RC_none		; gr_add_fldpic
	dc.l	RC_none		; gr_stopic
	dc.l	RC_none		; gr_find_el
	dc.l	RC_none		; deStepCk
	dc.l	RC_none		; gr_ck_solvergraph
	dc.l	RC_none		; GR3_addContours
	dc.l	RC_none		; GraphActivate
	dc.l	RC_none		; GR3_freeDB
	dc.l	RC_none		; GR3_handleEvent
	dc.l	RC_none		; GR3_paint3d
	dc.l	RC_none		; GR3_xyToWindow
	dc.l	RC_none		; GS_PlotTrace
	dc.l	RC_none		; GS_PlotAll
	dc.l	RC_none		; PlotDel
	dc.l	RC_none		; PlotPut
	dc.l	RC_none		; PlotGet
	dc.l	RC_none		; PlotInit
	dc.l	RC_none		; PlotDup
	dc.l	RC_none		; PlotSize
	dc.l	RC_none		; PlotLookup
	dc.l	RC_none		; QActivePlots
	dc.l	RC_none		; QPlotActive
	dc.l	RC_none		; GT_BackupToScr
	dc.l	RC_none		; GT_CalcDepVals
	dc.l	RC_none		; GT_CenterGraphCursor
	dc.l	RC_none		; GT_CursorKey
	dc.l	RC_none		; GT_DspFreeTraceCoords
	dc.l	RC_none		; GT_DspTraceCoords
	dc.l	RC_none		; GT_DspMsg
	dc.l	RC_none		; GT_Error
	dc.l	RC_none		; GT_Format
	dc.l	RC_none		; GT_FreeTrace
	dc.l	RC_none		; GT_IncXY
	dc.l	RC_none		; GT_KeyIn
	dc.l	RC_none		; GT_QFloatCursorsInRange
	dc.l	RC_none		; GT_Regraph
	dc.l	RC_none		; GT_Regraph_if_neccy
	dc.l	RC_none		; GT_Open
	dc.l	RC_none		; GT_SaveAs
	dc.l	RC_none		; GT_SelFunc
	dc.l	RC_none		; GT_SetGraphRange
	dc.l	RC_none		; GT_SetCursorXY
	dc.l	RC_none		; GT_ShowMarkers
	dc.l	RC_none		; GT_Trace
	dc.l	RC_none		; GT_ValidGraphRanges
	dc.l	RC_none		; GT_WinBound
	dc.l	RC_none		; GT_WinCursor
	dc.l	RC_none		; GYcoord
	dc.l	RC_none		; GXcoord
	dc.l	RC_none		; round12_err
	dc.l	RC_none		; GT_Set_Graph_Format
	dc.l	RC_none		; GT_PrintCursor
	dc.l	RC_none		; GT_DE_Init_Conds
	dc.l	RC_none		; GZ_Box
	dc.l	RC_none		; GZ_Center
	dc.l	RC_none		; GZ_Decimal
	dc.l	RC_none		; GZ_Fit
	dc.l	RC_none		; GZ_InOut
	dc.l	RC_none		; GZ_Integer
	dc.l	RC_none		; GZ_Previous
	dc.l	RC_none		; GZ_Recall
	dc.l	RC_none		; GZ_SetFactors
	dc.l	RC_none		; GZ_Square
	dc.l	RC_none		; GZ_Standard
	dc.l	RC_none		; GZ_Stat
	dc.l	RC_none		; GZ_Store
	dc.l	RC_none		; GZ_Trig
	dc.l	HeapGetHandle
	dc.l	HeapPtrToHandle
	dc.l	FreeHandles
	dc.l	RC_none		; HS_chopFIFO
	dc.l	RC_none		; HS_countFIFO
	dc.l	RC_none		; HS_deleteFIFONode
	dc.l	RC_none		; HS_freeAll
	dc.l	RC_none		; HS_freeFIFONode
	dc.l	RC_none		; HS_getAns
	dc.l	RC_none		; HS_getEntry
	dc.l	RC_none		; HS_getFIFONode
	dc.l	RC_none		; HS_popEStack
	dc.l	RC_none		; HS_newFIFONode
	dc.l	RC_none		; HS_pushFIFONode
	dc.l	RC_none		; HToESI
	dc.l	RC_none		; OSInitKeyInitDelay
	dc.l	RC_none		; OSInitBetweenKeyDelay
	dc.l	RC_none		; OSCheckSilentLink
	dc.l	RC_none		; OSLinkCmd
	dc.l	RC_none		; OSLinkReset
	dc.l	RC_none		; OSLinkOpen
	dc.l	RC_none		; OSLinkClose
	dc.l	RC_none		; OSReadLinkBlock
	dc.l	RC_none		; OSWriteLinkBlock
	dc.l	RC_none		; OSLinkTxQueueInquire
	dc.l	RC_none		; OSLinkTxQueueActive
	dc.l	RC_none		; LIO_SendProduct
	dc.l	RC_none		; MD5Init
	dc.l	RC_none		; MD5Update
	dc.l	RC_none		; MD5Final
	dc.l	RC_none		; MD5Done
	dc.l	RC_none		; convert_to_TI_92
	dc.l	RC_none		; gen_version
	dc.l	RC_none		; is_executable
	dc.l	RC_none		; NG_RPNToText
	dc.l	RC_none		; NG_approxESI
	dc.l	RC_none		; NG_execute
	dc.l	RC_none		; NG_graphESI
	dc.l	RC_none		; NG_rationalESI
	dc.l	RC_none		; NG_tokenize
	dc.l	RC_none		; NG_setup_graph_fun
	dc.l	RC_none		; NG_cleanup_graph_fun
	dc.l	RC_none		; push_END_TAG
	dc.l	RC_none		; push_LIST_TAG
	dc.l	RC_none		; tokenize_if_TI_92_or_text
	dc.l	RC_none		; setjmp
	dc.l	RC_none		; longjmp
	dc.l	RC_none		; VarGraphRefBitsClear
	dc.l	RC_none		; VarInit
	dc.l	memcpy
	dc.l	memmove
	dc.l	strcpy
	dc.l	strncpy
	dc.l	strcat
	dc.l	strncat
	dc.l	memcmp
	dc.l	strcmp
	dc.l	strncmp
	dc.l	memchr
	dc.l	strchr
	dc.l	strcspn
	dc.l	strpbrk
	dc.l	strrchr
	dc.l	strspn
	dc.l	strstr
	dc.l	strtok
	dc.l	_memset
	dc.l	memset
	dc.l	RC_none		; strerror
	dc.l	strlen
	dc.l	RC_none		; SymAddTwin
	dc.l	RC_none		; SymDelTwin
	dc.l	RC_none		; LoadSymFromFindHandle
	dc.l	RC_none		; MakeHsym
	dc.l	RC_none		; SymFindPtr
	dc.l	RC_none		; OSVRegisterTimer
	dc.l	RC_none		; OSVFreeTimer
	dc.l	RC_none		; sincos
	dc.l	RC_none		; asinh
	dc.l	RC_none		; acosh
	dc.l	RC_none		; atanh
	dc.l	RC_none		; itrig
	dc.l	RC_none		; trig
	dc.l	RC_none		; VarOpen
	dc.l	RC_none		; VarSaveAs
	dc.l	RC_none		; VarNew
	dc.l	RC_none		; VarCreateFolderPopup
	dc.l	RC_none		; VarSaveTitle
	dc.l	RC_none		; WinWidth
	dc.l	RC_none		; WinHeight
	dc.l	RC_none		; XR_stringPtr
	dc.l	RC_none		; OSReset
	dc.l	RC_none		; SumStoChkMem
	dc.l	RC_none		; OSContrastUp
	dc.l	RC_none		; OSContrastDn
	dc.l	RC_none		; OSKeyScan
	dc.l	RC_none		; OSGetStatKeys
	dc.l	RC_none		; off
	dc.l	RC_none		; idle
	dc.l	RC_none		; OSSetSR
	dc.l	RC_none		; AB_prodid
	dc.l	RC_none		; AB_prodname
	dc.l	RC_none		; AB_serno
	dc.l	RC_none		; cgetcertrevno
	dc.l	RC_none		; cgetsn
	dc.l	RC_none		; de_rng_no_graph
	dc.l	RC_none		; EV_hook
	dc.l	RC_none		; _ds16u16
	dc.l	RC_none		; _ms16u16
	dc.l	RC_none		; _du16u16
	dc.l	RC_none		; _mu16u16
	dc.l	RC_none		; _ds32s32
	dc.l	RC_none		; _ms32s32
	dc.l	RC_none		; _du32u32
	dc.l	RC_none		; _mu32u32
	dc.l	RC_none		; assign_between
	dc.l	RC_none		; did_push_var_val
	dc.l	RC_none		; does_push_fetch
	dc.l	RC_none		; delete_list_element
	dc.l	RC_none		; push_ans_entry
	dc.l	RC_none		; index_after_match_endtag
	dc.l	RC_none		; push_indir_name
	dc.l	RC_none		; push_user_func
	dc.l	RC_none		; store_func_def
	dc.l	RC_none		; store_to_subscripted_element
	dc.l	RC_none		; index_below_display_expression_aux
	dc.l	RC_none		; get_key_ptr
	dc.l	RC_none		; get_list_indices
	dc.l	RC_none		; get_matrix_indices
	dc.l	RC_none		; init_list_indices
	dc.l	RC_none		; init_matrix_indices
	dc.l	RC_none		; push_float_qr_fact
	dc.l	RC_none		; push_lu_fact
	dc.l	RC_none		; push_symbolic_qr_fact
	dc.l	RC_none		; are_expressions_identical
	dc.l	RC_none		; compare_expressions
	dc.l	RC_none		; find_error_message
	dc.l	RC_none		; check_estack_size
	dc.l	RC_none		; delete_between
	dc.l	RC_none		; deleted_between
	dc.l	RC_none		; delete_expression
	dc.l	RC_none		; deleted_expression
	dc.l	RC_none		; estack_to_short
	dc.l	RC_none		; estack_to_ushort
	dc.l	RC_none		; factor_base_index
	dc.l	RC_none		; factor_exponent_index
	dc.l	RC_none		; GetValue
	dc.l	RC_none		; im_index
	dc.l	RC_none		; index_numeric_term
	dc.l	RC_none		; index_of_lead_base_of_lead_term
	dc.l	RC_none		; index_main_var
	dc.l	RC_none		; is_advanced_tag
	dc.l	RC_none		; is_antisymmetric
	dc.l	RC_none		; is_complex_number
	dc.l	RC_none		; is_complex0
	dc.l	RC_none		; is_free_of_tag
	dc.l	RC_none		; is_independent_of
	dc.l	RC_none		; is_independent_of_de_seq_vars
	dc.l	RC_none		; is_independent_of_tail
	dc.l	RC_none		; is_independent_of_elements
	dc.l	RC_none		; is_monomial
	dc.l	RC_none		; is_monomial_in_kernel
	dc.l	RC_none		; is_narrowly_independent_of
	dc.l	RC_none		; is_symmetric
	dc.l	RC_none		; is_tail_independent_of
	dc.l	RC_none		; lead_base_index
	dc.l	RC_none		; lead_exponent_index
	dc.l	RC_none		; lead_factor_index
	dc.l	RC_none		; lead_term_index
	dc.l	RC_none		; main_gen_var_index
	dc.l	RC_none		; map_unary_over_comparison
	dc.l	RC_none		; min_quantum
	dc.l	RC_none		; move_between_to_top
	dc.l	RC_none		; moved_between_to_top
	dc.l	RC_none		; numeric_factor_index
	dc.l	RC_none		; push_between
	dc.l	RC_none		; push_expr_quantum
	dc.l	RC_none		; push_expr2_quantum
	dc.l	RC_none		; push_next_arb_int
	dc.l	RC_none		; push_next_arb_real
	dc.l	RC_none		; push_next_internal_var
	dc.l	RC_none		; push_quantum
	dc.l	RC_none		; push_quantum_pair
	dc.l	RC_none		; reductum_index
	dc.l	RC_none		; remaining_factors_index
	dc.l	RC_none		; re_index
	dc.l	RC_none		; reset_estack_size
	dc.l	RC_none		; reset_control_flags
	dc.l	RC_none		; can_be_approxed
	dc.l	RC_none		; compare_complex_magnitudes
	dc.l	RC_none		; compare_Floats
	dc.l	RC_none		; did_push_cnvrt_Float_to_integer
	dc.l	RC_none		; estack_number_to_Float
	dc.l	RC_none		; float_class
	dc.l	RC_none		; frexp10
	dc.l	RC_none		; gcd_exact_whole_Floats
	dc.l	RC_none		; init_float
	dc.l	RC_none		; is_Float_exact_whole_number
	dc.l	RC_none		; is_float_infinity
	dc.l	RC_none		; is_float_negative_zero
	dc.l	RC_none		; is_float_positive_zero
	dc.l	RC_none		; is_float_signed_infinity
	dc.l	RC_none		; is_float_transfinite
	dc.l	RC_none		; is_float_unsigned_inf_or_nan
	dc.l	RC_none		; is_float_unsigned_zero
	dc.l	RC_none		; is_nan
	dc.l	RC_none		; likely_approx_to_complex_number
	dc.l	RC_none		; likely_approx_to_number
	dc.l	RC_none		; norm1_complex_Float
	dc.l	RC_none		; push_Float
	dc.l	RC_none		; push_Float_to_nonneg_int
	dc.l	RC_none		; push_Float_to_rat
	dc.l	RC_none		; push_cnvrt_integer_if_whole_nmb
	dc.l	RC_none		; push_overflow_to_infinity
	dc.l	RC_none		; push_pow
	dc.l	RC_none		; push_round_Float
	dc.l	RC_none		; should_and_did_push_approx_arg2
	dc.l	RC_none		; signum_Float
	dc.l	RC_none		; did_push_to_polar
	dc.l	RC_none		; push_degrees
	dc.l	RC_none		; push_format
	dc.l	RC_none		; push_getkey
	dc.l	RC_none		; push_getfold
	dc.l	RC_none		; push_getmode
	dc.l	RC_none		; push_gettype
	dc.l	RC_none		; push_instring
	dc.l	RC_none		; push_mrow_aux
	dc.l	RC_none		; push_part
	dc.l	RC_none		; push_pttest
	dc.l	RC_none		; push_pxltest
	dc.l	RC_none		; push_rand
	dc.l	RC_none		; push_randpoly
	dc.l	RC_none		; push_setfold
	dc.l	RC_none		; push_setgraph
	dc.l	RC_none		; push_setmode
	dc.l	RC_none		; push_settable
	dc.l	RC_none		; push_str_to_expr
	dc.l	RC_none		; push_string
	dc.l	RC_none		; push_switch
	dc.l	RC_none		; push_to_cylin
	dc.l	RC_none		; push_to_sphere
	dc.l	RC_none		; cmd_andpic
	dc.l	RC_none		; cmd_blddata
	dc.l	RC_none		; cmd_circle
	dc.l	RC_none		; cmd_clrdraw
	dc.l	RC_none		; cmd_clrerr
	dc.l	RC_none		; cmd_clrgraph
	dc.l	RC_none		; cmd_clrhome
	dc.l	RC_none		; cmd_clrio
	dc.l	RC_none		; cmd_clrtable
	dc.l	RC_none		; cmd_copyvar
	dc.l	RC_none		; cmd_cubicreg
	dc.l	RC_none		; cmd_custmoff
	dc.l	RC_none		; cmd_custmon
	dc.l	RC_none		; cmd_custom
	dc.l	RC_none		; cmd_cycle
	dc.l	RC_none		; cmd_cyclepic
	dc.l	RC_none		; cmd_delfold
	dc.l	RC_none		; cmd_delvar
	dc.l	RC_none		; cmd_dialog
	dc.l	RC_none		; cmd_disp
	dc.l	RC_none		; cmd_dispg
	dc.l	RC_none		; cmd_disphome
	dc.l	RC_none		; cmd_disptbl
	dc.l	RC_none		; cmd_drawfunc
	dc.l	RC_none		; cmd_drawinv
	dc.l	RC_none		; cmd_drawparm
	dc.l	RC_none		; cmd_drawpol
	dc.l	RC_none		; cmd_else
	dc.l	RC_none		; cmd_endfor
	dc.l	RC_none		; cmd_endloop
	dc.l	RC_none		; cmd_endtry
	dc.l	RC_none		; cmd_endwhile
	dc.l	RC_none		; cmd_exit
	dc.l	RC_none		; cmd_expreg
	dc.l	RC_none		; cmd_fill
	dc.l	RC_none		; cmd_fnoff
	dc.l	RC_none		; cmd_fnon
	dc.l	RC_none		; cmd_for
	dc.l	RC_none		; cmd_get
	dc.l	RC_none		; cmd_getcalc
	dc.l	RC_none		; cmd_goto
	dc.l	RC_none		; cmd_graph
	dc.l	RC_none		; cmd_if
	dc.l	RC_none		; cmd_ifthen
	dc.l	RC_none		; cmd_input
	dc.l	RC_none		; cmd_inputstr
	dc.l	RC_none		; cmd_line
	dc.l	RC_none		; cmd_linehorz
	dc.l	RC_none		; cmd_linetan
	dc.l	RC_none		; cmd_linevert
	dc.l	RC_none		; cmd_linreg
	dc.l	RC_none		; cmd_lnreg
	dc.l	RC_none		; cmd_local
	dc.l	RC_none		; cmd_lock
	dc.l	RC_none		; cmd_logistic
	dc.l	RC_none		; cmd_medmed
	dc.l	RC_none		; cmd_movevar
	dc.l	RC_none		; cmd_newdata
	dc.l	RC_none		; cmd_newfold
	dc.l	RC_none		; cmd_newpic
	dc.l	RC_none		; cmd_newplot
	dc.l	RC_none		; cmd_newprob
	dc.l	RC_none		; cmd_onevar
	dc.l	RC_none		; cmd_output
	dc.l	RC_none		; cmd_passerr
	dc.l	RC_none		; cmd_pause
	dc.l	RC_none		; cmd_plotsoff
	dc.l	RC_none		; cmd_plotson
	dc.l	RC_none		; cmd_popup
	dc.l	RC_none		; cmd_powerreg
	dc.l	RC_none		; cmd_printobj
	dc.l	RC_none		; cmd_prompt
	dc.l	RC_none		; cmd_ptchg
	dc.l	RC_none		; cmd_ptoff
	dc.l	RC_none		; cmd_pton
	dc.l	RC_none		; cmd_pttext
	dc.l	RC_none		; cmd_pxlchg
	dc.l	RC_none		; cmd_pxlcircle
	dc.l	RC_none		; cmd_pxlhorz
	dc.l	RC_none		; cmd_pxlline
	dc.l	RC_none		; cmd_pxloff
	dc.l	RC_none		; cmd_pxlon
	dc.l	RC_none		; cmd_pxltext
	dc.l	RC_none		; cmd_pxlvert
	dc.l	RC_none		; cmd_quadreg
	dc.l	RC_none		; cmd_quartreg
	dc.l	RC_none		; cmd_randseed
	dc.l	RC_none		; cmd_rclgdb
	dc.l	RC_none		; cmd_rclpic
	dc.l	RC_none		; cmd_rename
	dc.l	RC_none		; cmd_request
	dc.l	RC_none		; cmd_return
	dc.l	RC_none		; cmd_rplcpic
	dc.l	RC_none		; cmd_send
	dc.l	RC_none		; cmd_sendcalc
	dc.l	RC_none		; cmd_sendchat
	dc.l	RC_none		; cmd_shade
	dc.l	RC_none		; cmd_showstat
	dc.l	RC_none		; cmd_sinreg
	dc.l	RC_none		; cmd_slpline
	dc.l	RC_none		; cmd_sorta
	dc.l	RC_none		; cmd_sortd
	dc.l	RC_none		; cmd_stogdb
	dc.l	RC_none		; cmd_stopic
	dc.l	RC_none		; cmd_style
	dc.l	RC_none		; cmd_table
	dc.l	RC_none		; cmd_text
	dc.l	RC_none		; cmd_toolbar
	dc.l	RC_none		; cmd_trace
	dc.l	RC_none		; cmd_try
	dc.l	RC_none		; cmd_twovar
	dc.l	RC_none		; cmd_unlock
	dc.l	RC_none		; cmd_while
	dc.l	RC_none		; cmd_xorpic
	dc.l	RC_none		; cmd_zoombox
	dc.l	RC_none		; cmd_zoomdata
	dc.l	RC_none		; cmd_zoomdec
	dc.l	RC_none		; cmd_zoomfit
	dc.l	RC_none		; cmd_zoomin
	dc.l	RC_none		; cmd_zoomint
	dc.l	RC_none		; cmd_zoomout
	dc.l	RC_none		; cmd_zoomprev
	dc.l	RC_none		; cmd_zoomrcl
	dc.l	RC_none		; cmd_zoomsqr
	dc.l	RC_none		; cmd_zoomstd
	dc.l	RC_none		; cmd_zoomsto
	dc.l	RC_none		; cmd_zoomtrig
	dc.l	RC_none		; OSenqueue
	dc.l	RC_none		; OSdequeue
	dc.l	RC_none		; OSqinquire
	dc.l	RC_none		; OSqhead
	dc.l	RC_none		; OSqclear
	dc.l	RC_none		; did_push_divide_units
	dc.l	RC_none		; has_unit_base
	dc.l	RC_none		; init_unit_system
	dc.l	RC_none		; is_units_term
	dc.l	RC_none		; push_auto_units_conversion
	dc.l	RC_none		; push_unit_system_list
	dc.l	RC_none		; setup_unit_system
	dc.l	RC_none		; all_tail
	dc.l	RC_none		; any_tail
	dc.l	RC_none		; is_matrix
	dc.l	RC_none		; is_square_matrix
	dc.l	RC_none		; is_valid_smap_aggregate
	dc.l	RC_none		; last_element_index
	dc.l	RC_none		; map_tail
	dc.l	RC_none		; map_tail_Int
	dc.l	RC_none		; push_list_plus
	dc.l	RC_none		; push_list_times
	dc.l	RC_none		; push_reversed_tail
	dc.l	RC_none		; push_sq_matrix_to_whole_number
	dc.l	RC_none		; push_transpose_aux
	dc.l	RC_none		; push_zero_partial_column
	dc.l	RC_none		; remaining_element_count
	dc.l	RC_none		; push_offset_array
	dc.l	RC_none		; push_matrix_product
	dc.l	RC_none		; is_pathname
	dc.l	RC_none		; next_token
	dc.l	RC_none		; nonblank
	dc.l	RC_none		; push_parse_prgm_or_func_text
	dc.l	RC_none		; push_parse_text
	dc.l	RC_none		; push_var
