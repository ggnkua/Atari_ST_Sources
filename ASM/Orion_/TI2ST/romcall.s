;---------------------------------------->
; ROMCalls Emulation

RC_none:	rts

;---------------------------------------->

RC_kbhit:
	lea	KeybTable89(pc),a0
	moveq	#0,d0
	move.b	KEYB.w,d0
	add.w	d0,d0
	move.w	(a0,d0.w),d0
	rts

;---------------------------------------->

RC_ngetchx:
	lea	KEYB.w,a0
	moveq	#0,d0
	move.b	(a0),d1
.wait:	move.b	(a0),d0
	cmp.b	d0,d1
	beq.s	.wait

	lea	KeybTable89(pc),a0
	add.w	d0,d0
	move.w	(a0,d0.w),d0

	rts

KeybTable89:
	dc.w	0,264,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0,$D,0,0,0,0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0,0,0,0,0,337,0,0,338,0,344,0,0
	dc.w	340,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	dc.w	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0

;---------------------------------------->
