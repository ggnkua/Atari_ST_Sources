
DSPHostStat		=	$FFFFA202
DSPHost32		=	$FFFFA204
DSPHost24		=	$FFFFA205
DSPHost16		=	$FFFFA206
DSPHost8		=	$FFFFA207

wall_command		=	0
upper_command		=	1
lower_command		=	2
resize_command		=	3
newscene_command	=	4
newssector_command	=	5
getssector_command	=	6
nodeincone_command	=	7
rotatemap_command	=	8
linear_command		=	9
perspected_command	=	10
setluminance_command	=	11
projectwall_command	=	12

end_code		=	0
wall_code		=	1
startfloor_code		=	2
endfloor_code		=	3
startceiling_code	=	4
endceiling_code		=	5

invisible_code		=	0
visible_code		=	1

