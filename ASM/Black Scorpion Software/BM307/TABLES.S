*=======================================================*
*	Data tables: updated 12/06/97			* 
*=======================================================*

sinres		=	4096

*-------------------------------------------------------*
			datlong
*-------------------------------------------------------*

*-------------------------------------------------------*
*	DSP Doom engine					*
*-------------------------------------------------------*
DoomCore:		incbin	"dsp\engine.dsp"
*-------------------------------------------------------*
DoomCore_e:
*-------------------------------------------------------*

*-------------------------------------------------------*
*	Sinetable	(4096 words -16384 <> +16384 )	*
*-------------------------------------------------------*
sine:			incbin	'data\sinewave.tab'
*-------------------------------------------------------*

*-------------------------------------------------------*
*	Standard 6x6 debugging font			*
*-------------------------------------------------------*
font:			incbin	'data\doom.fnt'
*-------------------------------------------------------*

*-------------------------------------------------------*
			txtlong
*-------------------------------------------------------*
