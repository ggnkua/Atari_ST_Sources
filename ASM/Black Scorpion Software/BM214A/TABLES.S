*=======================================================*
*	Data tables module: latest update 25/03/96	* 
*=======================================================*

sinres		=	4096

*-------------------------------------------------------*
			datlong
*-------------------------------------------------------*

*-------------------------------------------------------*
*	Sinetable	(4096 words -16384 <> +16384 )	*
*-------------------------------------------------------*
sine:			incbin	'data\sinewave.tab'
*-------------------------------------------------------*

*-------------------------------------------------------*
*	Standard 6x6 debugging font			*
*-------------------------------------------------------*
font:			incbin	'data\doom.fnt'
*-------------------------------------------------------*

*-------------------------------------------------------*
			txtlong
*-------------------------------------------------------*
