
Hi there !


A few remarks to this second disk:


1) We haven't done the promised 31 khz source code for two reasons:
  
  - As you've read in the player's scroller, we have much better
   routines (so why bother ?)
  - We are busy working on our Dream Demo (Yes Sir !)

   But if you want to know how to reach this frequency, then contact 
  us, we will explain it to you...


2) On this disk, you will find various source codes, we don't think
  they need any explanations. Once again, if you have any questions,
  then contact us ! The program is just a player, it is not supposed 
  to be a second sound demo (sinon ‡a sentirait le r‚chauff‚ … plein
  nez...).

3) There are a few musics on this disk, and I want to tell you who 
  have composed them (it would be lame to rip them and not tell you
  who have made them !):

    RVB_DEMO    --> PAT / Wild Copper            Ripped by Marlon
    SPREAD      --> Starbuck / Spreadpoint       Ripped by Vantage
    PAT_MIX     --> PAT / A.S.A.                 Ripped by Vantage     
                               (note to Rank Xerox: Je l'avais d‚j… !)

    The two other musics have been composed by our good friends on the 
Amiga: Devil Dread !!! You will see some other Devil Dread productions 
on the ST soon... One of them is a Dechavanne-mix (D_DREAD2), the other
one is a ehm... listen to it ! (D_DREAD1)


There are 2 ways to contact us:

If you live in France and have a Minitel, then:
    36-14 Code 135060318*RTEL, bal ST CONNEXION
or  36-14 Code TEASER, bal ST CNX

Otherwise, you can write a nice letter to the following address:

ST Connexion
B.P. 36
78860 St Nom la Bretˆche
FRANCE/EUROPE !!


    Have fun with those new routines, but don't forget to enjoy life 
also !



                                  Vantage / ST Connexion.






P.S.: Un bonjour en passant … nos 2 sysops pr‚f‚r‚s:
Chip (France Teaser) et Mic Dax (Gen 4-ST Mag).
