Notes about 10KHZ.S :

Written by ST Connexion May 1989.

This version is using interruptions and
replays the samples at 10 khz, three
registers left and 88000 clock cycles
free.

Sorry if the source code is not very
clear and not completely finished (there
are still a few things to fix), but we
have only decided last week to spread
this routine.

We will soon release a new version of
this soundtracker with a very clear
programming, more compatibility and even
faster routines; if you really need the
28 khz-version (without interrupts and
CPU-time left), then wait for the 
31 khz-version coming together.

Bye, Vantage/ST CNX



P.S.:Pub !

	  France Teaser, "to tease":
Se moquer gentiment. Serveur teletel 2
au 36-14 Code: 195150632*teaser.
Le serveur Teaser, les autres serveurs
ne lui disent pas merci !
