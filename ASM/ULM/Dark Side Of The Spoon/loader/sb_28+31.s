        dc.b $0d,$0d,$0d,$0f,$09,$0e,$00,$0a
        dc.b $0f,$0e,$0f,$0d,$0f,$0e,$0d,$0d
        dc.b $0f,$0a,$0d,$09,$0c,$00,$0f,$00
        dc.b $0f,$00,$00,$0c,$0c,$00,$0d,$0a
        dc.b $00,$0d,$00,$00,$00,$0c,$0b,$0b
        dc.b $0e,$0e,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0d,$0f,$0b,$0a,$00,$00
        ds.w 9
        dc.b $09,$0a,$07,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0e,$07,$00,$00,$00,$00,$00,$00
        ds.w 13
        dc.b $0c,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0e
        dc.b $0d,$0a,$00,$00,$00,$00,$00,$00
        ds.w 18
        dc.b $00,$0b,$0d,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0e,$0b,$09,$00,$00,$00,$00,$00
        ds.w 18
        dc.b $0a,$0d,$0d,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0e,$0e,$0d,$0c,$0c,$0b
        dc.b $0a,$09,$00,$07,$00,$00,$00,$00
        ds.w 16
        dc.b $07,$07,$09,$0c,$0c,$0c,$0d,$0d
        dc.b $0d,$0d,$0e,$0e,$0e,$0e,$0e,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0e,$0f,$0e,$0e,$0e,$0e
        dc.b $0e,$0e,$0e,$0e,$0e,$0d,$0d,$0d
        dc.b $0d,$0c,$0c,$0c,$0c,$0c,$0c,$0c
        dc.b $0b,$0b,$0b,$0b,$09,$0a,$09,$07
        dc.b $09,$09,$07,$07,$07,$07,$07,$07
        dc.b $09,$09,$07,$07,$09,$09,$0a,$0b
        dc.b $0a,$0a,$0b,$0b,$0c,$0b,$0c,$0c
        dc.b $0c,$0c,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0e,$0e,$0e,$0e,$0e
        dc.b $0e,$0e,$0e,$0e,$0e,$0e,$0e,$0e
        dc.b $0e,$0e,$0e,$0e,$0e,$0e,$0e,$0f
        dc.b $0e,$0e,$0e,$0e,$0e,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0e,$0e,$0e,$0e
        dc.b $0e,$0e,$0e,$0e,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0c,$0c,$0c,$0b,$0b
        dc.b $0b,$0b,$0a,$0a,$0a,$0a,$09,$09
        dc.b $09,$07,$09,$07,$07,$09,$07,$09
        dc.b $07,$07,$09,$07,$09,$09,$09,$0a
        dc.b $0a,$0a,$0b,$0a,$0b,$0b,$0b,$0b
        dc.b $0c,$0c,$0c,$0c,$0c,$0d,$0c,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0e,$0e
        dc.b $0e,$0e,$0e,$0e,$0e,$0e,$0e,$0e
        dc.b $0e,$0e,$0e,$0e,$0e,$0e,$0e,$0e
        dc.b $0e,$0e,$0e,$0e,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0c,$0c
        dc.b $0c,$0c,$0c,$0c,$0c,$0c,$0b,$0b
        dc.b $0b,$0b,$0b,$0a,$0b,$0b,$0b,$0b
        dc.b $0b,$0b,$0b,$0b,$0b,$0b,$0c,$0c
        dc.b $0c,$0c,$0c,$0c,$0c,$0d,$0c,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$88,$88,$88,$88,$88,$88,$88
        dc.b $88,$0d,$0d,$0d,$0b,$0b,$0c,$09
        dc.b $09,$0d,$0d,$0f,$0e,$0f,$0e,$0e
        dc.b $0e,$0d,$0d,$0c,$0c,$00,$09,$00
        dc.b $07,$00,$00,$00,$00,$00,$0b,$0d
        dc.b $0e,$0f,$0f,$0f,$0f,$0f,$0d,$0f
        dc.b $0e,$0e,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0d,$0c,$09,$00,$00,$00,$00,$00
        ds.w 3
        dc.b $00,$0b,$0d,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0e,$0d,$00
        ds.w 3
        dc.b $00,$07,$09,$07,$09,$09,$07,$00
        dc.b $07,$07,$09,$0a,$0a,$0e,$0d,$0d
        dc.b $0d,$0d,$0d,$0c,$0b,$00,$00,$00
        dc.b $00,$09,$0c,$0e,$0e,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0d,$0d,$0e,$0e,$0d,$0f,$0f,$0f
        dc.b $0f,$0e,$0e,$0d,$0d,$0c,$0d,$0b
        dc.b $0d,$0d,$0d,$0d,$0d,$0c,$0e,$0c
        dc.b $0b,$07,$00,$0a,$00,$0d,$07,$07
        dc.b $00,$09,$00,$0b,$09,$0d,$0c,$0d
        dc.b $0e,$0e,$0c,$0e,$0c,$0a,$0a,$00
        dc.b $00,$09,$07,$07,$09,$00,$00,$09
        dc.b $07,$09,$0b,$0d,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0d,$0b,$00,$00,$00
        ds.w 5
        dc.b $00,$09,$00,$07,$07,$09,$07,$0a
        dc.b $0b,$0c,$0c,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0e,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0e,$0d
        dc.b $0d,$0a,$0b,$00,$00,$00,$00,$00
        ds.w 6
        dc.b $00,$09,$0c,$07,$0c,$0c,$0d,$0e
        dc.b $0e,$0e,$0f,$0e,$0f,$0d,$0f,$0d
        dc.b $0f,$0d,$0f,$0e,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0e,$0d,$0b,$0a,$00,$00,$00
        ds.w 1
        dc.b $00,$09,$00,$07,$07,$00,$00,$07
        ds.w 5
        dc.b $09,$09,$0b,$0b,$0d,$0c,$0d,$0e
        dc.b $0e,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0e,$0f,$0e,$0e
        dc.b $0f,$0e,$0e,$0d,$0e,$0b,$0c,$07
        dc.b $07,$0b,$07,$00,$00,$00,$00,$07
        ds.w 1
        dc.b $00,$09,$0a,$0c,$0c,$0e,$0e,$0d
        dc.b $0d,$0e,$0e,$0c,$0e,$0d,$0d,$0c
        dc.b $0d,$0c,$0c,$0c,$0c,$0d,$0c,$0d
        dc.b $0d,$0e,$0d,$0e,$0e,$0e,$0e,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0e,$0e,$0d
        dc.b $0e,$0d,$0c,$0b,$0a,$00,$00,$00
        ds.w 3
        dc.b $0a,$00,$07,$0a,$07,$09,$09,$07
        dc.b $07,$00,$07,$00,$07,$00,$0a,$07
        dc.b $0b,$0b,$0c,$0c,$0d,$0d,$0e,$0e
        dc.b $0e,$0e,$0e,$0e,$0e,$0e,$0f,$0e
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$88,$88,$88,$88
        dc.b $88,$88,$88,$88,$0d,$0a,$0d,$0e
        dc.b $0c,$0d,$0f,$0d,$00,$0b,$0e,$0e
        dc.b $0e,$0e,$0c,$07,$0b,$0d,$0e,$0f
        dc.b $0f,$0c,$00,$00,$0c,$0f,$0f,$0d
        dc.b $0d,$09,$00,$0e,$0f,$0c,$09,$0d
        dc.b $0e,$07,$00,$0d,$0f,$0f,$0f,$00
        dc.b $00,$0c,$0c,$00,$00,$00,$0f,$0f
        dc.b $0f,$0f,$0f,$0d,$00,$00,$00,$00
        dc.b $00,$07,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$00,$00,$00,$00,$00
        ds.w 1
        dc.b $0a,$0e,$0f,$0f,$0f,$0f,$0e,$07
        ds.w 1
        dc.b $00,$0d,$0d,$0d,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0d,$00,$00,$00
        ds.w 2
        dc.b $00,$0c,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0d,$0e,$0f
        dc.b $0d,$0a,$00,$00,$00,$00,$00,$00
        ds.w 2
        dc.b $00,$0d,$0e,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0d,$0a,$0a,$00,$00,$00,$00,$00
        ds.w 2
        dc.b $00,$0a,$0a,$0c,$0e,$0c,$0e,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0b,$00,$0a,$00,$00
        ds.w 3
        dc.b $00,$0a,$0f,$0a,$00,$00,$0f,$0f
        dc.b $0f,$0d,$0d,$0e,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0d,$00,$00
        ds.w 2
        dc.b $00,$0c,$00,$00,$0c,$0c,$00,$0b
        dc.b $0b,$0a,$0d,$0a,$0c,$0f,$0d,$07
        dc.b $0c,$0d,$0d,$0e,$0f,$0f,$0f,$0e
        dc.b $0f,$0f,$0f,$0f,$09,$0c,$0f,$0f
        ds.w 1
        dc.b $00,$0a,$00,$00,$0b,$00,$00,$0a
        dc.b $0f,$0f,$07,$00,$0f,$0d,$00,$07
        dc.b $0f,$0e,$0c,$00,$0c,$0f,$0f,$0f
        dc.b $0f,$0e,$0f,$0f,$0f,$0d,$0b,$0f
        dc.b $0f,$00,$00,$0c,$0c,$00,$00,$00
        ds.w 1
        dc.b $0a,$0f,$0b,$00,$09,$0d,$0e,$00
        dc.b $00,$0d,$0f,$00,$00,$0f,$0f,$0f
        dc.b $0d,$0f,$0f,$0f,$0c,$0f,$0f,$0f
        dc.b $0f,$0f,$0d,$00,$00,$0f,$0f,$00
        dc.b $00,$0d,$0a,$00,$0c,$0d,$00,$00
        dc.b $09,$0f,$0f,$00,$00,$0b,$0f,$0f
        dc.b $0d,$0a,$0e,$0f,$0f,$0f,$0d,$0f
        dc.b $0f,$0f,$0d,$00,$0e,$0f,$0a,$00
        dc.b $0a,$0f,$0a,$00,$00,$0e,$0e,$0c
        ds.w 1
        dc.b $0f,$0d,$00,$00,$0f,$0f,$00,$00
        dc.b $00,$0f,$0f,$07,$00,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0c,$00,$0b
        dc.b $0f,$0f,$00,$00,$00,$0f,$0f,$07
        dc.b $00,$0d,$0f,$0e,$00,$0c,$0f,$00
        ds.w 1
        dc.b $0a,$00,$0d,$07,$07,$0f,$0f,$0f
        dc.b $07,$0b,$0f,$0f,$0f,$07,$00,$0e
        dc.b $0f,$0f,$00,$00,$0a,$0f,$0f,$09
        dc.b $00,$0e,$0f,$0c,$0e,$0e,$09,$0c
        dc.b $0f,$0d,$00,$00,$0f,$0e,$00,$00
        dc.b $07,$0e,$0e,$0e,$0f,$0f,$0f,$0d
        dc.b $0f,$0f,$0d,$0d,$0f,$0d,$00,$00
        dc.b $0f,$0f,$0d,$00,$0a,$0f,$0f,$00
        dc.b $00,$0f,$0d,$00,$00,$0b,$0e,$09
        ds.w 1
        dc.b $0c,$0f,$0c,$07,$0f,$0f,$0f,$0d
        dc.b $0c,$0f,$0f,$0f,$0e,$0d,$0b,$09
        dc.b $0f,$0f,$07,$00,$00,$00,$0d,$0e
        dc.b $0c,$00,$00,$0b,$0d,$0a,$0e,$0c
        dc.b $00,$09,$0f,$0f,$00,$00,$0a,$0f
        dc.b $0f,$0d,$09,$0c,$0f,$0f,$0e,$0f
        dc.b $0d,$00,$09,$0f,$0d,$0d,$0c,$00
        dc.b $0b,$0e,$0c,$0d,$0f,$0f,$00,$00
        dc.b $0f,$0f,$0d,$07,$00,$0c,$0f,$0a
        dc.b $00,$0f,$0f,$07,$00,$0f,$0f,$0e
        dc.b $00,$0c,$0f,$0f,$09,$0c,$0f,$0d
        dc.b $00,$0c,$0f,$0e,$00,$00,$0f,$0f
        dc.b $0f,$0f,$0a,$00,$0e,$0f,$00,$07
        dc.b $0f,$0b,$00,$0d,$0e,$0d,$00,$00
        dc.b $0f,$0f,$0d,$00,$0a,$0f,$0f,$00
        dc.b $00,$0f,$0f,$00,$07,$0f,$0f,$07
        dc.b $00,$0f,$0f,$0d,$0f,$0f,$07,$00
        dc.b $0f,$0f,$00,$00,$0e,$0e,$00,$0a
        dc.b $0f,$0e,$00,$00,$0e,$0f,$0d,$00
        dc.b $0c,$0f,$0d,$00,$0e,$0e,$0c,$0e
        ds.w 1
        dc.b $0f,$0f,$0d,$00,$0d,$0f,$0e,$07
        dc.b $0d,$0c,$0c,$07,$00,$0d,$0a,$00
        dc.b $00,$0e,$0f,$0b,$00,$00,$0f,$0f
        dc.b $0f,$0b,$0d,$0e,$0d,$0f,$0f,$0f
        dc.b $00,$0c,$0f,$0f,$0f,$0d,$07,$0d
        dc.b $0f,$0f,$0d,$00,$0d,$0e,$09,$07
        dc.b $0e,$0f,$0b,$00,$00,$0f,$0f,$00
        dc.b $00,$0d,$0f,$0f,$00,$07,$0f,$0f
        dc.b $0a,$00,$0e,$0f,$0b,$0a,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$88,$88,$88
        dc.b $88,$88,$88,$88,$88,$0d,$0e,$0d
        dc.b $0c,$0a,$00,$07,$0d,$00,$0b,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0e,$0b
        ds.w 4
        dc.b $00,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0c
        dc.b $07,$09,$00,$00,$00,$00,$00,$00
        ds.w 3
        dc.b $00,$09,$0e,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0b,$00,$07,$00,$00,$00,$00
        ds.w 4
        dc.b $00,$07,$0d,$0e,$0e,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0c,$00,$0a,$00,$00,$00,$00
        ds.w 3
        dc.b $0d,$0d,$0c,$0c,$0f,$0e,$0b,$0f
        dc.b $0f,$0d,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0d,$0f,$0e
        dc.b $0b,$00,$00,$00,$00,$00,$00,$00
        ds.w 1
        dc.b $00,$0c,$07,$0a,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0e
        dc.b $0e,$0f,$0d,$0f,$0e,$07,$0e,$09
        dc.b $00,$07,$00,$00,$00,$00,$00,$07
        dc.b $00,$0d,$07,$0c,$0f,$0d,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0e,$0d,$0e
        dc.b $0e,$0d,$07,$0e,$0c,$0e,$00,$0f
        dc.b $0c,$0e,$09,$0a,$0d,$0a,$09,$00
        dc.b $00,$0c,$00,$00,$0d,$0c,$00,$0d
        dc.b $0f,$0e,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0d,$0e,$0e,$0e,$0a
        dc.b $0e,$00,$0d,$0a,$09,$00,$0a,$0a
        dc.b $09,$07,$0d,$0c,$0a,$0c,$0f,$0d
        dc.b $0d,$0f,$0f,$0e,$0e,$0e,$0d,$0f
        dc.b $0f,$0d,$0e,$0d,$0f,$0d,$0e,$0e
        dc.b $0c,$0e,$0c,$00,$0b,$0b,$0a,$0a
        dc.b $0c,$07,$09,$0d,$00,$0d,$0c,$0d
        dc.b $0d,$0f,$0c,$0e,$0f,$0f,$0f,$0d
        dc.b $0e,$0f,$0e,$0c,$0e,$0e,$0e,$0c
        dc.b $0d,$0b,$0a,$0c,$09,$0c,$07,$0b
        dc.b $09,$07,$0a,$0b,$0b,$0c,$0d,$0b
        dc.b $0d,$0e,$0e,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0e,$0e,$0e,$0f,$0c,$0c,$0d
        dc.b $0b,$0c,$09,$0d,$0b,$0b,$0a,$0d
        dc.b $0d,$0c,$0f,$0d,$0f,$0e,$0e,$0d
        dc.b $0d,$0d,$0d,$0e,$0d,$0f,$0d,$0d
        dc.b $0f,$0d,$0f,$0e,$0d,$0e,$0e,$0d
        dc.b $0d,$0e,$0d,$0d,$0a,$0d,$0d,$0b
        dc.b $0c,$0d,$0b,$0a,$0d,$0d,$0e,$0d
        dc.b $0d,$0c,$0e,$0e,$0d,$0e,$0d,$0e
        dc.b $0d,$0f,$0e,$0d,$0a,$0f,$0e,$0d
        dc.b $0c,$0b,$0c,$09,$0d,$07,$07,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0c,$0d,$0b,$0d,$0e,$0c,$0e,$0c
        dc.b $0e,$0d,$0d,$0d,$0d,$0e,$0d,$0e
        dc.b $0d,$0e,$0c,$0d,$0d,$0c,$0d,$0b
        dc.b $0c,$0e,$0c,$0d,$0d,$0c,$0d,$0d
        dc.b $0d,$0d,$0e,$0e,$0e,$0f,$0d,$0f
        dc.b $0f,$0e,$0e,$0c,$0e,$0d,$0d,$0d
        dc.b $0c,$0d,$0d,$0c,$0e,$0c,$0d,$0c
        dc.b $0d,$0d,$0c,$0d,$0d,$0d,$0e,$0c
        dc.b $0b,$0e,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$88,$88,$88,$88,$88,$88,$88
        dc.b $88,$0c,$0c,$00,$00,$00,$00,$07
        dc.b $0c,$0c,$0d,$0f,$0f,$0f,$0f,$0f
        dc.b $0d,$00,$00,$0e,$0f,$0a,$0f,$0b
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0d
        dc.b $0b,$00,$00,$00,$00,$00,$00,$00
        ds.w 7
        dc.b $00,$0a,$0c,$0d,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0e,$0d,$0b,$00,$00
        ds.w 17
        dc.b $07,$0b,$0c,$0d,$0e,$0e,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0e,$0e
        dc.b $0e,$0e,$0d,$0d,$0d,$0d,$0c,$0c
        dc.b $0b,$07,$07,$07,$00,$00,$00,$00
        ds.w 14
        dc.b $07,$07,$0a,$0b,$0b,$0c,$0c,$0c
        dc.b $0c,$0d,$0c,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0e,$0e,$0e,$0e,$0e,$0e
        dc.b $0e,$0e,$0e,$0e,$0e,$0e,$0e,$0e
        dc.b $0e,$0e,$0e,$0e,$0e,$0e,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0e,$0e
        dc.b $0e,$0e,$0e,$0e,$0e,$0e,$0e,$0e
        dc.b $0e,$0f,$0f,$0e,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0e,$0e,$0e,$0e,$0e,$0e,$0e
        dc.b $0e,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0c,$0c,$0c,$0c,$0b,$0c,$0b
        dc.b $0b,$0b,$0b,$0b,$0b,$0c,$0c,$0b
        dc.b $0b,$0b,$0b,$0b,$0b,$0b,$0c,$0b
        dc.b $0c,$0c,$0c,$0c,$0c,$0c,$0c,$0c
        dc.b $0d,$0c,$0d,$0d,$0c,$0c,$0d,$0d
        dc.b $0c,$0d,$0d,$0c,$0c,$0c,$0c,$0c
        dc.b $0c,$0c,$0c,$0d,$0d,$0c,$0c,$0c
        dc.b $0c,$0c,$0c,$0c,$0b,$0c,$0b,$0b
        dc.b $0a,$0a,$0b,$0b,$0a,$0a,$0a,$0a
        dc.b $09,$0a,$0a,$0a,$0a,$0a,$0b,$0c
        dc.b $0c,$0c,$0c,$0c,$0c,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$88,$88,$88,$88,$88,$88,$88
        dc.b $88,$0a,$0f,$07,$0f,$07,$0f,$07
        dc.b $0e,$0e,$0e,$0f,$0c,$0f,$00,$0f
        dc.b $0d,$0e,$0f,$09,$0f,$0d,$09,$0f
        dc.b $0a,$0e,$0f,$00,$0f,$0b,$0a,$0f
        dc.b $00,$0f,$0d,$00,$0f,$0f,$07,$0f
        dc.b $0e,$00,$0e,$0e,$00,$0d,$0e,$07
        dc.b $07,$0f,$0d,$0d,$00,$0e,$0f,$09
        dc.b $0a,$0d,$0d,$0a,$0d,$0e,$0a,$0b
        dc.b $0e,$0e,$0a,$0b,$0f,$0e,$00,$0b
        dc.b $0e,$0e,$0b,$07,$0b,$0f,$0a,$00
        dc.b $0d,$0f,$0c,$07,$0e,$0f,$0b,$00
        dc.b $09,$0f,$0f,$0a,$00,$07,$0e,$0f
        dc.b $0f,$0d,$00,$0b,$0f,$0f,$0d,$09
        dc.b $0c,$0f,$0e,$0b,$09,$0c,$0f,$0f
        dc.b $0f,$0c,$00,$00,$0e,$0f,$0f,$0c
        dc.b $09,$07,$0e,$0e,$0d,$0f,$0d,$0e
        dc.b $0c,$00,$00,$0c,$0f,$0f,$0f,$0d
        dc.b $0a,$00,$07,$0d,$0f,$0f,$0d,$0c
        ds.w 1
        dc.b $09,$0c,$0f,$0f,$0f,$0e,$0a,$00
        dc.b $00,$0c,$0f,$0f,$0f,$0f,$0b,$00
        ds.w 1
        dc.b $09,$0e,$0f,$0f,$0f,$0f,$0c,$09
        ds.w 2
        dc.b $0d,$0f,$0f,$0f,$0f,$0f,$0e,$00
        dc.b $0a,$00,$00,$09,$0b,$0d,$0e,$0e
        dc.b $0f,$0f,$0d,$0e,$0e,$0f,$0e,$0c
        dc.b $09,$0a,$00,$09,$0c,$0a,$0c,$0f
        dc.b $0f,$0f,$0f,$0d,$0c,$0e,$0b,$0a
        ds.w 2
        dc.b $0d,$0e,$0e,$0f,$0f,$0f,$0f,$0f
        dc.b $0e,$0d,$0c,$0c,$0d,$0b,$00,$00
        ds.w 1
        dc.b $09,$0c,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0e,$0d,$0d,$0d,$0c,$09
        ds.w 1
        dc.b $00,$07,$09,$00,$09,$0b,$0d,$0e
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0d,$0e
        dc.b $0e,$0d,$0d,$0c,$0b,$09,$00,$00
        ds.w 1
        dc.b $00,$07,$0b,$0c,$0d,$0d,$0d,$0e
        dc.b $0e,$0f,$0f,$0f,$0f,$0f,$0f,$0e
        dc.b $0f,$0e,$0f,$0e,$0d,$07,$00,$00
        dc.b $0c,$00,$00,$00,$00,$0a,$0c,$0d
        dc.b $0c,$0c,$0d,$0d,$0d,$0e,$0d,$0d
        dc.b $0d,$0e,$0e,$0e,$0f,$0f,$0f,$0e
        dc.b $0d,$0d,$0d,$0d,$0e,$0e,$0f,$0f
        dc.b $0f,$0d,$0a,$0b,$0c,$0c,$0c,$09
        ds.w 1
        dc.b $09,$00,$00,$00,$00,$0a,$0d,$0e
        dc.b $0f,$0d,$0d,$0d,$0e,$0e,$0d,$0f
        dc.b $0f,$0f,$0f,$0f,$0e,$0d,$0c,$0d
        dc.b $0c,$0d,$0b,$0b,$0c,$0c,$0c,$0c
        dc.b $0d,$0d,$0c,$0c,$0d,$0d,$0f,$0f
        dc.b $0d,$0a,$00,$09,$0a,$0c,$0c,$0c
        dc.b $0d,$0c,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0e,$0e,$0e,$0d,$0d,$0e,$0e,$0e
        dc.b $0e,$0e,$0d,$0d,$0d,$0c,$0c,$0c
        dc.b $0c,$0c,$0c,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0e,$0d,$0d,$0c,$0a,$0a
        ds.w 2
        dc.b $0b,$0d,$0d,$0d,$0d,$0c,$0d,$0d
        dc.b $0d,$0d,$0e,$0e,$0e,$0f,$0e,$0e
        dc.b $0e,$0d,$0d,$0d,$0e,$0d,$0e,$0e
        dc.b $0e,$0e,$0d,$0e,$0e,$0e,$0e,$0e
        dc.b $0f,$0f,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$88,$88,$88,$88,$88,$88,$88
        dc.b $88,$0d,$0e,$0d,$0a,$09,$0b,$0c
        dc.b $0d,$0f,$0d,$0d,$0c,$0c,$0c,$0d
        dc.b $0d,$0d,$0f,$0d,$0c,$0a,$00,$0a
        dc.b $0b,$0d,$0e,$0e,$0d,$0d,$0c,$0d
        dc.b $0d,$0d,$0d,$0e,$0f,$0d,$0c,$0b
        dc.b $09,$00,$0c,$0c,$0d,$0e,$0e,$0f
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0f,$0e,$0c,$0b,$0a
        dc.b $07,$00,$0b,$0c,$0d,$0d,$0d,$0e
        dc.b $0f,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0f,$0e,$0c
        dc.b $0c,$0a,$09,$07,$0b,$0c,$0d,$0e
        dc.b $0d,$0e,$0e,$0e,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0f,$0f,$0c,$0b,$09,$09,$00,$0b
        dc.b $0b,$0d,$0d,$0d,$0d,$0f,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0e,$0d,$0e,$0c,$0a,$07
        dc.b $09,$07,$0b,$0c,$0d,$0d,$0d,$0e
        dc.b $0f,$0e,$0e,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0e,$0c,$0e
        dc.b $0c,$0a,$09,$09,$09,$0a,$0c,$0d
        dc.b $0d,$0e,$0f,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0e,$0e,$0c
        dc.b $0c,$0a,$00,$0b,$0b,$0c,$0d,$0e
        dc.b $0d,$0d,$0d,$0c,$0d,$0d,$0d,$0d
        dc.b $0d,$0e,$0e,$0c,$0c,$0a,$00,$0c
        dc.b $0c,$0d,$0d,$0e,$0d,$0d,$0d,$0c
        dc.b $0d,$0d,$0d,$0d,$0d,$0e,$0e,$0c
        dc.b $0c,$0a,$00,$0b,$0b,$0d,$0d,$0e
        dc.b $0d,$0d,$0d,$0c,$0d,$0d,$0d,$0d
        dc.b $0d,$0e,$0e,$0c,$0c,$0b,$00,$0c
        dc.b $0c,$0d,$0d,$0e,$0d,$0d,$0d,$0c
        dc.b $0d,$0d,$0d,$0d,$0d,$0e,$0e,$0c
        dc.b $0c,$0b,$00,$0c,$0c,$0d,$0d,$0f
        dc.b $0d,$0d,$0c,$0d,$0d,$0d,$0d,$0d
        dc.b $0e,$0f,$0d,$0c,$0a,$07,$0c,$0c
        dc.b $0d,$0d,$0f,$0d,$0d,$0c,$0d,$0d
        dc.b $0d,$0d,$0d,$0e,$0e,$0d,$0c,$0b
        dc.b $07,$0c,$0c,$0d,$0d,$0e,$0e,$0d
        dc.b $0d,$0c,$0d,$0d,$0d,$0d,$0d,$0e
        dc.b $0e,$0d,$0c,$0b,$07,$0c,$0c,$0d
        dc.b $0d,$0e,$0e,$0d,$0d,$0c,$0c,$0d
        dc.b $0d,$0d,$0d,$0e,$0e,$0d,$0c,$0a
        dc.b $00,$0b,$0c,$0d,$0d,$0e,$0e,$0d
        dc.b $0d,$0c,$0d,$0d,$0d,$0d,$0d,$0e
        dc.b $0e,$0d,$0c,$0b,$07,$0b,$0c,$0d
        dc.b $0d,$0d,$0f,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0e,$0e,$0d,$0c
        dc.b $0b,$09,$0a,$0c,$0c,$0d,$0d,$0f
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0f,$0e,$0c,$0c,$0a,$00
        dc.b $0c,$0c,$0d,$0d,$0d,$0f,$0d,$0d
        dc.b $0d,$0c,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0e,$0e,$0c,$0c,$0a,$09,$0a,$0c
        dc.b $0d,$0d,$0d,$0e,$0e,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0f
        dc.b $0e,$0c,$0b,$09,$00,$0c,$0c,$0d
        dc.b $0d,$0d,$0f,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0e,$0e,$0c
        dc.b $0c,$0a,$09,$0b,$0c,$0d,$0d,$0d
        dc.b $0e,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0e,$0e,$0d,$0c
        dc.b $0b,$0a,$07,$0b,$0c,$0d,$0d,$0d
        dc.b $0d,$0f,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0f,$0e
        dc.b $0c,$0a,$0a,$09,$09,$0c,$0d,$0d
        dc.b $0d,$0e,$0e,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0f
        dc.b $0f,$0c,$0b,$0a,$09,$07,$0c,$0c
        dc.b $0d,$0d,$0d,$0e,$0e,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0e,$0d,$0c,$0b,$09,$09,$09
        dc.b $0c,$0c,$0d,$0d,$0d,$0e,$0f,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0e,$0e,$0c,$0b,$0a
        dc.b $09,$07,$0b,$0c,$0d,$0d,$0d,$0e
        dc.b $0e,$0e,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0f
        dc.b $0e,$0c,$0b,$09,$09,$0a,$00,$0c
        dc.b $0c,$0d,$0d,$0d,$0e,$0e,$0f,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0f,$0e,$0c
        dc.b $0a,$09,$09,$0a,$00,$0c,$0d,$0d
        dc.b $0d,$0e,$0e,$0e,$0f,$0e,$0e,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0f,$0e,$0b,$0b,$09
        dc.b $09,$09,$00,$0b,$0c,$0d,$0d,$0e
        dc.b $0e,$0e,$0f,$0d,$0e,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0f,$0c,$0d,$0b,$09,$09,$0a
        dc.b $00,$0d,$0d,$0d,$0d,$0e,$0e,$0e
        dc.b $0f,$0c,$0e,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0e
        dc.b $0d,$0d,$09,$0a,$09,$09,$00,$0c
        dc.b $0c,$0d,$0d,$0e,$0e,$0e,$0f,$0e
        dc.b $0d,$0e,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0e,$0e,$0d
        dc.b $0a,$07,$0a,$07,$00,$09,$0e,$0c
        dc.b $0e,$0e,$0e,$0e,$0f,$0f,$0c,$0e
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0e,$0f,$0d,$0c,$00
        dc.b $0a,$07,$00,$0d,$0c,$0d,$0d,$0e
        dc.b $0e,$0e,$0f,$0e,$0e,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0e,$0d,$0d,$0b,$0a,$09
        dc.b $09,$09,$0a,$0c,$0d,$0d,$0e,$0e
        dc.b $0e,$0e,$0f,$0e,$0e,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0c
        dc.b $0d,$0d,$0d,$0d,$0e,$0b,$0a,$09
        dc.b $0a,$0a,$00,$0c,$0d,$0d,$0e,$0e
        dc.b $0e,$0e,$0e,$0f,$0e,$0e,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0c,$0c,$0c
        dc.b $0c,$0c,$0c,$0d,$0f,$0d,$0c,$0b
        dc.b $0a,$09,$0a,$0a,$07,$0c,$0d,$0d
        dc.b $0e,$0e,$0e,$0e,$0e,$0f,$0e,$0e
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0c
        dc.b $0c,$0c,$0c,$0c,$0d,$0d,$0f,$0d
        dc.b $0c,$0b,$0a,$0a,$0a,$0a,$07,$0d
        dc.b $0d,$0d,$0e,$0e,$0e,$0e,$0e,$0e
        dc.b $0f,$0e,$0e,$0d,$0d,$0d,$0c,$0c
        dc.b $0c,$0c,$0c,$0c,$0c,$0c,$0c,$0c
        dc.b $0c,$0d,$0e,$0e,$0c,$0b,$0a,$0a
        dc.b $0b,$0b,$07,$0d,$0d,$0e,$0e,$0e
        dc.b $0e,$0e,$0e,$0f,$0e,$0e,$0e,$0d
        dc.b $0d,$0d,$0c,$0c,$0c,$0c,$0c,$0c
        dc.b $0c,$0c,$0c,$0c,$0c,$0d,$0d,$0f
        dc.b $09,$0b,$0a,$0a,$0b,$0b,$00,$0d
        dc.b $0d,$0e,$0e,$0e,$0e,$0e,$0e,$0e
        dc.b $0e,$0e,$0e,$0d,$0d,$0c,$0c,$0c
        dc.b $0c,$0c,$0c,$0c,$0c,$0c,$0c,$0c
        dc.b $0c,$0d,$0d,$0d,$0d,$0e,$0e,$0c
        dc.b $0b,$0b,$0a,$0b,$0c,$0c,$09,$0d
        dc.b $0d,$0e,$0e,$0e,$0e,$0e,$0e,$0e
        dc.b $0e,$0e,$0d,$0d,$0c,$0c,$0c,$0c
        dc.b $0c,$0c,$0c,$0c,$0c,$0c,$0c,$0c
        dc.b $0c,$0c,$0d,$0d,$0d,$0e,$0e,$0c
        dc.b $0c,$0c,$0a,$0b,$0c,$0c,$00,$0d
        dc.b $0d,$0e,$0e,$0e,$0e,$0e,$0e,$0e
        dc.b $0e,$0f,$0e,$0d,$0c,$0c,$0c,$0c
        dc.b $0c,$0c,$0c,$0c,$0c,$0c,$0c,$0c
        dc.b $0c,$0d,$0d,$0d,$0d,$0f,$0a,$0e
        dc.b $07,$0c,$0a,$0b,$0b,$0c,$07,$0d
        dc.b $0d,$0e,$0e,$0e,$0e,$0e,$0e,$0e
        dc.b $0e,$0f,$0d,$0d,$0d,$0c,$0d,$0c
        dc.b $0c,$0c,$0c,$0c,$0c,$0c,$0c,$0c
        dc.b $0c,$0c,$0d,$0d,$0d,$0f,$0e,$0d
        dc.b $0c,$0a,$0a,$0a,$0b,$0c,$0c,$09
        dc.b $0d,$0e,$0e,$0e,$0e,$0e,$0e,$0e
        dc.b $0e,$0e,$0e,$0f,$0d,$0d,$0c,$0c
        dc.b $0b,$0b,$0b,$0b,$0b,$0b,$0c,$0c
        dc.b $0c,$0c,$0c,$0c,$0d,$0d,$0d,$0d
        dc.b $0d,$0e,$0d,$0f,$0c,$0c,$0c,$0b
        dc.b $0c,$0c,$0c,$0c,$0b,$0d,$0d,$0e
        dc.b $0e,$0e,$0e,$0e,$0e,$0e,$0e,$0e
        dc.b $0f,$0d,$0d,$0c,$0c,$0c,$0b,$0b
        dc.b $0b,$0b,$0b,$0b,$0c,$0c,$0c,$0c
        dc.b $0c,$0d,$0d,$0d,$0d,$0d,$0e,$0d
        dc.b $0f,$0d,$0c,$0c,$0b,$0c,$0c,$0c
        dc.b $0c,$00,$0e,$0d,$0e,$0e,$0e,$0e
        dc.b $0e,$0e,$0e,$0e,$0e,$0f,$0c,$0e
        dc.b $0b,$0c,$0b,$0b,$0b,$0b,$0b,$0b
        dc.b $0b,$0c,$0c,$0c,$0c,$0c,$0d,$0d
        dc.b $0d,$0d,$0d,$0e,$0f,$0d,$0e,$0c
        dc.b $0a,$0b,$0c,$0c,$0c,$0c,$09,$0c
        dc.b $0f,$0d,$0f,$0e,$0e,$0e,$0e,$0e
        dc.b $0e,$0e,$0f,$0d,$0d,$0c,$0c,$0c
        dc.b $0b,$0b,$0b,$0b,$0b,$0b,$0c,$0c
        dc.b $0c,$0c,$0c,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0f,$0d,$0f,$0c,$0c,$0b
        dc.b $0b,$0c,$0c,$0c,$0c,$07,$0d,$0d
        dc.b $0e,$0e,$0e,$0e,$0e,$0e,$0e,$0e
        dc.b $0e,$0e,$0f,$0d,$0d,$0c,$0c,$0b
        dc.b $0b,$0b,$0b,$0b,$0b,$0b,$0c,$0c
        dc.b $0c,$0c,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0f,$0d,$0e,$0a,$0c,$0b
        dc.b $0c,$0c,$0c,$0c,$0c,$07,$0e,$0d
        dc.b $0e,$0e,$0e,$0e,$0e,$0e,$0e,$0e
        dc.b $0e,$0e,$0f,$0b,$0d,$0a,$0c,$0b
        dc.b $0b,$0b,$0b,$0b,$0b,$0b,$0c,$0c
        dc.b $0c,$0c,$0c,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0e,$0f,$0d,$0e,$0d,$0a,$0b
        dc.b $0c,$0c,$0c,$0c,$0c,$07,$0e,$0d
        dc.b $0f,$0e,$0e,$0e,$0e,$0e,$0e,$0e
        dc.b $0e,$0e,$0e,$0e,$0d,$0c,$0b,$0a
        dc.b $0a,$0a,$0a,$0a,$0b,$0b,$0b,$0c
        dc.b $0c,$0c,$0c,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0e,$0d,$0d
        dc.b $0d,$0c,$0c,$0b,$0c,$0c,$0c,$0c
        dc.b $0d,$0d,$09,$0d,$0e,$0e,$0e,$0e
        dc.b $0e,$0e,$0e,$0e,$0e,$0e,$0d,$0d
        dc.b $0e,$0b,$0c,$0c,$0a,$0a,$0a,$0a
        dc.b $0a,$0a,$0a,$0b,$0b,$0c,$0c,$0c
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0e,$0f,$0c,$0e,$0d,$0a
        dc.b $0d,$0b,$0c,$0c,$0c,$0d,$0d,$0c
        dc.b $0b,$0f,$0d,$0f,$0e,$0f,$0e,$0e
        dc.b $0e,$0e,$0e,$0e,$0d,$0d,$0e,$0d
        dc.b $0c,$0b,$0a,$0a,$09,$09,$0a,$0a
        dc.b $0a,$0a,$0b,$0c,$0c,$0c,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0e
        dc.b $0e,$0d,$0d,$0d,$0e,$0d,$0d,$0e
        dc.b $0c,$0c,$0b,$0b,$0c,$0c,$0c,$0d
        dc.b $0d,$0d,$0c,$0e,$0e,$0e,$0f,$0f
        dc.b $0f,$0e,$0e,$0e,$0e,$0e,$0d,$0d
        dc.b $0d,$0d,$0d,$0c,$0c,$0a,$07,$07
        dc.b $07,$09,$09,$0a,$0a,$0b,$0b,$0c
        dc.b $0c,$0d,$0d,$0d,$0d,$0d,$0d,$0e
        dc.b $0e,$0e,$0e,$0e,$0e,$0e,$0e,$0e
        dc.b $0e,$0f,$0b,$0e,$0d,$0a,$0c,$0a
        dc.b $0c,$0c,$0c,$0d,$0d,$0d,$0d,$0a
        dc.b $0e,$0e,$0e,$0e,$0e,$0e,$0e,$0e
        dc.b $0e,$0e,$0d,$0d,$0d,$0d,$0c,$0c
        dc.b $0e,$0a,$0a,$07,$07,$07,$07,$09
        dc.b $0a,$0a,$0b,$0b,$0c,$0c,$0d,$0d
        dc.b $0d,$0d,$0d,$0e,$0e,$0e,$0e,$0e
        dc.b $0e,$0e,$0e,$0e,$0e,$0e,$0d,$0e
        dc.b $0f,$0d,$0d,$0d,$0c,$0b,$0b,$0c
        dc.b $0c,$0c,$0c,$0d,$0d,$0d,$0d,$0c
        dc.b $0e,$0e,$0e,$0e,$0e,$0e,$0e,$0e
        dc.b $0e,$0d,$0d,$0d,$0d,$0c,$0c,$0c
        dc.b $0e,$00,$0b,$00,$09,$07,$09,$09
        dc.b $0a,$0a,$0b,$0c,$0c,$0c,$0d,$0d
        dc.b $0d,$0d,$0e,$0e,$0e,$0e,$0e,$0e
        dc.b $0e,$0e,$0e,$0e,$0e,$0e,$0d,$0d
        dc.b $0f,$0d,$0d,$0e,$0a,$0c,$0b,$0c
        dc.b $0c,$0c,$0c,$0d,$0d,$0d,$0d,$0d
        dc.b $0a,$0e,$0e,$0e,$0e,$0e,$0e,$0e
        dc.b $0e,$0d,$0d,$0d,$0d,$0c,$0c,$0c
        dc.b $0b,$0b,$0b,$0d,$09,$09,$07,$07
        dc.b $09,$09,$0a,$0b,$0c,$0c,$0c,$0d
        dc.b $0d,$0d,$0d,$0d,$0e,$0e,$0e,$0e
        dc.b $0e,$0e,$0e,$0e,$0e,$0e,$0e,$0e
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0f
        dc.b $0b,$0d,$0d,$0c,$0b,$0c,$0b,$0c
        dc.b $0c,$0c,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0b,$0f,$0d,$0e,$0e,$0e,$0e,$0e
        dc.b $0d,$0d,$0d,$0d,$0d,$0c,$0c,$0c
        dc.b $0b,$0b,$0b,$0d,$0c,$07,$0a,$09
        dc.b $09,$0a,$0b,$0c,$0c,$0c,$0d,$0d
        dc.b $0d,$0d,$0d,$0e,$0e,$0e,$0e,$0e
        dc.b $0e,$0e,$0e,$0e,$0e,$0e,$0e,$0e
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0f,$0d,$0d,$0d,$0a
        dc.b $0c,$0b,$0b,$0c,$0c,$0c,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0e,$0e,$0e,$0e,$0d,$0d,$0d,$0d
        dc.b $0d,$0c,$0c,$0c,$0c,$0b,$0b,$0b
        dc.b $0b,$0b,$0b,$0d,$0a,$0a,$0b,$0a
        dc.b $0c,$0b,$0c,$0c,$0d,$0d,$0d,$0d
        dc.b $0e,$0e,$0e,$0e,$0e,$0e,$0e,$0e
        dc.b $0e,$0e,$0e,$0e,$0e,$0e,$0e,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0e,$0c,$0c
        dc.b $0c,$0c,$0c,$0b,$0b,$0b,$0c,$0c
        dc.b $0c,$0c,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0a,$0e,$0e,$0e,$0e,$0e,$0e,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0c,$0c,$0c
        dc.b $0c,$0c,$0c,$0c,$0c,$0c,$0e,$0a
        dc.b $0b,$0b,$0b,$0c,$0c,$0c,$0d,$0d
        dc.b $0d,$0d,$0d,$0e,$0e,$0e,$0e,$0e
        dc.b $0e,$0e,$0e,$0e,$0e,$0e,$0e,$0e
        dc.b $0e,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$88,$88,$88
        dc.b $88,$88,$88,$88,$88,$0e,$0d,$0e
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0e,$0c
        dc.b $0f,$00,$0d,$0c,$0b,$0c,$0d,$0d
        dc.b $0d,$0d,$0c,$0d,$00,$0b,$0c,$0d
        dc.b $0e,$0f,$0f,$0f,$0f,$0f,$0e,$0d
        dc.b $0b,$0a,$09,$07,$00,$00,$00,$00
        dc.b $07,$0d,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0e,$0d,$0b,$00,$00,$00
        ds.w 3
        dc.b $09,$0d,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0e,$0d,$0a,$00,$00
        ds.w 5
        dc.b $0a,$0d,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0e,$0d
        dc.b $0c,$07,$00,$00,$00,$00,$00,$00
        ds.w 4
        dc.b $0c,$0d,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0d,$0b,$00,$00,$00,$00
        ds.w 5
        dc.b $00,$09,$0c,$0e,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0e,$0d,$0c
        dc.b $07,$00,$00,$00,$00,$00,$00,$00
        ds.w 4
        dc.b $00,$07,$0b,$0c,$0d,$0e,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0e,$0d,$0c,$0b,$09,$00,$00
        ds.w 7
        dc.b $00,$09,$0c,$0d,$0e,$0e,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0e,$0d,$0c,$0a,$00,$00,$00,$00
        ds.w 6
        dc.b $00,$09,$0c,$0d,$0d,$0e,$0e,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0e,$0e,$0e,$0d,$0d,$0d,$0c
        dc.b $0c,$0b,$0a,$0a,$09,$09,$07,$09
        dc.b $09,$09,$09,$0a,$0b,$0c,$0c,$0c
        dc.b $0c,$0c,$0c,$0c,$0c,$0c,$0c,$0c
        dc.b $0c,$0c,$0c,$0c,$0c,$0c,$0c,$0c
        dc.b $0c,$0c,$0c,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0e,$0e,$0e,$0e,$0e
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0e,$0e,$0e,$0e,$0e,$0e
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0c,$0c
        dc.b $0b,$0b,$0a,$09,$07,$00,$00,$00
        ds.w 4
        dc.b $00,$07,$09,$0a,$0b,$0c,$0c,$0d
        dc.b $0d,$0d,$0d,$0e,$0e,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0e,$0e,$0d,$0d,$0c,$0d
        dc.b $0c,$0b,$0a,$09,$07,$00,$00,$00
        ds.w 6
        dc.b $00,$07,$09,$0a,$0b,$0c,$0c,$0d
        dc.b $0d,$0e,$0e,$0e,$0e,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0e,$0e,$0e,$0e,$0d
        dc.b $0d,$0d,$0c,$0c,$0b,$0a,$0a,$09
        dc.b $09,$07,$00,$00,$00,$00,$00,$00
        dc.b $00,$07,$07,$07,$09,$09,$0a,$0a
        dc.b $0b,$0b,$0c,$0c,$0c,$0c,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0e,$0e,$0e
        dc.b $0e,$0e,$0e,$0e,$0e,$0f,$0e,$0e
        dc.b $0e,$0e,$0e,$0e,$0e,$0e,$0e,$0e
        dc.b $0e,$0e,$0e,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0c,$0c,$0c,$0b,$0b,$0b,$0b,$0b
        dc.b $0b,$0b,$0b,$0b,$0c,$0c,$0c,$0c
        dc.b $0c,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0c,$0c,$0c,$0c,$0c,$0c,$0c
        dc.b $0c,$0c,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$88,$88,$88,$88
        dc.b $88,$88,$88,$88,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0c
        dc.b $0c,$0c,$0d,$0c,$0d,$0c,$0c,$0c
        dc.b $0c,$0c,$0c,$0c,$0c,$0c,$0c,$0b
        dc.b $0b,$0b,$0b,$0c,$0c,$0c,$0c,$0c
        dc.b $0d,$0d,$0d,$0e,$0e,$0e,$0e,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0e,$0e,$0e,$0e,$0d,$0d,$0d,$0c
        dc.b $0c,$0b,$0b,$0b,$0b,$0b,$0a,$09
        dc.b $0a,$09,$0a,$09,$0a,$09,$0b,$0b
        dc.b $0b,$0b,$0c,$0c,$0c,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0e,$0e,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0e,$0e,$0e,$0d,$0d
        dc.b $0b,$0a,$00,$00,$00,$00,$00,$00
        ds.w 8
        dc.b $00,$07,$07,$09,$07,$09,$07,$00
        ds.w 4
        dc.b $00,$07,$09,$09,$0b,$0a,$0b,$0b
        dc.b $0c,$0c,$0c,$0c,$0c,$0d,$0d,$0d
        dc.b $0d,$0e,$0e,$0e,$0e,$0e,$0e,$0e
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0e,$0e,$0d,$0d
        dc.b $0c,$0c,$0c,$0b,$0a,$0a,$0a,$0b
        dc.b $0b,$0c,$0c,$0c,$0c,$0c,$0d,$0d
        dc.b $0d,$0d,$0d,$0e,$0e,$0e,$0e,$0e
        dc.b $0e,$0f,$0e,$0f,$0e,$0e,$0e,$0d
        dc.b $0c,$0c,$0b,$0b,$0a,$0a,$0a,$0a
        dc.b $0b,$0c,$0c,$0c,$0c,$0c,$0b,$0b
        dc.b $0b,$0b,$0b,$0c,$0c,$0c,$0d,$0d
        dc.b $0d,$0d,$0e,$0e,$0e,$0e,$0e,$0e
        dc.b $0d,$0c,$0b,$0c,$0b,$0c,$0b,$0c
        dc.b $0d,$0d,$0d,$0d,$0e,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0e,$0e,$0e,$0e,$0e,$0e,$0e,$0d
        dc.b $0c,$0a,$07,$07,$00,$07,$09,$0a
        dc.b $0c,$0c,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0c,$0c,$0c,$0d,$0d,$0d,$0e,$0e
        dc.b $0e,$0e,$0f,$0f,$0f,$0f,$0e,$0d
        dc.b $0c,$07,$07,$00,$07,$09,$09,$0b
        dc.b $0c,$0d,$0d,$0d,$0d,$0d,$0d,$0c
        dc.b $0b,$0b,$0c,$0d,$0d,$0d,$0e,$0e
        dc.b $0f,$0f,$0f,$0f,$0f,$0e,$0c,$0b
        dc.b $07,$07,$00,$07,$09,$0b,$0d,$0d
        dc.b $0d,$0e,$0e,$0e,$0d,$0d,$0c,$0c
        dc.b $0c,$0c,$0d,$0d,$0e,$0e,$0f,$0f
        dc.b $0f,$0f,$0f,$0f,$0e,$0c,$0a,$07
        dc.b $07,$00,$07,$07,$0b,$0c,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0c,$0b,$0b,$0b
        dc.b $0c,$0c,$0d,$0e,$0e,$0e,$0f,$0f
        dc.b $0f,$0f,$0e,$0c,$0b,$07,$00,$00
        dc.b $00,$09,$0b,$0d,$0d,$0d,$0e,$0e
        dc.b $0d,$0d,$0b,$0b,$09,$09,$0a,$0c
        dc.b $0d,$0e,$0e,$0f,$0f,$0f,$0f,$0f
        dc.b $0f,$0e,$0a,$09,$00,$00,$00,$00
        dc.b $0b,$0d,$0e,$0e,$0e,$0f,$0e,$0d
        dc.b $0c,$0a,$09,$00,$07,$0b,$0c,$0d
        dc.b $0e,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0e,$0a,$0b,$00,$00,$00,$00,$0c
        dc.b $0c,$0d,$0f,$0f,$0f,$0d,$0d,$0d
        dc.b $0a,$00,$00,$09,$0b,$0b,$0d,$0e
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0f
        dc.b $0c,$0c,$07,$00,$00,$00,$09,$0c
        dc.b $0c,$0e,$0f,$0e,$0e,$0e,$0e,$0c
        dc.b $09,$07,$07,$07,$0a,$0c,$0d,$0e
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0d
        dc.b $0c,$0c,$00,$00,$00,$00,$07,$09
        dc.b $0d,$0e,$0e,$0e,$0f,$0e,$0d,$0c
        dc.b $0b,$0a,$00,$07,$0a,$0c,$0d,$0e
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0d
        dc.b $0d,$0a,$00,$00,$00,$00,$00,$09
        dc.b $0d,$0d,$0e,$0f,$0f,$0e,$0e,$0d
        dc.b $0c,$09,$07,$09,$09,$0c,$0d,$0e
        dc.b $0e,$0f,$0f,$0f,$0f,$0f,$0e,$0e
        dc.b $0d,$00,$00,$00,$00,$00,$00,$0a
        dc.b $0c,$0d,$0e,$0e,$0f,$0f,$0e,$0e
        dc.b $0c,$0b,$0b,$09,$0b,$0c,$0d,$0e
        dc.b $0f,$0f,$0f,$0f,$0f,$0f,$0f,$0c
        dc.b $0b,$09,$00,$00,$00,$00,$07,$0a
        dc.b $0c,$0d,$0d,$0e,$0e,$0e,$0e,$0d
        dc.b $0d,$0c,$0c,$0d,$0d,$0d,$0e,$0f
        dc.b $0f,$0f,$0e,$0f,$0e,$0b,$0d,$09
        dc.b $00,$09,$00,$00,$0a,$0a,$0b,$0c
        dc.b $0d,$0d,$0e,$0e,$0d,$0d,$0d,$0c
        dc.b $0d,$0d,$0d,$0e,$0e,$0f,$0f,$0f
        dc.b $0e,$0f,$0e,$0a,$0d,$0a,$00,$0a
        dc.b $07,$00,$0b,$0a,$0c,$0c,$0d,$0c
        dc.b $0d,$0e,$0d,$0d,$0d,$0c,$0d,$0d
        dc.b $0d,$0e,$0e,$0e,$0f,$0f,$0f,$0e
        dc.b $0f,$0c,$0d,$0d,$00,$09,$0a,$00
        dc.b $09,$0a,$0a,$0b,$0d,$0d,$0d,$0e
        dc.b $0d,$0d,$0e,$0d,$0d,$0d,$0d,$0d
        dc.b $0e,$0e,$0f,$0f,$0f,$0d,$0f,$0e
        dc.b $0b,$0e,$09,$07,$0c,$00,$07,$0a
        dc.b $09,$0a,$0c,$0d,$0c,$0e,$0d,$0d
        dc.b $0e,$0d,$0d,$0e,$0d,$0d,$0e,$0e
        dc.b $0e,$0f,$0f,$0e,$0e,$0f,$09,$0e
        dc.b $0c,$07,$0c,$09,$00,$0a,$09,$0a
        dc.b $0b,$0d,$0b,$0d,$0d,$0d,$0e,$0d
        dc.b $0d,$0e,$0d,$0d,$0e,$0e,$0e,$0f
        dc.b $0f,$0f,$0d,$0f,$0d,$0c,$0e,$09
        dc.b $0b,$0b,$00,$09,$09,$09,$09,$0c
        dc.b $0c,$0c,$0d,$0d,$0d,$0e,$0d,$0d
        dc.b $0d,$0d,$0d,$0e,$0e,$0e,$0f,$0f
        dc.b $0e,$0e,$0f,$0b,$0e,$0b,$0a,$0c
        dc.b $09,$07,$0a,$09,$09,$0a,$0c,$0b
        dc.b $0d,$0d,$0d,$0e,$0d,$0d,$0e,$0d
        dc.b $0d,$0d,$0e,$0e,$0f,$0f,$0f,$0e
        dc.b $0f,$0d,$0d,$0e,$09,$0c,$0a,$09
        dc.b $09,$0a,$09,$09,$0c,$0b,$0c,$0d
        dc.b $0c,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0e,$0e,$0e,$0f,$0f,$0f,$0e,$0f
        dc.b $0c,$0e,$0d,$0a,$0c,$0a,$09,$09
        dc.b $0a,$09,$0a,$0c,$0b,$0d,$0d,$0c
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0e
        dc.b $0e,$0e,$0e,$0f,$0e,$0e,$0f,$0c
        dc.b $0e,$0b,$0c,$0b,$0a,$09,$0a,$0a
        dc.b $09,$0b,$0c,$0a,$0d,$0c,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0e,$0e
        dc.b $0f,$0e,$0f,$0e,$0f,$0e,$0c,$0e
        dc.b $0b,$0c,$0c,$0a,$0a,$0a,$0a,$09
        dc.b $0b,$0c,$0b,$0d,$0c,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0e,$0d,$0f
        dc.b $0e,$0f,$0e,$0e,$0f,$0c,$0e,$0c
        dc.b $0b,$0c,$09,$0a,$0a,$0a,$0a,$0a
        dc.b $0c,$0b,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0e,$0d,$0e,$0e
        dc.b $0e,$0f,$0d,$0f,$0d,$0d,$0e,$0b
        dc.b $0c,$0c,$0a,$0b,$0a,$0b,$0a,$0b
        dc.b $0c,$0b,$0d,$0c,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0e,$0d,$0e,$0e
        dc.b $0e,$0f,$0e,$0e,$0e,$0c,$0e,$0c
        dc.b $0c,$0c,$0b,$0b,$0a,$0b,$0b,$0a
        dc.b $0c,$0b,$0c,$0d,$0c,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0e,$0d,$0e,$0e
        dc.b $0e,$0e,$0e,$0e,$0d,$0e,$0d,$0d
        dc.b $0d,$0c,$0c,$0c,$0b,$0a,$0b,$0c
        dc.b $0a,$0c,$0d,$0c,$0d,$0d,$0c,$0d
        dc.b $0d,$0c,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0e,$0e,$0e,$0e,$0e,$0d,$0e
        dc.b $0d,$0d,$0d,$0c,$0b,$0c,$0a,$0b
        dc.b $0b,$0c,$0c,$0c,$0d,$0c,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0e,$0d,$0e,$0e
        dc.b $0e,$0d,$0e,$0d,$0c,$0d,$0c,$0b
        dc.b $0c,$0b,$0b,$0c,$0c,$0c,$0c,$0d
        dc.b $0d,$0c,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0e,$0d,$0d,$0d
        dc.b $0d,$0e,$0d,$0e,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0c,$0c,$0c,$0c,$0c,$0c
        dc.b $0c,$0c,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0c,$0c,$0c,$0c,$0c,$0c,$0c
        dc.b $0c,$0c,$0d,$0c,$0d,$0d,$0c,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0c,$0e,$0d,$0e,$0d,$0d,$0e,$0d
        dc.b $0e,$0d,$0e,$0d,$0d,$0d,$0d,$0d
        dc.b $0c,$0d,$0c,$0d,$0c,$0d,$0d,$0c
        dc.b $0d,$0c,$0c,$0c,$0d,$0c,$0c,$0d
        dc.b $0c,$0d,$0d,$0d,$0d,$0d,$0d,$0e
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0c,$0c,$0c,$0c,$0c
        dc.b $0c,$0c,$0d,$0c,$0d,$0c,$0d,$0c
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0c,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0c,$0d,$0c
        dc.b $0d,$0d,$0c,$0d,$0c,$0d,$0d,$0c
        dc.b $0d,$0d,$0c,$0d,$0c,$0d,$0c,$0d
        dc.b $0d,$0c,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0c,$0d,$0d,$0d,$0d,$0c,$0d
        dc.b $0d,$0d,$0c,$0d,$0d,$0d,$0c,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0c,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0c,$0d,$0d,$0d,$0d,$0c
        dc.b $0d,$0c,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0c,$0d
        dc.b $0d,$0c,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0c,$0d,$0d
        dc.b $0d,$0d,$0c,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0c,$0d,$0d,$0d
        dc.b $0d,$0c,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0c,$0c,$0d,$0c,$0d
        dc.b $0c,$0d,$0d,$0d,$0d,$0d,$0c,$0d
        dc.b $0c,$0d,$0d,$0c,$0c,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0e,$0e
        dc.b $0e,$0e,$0e,$0e,$0e,$0e,$0e,$0d
        dc.b $0d,$0e,$0e,$0d,$0e,$0e,$0e,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0c,$0c,$0c,$0c,$0b,$0b
        dc.b $0c,$0b,$0b,$0b,$0c,$0b,$0b,$0b
        dc.b $0b,$0c,$0c,$0c,$0c,$0c,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0c,$0c,$0c,$0d,$0c,$0c,$0c
        dc.b $0c,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0c,$0c,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0c,$0c,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0e,$0e,$0d,$0d,$0d,$0d,$0c,$0c
        dc.b $0c,$0c,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0e,$0e,$0e,$0e,$0e,$0d
        dc.b $0d,$0c,$0c,$0c,$0c,$0c,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0e,$0e
        dc.b $0e,$0d,$0d,$0c,$0b,$0a,$0a,$0a
        dc.b $0b,$0c,$0c,$0c,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0c,$0c,$0b,$0b,$0c
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0e,$0e,$0e,$0e,$0e,$0d,$0d,$0c
        dc.b $0a,$0a,$0a,$0b,$0c,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0c,$0b
        dc.b $0a,$09,$09,$0b,$0d,$0d,$0e,$0e
        dc.b $0d,$0d,$0d,$0d,$0e,$0e,$0e,$0e
        dc.b $0d,$0c,$0a,$07,$07,$09,$0b,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0c,$0b,$09,$07,$09,$0b,$0d
        dc.b $0d,$0e,$0e,$0e,$0e,$0e,$0d,$0e
        dc.b $0e,$0f,$0f,$0e,$0d,$0b,$07,$00
        dc.b $09,$0c,$0d,$0e,$0e,$0e,$0e,$0d
        dc.b $0d,$0d,$0d,$0d,$0c,$0a,$07,$07
        dc.b $09,$0c,$0d,$0e,$0e,$0e,$0e,$0d
        dc.b $0d,$0e,$0e,$0e,$0f,$0f,$0e,$0c
        dc.b $07,$00,$00,$07,$0c,$0d,$0e,$0e
        dc.b $0e,$0d,$0d,$0d,$0d,$0d,$0c,$0a
        dc.b $09,$07,$0b,$0c,$0d,$0e,$0e,$0e
        dc.b $0d,$0d,$0d,$0d,$0e,$0e,$0f,$0f
        dc.b $0f,$0e,$0c,$00,$00,$00,$00,$0c
        dc.b $0e,$0f,$0f,$0e,$0e,$0d,$0d,$0c
        dc.b $0b,$09,$07,$09,$0b,$0d,$0e,$0e
        dc.b $0e,$0d,$0c,$0c,$0d,$0d,$0e,$0e
        dc.b $0f,$0f,$0f,$0f,$0e,$0c,$00,$00
        ds.w 1
        dc.b $0d,$0f,$0f,$0f,$0e,$0d,$0c,$0c
        dc.b $0b,$09,$00,$00,$0b,$0d,$0f,$0f
        dc.b $0e,$0c,$0a,$0b,$0c,$0e,$0e,$0e
        dc.b $0e,$0e,$0f,$0f,$0f,$0e,$09,$00
        ds.w 1
        dc.b $0c,$0f,$0f,$0f,$0e,$0d,$0d,$0d
        dc.b $0c,$00,$00,$00,$0c,$0f,$0f,$0f
        dc.b $0d,$09,$07,$0a,$0d,$0d,$0d,$0e
        dc.b $0e,$0f,$0f,$0f,$0f,$0f,$0f,$0c
        ds.w 1
        dc.b $00,$09,$0e,$0f,$0f,$0f,$0e,$0d
        dc.b $0c,$09,$00,$00,$07,$0d,$0f,$0f
        dc.b $0e,$0c,$09,$07,$0b,$0c,$0d,$0d
        dc.b $0e,$0e,$0e,$0e,$0e,$0e,$0f,$0f
        dc.b $0f,$0a,$00,$00,$00,$0d,$0f,$0f
        dc.b $0e,$0e,$0d,$0d,$0c,$00,$00,$00
        dc.b $0d,$0f,$0f,$0e,$0b,$09,$0a,$0b
        dc.b $0c,$0c,$0d,$0e,$0e,$0e,$0d,$0d
        dc.b $0e,$0f,$0f,$0f,$0f,$0c,$00,$00
        dc.b $00,$0c,$0e,$0f,$0f,$0f,$0e,$0d
        dc.b $0a,$00,$00,$09,$0d,$0f,$0f,$0e
        dc.b $0c,$0a,$09,$09,$0b,$0c,$0d,$0e
        dc.b $0e,$0d,$0c,$0d,$0e,$0f,$0f,$0f
        dc.b $0f,$0f,$0c,$00,$00,$00,$0d,$0f
        dc.b $0f,$0f,$0e,$0e,$0d,$00,$00,$00
        dc.b $0c,$0f,$0f,$0e,$0d,$0c,$09,$09
        dc.b $00,$0a,$0d,$0e,$0f,$0d,$0c,$0d
        dc.b $0e,$0f,$0e,$0e,$0f,$0f,$0f,$0d
        ds.w 1
        dc.b $00,$0d,$0e,$0f,$0f,$0f,$0f,$0d
        ds.w 1
        dc.b $00,$0d,$0e,$0f,$0f,$0f,$0e,$09
        ds.w 1
        dc.b $0a,$0e,$0e,$0d,$0d,$0d,$0d,$0c
        dc.b $0d,$0e,$0e,$0f,$0e,$0f,$0f,$0f
        ds.w 1
        dc.b $00,$0d,$0e,$0e,$0e,$0f,$0f,$0d
        ds.w 1
        dc.b $07,$0d,$0e,$0e,$0f,$0f,$0e,$09
        ds.w 1
        dc.b $0b,$0d,$0e,$0e,$0e,$0e,$0b,$0a
        dc.b $0c,$0e,$0f,$0e,$0e,$0f,$0f,$0f
        dc.b $0d,$00,$00,$00,$0a,$0d,$0e,$0f
        dc.b $0f,$0e,$0a,$00,$00,$09,$0a,$0d
        dc.b $0f,$0f,$0f,$0d,$0c,$09,$00,$00
        dc.b $0b,$0d,$0e,$0d,$0d,$0c,$0c,$0c
        dc.b $0d,$0e,$0e,$0e,$0e,$0f,$0f,$0f
        dc.b $0e,$00,$00,$00,$09,$0c,$0d,$0f
        dc.b $0f,$0e,$0c,$09,$07,$00,$00,$0d
        dc.b $0f,$0f,$0f,$0e,$0d,$0b,$00,$00
        dc.b $0b,$0d,$0e,$0e,$0e,$0e,$0b,$0c
        dc.b $0d,$0d,$0e,$0e,$0f,$0f,$0f,$0f
        dc.b $0f,$0d,$00,$00,$07,$07,$0c,$0e
        dc.b $0f,$0f,$0e,$0d,$0b,$00,$00,$00
        dc.b $0d,$0e,$0e,$0f,$0f,$0e,$0b,$00
        dc.b $00,$09,$07,$0c,$0e,$0e,$0e,$0d
        dc.b $0d,$0d,$0c,$0d,$0e,$0e,$0e,$0f
        dc.b $0f,$0f,$0f,$0c,$00,$07,$00,$00
        dc.b $0d,$0e,$0f,$0e,$0e,$0e,$0c,$07
        dc.b $09,$09,$0b,$0d,$0e,$0f,$0e,$0e
        dc.b $0e,$0b,$00,$09,$07,$0a,$0d,$0e
        dc.b $0e,$0d,$0e,$0e,$0c,$0d,$0d,$0d
        dc.b $0e,$0e,$0f,$0f,$0f,$0f,$0c,$09
        dc.b $0a,$00,$00,$0c,$0d,$0e,$0e,$0f
        dc.b $0e,$0d,$0c,$0b,$00,$07,$0b,$0c
        dc.b $0d,$0e,$0f,$0e,$0d,$0d,$0a,$09
        dc.b $07,$09,$0c,$0d,$0e,$0e,$0e,$0e
        dc.b $0e,$0e,$0d,$0d,$0e,$0e,$0e,$0f
        dc.b $0f,$0e,$0d,$0c,$0c,$00,$00,$0b
        dc.b $0a,$0c,$0e,$0e,$0e,$0e,$0e,$0d
        dc.b $0b,$0b,$0a,$07,$0c,$0c,$0d,$0e
        dc.b $0e,$0e,$0d,$0d,$0b,$09,$0b,$0a
        dc.b $0b,$0d,$0d,$0e,$0e,$0e,$0e,$0d
        dc.b $0e,$0d,$0d,$0e,$0e,$0e,$0e,$0d
        dc.b $0c,$0c,$07,$09,$0b,$0a,$0d,$0e
        dc.b $0d,$0e,$0e,$0d,$0d,$0c,$0c,$0c
        dc.b $0c,$0c,$0c,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0c,$0c,$0c,$0c,$0d,$0d
        dc.b $0d,$0d,$0d,$0e,$0e,$0e,$0e,$0e
        dc.b $0e,$0e,$0e,$0e,$0d,$0c,$0c,$0a
        dc.b $07,$0b,$0a,$0c,$0d,$0d,$0d,$0e
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0c,$0c
        dc.b $0c,$0c,$0c,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0c,$0d,$0d,$0c,$0d
        dc.b $0d,$0d,$0e,$0e,$0e,$0e,$0e,$0e
        dc.b $0e,$0e,$0d,$0c,$0d,$0b,$0a,$0b
        dc.b $09,$0a,$0c,$0c,$0d,$0d,$0d,$0e
        dc.b $0e,$0e,$0d,$0d,$0d,$0c,$0c,$0b
        dc.b $0b,$0c,$0c,$0c,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0e
        dc.b $0e,$0e,$0e,$0e,$0f,$0f,$0f,$0f
        dc.b $0f,$0d,$0d,$09,$09,$00,$00,$00
        dc.b $07,$09,$0b,$0d,$0d,$0e,$0e,$0e
        dc.b $0e,$0e,$0e,$0e,$0d,$0d,$0c,$0c
        dc.b $0a,$0a,$09,$09,$0b,$0b,$0c,$0d
        dc.b $0d,$0d,$0e,$0d,$0e,$0e,$0d,$0d
        dc.b $0e,$0e,$0f,$0f,$0f,$0f,$0f,$0d
        dc.b $0d,$0c,$0a,$0b,$09,$09,$0a,$09
        dc.b $07,$0b,$0b,$0c,$0d,$0e,$0e,$0f
        dc.b $0e,$0e,$0e,$0d,$0d,$0d,$0c,$0b
        dc.b $0b,$0a,$0a,$0c,$0b,$0b,$0d,$0c
        dc.b $0d,$0d,$0d,$0d,$0d,$0e,$0e,$0e
        dc.b $0e,$0f,$0f,$0f,$0e,$0f,$0d,$0d
        dc.b $0d,$0b,$0c,$0b,$07,$07,$07,$07
        dc.b $0a,$0c,$0c,$0d,$0d,$0d,$0e,$0e
        dc.b $0e,$0e,$0e,$0d,$0d,$0d,$0c,$0c
        dc.b $0b,$0b,$0c,$0b,$0b,$0c,$0c,$0c
        dc.b $0d,$0c,$0d,$0d,$0e,$0e,$0e,$0e
        dc.b $0e,$0e,$0e,$0e,$0e,$0f,$0e,$0e
        dc.b $0d,$0c,$0d,$09,$09,$09,$09,$0a
        dc.b $0b,$0c,$0c,$0d,$0d,$0d,$0e,$0e
        dc.b $0e,$0e,$0e,$0e,$0d,$0d,$0d,$0d
        dc.b $0c,$0c,$0b,$0b,$0a,$0b,$0b,$0c
        dc.b $0c,$0c,$0d,$0d,$0e,$0e,$0e,$0e
        dc.b $0e,$0e,$0e,$0e,$0e,$0e,$0e,$0e
        dc.b $0d,$0c,$0c,$0b,$0b,$0a,$0b,$0a
        dc.b $0b,$0b,$0c,$0c,$0d,$0d,$0d,$0d
        dc.b $0e,$0e,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0c,$0d,$0c,$0c,$0b,$0b,$0b,$0c
        dc.b $0c,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0e,$0e,$0e,$0e,$0e,$0f,$0e,$0e
        dc.b $0d,$0c,$0c,$0b,$0b,$0b,$0c,$0b
        dc.b $0c,$0c,$0b,$0c,$0c,$0d,$0d,$0d
        dc.b $0d,$0e,$0e,$0e,$0e,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0c,$0c,$0c,$0c,$0c
        dc.b $0c,$0c,$0c,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0e,$0e,$0e,$0e,$0e,$0e
        dc.b $0d,$0e,$0d,$0d,$0c,$0c,$0c,$0c
        dc.b $0b,$0b,$0c,$0c,$0c,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0e,$0e,$0e,$0d
        dc.b $0d,$0d,$0d,$0c,$0d,$0c,$0d,$0d
        dc.b $0d,$0d,$0d,$0c,$0c,$0c,$0c,$0c
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0c,$0c,$0c,$0c
        dc.b $0c,$0d,$0d,$0d,$0d,$0c,$0d,$0c
        dc.b $0c,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0c,$0c,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0c,$0c,$0c
        dc.b $0c,$0c,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0c,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0c
        dc.b $0c,$0c,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0c,$0c
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0c,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0c,$0c,$0c,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0c
        dc.b $0d,$0c,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0c,$0d,$0b
        dc.b $0d,$0c,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0c,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0c
        dc.b $0d,$0d,$0c,$0d,$0d,$0c,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0c,$0b
        dc.b $0d,$0c,$0e,$0d,$0e,$0c,$0e,$0d
        dc.b $0e,$0a,$0c,$0d,$0d,$0d,$0e,$0d
        dc.b $0d,$0e,$0d,$0d,$0d,$0d,$0d,$0c
        dc.b $0d,$0d,$0c,$0c,$0d,$0d,$0d,$0d
        dc.b $0c,$0c,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0c
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0c
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0c,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0c,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
        dc.b $0d,$0d,$0d,$0d,$0d,$0d,$0d,$0d
