	rept	100/14
	dc.w	$130,$140,$250,$470,$470,$470,$140,$070
	dc.w	$130,$140,$250,$470,$470,$470,$140,$070
	dc.w	$130,$140,$250,$470,$470,$470,$140,$070
	dc.w	$130,$140,$250,$470,$470,$470,$140,$070

	dc.w	$130,$140,$250,$470,$470,$470,$140,$070
	dc.w	$130,$140,$250,$470,$470,$470,$140,$070
	dc.w	$130,$140,$250,$470,$470,$470,$140,$070
	dc.w	$130,$140,$250,$470,$470,$470,$140,$070

	dc.w	$130,$140,$250,$470,$470,$470,$140,$070
	dc.w	$130,$140,$250,$470,$470,$470,$140,$070
	dc.w	$130,$140,$250,$470,$470,$470,$140,$070
	dc.w	$130,$140,$250,$470,$470,$470,$140,$070

	dc.w	$130,$140,$250,$470,$470,$140,$070,$070
	dc.w	$130,$140,$250,$470,$470,$140,$070,$070
	dc.w	$130,$140,$250,$470,$470,$140,$070,$070
	dc.w	$130,$140,$250,$470,$470,$140,$070,$070

	dc.w	$130,$140,$250,$470,$140,$070,$130,$070
	dc.w	$130,$140,$250,$470,$140,$070,$130,$070
	dc.w	$130,$140,$250,$470,$140,$070,$130,$070
	dc.w	$130,$140,$250,$470,$140,$070,$130,$070

	dc.w	$130,$140,$250,$140,$070,$130,$140,$070
	dc.w	$130,$140,$250,$140,$070,$130,$140,$070
	dc.w	$130,$140,$250,$140,$070,$130,$140,$070
	dc.w	$130,$140,$250,$140,$070,$130,$140,$070

	dc.w	$130,$140,$140,$070,$130,$250,$140,$070
	dc.w	$130,$140,$140,$070,$130,$250,$140,$070
	dc.w	$130,$140,$140,$070,$130,$250,$140,$070
	dc.w	$130,$140,$140,$070,$130,$250,$140,$070

	dc.w	$130,$140,$070,$130,$250,$470,$140,$070
	dc.w	$130,$140,$070,$130,$250,$470,$140,$070
	dc.w	$130,$140,$070,$130,$250,$470,$140,$070
	dc.w	$130,$140,$070,$130,$250,$470,$140,$070

	dc.w	$130,$070,$130,$250,$470,$470,$140,$070
	dc.w	$130,$070,$130,$250,$470,$470,$140,$070
	dc.w	$130,$070,$130,$250,$470,$470,$140,$070
	dc.w	$130,$070,$130,$250,$470,$470,$140,$070

	dc.w	$030,$130,$250,$470,$470,$470,$140,$070
	dc.w	$030,$130,$250,$470,$470,$470,$140,$070
	dc.w	$030,$130,$250,$470,$470,$470,$140,$070
	dc.w	$030,$130,$250,$470,$470,$470,$140,$070

	dc.w	$130,$140,$250,$470,$470,$470,$140,$070
	dc.w	$130,$140,$250,$470,$470,$470,$140,$070
	dc.w	$130,$140,$250,$470,$470,$470,$140,$070
	dc.w	$130,$140,$250,$470,$470,$470,$140,$070

	dc.w	$130,$140,$250,$470,$470,$470,$140,$070
	dc.w	$130,$140,$250,$470,$470,$470,$140,$070
	dc.w	$130,$140,$250,$470,$470,$470,$140,$070
	dc.w	$130,$140,$250,$470,$470,$470,$140,$070

	endr
