x:
	rept	26
	dc.w	$113,$114,$225,$447,$447,$447,$114,$007
	dc.w	$113,$114,$225,$447,$447,$447,$114,$007
	dc.w	$113,$114,$225,$447,$447,$447,$114,$007
	dc.w	$113,$114,$225,$447,$447,$447,$114,$007

	dc.w	$113,$114,$225,$447,$447,$447,$114,$007
	dc.w	$113,$114,$225,$447,$447,$447,$114,$007
	dc.w	$113,$114,$225,$447,$447,$447,$114,$007
	dc.w	$113,$114,$225,$447,$447,$447,$114,$007

	dc.w	$113,$114,$225,$447,$447,$447,$114,$007
	dc.w	$113,$114,$225,$447,$447,$447,$114,$007
	dc.w	$113,$114,$225,$447,$447,$447,$114,$007
	dc.w	$113,$114,$225,$447,$447,$447,$114,$007

	dc.w	$113,$114,$225,$447,$447,$114,$007,$007
	dc.w	$113,$114,$225,$447,$447,$114,$007,$007
	dc.w	$113,$114,$225,$447,$447,$114,$007,$007
	dc.w	$113,$114,$225,$447,$447,$114,$007,$007

	dc.w	$113,$114,$225,$447,$114,$007,$113,$007
	dc.w	$113,$114,$225,$447,$114,$007,$113,$007
	dc.w	$113,$114,$225,$447,$114,$007,$113,$007
	dc.w	$113,$114,$225,$447,$114,$007,$113,$007

	dc.w	$113,$114,$225,$114,$007,$113,$114,$007
	dc.w	$113,$114,$225,$114,$007,$113,$114,$007
	dc.w	$113,$114,$225,$114,$007,$113,$114,$007
	dc.w	$113,$114,$225,$114,$007,$113,$114,$007

	dc.w	$113,$114,$114,$007,$113,$225,$114,$007
	dc.w	$113,$114,$114,$007,$113,$225,$114,$007
	dc.w	$113,$114,$114,$007,$113,$225,$114,$007
	dc.w	$113,$114,$114,$007,$113,$225,$114,$007

	dc.w	$113,$114,$007,$113,$225,$447,$114,$007
	dc.w	$113,$114,$007,$113,$225,$447,$114,$007
	dc.w	$113,$114,$007,$113,$225,$447,$114,$007
	dc.w	$113,$114,$007,$113,$225,$447,$114,$007

	dc.w	$113,$007,$113,$225,$447,$447,$114,$007
	dc.w	$113,$007,$113,$225,$447,$447,$114,$007
	dc.w	$113,$007,$113,$225,$447,$447,$114,$007
	dc.w	$113,$007,$113,$225,$447,$447,$114,$007

	dc.w	$003,$113,$225,$447,$447,$447,$114,$007
	dc.w	$003,$113,$225,$447,$447,$447,$114,$007
	dc.w	$003,$113,$225,$447,$447,$447,$114,$007
	dc.w	$003,$113,$225,$447,$447,$447,$114,$007

	dc.w	$113,$114,$225,$447,$447,$447,$114,$007
	dc.w	$113,$114,$225,$447,$447,$447,$114,$007
	dc.w	$113,$114,$225,$447,$447,$447,$114,$007
	dc.w	$113,$114,$225,$447,$447,$447,$114,$007

	dc.w	$113,$114,$225,$447,$447,$447,$114,$007
	dc.w	$113,$114,$225,$447,$447,$447,$114,$007
	dc.w	$113,$114,$225,$447,$447,$447,$114,$007
	dc.w	$113,$114,$225,$447,$447,$447,$114,$007
;-----------------------------------------------------------------------
	endr

y:
