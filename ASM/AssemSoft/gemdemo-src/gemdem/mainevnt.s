*************************************************************************************************
**** Here, we wait for events to happend
wait_event	EVNT_MULTI	#(1<<MU_KEYBD)+(1<<MU_BUTTON)+(1<<MU_MESAG)+(1<<MU_TIMER),#256+2,#3,#0,,,,,,,,,,,#0,#0,aesin_msg(a6)
		rts

*************************************************************************************************
