                EXTRN   R_D0,R_A0,R_PC,R_USP,R_ISP,R_SR,R_SR_H,R_CCR,R_XC
                EXTRN   M68030_Run,M68030_Reset,M68030_ICount,R_IRQ,R_A7
                EXTRN   R_VBR,R_SFC,R_DFC,R_CAAR,R_CACR,R_MSP
                EXTRN   R_CRP,R_SRP,R_TC,R_TT0,R_TT1,R_MMUSR

