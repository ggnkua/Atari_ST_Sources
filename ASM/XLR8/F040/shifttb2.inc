 db 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
 db 0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,1
 db 0,0,0,0,0,0,0,0,0,0,0,0,1,1,0,0
 db 0,0,0,0,0,0,0,0,0,0,0,0,1,1,1,1
 db 0,0,0,0,0,0,0,0,0,0,1,1,0,0,0,0
 db 0,0,0,0,0,0,0,0,0,0,1,1,0,0,1,1
 db 0,0,0,0,0,0,0,0,0,0,1,1,1,1,0,0
 db 0,0,0,0,0,0,0,0,0,0,1,1,1,1,1,1
 db 0,0,0,0,0,0,0,0,1,1,0,0,0,0,0,0
 db 0,0,0,0,0,0,0,0,1,1,0,0,0,0,1,1
 db 0,0,0,0,0,0,0,0,1,1,0,0,1,1,0,0
 db 0,0,0,0,0,0,0,0,1,1,0,0,1,1,1,1
 db 0,0,0,0,0,0,0,0,1,1,1,1,0,0,0,0
 db 0,0,0,0,0,0,0,0,1,1,1,1,0,0,1,1
 db 0,0,0,0,0,0,0,0,1,1,1,1,1,1,0,0
 db 0,0,0,0,0,0,0,0,1,1,1,1,1,1,1,1
 db 0,0,0,0,0,0,1,1,0,0,0,0,0,0,0,0
 db 0,0,0,0,0,0,1,1,0,0,0,0,0,0,1,1
 db 0,0,0,0,0,0,1,1,0,0,0,0,1,1,0,0
 db 0,0,0,0,0,0,1,1,0,0,0,0,1,1,1,1
 db 0,0,0,0,0,0,1,1,0,0,1,1,0,0,0,0
 db 0,0,0,0,0,0,1,1,0,0,1,1,0,0,1,1
 db 0,0,0,0,0,0,1,1,0,0,1,1,1,1,0,0
 db 0,0,0,0,0,0,1,1,0,0,1,1,1,1,1,1
 db 0,0,0,0,0,0,1,1,1,1,0,0,0,0,0,0
 db 0,0,0,0,0,0,1,1,1,1,0,0,0,0,1,1
 db 0,0,0,0,0,0,1,1,1,1,0,0,1,1,0,0
 db 0,0,0,0,0,0,1,1,1,1,0,0,1,1,1,1
 db 0,0,0,0,0,0,1,1,1,1,1,1,0,0,0,0
 db 0,0,0,0,0,0,1,1,1,1,1,1,0,0,1,1
 db 0,0,0,0,0,0,1,1,1,1,1,1,1,1,0,0
 db 0,0,0,0,0,0,1,1,1,1,1,1,1,1,1,1
 db 0,0,0,0,1,1,0,0,0,0,0,0,0,0,0,0
 db 0,0,0,0,1,1,0,0,0,0,0,0,0,0,1,1
 db 0,0,0,0,1,1,0,0,0,0,0,0,1,1,0,0
 db 0,0,0,0,1,1,0,0,0,0,0,0,1,1,1,1
 db 0,0,0,0,1,1,0,0,0,0,1,1,0,0,0,0
 db 0,0,0,0,1,1,0,0,0,0,1,1,0,0,1,1
 db 0,0,0,0,1,1,0,0,0,0,1,1,1,1,0,0
 db 0,0,0,0,1,1,0,0,0,0,1,1,1,1,1,1
 db 0,0,0,0,1,1,0,0,1,1,0,0,0,0,0,0
 db 0,0,0,0,1,1,0,0,1,1,0,0,0,0,1,1
 db 0,0,0,0,1,1,0,0,1,1,0,0,1,1,0,0
 db 0,0,0,0,1,1,0,0,1,1,0,0,1,1,1,1
 db 0,0,0,0,1,1,0,0,1,1,1,1,0,0,0,0
 db 0,0,0,0,1,1,0,0,1,1,1,1,0,0,1,1
 db 0,0,0,0,1,1,0,0,1,1,1,1,1,1,0,0
 db 0,0,0,0,1,1,0,0,1,1,1,1,1,1,1,1
 db 0,0,0,0,1,1,1,1,0,0,0,0,0,0,0,0
 db 0,0,0,0,1,1,1,1,0,0,0,0,0,0,1,1
 db 0,0,0,0,1,1,1,1,0,0,0,0,1,1,0,0
 db 0,0,0,0,1,1,1,1,0,0,0,0,1,1,1,1
 db 0,0,0,0,1,1,1,1,0,0,1,1,0,0,0,0
 db 0,0,0,0,1,1,1,1,0,0,1,1,0,0,1,1
 db 0,0,0,0,1,1,1,1,0,0,1,1,1,1,0,0
 db 0,0,0,0,1,1,1,1,0,0,1,1,1,1,1,1
 db 0,0,0,0,1,1,1,1,1,1,0,0,0,0,0,0
 db 0,0,0,0,1,1,1,1,1,1,0,0,0,0,1,1
 db 0,0,0,0,1,1,1,1,1,1,0,0,1,1,0,0
 db 0,0,0,0,1,1,1,1,1,1,0,0,1,1,1,1
 db 0,0,0,0,1,1,1,1,1,1,1,1,0,0,0,0
 db 0,0,0,0,1,1,1,1,1,1,1,1,0,0,1,1
 db 0,0,0,0,1,1,1,1,1,1,1,1,1,1,0,0
 db 0,0,0,0,1,1,1,1,1,1,1,1,1,1,1,1
 db 0,0,1,1,0,0,0,0,0,0,0,0,0,0,0,0
 db 0,0,1,1,0,0,0,0,0,0,0,0,0,0,1,1
 db 0,0,1,1,0,0,0,0,0,0,0,0,1,1,0,0
 db 0,0,1,1,0,0,0,0,0,0,0,0,1,1,1,1
 db 0,0,1,1,0,0,0,0,0,0,1,1,0,0,0,0
 db 0,0,1,1,0,0,0,0,0,0,1,1,0,0,1,1
 db 0,0,1,1,0,0,0,0,0,0,1,1,1,1,0,0
 db 0,0,1,1,0,0,0,0,0,0,1,1,1,1,1,1
 db 0,0,1,1,0,0,0,0,1,1,0,0,0,0,0,0
 db 0,0,1,1,0,0,0,0,1,1,0,0,0,0,1,1
 db 0,0,1,1,0,0,0,0,1,1,0,0,1,1,0,0
 db 0,0,1,1,0,0,0,0,1,1,0,0,1,1,1,1
 db 0,0,1,1,0,0,0,0,1,1,1,1,0,0,0,0
 db 0,0,1,1,0,0,0,0,1,1,1,1,0,0,1,1
 db 0,0,1,1,0,0,0,0,1,1,1,1,1,1,0,0
 db 0,0,1,1,0,0,0,0,1,1,1,1,1,1,1,1
 db 0,0,1,1,0,0,1,1,0,0,0,0,0,0,0,0
 db 0,0,1,1,0,0,1,1,0,0,0,0,0,0,1,1
 db 0,0,1,1,0,0,1,1,0,0,0,0,1,1,0,0
 db 0,0,1,1,0,0,1,1,0,0,0,0,1,1,1,1
 db 0,0,1,1,0,0,1,1,0,0,1,1,0,0,0,0
 db 0,0,1,1,0,0,1,1,0,0,1,1,0,0,1,1
 db 0,0,1,1,0,0,1,1,0,0,1,1,1,1,0,0
 db 0,0,1,1,0,0,1,1,0,0,1,1,1,1,1,1
 db 0,0,1,1,0,0,1,1,1,1,0,0,0,0,0,0
 db 0,0,1,1,0,0,1,1,1,1,0,0,0,0,1,1
 db 0,0,1,1,0,0,1,1,1,1,0,0,1,1,0,0
 db 0,0,1,1,0,0,1,1,1,1,0,0,1,1,1,1
 db 0,0,1,1,0,0,1,1,1,1,1,1,0,0,0,0
 db 0,0,1,1,0,0,1,1,1,1,1,1,0,0,1,1
 db 0,0,1,1,0,0,1,1,1,1,1,1,1,1,0,0
 db 0,0,1,1,0,0,1,1,1,1,1,1,1,1,1,1
 db 0,0,1,1,1,1,0,0,0,0,0,0,0,0,0,0
 db 0,0,1,1,1,1,0,0,0,0,0,0,0,0,1,1
 db 0,0,1,1,1,1,0,0,0,0,0,0,1,1,0,0
 db 0,0,1,1,1,1,0,0,0,0,0,0,1,1,1,1
 db 0,0,1,1,1,1,0,0,0,0,1,1,0,0,0,0
 db 0,0,1,1,1,1,0,0,0,0,1,1,0,0,1,1
 db 0,0,1,1,1,1,0,0,0,0,1,1,1,1,0,0
 db 0,0,1,1,1,1,0,0,0,0,1,1,1,1,1,1
 db 0,0,1,1,1,1,0,0,1,1,0,0,0,0,0,0
 db 0,0,1,1,1,1,0,0,1,1,0,0,0,0,1,1
 db 0,0,1,1,1,1,0,0,1,1,0,0,1,1,0,0
 db 0,0,1,1,1,1,0,0,1,1,0,0,1,1,1,1
 db 0,0,1,1,1,1,0,0,1,1,1,1,0,0,0,0
 db 0,0,1,1,1,1,0,0,1,1,1,1,0,0,1,1
 db 0,0,1,1,1,1,0,0,1,1,1,1,1,1,0,0
 db 0,0,1,1,1,1,0,0,1,1,1,1,1,1,1,1
 db 0,0,1,1,1,1,1,1,0,0,0,0,0,0,0,0
 db 0,0,1,1,1,1,1,1,0,0,0,0,0,0,1,1
 db 0,0,1,1,1,1,1,1,0,0,0,0,1,1,0,0
 db 0,0,1,1,1,1,1,1,0,0,0,0,1,1,1,1
 db 0,0,1,1,1,1,1,1,0,0,1,1,0,0,0,0
 db 0,0,1,1,1,1,1,1,0,0,1,1,0,0,1,1
 db 0,0,1,1,1,1,1,1,0,0,1,1,1,1,0,0
 db 0,0,1,1,1,1,1,1,0,0,1,1,1,1,1,1
 db 0,0,1,1,1,1,1,1,1,1,0,0,0,0,0,0
 db 0,0,1,1,1,1,1,1,1,1,0,0,0,0,1,1
 db 0,0,1,1,1,1,1,1,1,1,0,0,1,1,0,0
 db 0,0,1,1,1,1,1,1,1,1,0,0,1,1,1,1
 db 0,0,1,1,1,1,1,1,1,1,1,1,0,0,0,0
 db 0,0,1,1,1,1,1,1,1,1,1,1,0,0,1,1
 db 0,0,1,1,1,1,1,1,1,1,1,1,1,1,0,0
 db 0,0,1,1,1,1,1,1,1,1,1,1,1,1,1,1
 db 1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0
 db 1,1,0,0,0,0,0,0,0,0,0,0,0,0,1,1
 db 1,1,0,0,0,0,0,0,0,0,0,0,1,1,0,0
 db 1,1,0,0,0,0,0,0,0,0,0,0,1,1,1,1
 db 1,1,0,0,0,0,0,0,0,0,1,1,0,0,0,0
 db 1,1,0,0,0,0,0,0,0,0,1,1,0,0,1,1
 db 1,1,0,0,0,0,0,0,0,0,1,1,1,1,0,0
 db 1,1,0,0,0,0,0,0,0,0,1,1,1,1,1,1
 db 1,1,0,0,0,0,0,0,1,1,0,0,0,0,0,0
 db 1,1,0,0,0,0,0,0,1,1,0,0,0,0,1,1
 db 1,1,0,0,0,0,0,0,1,1,0,0,1,1,0,0
 db 1,1,0,0,0,0,0,0,1,1,0,0,1,1,1,1
 db 1,1,0,0,0,0,0,0,1,1,1,1,0,0,0,0
 db 1,1,0,0,0,0,0,0,1,1,1,1,0,0,1,1
 db 1,1,0,0,0,0,0,0,1,1,1,1,1,1,0,0
 db 1,1,0,0,0,0,0,0,1,1,1,1,1,1,1,1
 db 1,1,0,0,0,0,1,1,0,0,0,0,0,0,0,0
 db 1,1,0,0,0,0,1,1,0,0,0,0,0,0,1,1
 db 1,1,0,0,0,0,1,1,0,0,0,0,1,1,0,0
 db 1,1,0,0,0,0,1,1,0,0,0,0,1,1,1,1
 db 1,1,0,0,0,0,1,1,0,0,1,1,0,0,0,0
 db 1,1,0,0,0,0,1,1,0,0,1,1,0,0,1,1
 db 1,1,0,0,0,0,1,1,0,0,1,1,1,1,0,0
 db 1,1,0,0,0,0,1,1,0,0,1,1,1,1,1,1
 db 1,1,0,0,0,0,1,1,1,1,0,0,0,0,0,0
 db 1,1,0,0,0,0,1,1,1,1,0,0,0,0,1,1
 db 1,1,0,0,0,0,1,1,1,1,0,0,1,1,0,0
 db 1,1,0,0,0,0,1,1,1,1,0,0,1,1,1,1
 db 1,1,0,0,0,0,1,1,1,1,1,1,0,0,0,0
 db 1,1,0,0,0,0,1,1,1,1,1,1,0,0,1,1
 db 1,1,0,0,0,0,1,1,1,1,1,1,1,1,0,0
 db 1,1,0,0,0,0,1,1,1,1,1,1,1,1,1,1
 db 1,1,0,0,1,1,0,0,0,0,0,0,0,0,0,0
 db 1,1,0,0,1,1,0,0,0,0,0,0,0,0,1,1
 db 1,1,0,0,1,1,0,0,0,0,0,0,1,1,0,0
 db 1,1,0,0,1,1,0,0,0,0,0,0,1,1,1,1
 db 1,1,0,0,1,1,0,0,0,0,1,1,0,0,0,0
 db 1,1,0,0,1,1,0,0,0,0,1,1,0,0,1,1
 db 1,1,0,0,1,1,0,0,0,0,1,1,1,1,0,0
 db 1,1,0,0,1,1,0,0,0,0,1,1,1,1,1,1
 db 1,1,0,0,1,1,0,0,1,1,0,0,0,0,0,0
 db 1,1,0,0,1,1,0,0,1,1,0,0,0,0,1,1
 db 1,1,0,0,1,1,0,0,1,1,0,0,1,1,0,0
 db 1,1,0,0,1,1,0,0,1,1,0,0,1,1,1,1
 db 1,1,0,0,1,1,0,0,1,1,1,1,0,0,0,0
 db 1,1,0,0,1,1,0,0,1,1,1,1,0,0,1,1
 db 1,1,0,0,1,1,0,0,1,1,1,1,1,1,0,0
 db 1,1,0,0,1,1,0,0,1,1,1,1,1,1,1,1
 db 1,1,0,0,1,1,1,1,0,0,0,0,0,0,0,0
 db 1,1,0,0,1,1,1,1,0,0,0,0,0,0,1,1
 db 1,1,0,0,1,1,1,1,0,0,0,0,1,1,0,0
 db 1,1,0,0,1,1,1,1,0,0,0,0,1,1,1,1
 db 1,1,0,0,1,1,1,1,0,0,1,1,0,0,0,0
 db 1,1,0,0,1,1,1,1,0,0,1,1,0,0,1,1
 db 1,1,0,0,1,1,1,1,0,0,1,1,1,1,0,0
 db 1,1,0,0,1,1,1,1,0,0,1,1,1,1,1,1
 db 1,1,0,0,1,1,1,1,1,1,0,0,0,0,0,0
 db 1,1,0,0,1,1,1,1,1,1,0,0,0,0,1,1
 db 1,1,0,0,1,1,1,1,1,1,0,0,1,1,0,0
 db 1,1,0,0,1,1,1,1,1,1,0,0,1,1,1,1
 db 1,1,0,0,1,1,1,1,1,1,1,1,0,0,0,0
 db 1,1,0,0,1,1,1,1,1,1,1,1,0,0,1,1
 db 1,1,0,0,1,1,1,1,1,1,1,1,1,1,0,0
 db 1,1,0,0,1,1,1,1,1,1,1,1,1,1,1,1
 db 1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0
 db 1,1,1,1,0,0,0,0,0,0,0,0,0,0,1,1
 db 1,1,1,1,0,0,0,0,0,0,0,0,1,1,0,0
 db 1,1,1,1,0,0,0,0,0,0,0,0,1,1,1,1
 db 1,1,1,1,0,0,0,0,0,0,1,1,0,0,0,0
 db 1,1,1,1,0,0,0,0,0,0,1,1,0,0,1,1
 db 1,1,1,1,0,0,0,0,0,0,1,1,1,1,0,0
 db 1,1,1,1,0,0,0,0,0,0,1,1,1,1,1,1
 db 1,1,1,1,0,0,0,0,1,1,0,0,0,0,0,0
 db 1,1,1,1,0,0,0,0,1,1,0,0,0,0,1,1
 db 1,1,1,1,0,0,0,0,1,1,0,0,1,1,0,0
 db 1,1,1,1,0,0,0,0,1,1,0,0,1,1,1,1
 db 1,1,1,1,0,0,0,0,1,1,1,1,0,0,0,0
 db 1,1,1,1,0,0,0,0,1,1,1,1,0,0,1,1
 db 1,1,1,1,0,0,0,0,1,1,1,1,1,1,0,0
 db 1,1,1,1,0,0,0,0,1,1,1,1,1,1,1,1
 db 1,1,1,1,0,0,1,1,0,0,0,0,0,0,0,0
 db 1,1,1,1,0,0,1,1,0,0,0,0,0,0,1,1
 db 1,1,1,1,0,0,1,1,0,0,0,0,1,1,0,0
 db 1,1,1,1,0,0,1,1,0,0,0,0,1,1,1,1
 db 1,1,1,1,0,0,1,1,0,0,1,1,0,0,0,0
 db 1,1,1,1,0,0,1,1,0,0,1,1,0,0,1,1
 db 1,1,1,1,0,0,1,1,0,0,1,1,1,1,0,0
 db 1,1,1,1,0,0,1,1,0,0,1,1,1,1,1,1
 db 1,1,1,1,0,0,1,1,1,1,0,0,0,0,0,0
 db 1,1,1,1,0,0,1,1,1,1,0,0,0,0,1,1
 db 1,1,1,1,0,0,1,1,1,1,0,0,1,1,0,0
 db 1,1,1,1,0,0,1,1,1,1,0,0,1,1,1,1
 db 1,1,1,1,0,0,1,1,1,1,1,1,0,0,0,0
 db 1,1,1,1,0,0,1,1,1,1,1,1,0,0,1,1
 db 1,1,1,1,0,0,1,1,1,1,1,1,1,1,0,0
 db 1,1,1,1,0,0,1,1,1,1,1,1,1,1,1,1
 db 1,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0
 db 1,1,1,1,1,1,0,0,0,0,0,0,0,0,1,1
 db 1,1,1,1,1,1,0,0,0,0,0,0,1,1,0,0
 db 1,1,1,1,1,1,0,0,0,0,0,0,1,1,1,1
 db 1,1,1,1,1,1,0,0,0,0,1,1,0,0,0,0
 db 1,1,1,1,1,1,0,0,0,0,1,1,0,0,1,1
 db 1,1,1,1,1,1,0,0,0,0,1,1,1,1,0,0
 db 1,1,1,1,1,1,0,0,0,0,1,1,1,1,1,1
 db 1,1,1,1,1,1,0,0,1,1,0,0,0,0,0,0
 db 1,1,1,1,1,1,0,0,1,1,0,0,0,0,1,1
 db 1,1,1,1,1,1,0,0,1,1,0,0,1,1,0,0
 db 1,1,1,1,1,1,0,0,1,1,0,0,1,1,1,1
 db 1,1,1,1,1,1,0,0,1,1,1,1,0,0,0,0
 db 1,1,1,1,1,1,0,0,1,1,1,1,0,0,1,1
 db 1,1,1,1,1,1,0,0,1,1,1,1,1,1,0,0
 db 1,1,1,1,1,1,0,0,1,1,1,1,1,1,1,1
 db 1,1,1,1,1,1,1,1,0,0,0,0,0,0,0,0
 db 1,1,1,1,1,1,1,1,0,0,0,0,0,0,1,1
 db 1,1,1,1,1,1,1,1,0,0,0,0,1,1,0,0
 db 1,1,1,1,1,1,1,1,0,0,0,0,1,1,1,1
 db 1,1,1,1,1,1,1,1,0,0,1,1,0,0,0,0
 db 1,1,1,1,1,1,1,1,0,0,1,1,0,0,1,1
 db 1,1,1,1,1,1,1,1,0,0,1,1,1,1,0,0
 db 1,1,1,1,1,1,1,1,0,0,1,1,1,1,1,1
 db 1,1,1,1,1,1,1,1,1,1,0,0,0,0,0,0
 db 1,1,1,1,1,1,1,1,1,1,0,0,0,0,1,1
 db 1,1,1,1,1,1,1,1,1,1,0,0,1,1,0,0
 db 1,1,1,1,1,1,1,1,1,1,0,0,1,1,1,1
 db 1,1,1,1,1,1,1,1,1,1,1,1,0,0,0,0
 db 1,1,1,1,1,1,1,1,1,1,1,1,0,0,1,1
 db 1,1,1,1,1,1,1,1,1,1,1,1,1,1,0,0
 db 1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1
 db 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
 db 0,0,0,0,0,0,0,0,0,0,0,0,0,0,2,2
 db 0,0,0,0,0,0,0,0,0,0,0,0,2,2,0,0
 db 0,0,0,0,0,0,0,0,0,0,0,0,2,2,2,2
 db 0,0,0,0,0,0,0,0,0,0,2,2,0,0,0,0
 db 0,0,0,0,0,0,0,0,0,0,2,2,0,0,2,2
 db 0,0,0,0,0,0,0,0,0,0,2,2,2,2,0,0
 db 0,0,0,0,0,0,0,0,0,0,2,2,2,2,2,2
 db 0,0,0,0,0,0,0,0,2,2,0,0,0,0,0,0
 db 0,0,0,0,0,0,0,0,2,2,0,0,0,0,2,2
 db 0,0,0,0,0,0,0,0,2,2,0,0,2,2,0,0
 db 0,0,0,0,0,0,0,0,2,2,0,0,2,2,2,2
 db 0,0,0,0,0,0,0,0,2,2,2,2,0,0,0,0
 db 0,0,0,0,0,0,0,0,2,2,2,2,0,0,2,2
 db 0,0,0,0,0,0,0,0,2,2,2,2,2,2,0,0
 db 0,0,0,0,0,0,0,0,2,2,2,2,2,2,2,2
 db 0,0,0,0,0,0,2,2,0,0,0,0,0,0,0,0
 db 0,0,0,0,0,0,2,2,0,0,0,0,0,0,2,2
 db 0,0,0,0,0,0,2,2,0,0,0,0,2,2,0,0
 db 0,0,0,0,0,0,2,2,0,0,0,0,2,2,2,2
 db 0,0,0,0,0,0,2,2,0,0,2,2,0,0,0,0
 db 0,0,0,0,0,0,2,2,0,0,2,2,0,0,2,2
 db 0,0,0,0,0,0,2,2,0,0,2,2,2,2,0,0
 db 0,0,0,0,0,0,2,2,0,0,2,2,2,2,2,2
 db 0,0,0,0,0,0,2,2,2,2,0,0,0,0,0,0
 db 0,0,0,0,0,0,2,2,2,2,0,0,0,0,2,2
 db 0,0,0,0,0,0,2,2,2,2,0,0,2,2,0,0
 db 0,0,0,0,0,0,2,2,2,2,0,0,2,2,2,2
 db 0,0,0,0,0,0,2,2,2,2,2,2,0,0,0,0
 db 0,0,0,0,0,0,2,2,2,2,2,2,0,0,2,2
 db 0,0,0,0,0,0,2,2,2,2,2,2,2,2,0,0
 db 0,0,0,0,0,0,2,2,2,2,2,2,2,2,2,2
 db 0,0,0,0,2,2,0,0,0,0,0,0,0,0,0,0
 db 0,0,0,0,2,2,0,0,0,0,0,0,0,0,2,2
 db 0,0,0,0,2,2,0,0,0,0,0,0,2,2,0,0
 db 0,0,0,0,2,2,0,0,0,0,0,0,2,2,2,2
 db 0,0,0,0,2,2,0,0,0,0,2,2,0,0,0,0
 db 0,0,0,0,2,2,0,0,0,0,2,2,0,0,2,2
 db 0,0,0,0,2,2,0,0,0,0,2,2,2,2,0,0
 db 0,0,0,0,2,2,0,0,0,0,2,2,2,2,2,2
 db 0,0,0,0,2,2,0,0,2,2,0,0,0,0,0,0
 db 0,0,0,0,2,2,0,0,2,2,0,0,0,0,2,2
 db 0,0,0,0,2,2,0,0,2,2,0,0,2,2,0,0
 db 0,0,0,0,2,2,0,0,2,2,0,0,2,2,2,2
 db 0,0,0,0,2,2,0,0,2,2,2,2,0,0,0,0
 db 0,0,0,0,2,2,0,0,2,2,2,2,0,0,2,2
 db 0,0,0,0,2,2,0,0,2,2,2,2,2,2,0,0
 db 0,0,0,0,2,2,0,0,2,2,2,2,2,2,2,2
 db 0,0,0,0,2,2,2,2,0,0,0,0,0,0,0,0
 db 0,0,0,0,2,2,2,2,0,0,0,0,0,0,2,2
 db 0,0,0,0,2,2,2,2,0,0,0,0,2,2,0,0
 db 0,0,0,0,2,2,2,2,0,0,0,0,2,2,2,2
 db 0,0,0,0,2,2,2,2,0,0,2,2,0,0,0,0
 db 0,0,0,0,2,2,2,2,0,0,2,2,0,0,2,2
 db 0,0,0,0,2,2,2,2,0,0,2,2,2,2,0,0
 db 0,0,0,0,2,2,2,2,0,0,2,2,2,2,2,2
 db 0,0,0,0,2,2,2,2,2,2,0,0,0,0,0,0
 db 0,0,0,0,2,2,2,2,2,2,0,0,0,0,2,2
 db 0,0,0,0,2,2,2,2,2,2,0,0,2,2,0,0
 db 0,0,0,0,2,2,2,2,2,2,0,0,2,2,2,2
 db 0,0,0,0,2,2,2,2,2,2,2,2,0,0,0,0
 db 0,0,0,0,2,2,2,2,2,2,2,2,0,0,2,2
 db 0,0,0,0,2,2,2,2,2,2,2,2,2,2,0,0
 db 0,0,0,0,2,2,2,2,2,2,2,2,2,2,2,2
 db 0,0,2,2,0,0,0,0,0,0,0,0,0,0,0,0
 db 0,0,2,2,0,0,0,0,0,0,0,0,0,0,2,2
 db 0,0,2,2,0,0,0,0,0,0,0,0,2,2,0,0
 db 0,0,2,2,0,0,0,0,0,0,0,0,2,2,2,2
 db 0,0,2,2,0,0,0,0,0,0,2,2,0,0,0,0
 db 0,0,2,2,0,0,0,0,0,0,2,2,0,0,2,2
 db 0,0,2,2,0,0,0,0,0,0,2,2,2,2,0,0
 db 0,0,2,2,0,0,0,0,0,0,2,2,2,2,2,2
 db 0,0,2,2,0,0,0,0,2,2,0,0,0,0,0,0
 db 0,0,2,2,0,0,0,0,2,2,0,0,0,0,2,2
 db 0,0,2,2,0,0,0,0,2,2,0,0,2,2,0,0
 db 0,0,2,2,0,0,0,0,2,2,0,0,2,2,2,2
 db 0,0,2,2,0,0,0,0,2,2,2,2,0,0,0,0
 db 0,0,2,2,0,0,0,0,2,2,2,2,0,0,2,2
 db 0,0,2,2,0,0,0,0,2,2,2,2,2,2,0,0
 db 0,0,2,2,0,0,0,0,2,2,2,2,2,2,2,2
 db 0,0,2,2,0,0,2,2,0,0,0,0,0,0,0,0
 db 0,0,2,2,0,0,2,2,0,0,0,0,0,0,2,2
 db 0,0,2,2,0,0,2,2,0,0,0,0,2,2,0,0
 db 0,0,2,2,0,0,2,2,0,0,0,0,2,2,2,2
 db 0,0,2,2,0,0,2,2,0,0,2,2,0,0,0,0
 db 0,0,2,2,0,0,2,2,0,0,2,2,0,0,2,2
 db 0,0,2,2,0,0,2,2,0,0,2,2,2,2,0,0
 db 0,0,2,2,0,0,2,2,0,0,2,2,2,2,2,2
 db 0,0,2,2,0,0,2,2,2,2,0,0,0,0,0,0
 db 0,0,2,2,0,0,2,2,2,2,0,0,0,0,2,2
 db 0,0,2,2,0,0,2,2,2,2,0,0,2,2,0,0
 db 0,0,2,2,0,0,2,2,2,2,0,0,2,2,2,2
 db 0,0,2,2,0,0,2,2,2,2,2,2,0,0,0,0
 db 0,0,2,2,0,0,2,2,2,2,2,2,0,0,2,2
 db 0,0,2,2,0,0,2,2,2,2,2,2,2,2,0,0
 db 0,0,2,2,0,0,2,2,2,2,2,2,2,2,2,2
 db 0,0,2,2,2,2,0,0,0,0,0,0,0,0,0,0
 db 0,0,2,2,2,2,0,0,0,0,0,0,0,0,2,2
 db 0,0,2,2,2,2,0,0,0,0,0,0,2,2,0,0
 db 0,0,2,2,2,2,0,0,0,0,0,0,2,2,2,2
 db 0,0,2,2,2,2,0,0,0,0,2,2,0,0,0,0
 db 0,0,2,2,2,2,0,0,0,0,2,2,0,0,2,2
 db 0,0,2,2,2,2,0,0,0,0,2,2,2,2,0,0
 db 0,0,2,2,2,2,0,0,0,0,2,2,2,2,2,2
 db 0,0,2,2,2,2,0,0,2,2,0,0,0,0,0,0
 db 0,0,2,2,2,2,0,0,2,2,0,0,0,0,2,2
 db 0,0,2,2,2,2,0,0,2,2,0,0,2,2,0,0
 db 0,0,2,2,2,2,0,0,2,2,0,0,2,2,2,2
 db 0,0,2,2,2,2,0,0,2,2,2,2,0,0,0,0
 db 0,0,2,2,2,2,0,0,2,2,2,2,0,0,2,2
 db 0,0,2,2,2,2,0,0,2,2,2,2,2,2,0,0
 db 0,0,2,2,2,2,0,0,2,2,2,2,2,2,2,2
 db 0,0,2,2,2,2,2,2,0,0,0,0,0,0,0,0
 db 0,0,2,2,2,2,2,2,0,0,0,0,0,0,2,2
 db 0,0,2,2,2,2,2,2,0,0,0,0,2,2,0,0
 db 0,0,2,2,2,2,2,2,0,0,0,0,2,2,2,2
 db 0,0,2,2,2,2,2,2,0,0,2,2,0,0,0,0
 db 0,0,2,2,2,2,2,2,0,0,2,2,0,0,2,2
 db 0,0,2,2,2,2,2,2,0,0,2,2,2,2,0,0
 db 0,0,2,2,2,2,2,2,0,0,2,2,2,2,2,2
 db 0,0,2,2,2,2,2,2,2,2,0,0,0,0,0,0
 db 0,0,2,2,2,2,2,2,2,2,0,0,0,0,2,2
 db 0,0,2,2,2,2,2,2,2,2,0,0,2,2,0,0
 db 0,0,2,2,2,2,2,2,2,2,0,0,2,2,2,2
 db 0,0,2,2,2,2,2,2,2,2,2,2,0,0,0,0
 db 0,0,2,2,2,2,2,2,2,2,2,2,0,0,2,2
 db 0,0,2,2,2,2,2,2,2,2,2,2,2,2,0,0
 db 0,0,2,2,2,2,2,2,2,2,2,2,2,2,2,2
 db 2,2,0,0,0,0,0,0,0,0,0,0,0,0,0,0
 db 2,2,0,0,0,0,0,0,0,0,0,0,0,0,2,2
 db 2,2,0,0,0,0,0,0,0,0,0,0,2,2,0,0
 db 2,2,0,0,0,0,0,0,0,0,0,0,2,2,2,2
 db 2,2,0,0,0,0,0,0,0,0,2,2,0,0,0,0
 db 2,2,0,0,0,0,0,0,0,0,2,2,0,0,2,2
 db 2,2,0,0,0,0,0,0,0,0,2,2,2,2,0,0
 db 2,2,0,0,0,0,0,0,0,0,2,2,2,2,2,2
 db 2,2,0,0,0,0,0,0,2,2,0,0,0,0,0,0
 db 2,2,0,0,0,0,0,0,2,2,0,0,0,0,2,2
 db 2,2,0,0,0,0,0,0,2,2,0,0,2,2,0,0
 db 2,2,0,0,0,0,0,0,2,2,0,0,2,2,2,2
 db 2,2,0,0,0,0,0,0,2,2,2,2,0,0,0,0
 db 2,2,0,0,0,0,0,0,2,2,2,2,0,0,2,2
 db 2,2,0,0,0,0,0,0,2,2,2,2,2,2,0,0
 db 2,2,0,0,0,0,0,0,2,2,2,2,2,2,2,2
 db 2,2,0,0,0,0,2,2,0,0,0,0,0,0,0,0
 db 2,2,0,0,0,0,2,2,0,0,0,0,0,0,2,2
 db 2,2,0,0,0,0,2,2,0,0,0,0,2,2,0,0
 db 2,2,0,0,0,0,2,2,0,0,0,0,2,2,2,2
 db 2,2,0,0,0,0,2,2,0,0,2,2,0,0,0,0
 db 2,2,0,0,0,0,2,2,0,0,2,2,0,0,2,2
 db 2,2,0,0,0,0,2,2,0,0,2,2,2,2,0,0
 db 2,2,0,0,0,0,2,2,0,0,2,2,2,2,2,2
 db 2,2,0,0,0,0,2,2,2,2,0,0,0,0,0,0
 db 2,2,0,0,0,0,2,2,2,2,0,0,0,0,2,2
 db 2,2,0,0,0,0,2,2,2,2,0,0,2,2,0,0
 db 2,2,0,0,0,0,2,2,2,2,0,0,2,2,2,2
 db 2,2,0,0,0,0,2,2,2,2,2,2,0,0,0,0
 db 2,2,0,0,0,0,2,2,2,2,2,2,0,0,2,2
 db 2,2,0,0,0,0,2,2,2,2,2,2,2,2,0,0
 db 2,2,0,0,0,0,2,2,2,2,2,2,2,2,2,2
 db 2,2,0,0,2,2,0,0,0,0,0,0,0,0,0,0
 db 2,2,0,0,2,2,0,0,0,0,0,0,0,0,2,2
 db 2,2,0,0,2,2,0,0,0,0,0,0,2,2,0,0
 db 2,2,0,0,2,2,0,0,0,0,0,0,2,2,2,2
 db 2,2,0,0,2,2,0,0,0,0,2,2,0,0,0,0
 db 2,2,0,0,2,2,0,0,0,0,2,2,0,0,2,2
 db 2,2,0,0,2,2,0,0,0,0,2,2,2,2,0,0
 db 2,2,0,0,2,2,0,0,0,0,2,2,2,2,2,2
 db 2,2,0,0,2,2,0,0,2,2,0,0,0,0,0,0
 db 2,2,0,0,2,2,0,0,2,2,0,0,0,0,2,2
 db 2,2,0,0,2,2,0,0,2,2,0,0,2,2,0,0
 db 2,2,0,0,2,2,0,0,2,2,0,0,2,2,2,2
 db 2,2,0,0,2,2,0,0,2,2,2,2,0,0,0,0
 db 2,2,0,0,2,2,0,0,2,2,2,2,0,0,2,2
 db 2,2,0,0,2,2,0,0,2,2,2,2,2,2,0,0
 db 2,2,0,0,2,2,0,0,2,2,2,2,2,2,2,2
 db 2,2,0,0,2,2,2,2,0,0,0,0,0,0,0,0
 db 2,2,0,0,2,2,2,2,0,0,0,0,0,0,2,2
 db 2,2,0,0,2,2,2,2,0,0,0,0,2,2,0,0
 db 2,2,0,0,2,2,2,2,0,0,0,0,2,2,2,2
 db 2,2,0,0,2,2,2,2,0,0,2,2,0,0,0,0
 db 2,2,0,0,2,2,2,2,0,0,2,2,0,0,2,2
 db 2,2,0,0,2,2,2,2,0,0,2,2,2,2,0,0
 db 2,2,0,0,2,2,2,2,0,0,2,2,2,2,2,2
 db 2,2,0,0,2,2,2,2,2,2,0,0,0,0,0,0
 db 2,2,0,0,2,2,2,2,2,2,0,0,0,0,2,2
 db 2,2,0,0,2,2,2,2,2,2,0,0,2,2,0,0
 db 2,2,0,0,2,2,2,2,2,2,0,0,2,2,2,2
 db 2,2,0,0,2,2,2,2,2,2,2,2,0,0,0,0
 db 2,2,0,0,2,2,2,2,2,2,2,2,0,0,2,2
 db 2,2,0,0,2,2,2,2,2,2,2,2,2,2,0,0
 db 2,2,0,0,2,2,2,2,2,2,2,2,2,2,2,2
 db 2,2,2,2,0,0,0,0,0,0,0,0,0,0,0,0
 db 2,2,2,2,0,0,0,0,0,0,0,0,0,0,2,2
 db 2,2,2,2,0,0,0,0,0,0,0,0,2,2,0,0
 db 2,2,2,2,0,0,0,0,0,0,0,0,2,2,2,2
 db 2,2,2,2,0,0,0,0,0,0,2,2,0,0,0,0
 db 2,2,2,2,0,0,0,0,0,0,2,2,0,0,2,2
 db 2,2,2,2,0,0,0,0,0,0,2,2,2,2,0,0
 db 2,2,2,2,0,0,0,0,0,0,2,2,2,2,2,2
 db 2,2,2,2,0,0,0,0,2,2,0,0,0,0,0,0
 db 2,2,2,2,0,0,0,0,2,2,0,0,0,0,2,2
 db 2,2,2,2,0,0,0,0,2,2,0,0,2,2,0,0
 db 2,2,2,2,0,0,0,0,2,2,0,0,2,2,2,2
 db 2,2,2,2,0,0,0,0,2,2,2,2,0,0,0,0
 db 2,2,2,2,0,0,0,0,2,2,2,2,0,0,2,2
 db 2,2,2,2,0,0,0,0,2,2,2,2,2,2,0,0
 db 2,2,2,2,0,0,0,0,2,2,2,2,2,2,2,2
 db 2,2,2,2,0,0,2,2,0,0,0,0,0,0,0,0
 db 2,2,2,2,0,0,2,2,0,0,0,0,0,0,2,2
 db 2,2,2,2,0,0,2,2,0,0,0,0,2,2,0,0
 db 2,2,2,2,0,0,2,2,0,0,0,0,2,2,2,2
 db 2,2,2,2,0,0,2,2,0,0,2,2,0,0,0,0
 db 2,2,2,2,0,0,2,2,0,0,2,2,0,0,2,2
 db 2,2,2,2,0,0,2,2,0,0,2,2,2,2,0,0
 db 2,2,2,2,0,0,2,2,0,0,2,2,2,2,2,2
 db 2,2,2,2,0,0,2,2,2,2,0,0,0,0,0,0
 db 2,2,2,2,0,0,2,2,2,2,0,0,0,0,2,2
 db 2,2,2,2,0,0,2,2,2,2,0,0,2,2,0,0
 db 2,2,2,2,0,0,2,2,2,2,0,0,2,2,2,2
 db 2,2,2,2,0,0,2,2,2,2,2,2,0,0,0,0
 db 2,2,2,2,0,0,2,2,2,2,2,2,0,0,2,2
 db 2,2,2,2,0,0,2,2,2,2,2,2,2,2,0,0
 db 2,2,2,2,0,0,2,2,2,2,2,2,2,2,2,2
 db 2,2,2,2,2,2,0,0,0,0,0,0,0,0,0,0
 db 2,2,2,2,2,2,0,0,0,0,0,0,0,0,2,2
 db 2,2,2,2,2,2,0,0,0,0,0,0,2,2,0,0
 db 2,2,2,2,2,2,0,0,0,0,0,0,2,2,2,2
 db 2,2,2,2,2,2,0,0,0,0,2,2,0,0,0,0
 db 2,2,2,2,2,2,0,0,0,0,2,2,0,0,2,2
 db 2,2,2,2,2,2,0,0,0,0,2,2,2,2,0,0
 db 2,2,2,2,2,2,0,0,0,0,2,2,2,2,2,2
 db 2,2,2,2,2,2,0,0,2,2,0,0,0,0,0,0
 db 2,2,2,2,2,2,0,0,2,2,0,0,0,0,2,2
 db 2,2,2,2,2,2,0,0,2,2,0,0,2,2,0,0
 db 2,2,2,2,2,2,0,0,2,2,0,0,2,2,2,2
 db 2,2,2,2,2,2,0,0,2,2,2,2,0,0,0,0
 db 2,2,2,2,2,2,0,0,2,2,2,2,0,0,2,2
 db 2,2,2,2,2,2,0,0,2,2,2,2,2,2,0,0
 db 2,2,2,2,2,2,0,0,2,2,2,2,2,2,2,2
 db 2,2,2,2,2,2,2,2,0,0,0,0,0,0,0,0
 db 2,2,2,2,2,2,2,2,0,0,0,0,0,0,2,2
 db 2,2,2,2,2,2,2,2,0,0,0,0,2,2,0,0
 db 2,2,2,2,2,2,2,2,0,0,0,0,2,2,2,2
 db 2,2,2,2,2,2,2,2,0,0,2,2,0,0,0,0
 db 2,2,2,2,2,2,2,2,0,0,2,2,0,0,2,2
 db 2,2,2,2,2,2,2,2,0,0,2,2,2,2,0,0
 db 2,2,2,2,2,2,2,2,0,0,2,2,2,2,2,2
 db 2,2,2,2,2,2,2,2,2,2,0,0,0,0,0,0
 db 2,2,2,2,2,2,2,2,2,2,0,0,0,0,2,2
 db 2,2,2,2,2,2,2,2,2,2,0,0,2,2,0,0
 db 2,2,2,2,2,2,2,2,2,2,0,0,2,2,2,2
 db 2,2,2,2,2,2,2,2,2,2,2,2,0,0,0,0
 db 2,2,2,2,2,2,2,2,2,2,2,2,0,0,2,2
 db 2,2,2,2,2,2,2,2,2,2,2,2,2,2,0,0
 db 2,2,2,2,2,2,2,2,2,2,2,2,2,2,2,2
 db 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
 db 0,0,0,0,0,0,0,0,0,0,0,0,0,0,4,4
 db 0,0,0,0,0,0,0,0,0,0,0,0,4,4,0,0
 db 0,0,0,0,0,0,0,0,0,0,0,0,4,4,4,4
 db 0,0,0,0,0,0,0,0,0,0,4,4,0,0,0,0
 db 0,0,0,0,0,0,0,0,0,0,4,4,0,0,4,4
 db 0,0,0,0,0,0,0,0,0,0,4,4,4,4,0,0
 db 0,0,0,0,0,0,0,0,0,0,4,4,4,4,4,4
 db 0,0,0,0,0,0,0,0,4,4,0,0,0,0,0,0
 db 0,0,0,0,0,0,0,0,4,4,0,0,0,0,4,4
 db 0,0,0,0,0,0,0,0,4,4,0,0,4,4,0,0
 db 0,0,0,0,0,0,0,0,4,4,0,0,4,4,4,4
 db 0,0,0,0,0,0,0,0,4,4,4,4,0,0,0,0
 db 0,0,0,0,0,0,0,0,4,4,4,4,0,0,4,4
 db 0,0,0,0,0,0,0,0,4,4,4,4,4,4,0,0
 db 0,0,0,0,0,0,0,0,4,4,4,4,4,4,4,4
 db 0,0,0,0,0,0,4,4,0,0,0,0,0,0,0,0
 db 0,0,0,0,0,0,4,4,0,0,0,0,0,0,4,4
 db 0,0,0,0,0,0,4,4,0,0,0,0,4,4,0,0
 db 0,0,0,0,0,0,4,4,0,0,0,0,4,4,4,4
 db 0,0,0,0,0,0,4,4,0,0,4,4,0,0,0,0
 db 0,0,0,0,0,0,4,4,0,0,4,4,0,0,4,4
 db 0,0,0,0,0,0,4,4,0,0,4,4,4,4,0,0
 db 0,0,0,0,0,0,4,4,0,0,4,4,4,4,4,4
 db 0,0,0,0,0,0,4,4,4,4,0,0,0,0,0,0
 db 0,0,0,0,0,0,4,4,4,4,0,0,0,0,4,4
 db 0,0,0,0,0,0,4,4,4,4,0,0,4,4,0,0
 db 0,0,0,0,0,0,4,4,4,4,0,0,4,4,4,4
 db 0,0,0,0,0,0,4,4,4,4,4,4,0,0,0,0
 db 0,0,0,0,0,0,4,4,4,4,4,4,0,0,4,4
 db 0,0,0,0,0,0,4,4,4,4,4,4,4,4,0,0
 db 0,0,0,0,0,0,4,4,4,4,4,4,4,4,4,4
 db 0,0,0,0,4,4,0,0,0,0,0,0,0,0,0,0
 db 0,0,0,0,4,4,0,0,0,0,0,0,0,0,4,4
 db 0,0,0,0,4,4,0,0,0,0,0,0,4,4,0,0
 db 0,0,0,0,4,4,0,0,0,0,0,0,4,4,4,4
 db 0,0,0,0,4,4,0,0,0,0,4,4,0,0,0,0
 db 0,0,0,0,4,4,0,0,0,0,4,4,0,0,4,4
 db 0,0,0,0,4,4,0,0,0,0,4,4,4,4,0,0
 db 0,0,0,0,4,4,0,0,0,0,4,4,4,4,4,4
 db 0,0,0,0,4,4,0,0,4,4,0,0,0,0,0,0
 db 0,0,0,0,4,4,0,0,4,4,0,0,0,0,4,4
 db 0,0,0,0,4,4,0,0,4,4,0,0,4,4,0,0
 db 0,0,0,0,4,4,0,0,4,4,0,0,4,4,4,4
 db 0,0,0,0,4,4,0,0,4,4,4,4,0,0,0,0
 db 0,0,0,0,4,4,0,0,4,4,4,4,0,0,4,4
 db 0,0,0,0,4,4,0,0,4,4,4,4,4,4,0,0
 db 0,0,0,0,4,4,0,0,4,4,4,4,4,4,4,4
 db 0,0,0,0,4,4,4,4,0,0,0,0,0,0,0,0
 db 0,0,0,0,4,4,4,4,0,0,0,0,0,0,4,4
 db 0,0,0,0,4,4,4,4,0,0,0,0,4,4,0,0
 db 0,0,0,0,4,4,4,4,0,0,0,0,4,4,4,4
 db 0,0,0,0,4,4,4,4,0,0,4,4,0,0,0,0
 db 0,0,0,0,4,4,4,4,0,0,4,4,0,0,4,4
 db 0,0,0,0,4,4,4,4,0,0,4,4,4,4,0,0
 db 0,0,0,0,4,4,4,4,0,0,4,4,4,4,4,4
 db 0,0,0,0,4,4,4,4,4,4,0,0,0,0,0,0
 db 0,0,0,0,4,4,4,4,4,4,0,0,0,0,4,4
 db 0,0,0,0,4,4,4,4,4,4,0,0,4,4,0,0
 db 0,0,0,0,4,4,4,4,4,4,0,0,4,4,4,4
 db 0,0,0,0,4,4,4,4,4,4,4,4,0,0,0,0
 db 0,0,0,0,4,4,4,4,4,4,4,4,0,0,4,4
 db 0,0,0,0,4,4,4,4,4,4,4,4,4,4,0,0
 db 0,0,0,0,4,4,4,4,4,4,4,4,4,4,4,4
 db 0,0,4,4,0,0,0,0,0,0,0,0,0,0,0,0
 db 0,0,4,4,0,0,0,0,0,0,0,0,0,0,4,4
 db 0,0,4,4,0,0,0,0,0,0,0,0,4,4,0,0
 db 0,0,4,4,0,0,0,0,0,0,0,0,4,4,4,4
 db 0,0,4,4,0,0,0,0,0,0,4,4,0,0,0,0
 db 0,0,4,4,0,0,0,0,0,0,4,4,0,0,4,4
 db 0,0,4,4,0,0,0,0,0,0,4,4,4,4,0,0
 db 0,0,4,4,0,0,0,0,0,0,4,4,4,4,4,4
 db 0,0,4,4,0,0,0,0,4,4,0,0,0,0,0,0
 db 0,0,4,4,0,0,0,0,4,4,0,0,0,0,4,4
 db 0,0,4,4,0,0,0,0,4,4,0,0,4,4,0,0
 db 0,0,4,4,0,0,0,0,4,4,0,0,4,4,4,4
 db 0,0,4,4,0,0,0,0,4,4,4,4,0,0,0,0
 db 0,0,4,4,0,0,0,0,4,4,4,4,0,0,4,4
 db 0,0,4,4,0,0,0,0,4,4,4,4,4,4,0,0
 db 0,0,4,4,0,0,0,0,4,4,4,4,4,4,4,4
 db 0,0,4,4,0,0,4,4,0,0,0,0,0,0,0,0
 db 0,0,4,4,0,0,4,4,0,0,0,0,0,0,4,4
 db 0,0,4,4,0,0,4,4,0,0,0,0,4,4,0,0
 db 0,0,4,4,0,0,4,4,0,0,0,0,4,4,4,4
 db 0,0,4,4,0,0,4,4,0,0,4,4,0,0,0,0
 db 0,0,4,4,0,0,4,4,0,0,4,4,0,0,4,4
 db 0,0,4,4,0,0,4,4,0,0,4,4,4,4,0,0
 db 0,0,4,4,0,0,4,4,0,0,4,4,4,4,4,4
 db 0,0,4,4,0,0,4,4,4,4,0,0,0,0,0,0
 db 0,0,4,4,0,0,4,4,4,4,0,0,0,0,4,4
 db 0,0,4,4,0,0,4,4,4,4,0,0,4,4,0,0
 db 0,0,4,4,0,0,4,4,4,4,0,0,4,4,4,4
 db 0,0,4,4,0,0,4,4,4,4,4,4,0,0,0,0
 db 0,0,4,4,0,0,4,4,4,4,4,4,0,0,4,4
 db 0,0,4,4,0,0,4,4,4,4,4,4,4,4,0,0
 db 0,0,4,4,0,0,4,4,4,4,4,4,4,4,4,4
 db 0,0,4,4,4,4,0,0,0,0,0,0,0,0,0,0
 db 0,0,4,4,4,4,0,0,0,0,0,0,0,0,4,4
 db 0,0,4,4,4,4,0,0,0,0,0,0,4,4,0,0
 db 0,0,4,4,4,4,0,0,0,0,0,0,4,4,4,4
 db 0,0,4,4,4,4,0,0,0,0,4,4,0,0,0,0
 db 0,0,4,4,4,4,0,0,0,0,4,4,0,0,4,4
 db 0,0,4,4,4,4,0,0,0,0,4,4,4,4,0,0
 db 0,0,4,4,4,4,0,0,0,0,4,4,4,4,4,4
 db 0,0,4,4,4,4,0,0,4,4,0,0,0,0,0,0
 db 0,0,4,4,4,4,0,0,4,4,0,0,0,0,4,4
 db 0,0,4,4,4,4,0,0,4,4,0,0,4,4,0,0
 db 0,0,4,4,4,4,0,0,4,4,0,0,4,4,4,4
 db 0,0,4,4,4,4,0,0,4,4,4,4,0,0,0,0
 db 0,0,4,4,4,4,0,0,4,4,4,4,0,0,4,4
 db 0,0,4,4,4,4,0,0,4,4,4,4,4,4,0,0
 db 0,0,4,4,4,4,0,0,4,4,4,4,4,4,4,4
 db 0,0,4,4,4,4,4,4,0,0,0,0,0,0,0,0
 db 0,0,4,4,4,4,4,4,0,0,0,0,0,0,4,4
 db 0,0,4,4,4,4,4,4,0,0,0,0,4,4,0,0
 db 0,0,4,4,4,4,4,4,0,0,0,0,4,4,4,4
 db 0,0,4,4,4,4,4,4,0,0,4,4,0,0,0,0
 db 0,0,4,4,4,4,4,4,0,0,4,4,0,0,4,4
 db 0,0,4,4,4,4,4,4,0,0,4,4,4,4,0,0
 db 0,0,4,4,4,4,4,4,0,0,4,4,4,4,4,4
 db 0,0,4,4,4,4,4,4,4,4,0,0,0,0,0,0
 db 0,0,4,4,4,4,4,4,4,4,0,0,0,0,4,4
 db 0,0,4,4,4,4,4,4,4,4,0,0,4,4,0,0
 db 0,0,4,4,4,4,4,4,4,4,0,0,4,4,4,4
 db 0,0,4,4,4,4,4,4,4,4,4,4,0,0,0,0
 db 0,0,4,4,4,4,4,4,4,4,4,4,0,0,4,4
 db 0,0,4,4,4,4,4,4,4,4,4,4,4,4,0,0
 db 0,0,4,4,4,4,4,4,4,4,4,4,4,4,4,4
 db 4,4,0,0,0,0,0,0,0,0,0,0,0,0,0,0
 db 4,4,0,0,0,0,0,0,0,0,0,0,0,0,4,4
 db 4,4,0,0,0,0,0,0,0,0,0,0,4,4,0,0
 db 4,4,0,0,0,0,0,0,0,0,0,0,4,4,4,4
 db 4,4,0,0,0,0,0,0,0,0,4,4,0,0,0,0
 db 4,4,0,0,0,0,0,0,0,0,4,4,0,0,4,4
 db 4,4,0,0,0,0,0,0,0,0,4,4,4,4,0,0
 db 4,4,0,0,0,0,0,0,0,0,4,4,4,4,4,4
 db 4,4,0,0,0,0,0,0,4,4,0,0,0,0,0,0
 db 4,4,0,0,0,0,0,0,4,4,0,0,0,0,4,4
 db 4,4,0,0,0,0,0,0,4,4,0,0,4,4,0,0
 db 4,4,0,0,0,0,0,0,4,4,0,0,4,4,4,4
 db 4,4,0,0,0,0,0,0,4,4,4,4,0,0,0,0
 db 4,4,0,0,0,0,0,0,4,4,4,4,0,0,4,4
 db 4,4,0,0,0,0,0,0,4,4,4,4,4,4,0,0
 db 4,4,0,0,0,0,0,0,4,4,4,4,4,4,4,4
 db 4,4,0,0,0,0,4,4,0,0,0,0,0,0,0,0
 db 4,4,0,0,0,0,4,4,0,0,0,0,0,0,4,4
 db 4,4,0,0,0,0,4,4,0,0,0,0,4,4,0,0
 db 4,4,0,0,0,0,4,4,0,0,0,0,4,4,4,4
 db 4,4,0,0,0,0,4,4,0,0,4,4,0,0,0,0
 db 4,4,0,0,0,0,4,4,0,0,4,4,0,0,4,4
 db 4,4,0,0,0,0,4,4,0,0,4,4,4,4,0,0
 db 4,4,0,0,0,0,4,4,0,0,4,4,4,4,4,4
 db 4,4,0,0,0,0,4,4,4,4,0,0,0,0,0,0
 db 4,4,0,0,0,0,4,4,4,4,0,0,0,0,4,4
 db 4,4,0,0,0,0,4,4,4,4,0,0,4,4,0,0
 db 4,4,0,0,0,0,4,4,4,4,0,0,4,4,4,4
 db 4,4,0,0,0,0,4,4,4,4,4,4,0,0,0,0
 db 4,4,0,0,0,0,4,4,4,4,4,4,0,0,4,4
 db 4,4,0,0,0,0,4,4,4,4,4,4,4,4,0,0
 db 4,4,0,0,0,0,4,4,4,4,4,4,4,4,4,4
 db 4,4,0,0,4,4,0,0,0,0,0,0,0,0,0,0
 db 4,4,0,0,4,4,0,0,0,0,0,0,0,0,4,4
 db 4,4,0,0,4,4,0,0,0,0,0,0,4,4,0,0
 db 4,4,0,0,4,4,0,0,0,0,0,0,4,4,4,4
 db 4,4,0,0,4,4,0,0,0,0,4,4,0,0,0,0
 db 4,4,0,0,4,4,0,0,0,0,4,4,0,0,4,4
 db 4,4,0,0,4,4,0,0,0,0,4,4,4,4,0,0
 db 4,4,0,0,4,4,0,0,0,0,4,4,4,4,4,4
 db 4,4,0,0,4,4,0,0,4,4,0,0,0,0,0,0
 db 4,4,0,0,4,4,0,0,4,4,0,0,0,0,4,4
 db 4,4,0,0,4,4,0,0,4,4,0,0,4,4,0,0
 db 4,4,0,0,4,4,0,0,4,4,0,0,4,4,4,4
 db 4,4,0,0,4,4,0,0,4,4,4,4,0,0,0,0
 db 4,4,0,0,4,4,0,0,4,4,4,4,0,0,4,4
 db 4,4,0,0,4,4,0,0,4,4,4,4,4,4,0,0
 db 4,4,0,0,4,4,0,0,4,4,4,4,4,4,4,4
 db 4,4,0,0,4,4,4,4,0,0,0,0,0,0,0,0
 db 4,4,0,0,4,4,4,4,0,0,0,0,0,0,4,4
 db 4,4,0,0,4,4,4,4,0,0,0,0,4,4,0,0
 db 4,4,0,0,4,4,4,4,0,0,0,0,4,4,4,4
 db 4,4,0,0,4,4,4,4,0,0,4,4,0,0,0,0
 db 4,4,0,0,4,4,4,4,0,0,4,4,0,0,4,4
 db 4,4,0,0,4,4,4,4,0,0,4,4,4,4,0,0
 db 4,4,0,0,4,4,4,4,0,0,4,4,4,4,4,4
 db 4,4,0,0,4,4,4,4,4,4,0,0,0,0,0,0
 db 4,4,0,0,4,4,4,4,4,4,0,0,0,0,4,4
 db 4,4,0,0,4,4,4,4,4,4,0,0,4,4,0,0
 db 4,4,0,0,4,4,4,4,4,4,0,0,4,4,4,4
 db 4,4,0,0,4,4,4,4,4,4,4,4,0,0,0,0
 db 4,4,0,0,4,4,4,4,4,4,4,4,0,0,4,4
 db 4,4,0,0,4,4,4,4,4,4,4,4,4,4,0,0
 db 4,4,0,0,4,4,4,4,4,4,4,4,4,4,4,4
 db 4,4,4,4,0,0,0,0,0,0,0,0,0,0,0,0
 db 4,4,4,4,0,0,0,0,0,0,0,0,0,0,4,4
 db 4,4,4,4,0,0,0,0,0,0,0,0,4,4,0,0
 db 4,4,4,4,0,0,0,0,0,0,0,0,4,4,4,4
 db 4,4,4,4,0,0,0,0,0,0,4,4,0,0,0,0
 db 4,4,4,4,0,0,0,0,0,0,4,4,0,0,4,4
 db 4,4,4,4,0,0,0,0,0,0,4,4,4,4,0,0
 db 4,4,4,4,0,0,0,0,0,0,4,4,4,4,4,4
 db 4,4,4,4,0,0,0,0,4,4,0,0,0,0,0,0
 db 4,4,4,4,0,0,0,0,4,4,0,0,0,0,4,4
 db 4,4,4,4,0,0,0,0,4,4,0,0,4,4,0,0
 db 4,4,4,4,0,0,0,0,4,4,0,0,4,4,4,4
 db 4,4,4,4,0,0,0,0,4,4,4,4,0,0,0,0
 db 4,4,4,4,0,0,0,0,4,4,4,4,0,0,4,4
 db 4,4,4,4,0,0,0,0,4,4,4,4,4,4,0,0
 db 4,4,4,4,0,0,0,0,4,4,4,4,4,4,4,4
 db 4,4,4,4,0,0,4,4,0,0,0,0,0,0,0,0
 db 4,4,4,4,0,0,4,4,0,0,0,0,0,0,4,4
 db 4,4,4,4,0,0,4,4,0,0,0,0,4,4,0,0
 db 4,4,4,4,0,0,4,4,0,0,0,0,4,4,4,4
 db 4,4,4,4,0,0,4,4,0,0,4,4,0,0,0,0
 db 4,4,4,4,0,0,4,4,0,0,4,4,0,0,4,4
 db 4,4,4,4,0,0,4,4,0,0,4,4,4,4,0,0
 db 4,4,4,4,0,0,4,4,0,0,4,4,4,4,4,4
 db 4,4,4,4,0,0,4,4,4,4,0,0,0,0,0,0
 db 4,4,4,4,0,0,4,4,4,4,0,0,0,0,4,4
 db 4,4,4,4,0,0,4,4,4,4,0,0,4,4,0,0
 db 4,4,4,4,0,0,4,4,4,4,0,0,4,4,4,4
 db 4,4,4,4,0,0,4,4,4,4,4,4,0,0,0,0
 db 4,4,4,4,0,0,4,4,4,4,4,4,0,0,4,4
 db 4,4,4,4,0,0,4,4,4,4,4,4,4,4,0,0
 db 4,4,4,4,0,0,4,4,4,4,4,4,4,4,4,4
 db 4,4,4,4,4,4,0,0,0,0,0,0,0,0,0,0
 db 4,4,4,4,4,4,0,0,0,0,0,0,0,0,4,4
 db 4,4,4,4,4,4,0,0,0,0,0,0,4,4,0,0
 db 4,4,4,4,4,4,0,0,0,0,0,0,4,4,4,4
 db 4,4,4,4,4,4,0,0,0,0,4,4,0,0,0,0
 db 4,4,4,4,4,4,0,0,0,0,4,4,0,0,4,4
 db 4,4,4,4,4,4,0,0,0,0,4,4,4,4,0,0
 db 4,4,4,4,4,4,0,0,0,0,4,4,4,4,4,4
 db 4,4,4,4,4,4,0,0,4,4,0,0,0,0,0,0
 db 4,4,4,4,4,4,0,0,4,4,0,0,0,0,4,4
 db 4,4,4,4,4,4,0,0,4,4,0,0,4,4,0,0
 db 4,4,4,4,4,4,0,0,4,4,0,0,4,4,4,4
 db 4,4,4,4,4,4,0,0,4,4,4,4,0,0,0,0
 db 4,4,4,4,4,4,0,0,4,4,4,4,0,0,4,4
 db 4,4,4,4,4,4,0,0,4,4,4,4,4,4,0,0
 db 4,4,4,4,4,4,0,0,4,4,4,4,4,4,4,4
 db 4,4,4,4,4,4,4,4,0,0,0,0,0,0,0,0
 db 4,4,4,4,4,4,4,4,0,0,0,0,0,0,4,4
 db 4,4,4,4,4,4,4,4,0,0,0,0,4,4,0,0
 db 4,4,4,4,4,4,4,4,0,0,0,0,4,4,4,4
 db 4,4,4,4,4,4,4,4,0,0,4,4,0,0,0,0
 db 4,4,4,4,4,4,4,4,0,0,4,4,0,0,4,4
 db 4,4,4,4,4,4,4,4,0,0,4,4,4,4,0,0
 db 4,4,4,4,4,4,4,4,0,0,4,4,4,4,4,4
 db 4,4,4,4,4,4,4,4,4,4,0,0,0,0,0,0
 db 4,4,4,4,4,4,4,4,4,4,0,0,0,0,4,4
 db 4,4,4,4,4,4,4,4,4,4,0,0,4,4,0,0
 db 4,4,4,4,4,4,4,4,4,4,0,0,4,4,4,4
 db 4,4,4,4,4,4,4,4,4,4,4,4,0,0,0,0
 db 4,4,4,4,4,4,4,4,4,4,4,4,0,0,4,4
 db 4,4,4,4,4,4,4,4,4,4,4,4,4,4,0,0
 db 4,4,4,4,4,4,4,4,4,4,4,4,4,4,4,4
 db 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
 db 0,0,0,0,0,0,0,0,0,0,0,0,0,0,8,8
 db 0,0,0,0,0,0,0,0,0,0,0,0,8,8,0,0
 db 0,0,0,0,0,0,0,0,0,0,0,0,8,8,8,8
 db 0,0,0,0,0,0,0,0,0,0,8,8,0,0,0,0
 db 0,0,0,0,0,0,0,0,0,0,8,8,0,0,8,8
 db 0,0,0,0,0,0,0,0,0,0,8,8,8,8,0,0
 db 0,0,0,0,0,0,0,0,0,0,8,8,8,8,8,8
 db 0,0,0,0,0,0,0,0,8,8,0,0,0,0,0,0
 db 0,0,0,0,0,0,0,0,8,8,0,0,0,0,8,8
 db 0,0,0,0,0,0,0,0,8,8,0,0,8,8,0,0
 db 0,0,0,0,0,0,0,0,8,8,0,0,8,8,8,8
 db 0,0,0,0,0,0,0,0,8,8,8,8,0,0,0,0
 db 0,0,0,0,0,0,0,0,8,8,8,8,0,0,8,8
 db 0,0,0,0,0,0,0,0,8,8,8,8,8,8,0,0
 db 0,0,0,0,0,0,0,0,8,8,8,8,8,8,8,8
 db 0,0,0,0,0,0,8,8,0,0,0,0,0,0,0,0
 db 0,0,0,0,0,0,8,8,0,0,0,0,0,0,8,8
 db 0,0,0,0,0,0,8,8,0,0,0,0,8,8,0,0
 db 0,0,0,0,0,0,8,8,0,0,0,0,8,8,8,8
 db 0,0,0,0,0,0,8,8,0,0,8,8,0,0,0,0
 db 0,0,0,0,0,0,8,8,0,0,8,8,0,0,8,8
 db 0,0,0,0,0,0,8,8,0,0,8,8,8,8,0,0
 db 0,0,0,0,0,0,8,8,0,0,8,8,8,8,8,8
 db 0,0,0,0,0,0,8,8,8,8,0,0,0,0,0,0
 db 0,0,0,0,0,0,8,8,8,8,0,0,0,0,8,8
 db 0,0,0,0,0,0,8,8,8,8,0,0,8,8,0,0
 db 0,0,0,0,0,0,8,8,8,8,0,0,8,8,8,8
 db 0,0,0,0,0,0,8,8,8,8,8,8,0,0,0,0
 db 0,0,0,0,0,0,8,8,8,8,8,8,0,0,8,8
 db 0,0,0,0,0,0,8,8,8,8,8,8,8,8,0,0
 db 0,0,0,0,0,0,8,8,8,8,8,8,8,8,8,8
 db 0,0,0,0,8,8,0,0,0,0,0,0,0,0,0,0
 db 0,0,0,0,8,8,0,0,0,0,0,0,0,0,8,8
 db 0,0,0,0,8,8,0,0,0,0,0,0,8,8,0,0
 db 0,0,0,0,8,8,0,0,0,0,0,0,8,8,8,8
 db 0,0,0,0,8,8,0,0,0,0,8,8,0,0,0,0
 db 0,0,0,0,8,8,0,0,0,0,8,8,0,0,8,8
 db 0,0,0,0,8,8,0,0,0,0,8,8,8,8,0,0
 db 0,0,0,0,8,8,0,0,0,0,8,8,8,8,8,8
 db 0,0,0,0,8,8,0,0,8,8,0,0,0,0,0,0
 db 0,0,0,0,8,8,0,0,8,8,0,0,0,0,8,8
 db 0,0,0,0,8,8,0,0,8,8,0,0,8,8,0,0
 db 0,0,0,0,8,8,0,0,8,8,0,0,8,8,8,8
 db 0,0,0,0,8,8,0,0,8,8,8,8,0,0,0,0
 db 0,0,0,0,8,8,0,0,8,8,8,8,0,0,8,8
 db 0,0,0,0,8,8,0,0,8,8,8,8,8,8,0,0
 db 0,0,0,0,8,8,0,0,8,8,8,8,8,8,8,8
 db 0,0,0,0,8,8,8,8,0,0,0,0,0,0,0,0
 db 0,0,0,0,8,8,8,8,0,0,0,0,0,0,8,8
 db 0,0,0,0,8,8,8,8,0,0,0,0,8,8,0,0
 db 0,0,0,0,8,8,8,8,0,0,0,0,8,8,8,8
 db 0,0,0,0,8,8,8,8,0,0,8,8,0,0,0,0
 db 0,0,0,0,8,8,8,8,0,0,8,8,0,0,8,8
 db 0,0,0,0,8,8,8,8,0,0,8,8,8,8,0,0
 db 0,0,0,0,8,8,8,8,0,0,8,8,8,8,8,8
 db 0,0,0,0,8,8,8,8,8,8,0,0,0,0,0,0
 db 0,0,0,0,8,8,8,8,8,8,0,0,0,0,8,8
 db 0,0,0,0,8,8,8,8,8,8,0,0,8,8,0,0
 db 0,0,0,0,8,8,8,8,8,8,0,0,8,8,8,8
 db 0,0,0,0,8,8,8,8,8,8,8,8,0,0,0,0
 db 0,0,0,0,8,8,8,8,8,8,8,8,0,0,8,8
 db 0,0,0,0,8,8,8,8,8,8,8,8,8,8,0,0
 db 0,0,0,0,8,8,8,8,8,8,8,8,8,8,8,8
 db 0,0,8,8,0,0,0,0,0,0,0,0,0,0,0,0
 db 0,0,8,8,0,0,0,0,0,0,0,0,0,0,8,8
 db 0,0,8,8,0,0,0,0,0,0,0,0,8,8,0,0
 db 0,0,8,8,0,0,0,0,0,0,0,0,8,8,8,8
 db 0,0,8,8,0,0,0,0,0,0,8,8,0,0,0,0
 db 0,0,8,8,0,0,0,0,0,0,8,8,0,0,8,8
 db 0,0,8,8,0,0,0,0,0,0,8,8,8,8,0,0
 db 0,0,8,8,0,0,0,0,0,0,8,8,8,8,8,8
 db 0,0,8,8,0,0,0,0,8,8,0,0,0,0,0,0
 db 0,0,8,8,0,0,0,0,8,8,0,0,0,0,8,8
 db 0,0,8,8,0,0,0,0,8,8,0,0,8,8,0,0
 db 0,0,8,8,0,0,0,0,8,8,0,0,8,8,8,8
 db 0,0,8,8,0,0,0,0,8,8,8,8,0,0,0,0
 db 0,0,8,8,0,0,0,0,8,8,8,8,0,0,8,8
 db 0,0,8,8,0,0,0,0,8,8,8,8,8,8,0,0
 db 0,0,8,8,0,0,0,0,8,8,8,8,8,8,8,8
 db 0,0,8,8,0,0,8,8,0,0,0,0,0,0,0,0
 db 0,0,8,8,0,0,8,8,0,0,0,0,0,0,8,8
 db 0,0,8,8,0,0,8,8,0,0,0,0,8,8,0,0
 db 0,0,8,8,0,0,8,8,0,0,0,0,8,8,8,8
 db 0,0,8,8,0,0,8,8,0,0,8,8,0,0,0,0
 db 0,0,8,8,0,0,8,8,0,0,8,8,0,0,8,8
 db 0,0,8,8,0,0,8,8,0,0,8,8,8,8,0,0
 db 0,0,8,8,0,0,8,8,0,0,8,8,8,8,8,8
 db 0,0,8,8,0,0,8,8,8,8,0,0,0,0,0,0
 db 0,0,8,8,0,0,8,8,8,8,0,0,0,0,8,8
 db 0,0,8,8,0,0,8,8,8,8,0,0,8,8,0,0
 db 0,0,8,8,0,0,8,8,8,8,0,0,8,8,8,8
 db 0,0,8,8,0,0,8,8,8,8,8,8,0,0,0,0
 db 0,0,8,8,0,0,8,8,8,8,8,8,0,0,8,8
 db 0,0,8,8,0,0,8,8,8,8,8,8,8,8,0,0
 db 0,0,8,8,0,0,8,8,8,8,8,8,8,8,8,8
 db 0,0,8,8,8,8,0,0,0,0,0,0,0,0,0,0
 db 0,0,8,8,8,8,0,0,0,0,0,0,0,0,8,8
 db 0,0,8,8,8,8,0,0,0,0,0,0,8,8,0,0
 db 0,0,8,8,8,8,0,0,0,0,0,0,8,8,8,8
 db 0,0,8,8,8,8,0,0,0,0,8,8,0,0,0,0
 db 0,0,8,8,8,8,0,0,0,0,8,8,0,0,8,8
 db 0,0,8,8,8,8,0,0,0,0,8,8,8,8,0,0
 db 0,0,8,8,8,8,0,0,0,0,8,8,8,8,8,8
 db 0,0,8,8,8,8,0,0,8,8,0,0,0,0,0,0
 db 0,0,8,8,8,8,0,0,8,8,0,0,0,0,8,8
 db 0,0,8,8,8,8,0,0,8,8,0,0,8,8,0,0
 db 0,0,8,8,8,8,0,0,8,8,0,0,8,8,8,8
 db 0,0,8,8,8,8,0,0,8,8,8,8,0,0,0,0
 db 0,0,8,8,8,8,0,0,8,8,8,8,0,0,8,8
 db 0,0,8,8,8,8,0,0,8,8,8,8,8,8,0,0
 db 0,0,8,8,8,8,0,0,8,8,8,8,8,8,8,8
 db 0,0,8,8,8,8,8,8,0,0,0,0,0,0,0,0
 db 0,0,8,8,8,8,8,8,0,0,0,0,0,0,8,8
 db 0,0,8,8,8,8,8,8,0,0,0,0,8,8,0,0
 db 0,0,8,8,8,8,8,8,0,0,0,0,8,8,8,8
 db 0,0,8,8,8,8,8,8,0,0,8,8,0,0,0,0
 db 0,0,8,8,8,8,8,8,0,0,8,8,0,0,8,8
 db 0,0,8,8,8,8,8,8,0,0,8,8,8,8,0,0
 db 0,0,8,8,8,8,8,8,0,0,8,8,8,8,8,8
 db 0,0,8,8,8,8,8,8,8,8,0,0,0,0,0,0
 db 0,0,8,8,8,8,8,8,8,8,0,0,0,0,8,8
 db 0,0,8,8,8,8,8,8,8,8,0,0,8,8,0,0
 db 0,0,8,8,8,8,8,8,8,8,0,0,8,8,8,8
 db 0,0,8,8,8,8,8,8,8,8,8,8,0,0,0,0
 db 0,0,8,8,8,8,8,8,8,8,8,8,0,0,8,8
 db 0,0,8,8,8,8,8,8,8,8,8,8,8,8,0,0
 db 0,0,8,8,8,8,8,8,8,8,8,8,8,8,8,8
 db 8,8,0,0,0,0,0,0,0,0,0,0,0,0,0,0
 db 8,8,0,0,0,0,0,0,0,0,0,0,0,0,8,8
 db 8,8,0,0,0,0,0,0,0,0,0,0,8,8,0,0
 db 8,8,0,0,0,0,0,0,0,0,0,0,8,8,8,8
 db 8,8,0,0,0,0,0,0,0,0,8,8,0,0,0,0
 db 8,8,0,0,0,0,0,0,0,0,8,8,0,0,8,8
 db 8,8,0,0,0,0,0,0,0,0,8,8,8,8,0,0
 db 8,8,0,0,0,0,0,0,0,0,8,8,8,8,8,8
 db 8,8,0,0,0,0,0,0,8,8,0,0,0,0,0,0
 db 8,8,0,0,0,0,0,0,8,8,0,0,0,0,8,8
 db 8,8,0,0,0,0,0,0,8,8,0,0,8,8,0,0
 db 8,8,0,0,0,0,0,0,8,8,0,0,8,8,8,8
 db 8,8,0,0,0,0,0,0,8,8,8,8,0,0,0,0
 db 8,8,0,0,0,0,0,0,8,8,8,8,0,0,8,8
 db 8,8,0,0,0,0,0,0,8,8,8,8,8,8,0,0
 db 8,8,0,0,0,0,0,0,8,8,8,8,8,8,8,8
 db 8,8,0,0,0,0,8,8,0,0,0,0,0,0,0,0
 db 8,8,0,0,0,0,8,8,0,0,0,0,0,0,8,8
 db 8,8,0,0,0,0,8,8,0,0,0,0,8,8,0,0
 db 8,8,0,0,0,0,8,8,0,0,0,0,8,8,8,8
 db 8,8,0,0,0,0,8,8,0,0,8,8,0,0,0,0
 db 8,8,0,0,0,0,8,8,0,0,8,8,0,0,8,8
 db 8,8,0,0,0,0,8,8,0,0,8,8,8,8,0,0
 db 8,8,0,0,0,0,8,8,0,0,8,8,8,8,8,8
 db 8,8,0,0,0,0,8,8,8,8,0,0,0,0,0,0
 db 8,8,0,0,0,0,8,8,8,8,0,0,0,0,8,8
 db 8,8,0,0,0,0,8,8,8,8,0,0,8,8,0,0
 db 8,8,0,0,0,0,8,8,8,8,0,0,8,8,8,8
 db 8,8,0,0,0,0,8,8,8,8,8,8,0,0,0,0
 db 8,8,0,0,0,0,8,8,8,8,8,8,0,0,8,8
 db 8,8,0,0,0,0,8,8,8,8,8,8,8,8,0,0
 db 8,8,0,0,0,0,8,8,8,8,8,8,8,8,8,8
 db 8,8,0,0,8,8,0,0,0,0,0,0,0,0,0,0
 db 8,8,0,0,8,8,0,0,0,0,0,0,0,0,8,8
 db 8,8,0,0,8,8,0,0,0,0,0,0,8,8,0,0
 db 8,8,0,0,8,8,0,0,0,0,0,0,8,8,8,8
 db 8,8,0,0,8,8,0,0,0,0,8,8,0,0,0,0
 db 8,8,0,0,8,8,0,0,0,0,8,8,0,0,8,8
 db 8,8,0,0,8,8,0,0,0,0,8,8,8,8,0,0
 db 8,8,0,0,8,8,0,0,0,0,8,8,8,8,8,8
 db 8,8,0,0,8,8,0,0,8,8,0,0,0,0,0,0
 db 8,8,0,0,8,8,0,0,8,8,0,0,0,0,8,8
 db 8,8,0,0,8,8,0,0,8,8,0,0,8,8,0,0
 db 8,8,0,0,8,8,0,0,8,8,0,0,8,8,8,8
 db 8,8,0,0,8,8,0,0,8,8,8,8,0,0,0,0
 db 8,8,0,0,8,8,0,0,8,8,8,8,0,0,8,8
 db 8,8,0,0,8,8,0,0,8,8,8,8,8,8,0,0
 db 8,8,0,0,8,8,0,0,8,8,8,8,8,8,8,8
 db 8,8,0,0,8,8,8,8,0,0,0,0,0,0,0,0
 db 8,8,0,0,8,8,8,8,0,0,0,0,0,0,8,8
 db 8,8,0,0,8,8,8,8,0,0,0,0,8,8,0,0
 db 8,8,0,0,8,8,8,8,0,0,0,0,8,8,8,8
 db 8,8,0,0,8,8,8,8,0,0,8,8,0,0,0,0
 db 8,8,0,0,8,8,8,8,0,0,8,8,0,0,8,8
 db 8,8,0,0,8,8,8,8,0,0,8,8,8,8,0,0
 db 8,8,0,0,8,8,8,8,0,0,8,8,8,8,8,8
 db 8,8,0,0,8,8,8,8,8,8,0,0,0,0,0,0
 db 8,8,0,0,8,8,8,8,8,8,0,0,0,0,8,8
 db 8,8,0,0,8,8,8,8,8,8,0,0,8,8,0,0
 db 8,8,0,0,8,8,8,8,8,8,0,0,8,8,8,8
 db 8,8,0,0,8,8,8,8,8,8,8,8,0,0,0,0
 db 8,8,0,0,8,8,8,8,8,8,8,8,0,0,8,8
 db 8,8,0,0,8,8,8,8,8,8,8,8,8,8,0,0
 db 8,8,0,0,8,8,8,8,8,8,8,8,8,8,8,8
 db 8,8,8,8,0,0,0,0,0,0,0,0,0,0,0,0
 db 8,8,8,8,0,0,0,0,0,0,0,0,0,0,8,8
 db 8,8,8,8,0,0,0,0,0,0,0,0,8,8,0,0
 db 8,8,8,8,0,0,0,0,0,0,0,0,8,8,8,8
 db 8,8,8,8,0,0,0,0,0,0,8,8,0,0,0,0
 db 8,8,8,8,0,0,0,0,0,0,8,8,0,0,8,8
 db 8,8,8,8,0,0,0,0,0,0,8,8,8,8,0,0
 db 8,8,8,8,0,0,0,0,0,0,8,8,8,8,8,8
 db 8,8,8,8,0,0,0,0,8,8,0,0,0,0,0,0
 db 8,8,8,8,0,0,0,0,8,8,0,0,0,0,8,8
 db 8,8,8,8,0,0,0,0,8,8,0,0,8,8,0,0
 db 8,8,8,8,0,0,0,0,8,8,0,0,8,8,8,8
 db 8,8,8,8,0,0,0,0,8,8,8,8,0,0,0,0
 db 8,8,8,8,0,0,0,0,8,8,8,8,0,0,8,8
 db 8,8,8,8,0,0,0,0,8,8,8,8,8,8,0,0
 db 8,8,8,8,0,0,0,0,8,8,8,8,8,8,8,8
 db 8,8,8,8,0,0,8,8,0,0,0,0,0,0,0,0
 db 8,8,8,8,0,0,8,8,0,0,0,0,0,0,8,8
 db 8,8,8,8,0,0,8,8,0,0,0,0,8,8,0,0
 db 8,8,8,8,0,0,8,8,0,0,0,0,8,8,8,8
 db 8,8,8,8,0,0,8,8,0,0,8,8,0,0,0,0
 db 8,8,8,8,0,0,8,8,0,0,8,8,0,0,8,8
 db 8,8,8,8,0,0,8,8,0,0,8,8,8,8,0,0
 db 8,8,8,8,0,0,8,8,0,0,8,8,8,8,8,8
 db 8,8,8,8,0,0,8,8,8,8,0,0,0,0,0,0
 db 8,8,8,8,0,0,8,8,8,8,0,0,0,0,8,8
 db 8,8,8,8,0,0,8,8,8,8,0,0,8,8,0,0
 db 8,8,8,8,0,0,8,8,8,8,0,0,8,8,8,8
 db 8,8,8,8,0,0,8,8,8,8,8,8,0,0,0,0
 db 8,8,8,8,0,0,8,8,8,8,8,8,0,0,8,8
 db 8,8,8,8,0,0,8,8,8,8,8,8,8,8,0,0
 db 8,8,8,8,0,0,8,8,8,8,8,8,8,8,8,8
 db 8,8,8,8,8,8,0,0,0,0,0,0,0,0,0,0
 db 8,8,8,8,8,8,0,0,0,0,0,0,0,0,8,8
 db 8,8,8,8,8,8,0,0,0,0,0,0,8,8,0,0
 db 8,8,8,8,8,8,0,0,0,0,0,0,8,8,8,8
 db 8,8,8,8,8,8,0,0,0,0,8,8,0,0,0,0
 db 8,8,8,8,8,8,0,0,0,0,8,8,0,0,8,8
 db 8,8,8,8,8,8,0,0,0,0,8,8,8,8,0,0
 db 8,8,8,8,8,8,0,0,0,0,8,8,8,8,8,8
 db 8,8,8,8,8,8,0,0,8,8,0,0,0,0,0,0
 db 8,8,8,8,8,8,0,0,8,8,0,0,0,0,8,8
 db 8,8,8,8,8,8,0,0,8,8,0,0,8,8,0,0
 db 8,8,8,8,8,8,0,0,8,8,0,0,8,8,8,8
 db 8,8,8,8,8,8,0,0,8,8,8,8,0,0,0,0
 db 8,8,8,8,8,8,0,0,8,8,8,8,0,0,8,8
 db 8,8,8,8,8,8,0,0,8,8,8,8,8,8,0,0
 db 8,8,8,8,8,8,0,0,8,8,8,8,8,8,8,8
 db 8,8,8,8,8,8,8,8,0,0,0,0,0,0,0,0
 db 8,8,8,8,8,8,8,8,0,0,0,0,0,0,8,8
 db 8,8,8,8,8,8,8,8,0,0,0,0,8,8,0,0
 db 8,8,8,8,8,8,8,8,0,0,0,0,8,8,8,8
 db 8,8,8,8,8,8,8,8,0,0,8,8,0,0,0,0
 db 8,8,8,8,8,8,8,8,0,0,8,8,0,0,8,8
 db 8,8,8,8,8,8,8,8,0,0,8,8,8,8,0,0
 db 8,8,8,8,8,8,8,8,0,0,8,8,8,8,8,8
 db 8,8,8,8,8,8,8,8,8,8,0,0,0,0,0,0
 db 8,8,8,8,8,8,8,8,8,8,0,0,0,0,8,8
 db 8,8,8,8,8,8,8,8,8,8,0,0,8,8,0,0
 db 8,8,8,8,8,8,8,8,8,8,0,0,8,8,8,8
 db 8,8,8,8,8,8,8,8,8,8,8,8,0,0,0,0
 db 8,8,8,8,8,8,8,8,8,8,8,8,0,0,8,8
 db 8,8,8,8,8,8,8,8,8,8,8,8,8,8,0,0
 db 8,8,8,8,8,8,8,8,8,8,8,8,8,8,8,8
 db 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
 db 0,0,0,0,0,0,0,0,0,0,0,0,0,0,16,16
 db 0,0,0,0,0,0,0,0,0,0,0,0,16,16,0,0
 db 0,0,0,0,0,0,0,0,0,0,0,0,16,16,16,16
 db 0,0,0,0,0,0,0,0,0,0,16,16,0,0,0,0
 db 0,0,0,0,0,0,0,0,0,0,16,16,0,0,16,16
 db 0,0,0,0,0,0,0,0,0,0,16,16,16,16,0,0
 db 0,0,0,0,0,0,0,0,0,0,16,16,16,16,16,16
 db 0,0,0,0,0,0,0,0,16,16,0,0,0,0,0,0
 db 0,0,0,0,0,0,0,0,16,16,0,0,0,0,16,16
 db 0,0,0,0,0,0,0,0,16,16,0,0,16,16,0,0
 db 0,0,0,0,0,0,0,0,16,16,0,0,16,16,16,16
 db 0,0,0,0,0,0,0,0,16,16,16,16,0,0,0,0
 db 0,0,0,0,0,0,0,0,16,16,16,16,0,0,16,16
 db 0,0,0,0,0,0,0,0,16,16,16,16,16,16,0,0
 db 0,0,0,0,0,0,0,0,16,16,16,16,16,16,16,16
 db 0,0,0,0,0,0,16,16,0,0,0,0,0,0,0,0
 db 0,0,0,0,0,0,16,16,0,0,0,0,0,0,16,16
 db 0,0,0,0,0,0,16,16,0,0,0,0,16,16,0,0
 db 0,0,0,0,0,0,16,16,0,0,0,0,16,16,16,16
 db 0,0,0,0,0,0,16,16,0,0,16,16,0,0,0,0
 db 0,0,0,0,0,0,16,16,0,0,16,16,0,0,16,16
 db 0,0,0,0,0,0,16,16,0,0,16,16,16,16,0,0
 db 0,0,0,0,0,0,16,16,0,0,16,16,16,16,16,16
 db 0,0,0,0,0,0,16,16,16,16,0,0,0,0,0,0
 db 0,0,0,0,0,0,16,16,16,16,0,0,0,0,16,16
 db 0,0,0,0,0,0,16,16,16,16,0,0,16,16,0,0
 db 0,0,0,0,0,0,16,16,16,16,0,0,16,16,16,16
 db 0,0,0,0,0,0,16,16,16,16,16,16,0,0,0,0
 db 0,0,0,0,0,0,16,16,16,16,16,16,0,0,16,16
 db 0,0,0,0,0,0,16,16,16,16,16,16,16,16,0,0
 db 0,0,0,0,0,0,16,16,16,16,16,16,16,16,16,16
 db 0,0,0,0,16,16,0,0,0,0,0,0,0,0,0,0
 db 0,0,0,0,16,16,0,0,0,0,0,0,0,0,16,16
 db 0,0,0,0,16,16,0,0,0,0,0,0,16,16,0,0
 db 0,0,0,0,16,16,0,0,0,0,0,0,16,16,16,16
 db 0,0,0,0,16,16,0,0,0,0,16,16,0,0,0,0
 db 0,0,0,0,16,16,0,0,0,0,16,16,0,0,16,16
 db 0,0,0,0,16,16,0,0,0,0,16,16,16,16,0,0
 db 0,0,0,0,16,16,0,0,0,0,16,16,16,16,16,16
 db 0,0,0,0,16,16,0,0,16,16,0,0,0,0,0,0
 db 0,0,0,0,16,16,0,0,16,16,0,0,0,0,16,16
 db 0,0,0,0,16,16,0,0,16,16,0,0,16,16,0,0
 db 0,0,0,0,16,16,0,0,16,16,0,0,16,16,16,16
 db 0,0,0,0,16,16,0,0,16,16,16,16,0,0,0,0
 db 0,0,0,0,16,16,0,0,16,16,16,16,0,0,16,16
 db 0,0,0,0,16,16,0,0,16,16,16,16,16,16,0,0
 db 0,0,0,0,16,16,0,0,16,16,16,16,16,16,16,16
 db 0,0,0,0,16,16,16,16,0,0,0,0,0,0,0,0
 db 0,0,0,0,16,16,16,16,0,0,0,0,0,0,16,16
 db 0,0,0,0,16,16,16,16,0,0,0,0,16,16,0,0
 db 0,0,0,0,16,16,16,16,0,0,0,0,16,16,16,16
 db 0,0,0,0,16,16,16,16,0,0,16,16,0,0,0,0
 db 0,0,0,0,16,16,16,16,0,0,16,16,0,0,16,16
 db 0,0,0,0,16,16,16,16,0,0,16,16,16,16,0,0
 db 0,0,0,0,16,16,16,16,0,0,16,16,16,16,16,16
 db 0,0,0,0,16,16,16,16,16,16,0,0,0,0,0,0
 db 0,0,0,0,16,16,16,16,16,16,0,0,0,0,16,16
 db 0,0,0,0,16,16,16,16,16,16,0,0,16,16,0,0
 db 0,0,0,0,16,16,16,16,16,16,0,0,16,16,16,16
 db 0,0,0,0,16,16,16,16,16,16,16,16,0,0,0,0
 db 0,0,0,0,16,16,16,16,16,16,16,16,0,0,16,16
 db 0,0,0,0,16,16,16,16,16,16,16,16,16,16,0,0
 db 0,0,0,0,16,16,16,16,16,16,16,16,16,16,16,16
 db 0,0,16,16,0,0,0,0,0,0,0,0,0,0,0,0
 db 0,0,16,16,0,0,0,0,0,0,0,0,0,0,16,16
 db 0,0,16,16,0,0,0,0,0,0,0,0,16,16,0,0
 db 0,0,16,16,0,0,0,0,0,0,0,0,16,16,16,16
 db 0,0,16,16,0,0,0,0,0,0,16,16,0,0,0,0
 db 0,0,16,16,0,0,0,0,0,0,16,16,0,0,16,16
 db 0,0,16,16,0,0,0,0,0,0,16,16,16,16,0,0
 db 0,0,16,16,0,0,0,0,0,0,16,16,16,16,16,16
 db 0,0,16,16,0,0,0,0,16,16,0,0,0,0,0,0
 db 0,0,16,16,0,0,0,0,16,16,0,0,0,0,16,16
 db 0,0,16,16,0,0,0,0,16,16,0,0,16,16,0,0
 db 0,0,16,16,0,0,0,0,16,16,0,0,16,16,16,16
 db 0,0,16,16,0,0,0,0,16,16,16,16,0,0,0,0
 db 0,0,16,16,0,0,0,0,16,16,16,16,0,0,16,16
 db 0,0,16,16,0,0,0,0,16,16,16,16,16,16,0,0
 db 0,0,16,16,0,0,0,0,16,16,16,16,16,16,16,16
 db 0,0,16,16,0,0,16,16,0,0,0,0,0,0,0,0
 db 0,0,16,16,0,0,16,16,0,0,0,0,0,0,16,16
 db 0,0,16,16,0,0,16,16,0,0,0,0,16,16,0,0
 db 0,0,16,16,0,0,16,16,0,0,0,0,16,16,16,16
 db 0,0,16,16,0,0,16,16,0,0,16,16,0,0,0,0
 db 0,0,16,16,0,0,16,16,0,0,16,16,0,0,16,16
 db 0,0,16,16,0,0,16,16,0,0,16,16,16,16,0,0
 db 0,0,16,16,0,0,16,16,0,0,16,16,16,16,16,16
 db 0,0,16,16,0,0,16,16,16,16,0,0,0,0,0,0
 db 0,0,16,16,0,0,16,16,16,16,0,0,0,0,16,16
 db 0,0,16,16,0,0,16,16,16,16,0,0,16,16,0,0
 db 0,0,16,16,0,0,16,16,16,16,0,0,16,16,16,16
 db 0,0,16,16,0,0,16,16,16,16,16,16,0,0,0,0
 db 0,0,16,16,0,0,16,16,16,16,16,16,0,0,16,16
 db 0,0,16,16,0,0,16,16,16,16,16,16,16,16,0,0
 db 0,0,16,16,0,0,16,16,16,16,16,16,16,16,16,16
 db 0,0,16,16,16,16,0,0,0,0,0,0,0,0,0,0
 db 0,0,16,16,16,16,0,0,0,0,0,0,0,0,16,16
 db 0,0,16,16,16,16,0,0,0,0,0,0,16,16,0,0
 db 0,0,16,16,16,16,0,0,0,0,0,0,16,16,16,16
 db 0,0,16,16,16,16,0,0,0,0,16,16,0,0,0,0
 db 0,0,16,16,16,16,0,0,0,0,16,16,0,0,16,16
 db 0,0,16,16,16,16,0,0,0,0,16,16,16,16,0,0
 db 0,0,16,16,16,16,0,0,0,0,16,16,16,16,16,16
 db 0,0,16,16,16,16,0,0,16,16,0,0,0,0,0,0
 db 0,0,16,16,16,16,0,0,16,16,0,0,0,0,16,16
 db 0,0,16,16,16,16,0,0,16,16,0,0,16,16,0,0
 db 0,0,16,16,16,16,0,0,16,16,0,0,16,16,16,16
 db 0,0,16,16,16,16,0,0,16,16,16,16,0,0,0,0
 db 0,0,16,16,16,16,0,0,16,16,16,16,0,0,16,16
 db 0,0,16,16,16,16,0,0,16,16,16,16,16,16,0,0
 db 0,0,16,16,16,16,0,0,16,16,16,16,16,16,16,16
 db 0,0,16,16,16,16,16,16,0,0,0,0,0,0,0,0
 db 0,0,16,16,16,16,16,16,0,0,0,0,0,0,16,16
 db 0,0,16,16,16,16,16,16,0,0,0,0,16,16,0,0
 db 0,0,16,16,16,16,16,16,0,0,0,0,16,16,16,16
 db 0,0,16,16,16,16,16,16,0,0,16,16,0,0,0,0
 db 0,0,16,16,16,16,16,16,0,0,16,16,0,0,16,16
 db 0,0,16,16,16,16,16,16,0,0,16,16,16,16,0,0
 db 0,0,16,16,16,16,16,16,0,0,16,16,16,16,16,16
 db 0,0,16,16,16,16,16,16,16,16,0,0,0,0,0,0
 db 0,0,16,16,16,16,16,16,16,16,0,0,0,0,16,16
 db 0,0,16,16,16,16,16,16,16,16,0,0,16,16,0,0
 db 0,0,16,16,16,16,16,16,16,16,0,0,16,16,16,16
 db 0,0,16,16,16,16,16,16,16,16,16,16,0,0,0,0
 db 0,0,16,16,16,16,16,16,16,16,16,16,0,0,16,16
 db 0,0,16,16,16,16,16,16,16,16,16,16,16,16,0,0
 db 0,0,16,16,16,16,16,16,16,16,16,16,16,16,16,16
 db 16,16,0,0,0,0,0,0,0,0,0,0,0,0,0,0
 db 16,16,0,0,0,0,0,0,0,0,0,0,0,0,16,16
 db 16,16,0,0,0,0,0,0,0,0,0,0,16,16,0,0
 db 16,16,0,0,0,0,0,0,0,0,0,0,16,16,16,16
 db 16,16,0,0,0,0,0,0,0,0,16,16,0,0,0,0
 db 16,16,0,0,0,0,0,0,0,0,16,16,0,0,16,16
 db 16,16,0,0,0,0,0,0,0,0,16,16,16,16,0,0
 db 16,16,0,0,0,0,0,0,0,0,16,16,16,16,16,16
 db 16,16,0,0,0,0,0,0,16,16,0,0,0,0,0,0
 db 16,16,0,0,0,0,0,0,16,16,0,0,0,0,16,16
 db 16,16,0,0,0,0,0,0,16,16,0,0,16,16,0,0
 db 16,16,0,0,0,0,0,0,16,16,0,0,16,16,16,16
 db 16,16,0,0,0,0,0,0,16,16,16,16,0,0,0,0
 db 16,16,0,0,0,0,0,0,16,16,16,16,0,0,16,16
 db 16,16,0,0,0,0,0,0,16,16,16,16,16,16,0,0
 db 16,16,0,0,0,0,0,0,16,16,16,16,16,16,16,16
 db 16,16,0,0,0,0,16,16,0,0,0,0,0,0,0,0
 db 16,16,0,0,0,0,16,16,0,0,0,0,0,0,16,16
 db 16,16,0,0,0,0,16,16,0,0,0,0,16,16,0,0
 db 16,16,0,0,0,0,16,16,0,0,0,0,16,16,16,16
 db 16,16,0,0,0,0,16,16,0,0,16,16,0,0,0,0
 db 16,16,0,0,0,0,16,16,0,0,16,16,0,0,16,16
 db 16,16,0,0,0,0,16,16,0,0,16,16,16,16,0,0
 db 16,16,0,0,0,0,16,16,0,0,16,16,16,16,16,16
 db 16,16,0,0,0,0,16,16,16,16,0,0,0,0,0,0
 db 16,16,0,0,0,0,16,16,16,16,0,0,0,0,16,16
 db 16,16,0,0,0,0,16,16,16,16,0,0,16,16,0,0
 db 16,16,0,0,0,0,16,16,16,16,0,0,16,16,16,16
 db 16,16,0,0,0,0,16,16,16,16,16,16,0,0,0,0
 db 16,16,0,0,0,0,16,16,16,16,16,16,0,0,16,16
 db 16,16,0,0,0,0,16,16,16,16,16,16,16,16,0,0
 db 16,16,0,0,0,0,16,16,16,16,16,16,16,16,16,16
 db 16,16,0,0,16,16,0,0,0,0,0,0,0,0,0,0
 db 16,16,0,0,16,16,0,0,0,0,0,0,0,0,16,16
 db 16,16,0,0,16,16,0,0,0,0,0,0,16,16,0,0
 db 16,16,0,0,16,16,0,0,0,0,0,0,16,16,16,16
 db 16,16,0,0,16,16,0,0,0,0,16,16,0,0,0,0
 db 16,16,0,0,16,16,0,0,0,0,16,16,0,0,16,16
 db 16,16,0,0,16,16,0,0,0,0,16,16,16,16,0,0
 db 16,16,0,0,16,16,0,0,0,0,16,16,16,16,16,16
 db 16,16,0,0,16,16,0,0,16,16,0,0,0,0,0,0
 db 16,16,0,0,16,16,0,0,16,16,0,0,0,0,16,16
 db 16,16,0,0,16,16,0,0,16,16,0,0,16,16,0,0
 db 16,16,0,0,16,16,0,0,16,16,0,0,16,16,16,16
 db 16,16,0,0,16,16,0,0,16,16,16,16,0,0,0,0
 db 16,16,0,0,16,16,0,0,16,16,16,16,0,0,16,16
 db 16,16,0,0,16,16,0,0,16,16,16,16,16,16,0,0
 db 16,16,0,0,16,16,0,0,16,16,16,16,16,16,16,16
 db 16,16,0,0,16,16,16,16,0,0,0,0,0,0,0,0
 db 16,16,0,0,16,16,16,16,0,0,0,0,0,0,16,16
 db 16,16,0,0,16,16,16,16,0,0,0,0,16,16,0,0
 db 16,16,0,0,16,16,16,16,0,0,0,0,16,16,16,16
 db 16,16,0,0,16,16,16,16,0,0,16,16,0,0,0,0
 db 16,16,0,0,16,16,16,16,0,0,16,16,0,0,16,16
 db 16,16,0,0,16,16,16,16,0,0,16,16,16,16,0,0
 db 16,16,0,0,16,16,16,16,0,0,16,16,16,16,16,16
 db 16,16,0,0,16,16,16,16,16,16,0,0,0,0,0,0
 db 16,16,0,0,16,16,16,16,16,16,0,0,0,0,16,16
 db 16,16,0,0,16,16,16,16,16,16,0,0,16,16,0,0
 db 16,16,0,0,16,16,16,16,16,16,0,0,16,16,16,16
 db 16,16,0,0,16,16,16,16,16,16,16,16,0,0,0,0
 db 16,16,0,0,16,16,16,16,16,16,16,16,0,0,16,16
 db 16,16,0,0,16,16,16,16,16,16,16,16,16,16,0,0
 db 16,16,0,0,16,16,16,16,16,16,16,16,16,16,16,16
 db 16,16,16,16,0,0,0,0,0,0,0,0,0,0,0,0
 db 16,16,16,16,0,0,0,0,0,0,0,0,0,0,16,16
 db 16,16,16,16,0,0,0,0,0,0,0,0,16,16,0,0
 db 16,16,16,16,0,0,0,0,0,0,0,0,16,16,16,16
 db 16,16,16,16,0,0,0,0,0,0,16,16,0,0,0,0
 db 16,16,16,16,0,0,0,0,0,0,16,16,0,0,16,16
 db 16,16,16,16,0,0,0,0,0,0,16,16,16,16,0,0
 db 16,16,16,16,0,0,0,0,0,0,16,16,16,16,16,16
 db 16,16,16,16,0,0,0,0,16,16,0,0,0,0,0,0
 db 16,16,16,16,0,0,0,0,16,16,0,0,0,0,16,16
 db 16,16,16,16,0,0,0,0,16,16,0,0,16,16,0,0
 db 16,16,16,16,0,0,0,0,16,16,0,0,16,16,16,16
 db 16,16,16,16,0,0,0,0,16,16,16,16,0,0,0,0
 db 16,16,16,16,0,0,0,0,16,16,16,16,0,0,16,16
 db 16,16,16,16,0,0,0,0,16,16,16,16,16,16,0,0
 db 16,16,16,16,0,0,0,0,16,16,16,16,16,16,16,16
 db 16,16,16,16,0,0,16,16,0,0,0,0,0,0,0,0
 db 16,16,16,16,0,0,16,16,0,0,0,0,0,0,16,16
 db 16,16,16,16,0,0,16,16,0,0,0,0,16,16,0,0
 db 16,16,16,16,0,0,16,16,0,0,0,0,16,16,16,16
 db 16,16,16,16,0,0,16,16,0,0,16,16,0,0,0,0
 db 16,16,16,16,0,0,16,16,0,0,16,16,0,0,16,16
 db 16,16,16,16,0,0,16,16,0,0,16,16,16,16,0,0
 db 16,16,16,16,0,0,16,16,0,0,16,16,16,16,16,16
 db 16,16,16,16,0,0,16,16,16,16,0,0,0,0,0,0
 db 16,16,16,16,0,0,16,16,16,16,0,0,0,0,16,16
 db 16,16,16,16,0,0,16,16,16,16,0,0,16,16,0,0
 db 16,16,16,16,0,0,16,16,16,16,0,0,16,16,16,16
 db 16,16,16,16,0,0,16,16,16,16,16,16,0,0,0,0
 db 16,16,16,16,0,0,16,16,16,16,16,16,0,0,16,16
 db 16,16,16,16,0,0,16,16,16,16,16,16,16,16,0,0
 db 16,16,16,16,0,0,16,16,16,16,16,16,16,16,16,16
 db 16,16,16,16,16,16,0,0,0,0,0,0,0,0,0,0
 db 16,16,16,16,16,16,0,0,0,0,0,0,0,0,16,16
 db 16,16,16,16,16,16,0,0,0,0,0,0,16,16,0,0
 db 16,16,16,16,16,16,0,0,0,0,0,0,16,16,16,16
 db 16,16,16,16,16,16,0,0,0,0,16,16,0,0,0,0
 db 16,16,16,16,16,16,0,0,0,0,16,16,0,0,16,16
 db 16,16,16,16,16,16,0,0,0,0,16,16,16,16,0,0
 db 16,16,16,16,16,16,0,0,0,0,16,16,16,16,16,16
 db 16,16,16,16,16,16,0,0,16,16,0,0,0,0,0,0
 db 16,16,16,16,16,16,0,0,16,16,0,0,0,0,16,16
 db 16,16,16,16,16,16,0,0,16,16,0,0,16,16,0,0
 db 16,16,16,16,16,16,0,0,16,16,0,0,16,16,16,16
 db 16,16,16,16,16,16,0,0,16,16,16,16,0,0,0,0
 db 16,16,16,16,16,16,0,0,16,16,16,16,0,0,16,16
 db 16,16,16,16,16,16,0,0,16,16,16,16,16,16,0,0
 db 16,16,16,16,16,16,0,0,16,16,16,16,16,16,16,16
 db 16,16,16,16,16,16,16,16,0,0,0,0,0,0,0,0
 db 16,16,16,16,16,16,16,16,0,0,0,0,0,0,16,16
 db 16,16,16,16,16,16,16,16,0,0,0,0,16,16,0,0
 db 16,16,16,16,16,16,16,16,0,0,0,0,16,16,16,16
 db 16,16,16,16,16,16,16,16,0,0,16,16,0,0,0,0
 db 16,16,16,16,16,16,16,16,0,0,16,16,0,0,16,16
 db 16,16,16,16,16,16,16,16,0,0,16,16,16,16,0,0
 db 16,16,16,16,16,16,16,16,0,0,16,16,16,16,16,16
 db 16,16,16,16,16,16,16,16,16,16,0,0,0,0,0,0
 db 16,16,16,16,16,16,16,16,16,16,0,0,0,0,16,16
 db 16,16,16,16,16,16,16,16,16,16,0,0,16,16,0,0
 db 16,16,16,16,16,16,16,16,16,16,0,0,16,16,16,16
 db 16,16,16,16,16,16,16,16,16,16,16,16,0,0,0,0
 db 16,16,16,16,16,16,16,16,16,16,16,16,0,0,16,16
 db 16,16,16,16,16,16,16,16,16,16,16,16,16,16,0,0
 db 16,16,16,16,16,16,16,16,16,16,16,16,16,16,16,16
 db 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
 db 0,0,0,0,0,0,0,0,0,0,0,0,0,0,32,32
 db 0,0,0,0,0,0,0,0,0,0,0,0,32,32,0,0
 db 0,0,0,0,0,0,0,0,0,0,0,0,32,32,32,32
 db 0,0,0,0,0,0,0,0,0,0,32,32,0,0,0,0
 db 0,0,0,0,0,0,0,0,0,0,32,32,0,0,32,32
 db 0,0,0,0,0,0,0,0,0,0,32,32,32,32,0,0
 db 0,0,0,0,0,0,0,0,0,0,32,32,32,32,32,32
 db 0,0,0,0,0,0,0,0,32,32,0,0,0,0,0,0
 db 0,0,0,0,0,0,0,0,32,32,0,0,0,0,32,32
 db 0,0,0,0,0,0,0,0,32,32,0,0,32,32,0,0
 db 0,0,0,0,0,0,0,0,32,32,0,0,32,32,32,32
 db 0,0,0,0,0,0,0,0,32,32,32,32,0,0,0,0
 db 0,0,0,0,0,0,0,0,32,32,32,32,0,0,32,32
 db 0,0,0,0,0,0,0,0,32,32,32,32,32,32,0,0
 db 0,0,0,0,0,0,0,0,32,32,32,32,32,32,32,32
 db 0,0,0,0,0,0,32,32,0,0,0,0,0,0,0,0
 db 0,0,0,0,0,0,32,32,0,0,0,0,0,0,32,32
 db 0,0,0,0,0,0,32,32,0,0,0,0,32,32,0,0
 db 0,0,0,0,0,0,32,32,0,0,0,0,32,32,32,32
 db 0,0,0,0,0,0,32,32,0,0,32,32,0,0,0,0
 db 0,0,0,0,0,0,32,32,0,0,32,32,0,0,32,32
 db 0,0,0,0,0,0,32,32,0,0,32,32,32,32,0,0
 db 0,0,0,0,0,0,32,32,0,0,32,32,32,32,32,32
 db 0,0,0,0,0,0,32,32,32,32,0,0,0,0,0,0
 db 0,0,0,0,0,0,32,32,32,32,0,0,0,0,32,32
 db 0,0,0,0,0,0,32,32,32,32,0,0,32,32,0,0
 db 0,0,0,0,0,0,32,32,32,32,0,0,32,32,32,32
 db 0,0,0,0,0,0,32,32,32,32,32,32,0,0,0,0
 db 0,0,0,0,0,0,32,32,32,32,32,32,0,0,32,32
 db 0,0,0,0,0,0,32,32,32,32,32,32,32,32,0,0
 db 0,0,0,0,0,0,32,32,32,32,32,32,32,32,32,32
 db 0,0,0,0,32,32,0,0,0,0,0,0,0,0,0,0
 db 0,0,0,0,32,32,0,0,0,0,0,0,0,0,32,32
 db 0,0,0,0,32,32,0,0,0,0,0,0,32,32,0,0
 db 0,0,0,0,32,32,0,0,0,0,0,0,32,32,32,32
 db 0,0,0,0,32,32,0,0,0,0,32,32,0,0,0,0
 db 0,0,0,0,32,32,0,0,0,0,32,32,0,0,32,32
 db 0,0,0,0,32,32,0,0,0,0,32,32,32,32,0,0
 db 0,0,0,0,32,32,0,0,0,0,32,32,32,32,32,32
 db 0,0,0,0,32,32,0,0,32,32,0,0,0,0,0,0
 db 0,0,0,0,32,32,0,0,32,32,0,0,0,0,32,32
 db 0,0,0,0,32,32,0,0,32,32,0,0,32,32,0,0
 db 0,0,0,0,32,32,0,0,32,32,0,0,32,32,32,32
 db 0,0,0,0,32,32,0,0,32,32,32,32,0,0,0,0
 db 0,0,0,0,32,32,0,0,32,32,32,32,0,0,32,32
 db 0,0,0,0,32,32,0,0,32,32,32,32,32,32,0,0
 db 0,0,0,0,32,32,0,0,32,32,32,32,32,32,32,32
 db 0,0,0,0,32,32,32,32,0,0,0,0,0,0,0,0
 db 0,0,0,0,32,32,32,32,0,0,0,0,0,0,32,32
 db 0,0,0,0,32,32,32,32,0,0,0,0,32,32,0,0
 db 0,0,0,0,32,32,32,32,0,0,0,0,32,32,32,32
 db 0,0,0,0,32,32,32,32,0,0,32,32,0,0,0,0
 db 0,0,0,0,32,32,32,32,0,0,32,32,0,0,32,32
 db 0,0,0,0,32,32,32,32,0,0,32,32,32,32,0,0
 db 0,0,0,0,32,32,32,32,0,0,32,32,32,32,32,32
 db 0,0,0,0,32,32,32,32,32,32,0,0,0,0,0,0
 db 0,0,0,0,32,32,32,32,32,32,0,0,0,0,32,32
 db 0,0,0,0,32,32,32,32,32,32,0,0,32,32,0,0
 db 0,0,0,0,32,32,32,32,32,32,0,0,32,32,32,32
 db 0,0,0,0,32,32,32,32,32,32,32,32,0,0,0,0
 db 0,0,0,0,32,32,32,32,32,32,32,32,0,0,32,32
 db 0,0,0,0,32,32,32,32,32,32,32,32,32,32,0,0
 db 0,0,0,0,32,32,32,32,32,32,32,32,32,32,32,32
 db 0,0,32,32,0,0,0,0,0,0,0,0,0,0,0,0
 db 0,0,32,32,0,0,0,0,0,0,0,0,0,0,32,32
 db 0,0,32,32,0,0,0,0,0,0,0,0,32,32,0,0
 db 0,0,32,32,0,0,0,0,0,0,0,0,32,32,32,32
 db 0,0,32,32,0,0,0,0,0,0,32,32,0,0,0,0
 db 0,0,32,32,0,0,0,0,0,0,32,32,0,0,32,32
 db 0,0,32,32,0,0,0,0,0,0,32,32,32,32,0,0
 db 0,0,32,32,0,0,0,0,0,0,32,32,32,32,32,32
 db 0,0,32,32,0,0,0,0,32,32,0,0,0,0,0,0
 db 0,0,32,32,0,0,0,0,32,32,0,0,0,0,32,32
 db 0,0,32,32,0,0,0,0,32,32,0,0,32,32,0,0
 db 0,0,32,32,0,0,0,0,32,32,0,0,32,32,32,32
 db 0,0,32,32,0,0,0,0,32,32,32,32,0,0,0,0
 db 0,0,32,32,0,0,0,0,32,32,32,32,0,0,32,32
 db 0,0,32,32,0,0,0,0,32,32,32,32,32,32,0,0
 db 0,0,32,32,0,0,0,0,32,32,32,32,32,32,32,32
 db 0,0,32,32,0,0,32,32,0,0,0,0,0,0,0,0
 db 0,0,32,32,0,0,32,32,0,0,0,0,0,0,32,32
 db 0,0,32,32,0,0,32,32,0,0,0,0,32,32,0,0
 db 0,0,32,32,0,0,32,32,0,0,0,0,32,32,32,32
 db 0,0,32,32,0,0,32,32,0,0,32,32,0,0,0,0
 db 0,0,32,32,0,0,32,32,0,0,32,32,0,0,32,32
 db 0,0,32,32,0,0,32,32,0,0,32,32,32,32,0,0
 db 0,0,32,32,0,0,32,32,0,0,32,32,32,32,32,32
 db 0,0,32,32,0,0,32,32,32,32,0,0,0,0,0,0
 db 0,0,32,32,0,0,32,32,32,32,0,0,0,0,32,32
 db 0,0,32,32,0,0,32,32,32,32,0,0,32,32,0,0
 db 0,0,32,32,0,0,32,32,32,32,0,0,32,32,32,32
 db 0,0,32,32,0,0,32,32,32,32,32,32,0,0,0,0
 db 0,0,32,32,0,0,32,32,32,32,32,32,0,0,32,32
 db 0,0,32,32,0,0,32,32,32,32,32,32,32,32,0,0
 db 0,0,32,32,0,0,32,32,32,32,32,32,32,32,32,32
 db 0,0,32,32,32,32,0,0,0,0,0,0,0,0,0,0
 db 0,0,32,32,32,32,0,0,0,0,0,0,0,0,32,32
 db 0,0,32,32,32,32,0,0,0,0,0,0,32,32,0,0
 db 0,0,32,32,32,32,0,0,0,0,0,0,32,32,32,32
 db 0,0,32,32,32,32,0,0,0,0,32,32,0,0,0,0
 db 0,0,32,32,32,32,0,0,0,0,32,32,0,0,32,32
 db 0,0,32,32,32,32,0,0,0,0,32,32,32,32,0,0
 db 0,0,32,32,32,32,0,0,0,0,32,32,32,32,32,32
 db 0,0,32,32,32,32,0,0,32,32,0,0,0,0,0,0
 db 0,0,32,32,32,32,0,0,32,32,0,0,0,0,32,32
 db 0,0,32,32,32,32,0,0,32,32,0,0,32,32,0,0
 db 0,0,32,32,32,32,0,0,32,32,0,0,32,32,32,32
 db 0,0,32,32,32,32,0,0,32,32,32,32,0,0,0,0
 db 0,0,32,32,32,32,0,0,32,32,32,32,0,0,32,32
 db 0,0,32,32,32,32,0,0,32,32,32,32,32,32,0,0
 db 0,0,32,32,32,32,0,0,32,32,32,32,32,32,32,32
 db 0,0,32,32,32,32,32,32,0,0,0,0,0,0,0,0
 db 0,0,32,32,32,32,32,32,0,0,0,0,0,0,32,32
 db 0,0,32,32,32,32,32,32,0,0,0,0,32,32,0,0
 db 0,0,32,32,32,32,32,32,0,0,0,0,32,32,32,32
 db 0,0,32,32,32,32,32,32,0,0,32,32,0,0,0,0
 db 0,0,32,32,32,32,32,32,0,0,32,32,0,0,32,32
 db 0,0,32,32,32,32,32,32,0,0,32,32,32,32,0,0
 db 0,0,32,32,32,32,32,32,0,0,32,32,32,32,32,32
 db 0,0,32,32,32,32,32,32,32,32,0,0,0,0,0,0
 db 0,0,32,32,32,32,32,32,32,32,0,0,0,0,32,32
 db 0,0,32,32,32,32,32,32,32,32,0,0,32,32,0,0
 db 0,0,32,32,32,32,32,32,32,32,0,0,32,32,32,32
 db 0,0,32,32,32,32,32,32,32,32,32,32,0,0,0,0
 db 0,0,32,32,32,32,32,32,32,32,32,32,0,0,32,32
 db 0,0,32,32,32,32,32,32,32,32,32,32,32,32,0,0
 db 0,0,32,32,32,32,32,32,32,32,32,32,32,32,32,32
 db 32,32,0,0,0,0,0,0,0,0,0,0,0,0,0,0
 db 32,32,0,0,0,0,0,0,0,0,0,0,0,0,32,32
 db 32,32,0,0,0,0,0,0,0,0,0,0,32,32,0,0
 db 32,32,0,0,0,0,0,0,0,0,0,0,32,32,32,32
 db 32,32,0,0,0,0,0,0,0,0,32,32,0,0,0,0
 db 32,32,0,0,0,0,0,0,0,0,32,32,0,0,32,32
 db 32,32,0,0,0,0,0,0,0,0,32,32,32,32,0,0
 db 32,32,0,0,0,0,0,0,0,0,32,32,32,32,32,32
 db 32,32,0,0,0,0,0,0,32,32,0,0,0,0,0,0
 db 32,32,0,0,0,0,0,0,32,32,0,0,0,0,32,32
 db 32,32,0,0,0,0,0,0,32,32,0,0,32,32,0,0
 db 32,32,0,0,0,0,0,0,32,32,0,0,32,32,32,32
 db 32,32,0,0,0,0,0,0,32,32,32,32,0,0,0,0
 db 32,32,0,0,0,0,0,0,32,32,32,32,0,0,32,32
 db 32,32,0,0,0,0,0,0,32,32,32,32,32,32,0,0
 db 32,32,0,0,0,0,0,0,32,32,32,32,32,32,32,32
 db 32,32,0,0,0,0,32,32,0,0,0,0,0,0,0,0
 db 32,32,0,0,0,0,32,32,0,0,0,0,0,0,32,32
 db 32,32,0,0,0,0,32,32,0,0,0,0,32,32,0,0
 db 32,32,0,0,0,0,32,32,0,0,0,0,32,32,32,32
 db 32,32,0,0,0,0,32,32,0,0,32,32,0,0,0,0
 db 32,32,0,0,0,0,32,32,0,0,32,32,0,0,32,32
 db 32,32,0,0,0,0,32,32,0,0,32,32,32,32,0,0
 db 32,32,0,0,0,0,32,32,0,0,32,32,32,32,32,32
 db 32,32,0,0,0,0,32,32,32,32,0,0,0,0,0,0
 db 32,32,0,0,0,0,32,32,32,32,0,0,0,0,32,32
 db 32,32,0,0,0,0,32,32,32,32,0,0,32,32,0,0
 db 32,32,0,0,0,0,32,32,32,32,0,0,32,32,32,32
 db 32,32,0,0,0,0,32,32,32,32,32,32,0,0,0,0
 db 32,32,0,0,0,0,32,32,32,32,32,32,0,0,32,32
 db 32,32,0,0,0,0,32,32,32,32,32,32,32,32,0,0
 db 32,32,0,0,0,0,32,32,32,32,32,32,32,32,32,32
 db 32,32,0,0,32,32,0,0,0,0,0,0,0,0,0,0
 db 32,32,0,0,32,32,0,0,0,0,0,0,0,0,32,32
 db 32,32,0,0,32,32,0,0,0,0,0,0,32,32,0,0
 db 32,32,0,0,32,32,0,0,0,0,0,0,32,32,32,32
 db 32,32,0,0,32,32,0,0,0,0,32,32,0,0,0,0
 db 32,32,0,0,32,32,0,0,0,0,32,32,0,0,32,32
 db 32,32,0,0,32,32,0,0,0,0,32,32,32,32,0,0
 db 32,32,0,0,32,32,0,0,0,0,32,32,32,32,32,32
 db 32,32,0,0,32,32,0,0,32,32,0,0,0,0,0,0
 db 32,32,0,0,32,32,0,0,32,32,0,0,0,0,32,32
 db 32,32,0,0,32,32,0,0,32,32,0,0,32,32,0,0
 db 32,32,0,0,32,32,0,0,32,32,0,0,32,32,32,32
 db 32,32,0,0,32,32,0,0,32,32,32,32,0,0,0,0
 db 32,32,0,0,32,32,0,0,32,32,32,32,0,0,32,32
 db 32,32,0,0,32,32,0,0,32,32,32,32,32,32,0,0
 db 32,32,0,0,32,32,0,0,32,32,32,32,32,32,32,32
 db 32,32,0,0,32,32,32,32,0,0,0,0,0,0,0,0
 db 32,32,0,0,32,32,32,32,0,0,0,0,0,0,32,32
 db 32,32,0,0,32,32,32,32,0,0,0,0,32,32,0,0
 db 32,32,0,0,32,32,32,32,0,0,0,0,32,32,32,32
 db 32,32,0,0,32,32,32,32,0,0,32,32,0,0,0,0
 db 32,32,0,0,32,32,32,32,0,0,32,32,0,0,32,32
 db 32,32,0,0,32,32,32,32,0,0,32,32,32,32,0,0
 db 32,32,0,0,32,32,32,32,0,0,32,32,32,32,32,32
 db 32,32,0,0,32,32,32,32,32,32,0,0,0,0,0,0
 db 32,32,0,0,32,32,32,32,32,32,0,0,0,0,32,32
 db 32,32,0,0,32,32,32,32,32,32,0,0,32,32,0,0
 db 32,32,0,0,32,32,32,32,32,32,0,0,32,32,32,32
 db 32,32,0,0,32,32,32,32,32,32,32,32,0,0,0,0
 db 32,32,0,0,32,32,32,32,32,32,32,32,0,0,32,32
 db 32,32,0,0,32,32,32,32,32,32,32,32,32,32,0,0
 db 32,32,0,0,32,32,32,32,32,32,32,32,32,32,32,32
 db 32,32,32,32,0,0,0,0,0,0,0,0,0,0,0,0
 db 32,32,32,32,0,0,0,0,0,0,0,0,0,0,32,32
 db 32,32,32,32,0,0,0,0,0,0,0,0,32,32,0,0
 db 32,32,32,32,0,0,0,0,0,0,0,0,32,32,32,32
 db 32,32,32,32,0,0,0,0,0,0,32,32,0,0,0,0
 db 32,32,32,32,0,0,0,0,0,0,32,32,0,0,32,32
 db 32,32,32,32,0,0,0,0,0,0,32,32,32,32,0,0
 db 32,32,32,32,0,0,0,0,0,0,32,32,32,32,32,32
 db 32,32,32,32,0,0,0,0,32,32,0,0,0,0,0,0
 db 32,32,32,32,0,0,0,0,32,32,0,0,0,0,32,32
 db 32,32,32,32,0,0,0,0,32,32,0,0,32,32,0,0
 db 32,32,32,32,0,0,0,0,32,32,0,0,32,32,32,32
 db 32,32,32,32,0,0,0,0,32,32,32,32,0,0,0,0
 db 32,32,32,32,0,0,0,0,32,32,32,32,0,0,32,32
 db 32,32,32,32,0,0,0,0,32,32,32,32,32,32,0,0
 db 32,32,32,32,0,0,0,0,32,32,32,32,32,32,32,32
 db 32,32,32,32,0,0,32,32,0,0,0,0,0,0,0,0
 db 32,32,32,32,0,0,32,32,0,0,0,0,0,0,32,32
 db 32,32,32,32,0,0,32,32,0,0,0,0,32,32,0,0
 db 32,32,32,32,0,0,32,32,0,0,0,0,32,32,32,32
 db 32,32,32,32,0,0,32,32,0,0,32,32,0,0,0,0
 db 32,32,32,32,0,0,32,32,0,0,32,32,0,0,32,32
 db 32,32,32,32,0,0,32,32,0,0,32,32,32,32,0,0
 db 32,32,32,32,0,0,32,32,0,0,32,32,32,32,32,32
 db 32,32,32,32,0,0,32,32,32,32,0,0,0,0,0,0
 db 32,32,32,32,0,0,32,32,32,32,0,0,0,0,32,32
 db 32,32,32,32,0,0,32,32,32,32,0,0,32,32,0,0
 db 32,32,32,32,0,0,32,32,32,32,0,0,32,32,32,32
 db 32,32,32,32,0,0,32,32,32,32,32,32,0,0,0,0
 db 32,32,32,32,0,0,32,32,32,32,32,32,0,0,32,32
 db 32,32,32,32,0,0,32,32,32,32,32,32,32,32,0,0
 db 32,32,32,32,0,0,32,32,32,32,32,32,32,32,32,32
 db 32,32,32,32,32,32,0,0,0,0,0,0,0,0,0,0
 db 32,32,32,32,32,32,0,0,0,0,0,0,0,0,32,32
 db 32,32,32,32,32,32,0,0,0,0,0,0,32,32,0,0
 db 32,32,32,32,32,32,0,0,0,0,0,0,32,32,32,32
 db 32,32,32,32,32,32,0,0,0,0,32,32,0,0,0,0
 db 32,32,32,32,32,32,0,0,0,0,32,32,0,0,32,32
 db 32,32,32,32,32,32,0,0,0,0,32,32,32,32,0,0
 db 32,32,32,32,32,32,0,0,0,0,32,32,32,32,32,32
 db 32,32,32,32,32,32,0,0,32,32,0,0,0,0,0,0
 db 32,32,32,32,32,32,0,0,32,32,0,0,0,0,32,32
 db 32,32,32,32,32,32,0,0,32,32,0,0,32,32,0,0
 db 32,32,32,32,32,32,0,0,32,32,0,0,32,32,32,32
 db 32,32,32,32,32,32,0,0,32,32,32,32,0,0,0,0
 db 32,32,32,32,32,32,0,0,32,32,32,32,0,0,32,32
 db 32,32,32,32,32,32,0,0,32,32,32,32,32,32,0,0
 db 32,32,32,32,32,32,0,0,32,32,32,32,32,32,32,32
 db 32,32,32,32,32,32,32,32,0,0,0,0,0,0,0,0
 db 32,32,32,32,32,32,32,32,0,0,0,0,0,0,32,32
 db 32,32,32,32,32,32,32,32,0,0,0,0,32,32,0,0
 db 32,32,32,32,32,32,32,32,0,0,0,0,32,32,32,32
 db 32,32,32,32,32,32,32,32,0,0,32,32,0,0,0,0
 db 32,32,32,32,32,32,32,32,0,0,32,32,0,0,32,32
 db 32,32,32,32,32,32,32,32,0,0,32,32,32,32,0,0
 db 32,32,32,32,32,32,32,32,0,0,32,32,32,32,32,32
 db 32,32,32,32,32,32,32,32,32,32,0,0,0,0,0,0
 db 32,32,32,32,32,32,32,32,32,32,0,0,0,0,32,32
 db 32,32,32,32,32,32,32,32,32,32,0,0,32,32,0,0
 db 32,32,32,32,32,32,32,32,32,32,0,0,32,32,32,32
 db 32,32,32,32,32,32,32,32,32,32,32,32,0,0,0,0
 db 32,32,32,32,32,32,32,32,32,32,32,32,0,0,32,32
 db 32,32,32,32,32,32,32,32,32,32,32,32,32,32,0,0
 db 32,32,32,32,32,32,32,32,32,32,32,32,32,32,32,32
 db 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
 db 0,0,0,0,0,0,0,0,0,0,0,0,0,0,64,64
 db 0,0,0,0,0,0,0,0,0,0,0,0,64,64,0,0
 db 0,0,0,0,0,0,0,0,0,0,0,0,64,64,64,64
 db 0,0,0,0,0,0,0,0,0,0,64,64,0,0,0,0
 db 0,0,0,0,0,0,0,0,0,0,64,64,0,0,64,64
 db 0,0,0,0,0,0,0,0,0,0,64,64,64,64,0,0
 db 0,0,0,0,0,0,0,0,0,0,64,64,64,64,64,64
 db 0,0,0,0,0,0,0,0,64,64,0,0,0,0,0,0
 db 0,0,0,0,0,0,0,0,64,64,0,0,0,0,64,64
 db 0,0,0,0,0,0,0,0,64,64,0,0,64,64,0,0
 db 0,0,0,0,0,0,0,0,64,64,0,0,64,64,64,64
 db 0,0,0,0,0,0,0,0,64,64,64,64,0,0,0,0
 db 0,0,0,0,0,0,0,0,64,64,64,64,0,0,64,64
 db 0,0,0,0,0,0,0,0,64,64,64,64,64,64,0,0
 db 0,0,0,0,0,0,0,0,64,64,64,64,64,64,64,64
 db 0,0,0,0,0,0,64,64,0,0,0,0,0,0,0,0
 db 0,0,0,0,0,0,64,64,0,0,0,0,0,0,64,64
 db 0,0,0,0,0,0,64,64,0,0,0,0,64,64,0,0
 db 0,0,0,0,0,0,64,64,0,0,0,0,64,64,64,64
 db 0,0,0,0,0,0,64,64,0,0,64,64,0,0,0,0
 db 0,0,0,0,0,0,64,64,0,0,64,64,0,0,64,64
 db 0,0,0,0,0,0,64,64,0,0,64,64,64,64,0,0
 db 0,0,0,0,0,0,64,64,0,0,64,64,64,64,64,64
 db 0,0,0,0,0,0,64,64,64,64,0,0,0,0,0,0
 db 0,0,0,0,0,0,64,64,64,64,0,0,0,0,64,64
 db 0,0,0,0,0,0,64,64,64,64,0,0,64,64,0,0
 db 0,0,0,0,0,0,64,64,64,64,0,0,64,64,64,64
 db 0,0,0,0,0,0,64,64,64,64,64,64,0,0,0,0
 db 0,0,0,0,0,0,64,64,64,64,64,64,0,0,64,64
 db 0,0,0,0,0,0,64,64,64,64,64,64,64,64,0,0
 db 0,0,0,0,0,0,64,64,64,64,64,64,64,64,64,64
 db 0,0,0,0,64,64,0,0,0,0,0,0,0,0,0,0
 db 0,0,0,0,64,64,0,0,0,0,0,0,0,0,64,64
 db 0,0,0,0,64,64,0,0,0,0,0,0,64,64,0,0
 db 0,0,0,0,64,64,0,0,0,0,0,0,64,64,64,64
 db 0,0,0,0,64,64,0,0,0,0,64,64,0,0,0,0
 db 0,0,0,0,64,64,0,0,0,0,64,64,0,0,64,64
 db 0,0,0,0,64,64,0,0,0,0,64,64,64,64,0,0
 db 0,0,0,0,64,64,0,0,0,0,64,64,64,64,64,64
 db 0,0,0,0,64,64,0,0,64,64,0,0,0,0,0,0
 db 0,0,0,0,64,64,0,0,64,64,0,0,0,0,64,64
 db 0,0,0,0,64,64,0,0,64,64,0,0,64,64,0,0
 db 0,0,0,0,64,64,0,0,64,64,0,0,64,64,64,64
 db 0,0,0,0,64,64,0,0,64,64,64,64,0,0,0,0
 db 0,0,0,0,64,64,0,0,64,64,64,64,0,0,64,64
 db 0,0,0,0,64,64,0,0,64,64,64,64,64,64,0,0
 db 0,0,0,0,64,64,0,0,64,64,64,64,64,64,64,64
 db 0,0,0,0,64,64,64,64,0,0,0,0,0,0,0,0
 db 0,0,0,0,64,64,64,64,0,0,0,0,0,0,64,64
 db 0,0,0,0,64,64,64,64,0,0,0,0,64,64,0,0
 db 0,0,0,0,64,64,64,64,0,0,0,0,64,64,64,64
 db 0,0,0,0,64,64,64,64,0,0,64,64,0,0,0,0
 db 0,0,0,0,64,64,64,64,0,0,64,64,0,0,64,64
 db 0,0,0,0,64,64,64,64,0,0,64,64,64,64,0,0
 db 0,0,0,0,64,64,64,64,0,0,64,64,64,64,64,64
 db 0,0,0,0,64,64,64,64,64,64,0,0,0,0,0,0
 db 0,0,0,0,64,64,64,64,64,64,0,0,0,0,64,64
 db 0,0,0,0,64,64,64,64,64,64,0,0,64,64,0,0
 db 0,0,0,0,64,64,64,64,64,64,0,0,64,64,64,64
 db 0,0,0,0,64,64,64,64,64,64,64,64,0,0,0,0
 db 0,0,0,0,64,64,64,64,64,64,64,64,0,0,64,64
 db 0,0,0,0,64,64,64,64,64,64,64,64,64,64,0,0
 db 0,0,0,0,64,64,64,64,64,64,64,64,64,64,64,64
 db 0,0,64,64,0,0,0,0,0,0,0,0,0,0,0,0
 db 0,0,64,64,0,0,0,0,0,0,0,0,0,0,64,64
 db 0,0,64,64,0,0,0,0,0,0,0,0,64,64,0,0
 db 0,0,64,64,0,0,0,0,0,0,0,0,64,64,64,64
 db 0,0,64,64,0,0,0,0,0,0,64,64,0,0,0,0
 db 0,0,64,64,0,0,0,0,0,0,64,64,0,0,64,64
 db 0,0,64,64,0,0,0,0,0,0,64,64,64,64,0,0
 db 0,0,64,64,0,0,0,0,0,0,64,64,64,64,64,64
 db 0,0,64,64,0,0,0,0,64,64,0,0,0,0,0,0
 db 0,0,64,64,0,0,0,0,64,64,0,0,0,0,64,64
 db 0,0,64,64,0,0,0,0,64,64,0,0,64,64,0,0
 db 0,0,64,64,0,0,0,0,64,64,0,0,64,64,64,64
 db 0,0,64,64,0,0,0,0,64,64,64,64,0,0,0,0
 db 0,0,64,64,0,0,0,0,64,64,64,64,0,0,64,64
 db 0,0,64,64,0,0,0,0,64,64,64,64,64,64,0,0
 db 0,0,64,64,0,0,0,0,64,64,64,64,64,64,64,64
 db 0,0,64,64,0,0,64,64,0,0,0,0,0,0,0,0
 db 0,0,64,64,0,0,64,64,0,0,0,0,0,0,64,64
 db 0,0,64,64,0,0,64,64,0,0,0,0,64,64,0,0
 db 0,0,64,64,0,0,64,64,0,0,0,0,64,64,64,64
 db 0,0,64,64,0,0,64,64,0,0,64,64,0,0,0,0
 db 0,0,64,64,0,0,64,64,0,0,64,64,0,0,64,64
 db 0,0,64,64,0,0,64,64,0,0,64,64,64,64,0,0
 db 0,0,64,64,0,0,64,64,0,0,64,64,64,64,64,64
 db 0,0,64,64,0,0,64,64,64,64,0,0,0,0,0,0
 db 0,0,64,64,0,0,64,64,64,64,0,0,0,0,64,64
 db 0,0,64,64,0,0,64,64,64,64,0,0,64,64,0,0
 db 0,0,64,64,0,0,64,64,64,64,0,0,64,64,64,64
 db 0,0,64,64,0,0,64,64,64,64,64,64,0,0,0,0
 db 0,0,64,64,0,0,64,64,64,64,64,64,0,0,64,64
 db 0,0,64,64,0,0,64,64,64,64,64,64,64,64,0,0
 db 0,0,64,64,0,0,64,64,64,64,64,64,64,64,64,64
 db 0,0,64,64,64,64,0,0,0,0,0,0,0,0,0,0
 db 0,0,64,64,64,64,0,0,0,0,0,0,0,0,64,64
 db 0,0,64,64,64,64,0,0,0,0,0,0,64,64,0,0
 db 0,0,64,64,64,64,0,0,0,0,0,0,64,64,64,64
 db 0,0,64,64,64,64,0,0,0,0,64,64,0,0,0,0
 db 0,0,64,64,64,64,0,0,0,0,64,64,0,0,64,64
 db 0,0,64,64,64,64,0,0,0,0,64,64,64,64,0,0
 db 0,0,64,64,64,64,0,0,0,0,64,64,64,64,64,64
 db 0,0,64,64,64,64,0,0,64,64,0,0,0,0,0,0
 db 0,0,64,64,64,64,0,0,64,64,0,0,0,0,64,64
 db 0,0,64,64,64,64,0,0,64,64,0,0,64,64,0,0
 db 0,0,64,64,64,64,0,0,64,64,0,0,64,64,64,64
 db 0,0,64,64,64,64,0,0,64,64,64,64,0,0,0,0
 db 0,0,64,64,64,64,0,0,64,64,64,64,0,0,64,64
 db 0,0,64,64,64,64,0,0,64,64,64,64,64,64,0,0
 db 0,0,64,64,64,64,0,0,64,64,64,64,64,64,64,64
 db 0,0,64,64,64,64,64,64,0,0,0,0,0,0,0,0
 db 0,0,64,64,64,64,64,64,0,0,0,0,0,0,64,64
 db 0,0,64,64,64,64,64,64,0,0,0,0,64,64,0,0
 db 0,0,64,64,64,64,64,64,0,0,0,0,64,64,64,64
 db 0,0,64,64,64,64,64,64,0,0,64,64,0,0,0,0
 db 0,0,64,64,64,64,64,64,0,0,64,64,0,0,64,64
 db 0,0,64,64,64,64,64,64,0,0,64,64,64,64,0,0
 db 0,0,64,64,64,64,64,64,0,0,64,64,64,64,64,64
 db 0,0,64,64,64,64,64,64,64,64,0,0,0,0,0,0
 db 0,0,64,64,64,64,64,64,64,64,0,0,0,0,64,64
 db 0,0,64,64,64,64,64,64,64,64,0,0,64,64,0,0
 db 0,0,64,64,64,64,64,64,64,64,0,0,64,64,64,64
 db 0,0,64,64,64,64,64,64,64,64,64,64,0,0,0,0
 db 0,0,64,64,64,64,64,64,64,64,64,64,0,0,64,64
 db 0,0,64,64,64,64,64,64,64,64,64,64,64,64,0,0
 db 0,0,64,64,64,64,64,64,64,64,64,64,64,64,64,64
 db 64,64,0,0,0,0,0,0,0,0,0,0,0,0,0,0
 db 64,64,0,0,0,0,0,0,0,0,0,0,0,0,64,64
 db 64,64,0,0,0,0,0,0,0,0,0,0,64,64,0,0
 db 64,64,0,0,0,0,0,0,0,0,0,0,64,64,64,64
 db 64,64,0,0,0,0,0,0,0,0,64,64,0,0,0,0
 db 64,64,0,0,0,0,0,0,0,0,64,64,0,0,64,64
 db 64,64,0,0,0,0,0,0,0,0,64,64,64,64,0,0
 db 64,64,0,0,0,0,0,0,0,0,64,64,64,64,64,64
 db 64,64,0,0,0,0,0,0,64,64,0,0,0,0,0,0
 db 64,64,0,0,0,0,0,0,64,64,0,0,0,0,64,64
 db 64,64,0,0,0,0,0,0,64,64,0,0,64,64,0,0
 db 64,64,0,0,0,0,0,0,64,64,0,0,64,64,64,64
 db 64,64,0,0,0,0,0,0,64,64,64,64,0,0,0,0
 db 64,64,0,0,0,0,0,0,64,64,64,64,0,0,64,64
 db 64,64,0,0,0,0,0,0,64,64,64,64,64,64,0,0
 db 64,64,0,0,0,0,0,0,64,64,64,64,64,64,64,64
 db 64,64,0,0,0,0,64,64,0,0,0,0,0,0,0,0
 db 64,64,0,0,0,0,64,64,0,0,0,0,0,0,64,64
 db 64,64,0,0,0,0,64,64,0,0,0,0,64,64,0,0
 db 64,64,0,0,0,0,64,64,0,0,0,0,64,64,64,64
 db 64,64,0,0,0,0,64,64,0,0,64,64,0,0,0,0
 db 64,64,0,0,0,0,64,64,0,0,64,64,0,0,64,64
 db 64,64,0,0,0,0,64,64,0,0,64,64,64,64,0,0
 db 64,64,0,0,0,0,64,64,0,0,64,64,64,64,64,64
 db 64,64,0,0,0,0,64,64,64,64,0,0,0,0,0,0
 db 64,64,0,0,0,0,64,64,64,64,0,0,0,0,64,64
 db 64,64,0,0,0,0,64,64,64,64,0,0,64,64,0,0
 db 64,64,0,0,0,0,64,64,64,64,0,0,64,64,64,64
 db 64,64,0,0,0,0,64,64,64,64,64,64,0,0,0,0
 db 64,64,0,0,0,0,64,64,64,64,64,64,0,0,64,64
 db 64,64,0,0,0,0,64,64,64,64,64,64,64,64,0,0
 db 64,64,0,0,0,0,64,64,64,64,64,64,64,64,64,64
 db 64,64,0,0,64,64,0,0,0,0,0,0,0,0,0,0
 db 64,64,0,0,64,64,0,0,0,0,0,0,0,0,64,64
 db 64,64,0,0,64,64,0,0,0,0,0,0,64,64,0,0
 db 64,64,0,0,64,64,0,0,0,0,0,0,64,64,64,64
 db 64,64,0,0,64,64,0,0,0,0,64,64,0,0,0,0
 db 64,64,0,0,64,64,0,0,0,0,64,64,0,0,64,64
 db 64,64,0,0,64,64,0,0,0,0,64,64,64,64,0,0
 db 64,64,0,0,64,64,0,0,0,0,64,64,64,64,64,64
 db 64,64,0,0,64,64,0,0,64,64,0,0,0,0,0,0
 db 64,64,0,0,64,64,0,0,64,64,0,0,0,0,64,64
 db 64,64,0,0,64,64,0,0,64,64,0,0,64,64,0,0
 db 64,64,0,0,64,64,0,0,64,64,0,0,64,64,64,64
 db 64,64,0,0,64,64,0,0,64,64,64,64,0,0,0,0
 db 64,64,0,0,64,64,0,0,64,64,64,64,0,0,64,64
 db 64,64,0,0,64,64,0,0,64,64,64,64,64,64,0,0
 db 64,64,0,0,64,64,0,0,64,64,64,64,64,64,64,64
 db 64,64,0,0,64,64,64,64,0,0,0,0,0,0,0,0
 db 64,64,0,0,64,64,64,64,0,0,0,0,0,0,64,64
 db 64,64,0,0,64,64,64,64,0,0,0,0,64,64,0,0
 db 64,64,0,0,64,64,64,64,0,0,0,0,64,64,64,64
 db 64,64,0,0,64,64,64,64,0,0,64,64,0,0,0,0
 db 64,64,0,0,64,64,64,64,0,0,64,64,0,0,64,64
 db 64,64,0,0,64,64,64,64,0,0,64,64,64,64,0,0
 db 64,64,0,0,64,64,64,64,0,0,64,64,64,64,64,64
 db 64,64,0,0,64,64,64,64,64,64,0,0,0,0,0,0
 db 64,64,0,0,64,64,64,64,64,64,0,0,0,0,64,64
 db 64,64,0,0,64,64,64,64,64,64,0,0,64,64,0,0
 db 64,64,0,0,64,64,64,64,64,64,0,0,64,64,64,64
 db 64,64,0,0,64,64,64,64,64,64,64,64,0,0,0,0
 db 64,64,0,0,64,64,64,64,64,64,64,64,0,0,64,64
 db 64,64,0,0,64,64,64,64,64,64,64,64,64,64,0,0
 db 64,64,0,0,64,64,64,64,64,64,64,64,64,64,64,64
 db 64,64,64,64,0,0,0,0,0,0,0,0,0,0,0,0
 db 64,64,64,64,0,0,0,0,0,0,0,0,0,0,64,64
 db 64,64,64,64,0,0,0,0,0,0,0,0,64,64,0,0
 db 64,64,64,64,0,0,0,0,0,0,0,0,64,64,64,64
 db 64,64,64,64,0,0,0,0,0,0,64,64,0,0,0,0
 db 64,64,64,64,0,0,0,0,0,0,64,64,0,0,64,64
 db 64,64,64,64,0,0,0,0,0,0,64,64,64,64,0,0
 db 64,64,64,64,0,0,0,0,0,0,64,64,64,64,64,64
 db 64,64,64,64,0,0,0,0,64,64,0,0,0,0,0,0
 db 64,64,64,64,0,0,0,0,64,64,0,0,0,0,64,64
 db 64,64,64,64,0,0,0,0,64,64,0,0,64,64,0,0
 db 64,64,64,64,0,0,0,0,64,64,0,0,64,64,64,64
 db 64,64,64,64,0,0,0,0,64,64,64,64,0,0,0,0
 db 64,64,64,64,0,0,0,0,64,64,64,64,0,0,64,64
 db 64,64,64,64,0,0,0,0,64,64,64,64,64,64,0,0
 db 64,64,64,64,0,0,0,0,64,64,64,64,64,64,64,64
 db 64,64,64,64,0,0,64,64,0,0,0,0,0,0,0,0
 db 64,64,64,64,0,0,64,64,0,0,0,0,0,0,64,64
 db 64,64,64,64,0,0,64,64,0,0,0,0,64,64,0,0
 db 64,64,64,64,0,0,64,64,0,0,0,0,64,64,64,64
 db 64,64,64,64,0,0,64,64,0,0,64,64,0,0,0,0
 db 64,64,64,64,0,0,64,64,0,0,64,64,0,0,64,64
 db 64,64,64,64,0,0,64,64,0,0,64,64,64,64,0,0
 db 64,64,64,64,0,0,64,64,0,0,64,64,64,64,64,64
 db 64,64,64,64,0,0,64,64,64,64,0,0,0,0,0,0
 db 64,64,64,64,0,0,64,64,64,64,0,0,0,0,64,64
 db 64,64,64,64,0,0,64,64,64,64,0,0,64,64,0,0
 db 64,64,64,64,0,0,64,64,64,64,0,0,64,64,64,64
 db 64,64,64,64,0,0,64,64,64,64,64,64,0,0,0,0
 db 64,64,64,64,0,0,64,64,64,64,64,64,0,0,64,64
 db 64,64,64,64,0,0,64,64,64,64,64,64,64,64,0,0
 db 64,64,64,64,0,0,64,64,64,64,64,64,64,64,64,64
 db 64,64,64,64,64,64,0,0,0,0,0,0,0,0,0,0
 db 64,64,64,64,64,64,0,0,0,0,0,0,0,0,64,64
 db 64,64,64,64,64,64,0,0,0,0,0,0,64,64,0,0
 db 64,64,64,64,64,64,0,0,0,0,0,0,64,64,64,64
 db 64,64,64,64,64,64,0,0,0,0,64,64,0,0,0,0
 db 64,64,64,64,64,64,0,0,0,0,64,64,0,0,64,64
 db 64,64,64,64,64,64,0,0,0,0,64,64,64,64,0,0
 db 64,64,64,64,64,64,0,0,0,0,64,64,64,64,64,64
 db 64,64,64,64,64,64,0,0,64,64,0,0,0,0,0,0
 db 64,64,64,64,64,64,0,0,64,64,0,0,0,0,64,64
 db 64,64,64,64,64,64,0,0,64,64,0,0,64,64,0,0
 db 64,64,64,64,64,64,0,0,64,64,0,0,64,64,64,64
 db 64,64,64,64,64,64,0,0,64,64,64,64,0,0,0,0
 db 64,64,64,64,64,64,0,0,64,64,64,64,0,0,64,64
 db 64,64,64,64,64,64,0,0,64,64,64,64,64,64,0,0
 db 64,64,64,64,64,64,0,0,64,64,64,64,64,64,64,64
 db 64,64,64,64,64,64,64,64,0,0,0,0,0,0,0,0
 db 64,64,64,64,64,64,64,64,0,0,0,0,0,0,64,64
 db 64,64,64,64,64,64,64,64,0,0,0,0,64,64,0,0
 db 64,64,64,64,64,64,64,64,0,0,0,0,64,64,64,64
 db 64,64,64,64,64,64,64,64,0,0,64,64,0,0,0,0
 db 64,64,64,64,64,64,64,64,0,0,64,64,0,0,64,64
 db 64,64,64,64,64,64,64,64,0,0,64,64,64,64,0,0
 db 64,64,64,64,64,64,64,64,0,0,64,64,64,64,64,64
 db 64,64,64,64,64,64,64,64,64,64,0,0,0,0,0,0
 db 64,64,64,64,64,64,64,64,64,64,0,0,0,0,64,64
 db 64,64,64,64,64,64,64,64,64,64,0,0,64,64,0,0
 db 64,64,64,64,64,64,64,64,64,64,0,0,64,64,64,64
 db 64,64,64,64,64,64,64,64,64,64,64,64,0,0,0,0
 db 64,64,64,64,64,64,64,64,64,64,64,64,0,0,64,64
 db 64,64,64,64,64,64,64,64,64,64,64,64,64,64,0,0
 db 64,64,64,64,64,64,64,64,64,64,64,64,64,64,64,64
 db 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
 db 0,0,0,0,0,0,0,0,0,0,0,0,0,0,128,128
 db 0,0,0,0,0,0,0,0,0,0,0,0,128,128,0,0
 db 0,0,0,0,0,0,0,0,0,0,0,0,128,128,128,128
 db 0,0,0,0,0,0,0,0,0,0,128,128,0,0,0,0
 db 0,0,0,0,0,0,0,0,0,0,128,128,0,0,128,128
 db 0,0,0,0,0,0,0,0,0,0,128,128,128,128,0,0
 db 0,0,0,0,0,0,0,0,0,0,128,128,128,128,128,128
 db 0,0,0,0,0,0,0,0,128,128,0,0,0,0,0,0
 db 0,0,0,0,0,0,0,0,128,128,0,0,0,0,128,128
 db 0,0,0,0,0,0,0,0,128,128,0,0,128,128,0,0
 db 0,0,0,0,0,0,0,0,128,128,0,0,128,128,128,128
 db 0,0,0,0,0,0,0,0,128,128,128,128,0,0,0,0
 db 0,0,0,0,0,0,0,0,128,128,128,128,0,0,128,128
 db 0,0,0,0,0,0,0,0,128,128,128,128,128,128,0,0
 db 0,0,0,0,0,0,0,0,128,128,128,128,128,128,128,128
 db 0,0,0,0,0,0,128,128,0,0,0,0,0,0,0,0
 db 0,0,0,0,0,0,128,128,0,0,0,0,0,0,128,128
 db 0,0,0,0,0,0,128,128,0,0,0,0,128,128,0,0
 db 0,0,0,0,0,0,128,128,0,0,0,0,128,128,128,128
 db 0,0,0,0,0,0,128,128,0,0,128,128,0,0,0,0
 db 0,0,0,0,0,0,128,128,0,0,128,128,0,0,128,128
 db 0,0,0,0,0,0,128,128,0,0,128,128,128,128,0,0
 db 0,0,0,0,0,0,128,128,0,0,128,128,128,128,128,128
 db 0,0,0,0,0,0,128,128,128,128,0,0,0,0,0,0
 db 0,0,0,0,0,0,128,128,128,128,0,0,0,0,128,128
 db 0,0,0,0,0,0,128,128,128,128,0,0,128,128,0,0
 db 0,0,0,0,0,0,128,128,128,128,0,0,128,128,128,128
 db 0,0,0,0,0,0,128,128,128,128,128,128,0,0,0,0
 db 0,0,0,0,0,0,128,128,128,128,128,128,0,0,128,128
 db 0,0,0,0,0,0,128,128,128,128,128,128,128,128,0,0
 db 0,0,0,0,0,0,128,128,128,128,128,128,128,128,128,128
 db 0,0,0,0,128,128,0,0,0,0,0,0,0,0,0,0
 db 0,0,0,0,128,128,0,0,0,0,0,0,0,0,128,128
 db 0,0,0,0,128,128,0,0,0,0,0,0,128,128,0,0
 db 0,0,0,0,128,128,0,0,0,0,0,0,128,128,128,128
 db 0,0,0,0,128,128,0,0,0,0,128,128,0,0,0,0
 db 0,0,0,0,128,128,0,0,0,0,128,128,0,0,128,128
 db 0,0,0,0,128,128,0,0,0,0,128,128,128,128,0,0
 db 0,0,0,0,128,128,0,0,0,0,128,128,128,128,128,128
 db 0,0,0,0,128,128,0,0,128,128,0,0,0,0,0,0
 db 0,0,0,0,128,128,0,0,128,128,0,0,0,0,128,128
 db 0,0,0,0,128,128,0,0,128,128,0,0,128,128,0,0
 db 0,0,0,0,128,128,0,0,128,128,0,0,128,128,128,128
 db 0,0,0,0,128,128,0,0,128,128,128,128,0,0,0,0
 db 0,0,0,0,128,128,0,0,128,128,128,128,0,0,128,128
 db 0,0,0,0,128,128,0,0,128,128,128,128,128,128,0,0
 db 0,0,0,0,128,128,0,0,128,128,128,128,128,128,128,128
 db 0,0,0,0,128,128,128,128,0,0,0,0,0,0,0,0
 db 0,0,0,0,128,128,128,128,0,0,0,0,0,0,128,128
 db 0,0,0,0,128,128,128,128,0,0,0,0,128,128,0,0
 db 0,0,0,0,128,128,128,128,0,0,0,0,128,128,128,128
 db 0,0,0,0,128,128,128,128,0,0,128,128,0,0,0,0
 db 0,0,0,0,128,128,128,128,0,0,128,128,0,0,128,128
 db 0,0,0,0,128,128,128,128,0,0,128,128,128,128,0,0
 db 0,0,0,0,128,128,128,128,0,0,128,128,128,128,128,128
 db 0,0,0,0,128,128,128,128,128,128,0,0,0,0,0,0
 db 0,0,0,0,128,128,128,128,128,128,0,0,0,0,128,128
 db 0,0,0,0,128,128,128,128,128,128,0,0,128,128,0,0
 db 0,0,0,0,128,128,128,128,128,128,0,0,128,128,128,128
 db 0,0,0,0,128,128,128,128,128,128,128,128,0,0,0,0
 db 0,0,0,0,128,128,128,128,128,128,128,128,0,0,128,128
 db 0,0,0,0,128,128,128,128,128,128,128,128,128,128,0,0
 db 0,0,0,0,128,128,128,128,128,128,128,128,128,128,128,128
 db 0,0,128,128,0,0,0,0,0,0,0,0,0,0,0,0
 db 0,0,128,128,0,0,0,0,0,0,0,0,0,0,128,128
 db 0,0,128,128,0,0,0,0,0,0,0,0,128,128,0,0
 db 0,0,128,128,0,0,0,0,0,0,0,0,128,128,128,128
 db 0,0,128,128,0,0,0,0,0,0,128,128,0,0,0,0
 db 0,0,128,128,0,0,0,0,0,0,128,128,0,0,128,128
 db 0,0,128,128,0,0,0,0,0,0,128,128,128,128,0,0
 db 0,0,128,128,0,0,0,0,0,0,128,128,128,128,128,128
 db 0,0,128,128,0,0,0,0,128,128,0,0,0,0,0,0
 db 0,0,128,128,0,0,0,0,128,128,0,0,0,0,128,128
 db 0,0,128,128,0,0,0,0,128,128,0,0,128,128,0,0
 db 0,0,128,128,0,0,0,0,128,128,0,0,128,128,128,128
 db 0,0,128,128,0,0,0,0,128,128,128,128,0,0,0,0
 db 0,0,128,128,0,0,0,0,128,128,128,128,0,0,128,128
 db 0,0,128,128,0,0,0,0,128,128,128,128,128,128,0,0
 db 0,0,128,128,0,0,0,0,128,128,128,128,128,128,128,128
 db 0,0,128,128,0,0,128,128,0,0,0,0,0,0,0,0
 db 0,0,128,128,0,0,128,128,0,0,0,0,0,0,128,128
 db 0,0,128,128,0,0,128,128,0,0,0,0,128,128,0,0
 db 0,0,128,128,0,0,128,128,0,0,0,0,128,128,128,128
 db 0,0,128,128,0,0,128,128,0,0,128,128,0,0,0,0
 db 0,0,128,128,0,0,128,128,0,0,128,128,0,0,128,128
 db 0,0,128,128,0,0,128,128,0,0,128,128,128,128,0,0
 db 0,0,128,128,0,0,128,128,0,0,128,128,128,128,128,128
 db 0,0,128,128,0,0,128,128,128,128,0,0,0,0,0,0
 db 0,0,128,128,0,0,128,128,128,128,0,0,0,0,128,128
 db 0,0,128,128,0,0,128,128,128,128,0,0,128,128,0,0
 db 0,0,128,128,0,0,128,128,128,128,0,0,128,128,128,128
 db 0,0,128,128,0,0,128,128,128,128,128,128,0,0,0,0
 db 0,0,128,128,0,0,128,128,128,128,128,128,0,0,128,128
 db 0,0,128,128,0,0,128,128,128,128,128,128,128,128,0,0
 db 0,0,128,128,0,0,128,128,128,128,128,128,128,128,128,128
 db 0,0,128,128,128,128,0,0,0,0,0,0,0,0,0,0
 db 0,0,128,128,128,128,0,0,0,0,0,0,0,0,128,128
 db 0,0,128,128,128,128,0,0,0,0,0,0,128,128,0,0
 db 0,0,128,128,128,128,0,0,0,0,0,0,128,128,128,128
 db 0,0,128,128,128,128,0,0,0,0,128,128,0,0,0,0
 db 0,0,128,128,128,128,0,0,0,0,128,128,0,0,128,128
 db 0,0,128,128,128,128,0,0,0,0,128,128,128,128,0,0
 db 0,0,128,128,128,128,0,0,0,0,128,128,128,128,128,128
 db 0,0,128,128,128,128,0,0,128,128,0,0,0,0,0,0
 db 0,0,128,128,128,128,0,0,128,128,0,0,0,0,128,128
 db 0,0,128,128,128,128,0,0,128,128,0,0,128,128,0,0
 db 0,0,128,128,128,128,0,0,128,128,0,0,128,128,128,128
 db 0,0,128,128,128,128,0,0,128,128,128,128,0,0,0,0
 db 0,0,128,128,128,128,0,0,128,128,128,128,0,0,128,128
 db 0,0,128,128,128,128,0,0,128,128,128,128,128,128,0,0
 db 0,0,128,128,128,128,0,0,128,128,128,128,128,128,128,128
 db 0,0,128,128,128,128,128,128,0,0,0,0,0,0,0,0
 db 0,0,128,128,128,128,128,128,0,0,0,0,0,0,128,128
 db 0,0,128,128,128,128,128,128,0,0,0,0,128,128,0,0
 db 0,0,128,128,128,128,128,128,0,0,0,0,128,128,128,128
 db 0,0,128,128,128,128,128,128,0,0,128,128,0,0,0,0
 db 0,0,128,128,128,128,128,128,0,0,128,128,0,0,128,128
 db 0,0,128,128,128,128,128,128,0,0,128,128,128,128,0,0
 db 0,0,128,128,128,128,128,128,0,0,128,128,128,128,128,128
 db 0,0,128,128,128,128,128,128,128,128,0,0,0,0,0,0
 db 0,0,128,128,128,128,128,128,128,128,0,0,0,0,128,128
 db 0,0,128,128,128,128,128,128,128,128,0,0,128,128,0,0
 db 0,0,128,128,128,128,128,128,128,128,0,0,128,128,128,128
 db 0,0,128,128,128,128,128,128,128,128,128,128,0,0,0,0
 db 0,0,128,128,128,128,128,128,128,128,128,128,0,0,128,128
 db 0,0,128,128,128,128,128,128,128,128,128,128,128,128,0,0
 db 0,0,128,128,128,128,128,128,128,128,128,128,128,128,128,128
 db 128,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0
 db 128,128,0,0,0,0,0,0,0,0,0,0,0,0,128,128
 db 128,128,0,0,0,0,0,0,0,0,0,0,128,128,0,0
 db 128,128,0,0,0,0,0,0,0,0,0,0,128,128,128,128
 db 128,128,0,0,0,0,0,0,0,0,128,128,0,0,0,0
 db 128,128,0,0,0,0,0,0,0,0,128,128,0,0,128,128
 db 128,128,0,0,0,0,0,0,0,0,128,128,128,128,0,0
 db 128,128,0,0,0,0,0,0,0,0,128,128,128,128,128,128
 db 128,128,0,0,0,0,0,0,128,128,0,0,0,0,0,0
 db 128,128,0,0,0,0,0,0,128,128,0,0,0,0,128,128
 db 128,128,0,0,0,0,0,0,128,128,0,0,128,128,0,0
 db 128,128,0,0,0,0,0,0,128,128,0,0,128,128,128,128
 db 128,128,0,0,0,0,0,0,128,128,128,128,0,0,0,0
 db 128,128,0,0,0,0,0,0,128,128,128,128,0,0,128,128
 db 128,128,0,0,0,0,0,0,128,128,128,128,128,128,0,0
 db 128,128,0,0,0,0,0,0,128,128,128,128,128,128,128,128
 db 128,128,0,0,0,0,128,128,0,0,0,0,0,0,0,0
 db 128,128,0,0,0,0,128,128,0,0,0,0,0,0,128,128
 db 128,128,0,0,0,0,128,128,0,0,0,0,128,128,0,0
 db 128,128,0,0,0,0,128,128,0,0,0,0,128,128,128,128
 db 128,128,0,0,0,0,128,128,0,0,128,128,0,0,0,0
 db 128,128,0,0,0,0,128,128,0,0,128,128,0,0,128,128
 db 128,128,0,0,0,0,128,128,0,0,128,128,128,128,0,0
 db 128,128,0,0,0,0,128,128,0,0,128,128,128,128,128,128
 db 128,128,0,0,0,0,128,128,128,128,0,0,0,0,0,0
 db 128,128,0,0,0,0,128,128,128,128,0,0,0,0,128,128
 db 128,128,0,0,0,0,128,128,128,128,0,0,128,128,0,0
 db 128,128,0,0,0,0,128,128,128,128,0,0,128,128,128,128
 db 128,128,0,0,0,0,128,128,128,128,128,128,0,0,0,0
 db 128,128,0,0,0,0,128,128,128,128,128,128,0,0,128,128
 db 128,128,0,0,0,0,128,128,128,128,128,128,128,128,0,0
 db 128,128,0,0,0,0,128,128,128,128,128,128,128,128,128,128
 db 128,128,0,0,128,128,0,0,0,0,0,0,0,0,0,0
 db 128,128,0,0,128,128,0,0,0,0,0,0,0,0,128,128
 db 128,128,0,0,128,128,0,0,0,0,0,0,128,128,0,0
 db 128,128,0,0,128,128,0,0,0,0,0,0,128,128,128,128
 db 128,128,0,0,128,128,0,0,0,0,128,128,0,0,0,0
 db 128,128,0,0,128,128,0,0,0,0,128,128,0,0,128,128
 db 128,128,0,0,128,128,0,0,0,0,128,128,128,128,0,0
 db 128,128,0,0,128,128,0,0,0,0,128,128,128,128,128,128
 db 128,128,0,0,128,128,0,0,128,128,0,0,0,0,0,0
 db 128,128,0,0,128,128,0,0,128,128,0,0,0,0,128,128
 db 128,128,0,0,128,128,0,0,128,128,0,0,128,128,0,0
 db 128,128,0,0,128,128,0,0,128,128,0,0,128,128,128,128
 db 128,128,0,0,128,128,0,0,128,128,128,128,0,0,0,0
 db 128,128,0,0,128,128,0,0,128,128,128,128,0,0,128,128
 db 128,128,0,0,128,128,0,0,128,128,128,128,128,128,0,0
 db 128,128,0,0,128,128,0,0,128,128,128,128,128,128,128,128
 db 128,128,0,0,128,128,128,128,0,0,0,0,0,0,0,0
 db 128,128,0,0,128,128,128,128,0,0,0,0,0,0,128,128
 db 128,128,0,0,128,128,128,128,0,0,0,0,128,128,0,0
 db 128,128,0,0,128,128,128,128,0,0,0,0,128,128,128,128
 db 128,128,0,0,128,128,128,128,0,0,128,128,0,0,0,0
 db 128,128,0,0,128,128,128,128,0,0,128,128,0,0,128,128
 db 128,128,0,0,128,128,128,128,0,0,128,128,128,128,0,0
 db 128,128,0,0,128,128,128,128,0,0,128,128,128,128,128,128
 db 128,128,0,0,128,128,128,128,128,128,0,0,0,0,0,0
 db 128,128,0,0,128,128,128,128,128,128,0,0,0,0,128,128
 db 128,128,0,0,128,128,128,128,128,128,0,0,128,128,0,0
 db 128,128,0,0,128,128,128,128,128,128,0,0,128,128,128,128
 db 128,128,0,0,128,128,128,128,128,128,128,128,0,0,0,0
 db 128,128,0,0,128,128,128,128,128,128,128,128,0,0,128,128
 db 128,128,0,0,128,128,128,128,128,128,128,128,128,128,0,0
 db 128,128,0,0,128,128,128,128,128,128,128,128,128,128,128,128
 db 128,128,128,128,0,0,0,0,0,0,0,0,0,0,0,0
 db 128,128,128,128,0,0,0,0,0,0,0,0,0,0,128,128
 db 128,128,128,128,0,0,0,0,0,0,0,0,128,128,0,0
 db 128,128,128,128,0,0,0,0,0,0,0,0,128,128,128,128
 db 128,128,128,128,0,0,0,0,0,0,128,128,0,0,0,0
 db 128,128,128,128,0,0,0,0,0,0,128,128,0,0,128,128
 db 128,128,128,128,0,0,0,0,0,0,128,128,128,128,0,0
 db 128,128,128,128,0,0,0,0,0,0,128,128,128,128,128,128
 db 128,128,128,128,0,0,0,0,128,128,0,0,0,0,0,0
 db 128,128,128,128,0,0,0,0,128,128,0,0,0,0,128,128
 db 128,128,128,128,0,0,0,0,128,128,0,0,128,128,0,0
 db 128,128,128,128,0,0,0,0,128,128,0,0,128,128,128,128
 db 128,128,128,128,0,0,0,0,128,128,128,128,0,0,0,0
 db 128,128,128,128,0,0,0,0,128,128,128,128,0,0,128,128
 db 128,128,128,128,0,0,0,0,128,128,128,128,128,128,0,0
 db 128,128,128,128,0,0,0,0,128,128,128,128,128,128,128,128
 db 128,128,128,128,0,0,128,128,0,0,0,0,0,0,0,0
 db 128,128,128,128,0,0,128,128,0,0,0,0,0,0,128,128
 db 128,128,128,128,0,0,128,128,0,0,0,0,128,128,0,0
 db 128,128,128,128,0,0,128,128,0,0,0,0,128,128,128,128
 db 128,128,128,128,0,0,128,128,0,0,128,128,0,0,0,0
 db 128,128,128,128,0,0,128,128,0,0,128,128,0,0,128,128
 db 128,128,128,128,0,0,128,128,0,0,128,128,128,128,0,0
 db 128,128,128,128,0,0,128,128,0,0,128,128,128,128,128,128
 db 128,128,128,128,0,0,128,128,128,128,0,0,0,0,0,0
 db 128,128,128,128,0,0,128,128,128,128,0,0,0,0,128,128
 db 128,128,128,128,0,0,128,128,128,128,0,0,128,128,0,0
 db 128,128,128,128,0,0,128,128,128,128,0,0,128,128,128,128
 db 128,128,128,128,0,0,128,128,128,128,128,128,0,0,0,0
 db 128,128,128,128,0,0,128,128,128,128,128,128,0,0,128,128
 db 128,128,128,128,0,0,128,128,128,128,128,128,128,128,0,0
 db 128,128,128,128,0,0,128,128,128,128,128,128,128,128,128,128
 db 128,128,128,128,128,128,0,0,0,0,0,0,0,0,0,0
 db 128,128,128,128,128,128,0,0,0,0,0,0,0,0,128,128
 db 128,128,128,128,128,128,0,0,0,0,0,0,128,128,0,0
 db 128,128,128,128,128,128,0,0,0,0,0,0,128,128,128,128
 db 128,128,128,128,128,128,0,0,0,0,128,128,0,0,0,0
 db 128,128,128,128,128,128,0,0,0,0,128,128,0,0,128,128
 db 128,128,128,128,128,128,0,0,0,0,128,128,128,128,0,0
 db 128,128,128,128,128,128,0,0,0,0,128,128,128,128,128,128
 db 128,128,128,128,128,128,0,0,128,128,0,0,0,0,0,0
 db 128,128,128,128,128,128,0,0,128,128,0,0,0,0,128,128
 db 128,128,128,128,128,128,0,0,128,128,0,0,128,128,0,0
 db 128,128,128,128,128,128,0,0,128,128,0,0,128,128,128,128
 db 128,128,128,128,128,128,0,0,128,128,128,128,0,0,0,0
 db 128,128,128,128,128,128,0,0,128,128,128,128,0,0,128,128
 db 128,128,128,128,128,128,0,0,128,128,128,128,128,128,0,0
 db 128,128,128,128,128,128,0,0,128,128,128,128,128,128,128,128
 db 128,128,128,128,128,128,128,128,0,0,0,0,0,0,0,0
 db 128,128,128,128,128,128,128,128,0,0,0,0,0,0,128,128
 db 128,128,128,128,128,128,128,128,0,0,0,0,128,128,0,0
 db 128,128,128,128,128,128,128,128,0,0,0,0,128,128,128,128
 db 128,128,128,128,128,128,128,128,0,0,128,128,0,0,0,0
 db 128,128,128,128,128,128,128,128,0,0,128,128,0,0,128,128
 db 128,128,128,128,128,128,128,128,0,0,128,128,128,128,0,0
 db 128,128,128,128,128,128,128,128,0,0,128,128,128,128,128,128
 db 128,128,128,128,128,128,128,128,128,128,0,0,0,0,0,0
 db 128,128,128,128,128,128,128,128,128,128,0,0,0,0,128,128
 db 128,128,128,128,128,128,128,128,128,128,0,0,128,128,0,0
 db 128,128,128,128,128,128,128,128,128,128,0,0,128,128,128,128
 db 128,128,128,128,128,128,128,128,128,128,128,128,0,0,0,0
 db 128,128,128,128,128,128,128,128,128,128,128,128,0,0,128,128
 db 128,128,128,128,128,128,128,128,128,128,128,128,128,128,0,0
 db 128,128,128,128,128,128,128,128,128,128,128,128,128,128,128,128
