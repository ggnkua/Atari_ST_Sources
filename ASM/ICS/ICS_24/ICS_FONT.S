;
; Font for ICS intro come menu !!
;

FONT	DC.B	%00110000 	; 'A'
	DC.B	%00010000 
	DC.B	%01011000 
	DC.B	%01001000 
	DC.B	%01101100 
	DC.B	%01000100 
	DC.B	%11101110 
	DC.B	%00000000 

	DC.B	%11101100 	; 'B'
	DC.B	%01100010 
	DC.B	%01100010 
	DC.B	%01101100 
	DC.B	%01100010 
	DC.B	%01100010 
	DC.B	%11101100 
	DC.B	%00000000 

	DC.B	%00101100 	; 'C'
	DC.B	%01100110 
	DC.B	%11000000 
	DC.B	%11000000 
	DC.B	%11000000 
	DC.B	%01100110 
	DC.B	%00101100 
	DC.B	%00000000 

	DC.B	%11101000 	; 'D' 
	DC.B	%01101100 
	DC.B	%01100110 
	DC.B	%01100110 
	DC.B	%01100110 
	DC.B	%01101100 
	DC.B	%11101000 
	DC.B	%00000000 

	DC.B	%11101100 	; 'E' 
	DC.B	%01100110 
	DC.B	%01100000 
	DC.B	%01110000 
	DC.B	%01100000 
	DC.B	%01100110 
	DC.B	%11101100 
	DC.B	%00000000 

	DC.B	%11101110 	; 'F' 
	DC.B	%01100110 
	DC.B	%01100000 
	DC.B	%01101000 
	DC.B	%01101000 
	DC.B	%01100000 
	DC.B	%11100000 
	DC.B	%00000000 

	DC.B	%01101110 	; 'G' 
	DC.B	%11000110 
	DC.B	%11000000 
	DC.B	%11001110 
	DC.B	%11000010 
	DC.B	%11000110 
	DC.B	%01101110 
	DC.B	%00000000 

	DC.B	%11100110 	; 'H' 
	DC.B	%01100110 
	DC.B	%01100110 
	DC.B	%01111110 
	DC.B	%01100110 
	DC.B	%01100110 
	DC.B	%11100110 
	DC.B	%00000000 

	DC.B	%00111100 	; 'I' 
	DC.B	%00011000 
	DC.B	%00011000 
	DC.B	%00011000 
	DC.B	%00011000 
	DC.B	%00011000 
	DC.B	%00111100 
	DC.B	%00000000 

	DC.B	%00011110  	; 'J'
	DC.B	%00001100 
	DC.B	%00001100 
	DC.B	%00001100 
	DC.B	%00001100 
	DC.B	%11001100 
	DC.B	%01101000 
	DC.B	%00000000 

	DC.B	%11100110  	; 'K'
	DC.B	%01100100 
	DC.B	%01101000 
	DC.B	%01101000 
	DC.B	%01101000 
	DC.B	%01100100 
	DC.B	%11100110 
	DC.B	%00000000 

	DC.B	%11100000  	; 'L'
	DC.B	%01100000 
	DC.B	%01100000 
	DC.B	%01100000 
	DC.B	%01100010 
	DC.B	%01100110 
	DC.B	%11101110 
	DC.B	%00000000 

	DC.B	%11000110  	; 'M'
	DC.B	%11000110 
	DC.B	%11101110 
	DC.B	%11101110 
	DC.B	%10110110 
	DC.B	%10110110 
	DC.B	%10110110 
	DC.B	%00000000 

	DC.B	%11000110  	; 'N'
	DC.B	%11100010 
	DC.B	%11110000 
	DC.B	%10111010 
	DC.B	%00011110 
	DC.B	%10001110 
	DC.B	%11000110 
	DC.B	%00000000 

	DC.B	%00101000  	; 'O'
	DC.B	%01101100 
	DC.B	%11000110 
	DC.B	%11000110 
	DC.B	%11000110 
	DC.B	%01101100 
	DC.B	%00101000 
	DC.B	%00000000 

	DC.B	%11101100  	; 'P'
	DC.B	%01100110 
	DC.B	%01100110 
	DC.B	%01100110 
	DC.B	%01101100 
	DC.B	%01100000 
	DC.B	%11100000 
	DC.B	%00000000 

	DC.B	%00101000  	; 'Q'
	DC.B	%01101100 
	DC.B	%11000110 
	DC.B	%11000110 
	DC.B	%11001110 
	DC.B	%01101100 
	DC.B	%00101110 
	DC.B	%00000000 

	DC.B	%11101100  	; 'R'
	DC.B	%01100110 
	DC.B	%01100110 
	DC.B	%01111100 
	DC.B	%01101000 
	DC.B	%01100100 
	DC.B	%11100110 
	DC.B	%00000000 

	DC.B	%01111010  	; 'S'
	DC.B	%11100010 
	DC.B	%11100000 
	DC.B	%01111100 
	DC.B	%00001110 
	DC.B	%10001110 
	DC.B	%10111100 
	DC.B	%00000000 

	DC.B	%01111110  	; 'T'
	DC.B	%01011010 
	DC.B	%00011000 
	DC.B	%00011000 
	DC.B	%00011000 
	DC.B	%00011000 
	DC.B	%00011000 
	DC.B	%00000000 

	DC.B	%11110111  	; 'U'
	DC.B	%01100010 
	DC.B	%01100010 
	DC.B	%01100010 
	DC.B	%01100010 
	DC.B	%01100010 
	DC.B	%00110100 
	DC.B	%00000000 

	DC.B	%11101110  	; 'V'
	DC.B	%01000100 
	DC.B	%01000100 
	DC.B	%01101100 
	DC.B	%00101000 
	DC.B	%00110000 
	DC.B	%00110000 
	DC.B	%00000000 

	DC.B	%11000110  	; 'W'
	DC.B	%10010100 
	DC.B	%10010100 
	DC.B	%11010100 
	DC.B	%11011000 
	DC.B	%11101100 
	DC.B	%01101100 
	DC.B	%00000000 

	DC.B	%11000110  	; 'X'
	DC.B	%11000110 
	DC.B	%01101000 
	DC.B	%00111000 
	DC.B	%01101100 
	DC.B	%11000110 
	DC.B	%11000110 
	DC.B	%00000000 

	DC.B	%10000010  	; 'Y'
	DC.B	%11000110 
	DC.B	%01100100 
	DC.B	%00110000 
	DC.B	%00110000 
	DC.B	%00110000 
	DC.B	%00110000 
	DC.B	%00000000 

	DC.B	%11101110  	; 'Z'
	DC.B	%11000110 
	DC.B	%10001100 
	DC.B	%00011000 
	DC.B	%00110010 
	DC.B	%01100110 
	DC.B	%11101110 
	DC.B	%00000000 

	DC.B	%00101000  	; '0'
	DC.B	%01101100 
	DC.B	%11001110 
	DC.B	%11010110 
	DC.B	%11100110 
	DC.B	%01101100 
	DC.B	%00101000 
	DC.B	%00000000 

	DC.B	%00011000  	; '1'
	DC.B	%00111000 
	DC.B	%00011000 
	DC.B	%00011000 
	DC.B	%00011000 
	DC.B	%00011000 
	DC.B	%00111100 
	DC.B	%00000000 

	DC.B	%01101100  	; '2'
	DC.B	%11000110 
	DC.B	%00001100 
	DC.B	%00011000 
	DC.B	%00110000 
	DC.B	%01100010 
	DC.B	%11101110 
	DC.B	%00000000 

	DC.B	%01011100  	; '3'
	DC.B	%11011110 
	DC.B	%00000110 
	DC.B	%00011100 
	DC.B	%10000110 
	DC.B	%11011110 
	DC.B	%01011100 
	DC.B	%00000000 

	DC.B	%01011000  	; '4'
	DC.B	%01011000 
	DC.B	%10011000 
	DC.B	%11011110 
	DC.B	%00011000 
	DC.B	%00011000 
	DC.B	%00111100 
	DC.B	%00000000 

	DC.B	%11011110  	; '5'
	DC.B	%11000000 
	DC.B	%11111100 
	DC.B	%00001110 
	DC.B	%10000110 
	DC.B	%11000110 
	DC.B	%01011100 
	DC.B	%00000000 

	DC.B	%01001100  	; '6'
	DC.B	%11001110 
	DC.B	%11000000 
	DC.B	%11111100 
	DC.B	%11000110 
	DC.B	%11000110 
	DC.B	%01011100 
	DC.B	%00000000 

	DC.B	%11110010  	; '7'
	DC.B	%11000110 
	DC.B	%10001100 
	DC.B	%00011000 
	DC.B	%00110000 
	DC.B	%00110000 
	DC.B	%00110000 
	DC.B	%00000000 

	DC.B	%01101100  	; '8'
	DC.B	%11000110 
	DC.B	%01101100 
	DC.B	%01101100 
	DC.B	%11000110 
	DC.B	%11000110 
	DC.B	%01101100 
	DC.B	%00000000 

	DC.B	%01101100  	; '9'
	DC.B	%11000110 
	DC.B	%11000110 
	DC.B	%01110110 
	DC.B	%00000110 
	DC.B	%10001100 
	DC.B	%11011000 
	DC.B	%00000000 

	DC.B	%00000000  	; ':'
	DC.B	%00011000 
	DC.B	%00011000 
	DC.B	%00000000 
	DC.B	%00000000 
	DC.B	%00011000 
	DC.B	%00011000 
	DC.B	%00000000 

	DC.B	%00011000  	; '
	DC.B	%00011000 
	DC.B	%00110000 
	DC.B	%00000000 
	DC.B	%00000000 
	DC.B	%00000000 
	DC.B	%00000000 
	DC.B	%00000000 

	DC.B	%00000110  	; '/'
	DC.B	%00001100 
	DC.B	%00011000 
	DC.B	%00110000 
	DC.B	%01100000 
	DC.B	%11000000 
	DC.B	%10000000 
	DC.B	%00000000 

	DC.B	%01111100  	; '?'
	DC.B	%11000110 
	DC.B	%11000110 
	DC.B	%00001100 
	DC.B	%00011000 
	DC.B	%00000000 
	DC.B	%00011000 
	DC.B	%00000000 

	DC.B	%00000000  	; '.'
	DC.B	%00000000 
	DC.B	%00000000 
	DC.B	%00000000 
	DC.B	%00000000 
	DC.B	%00011000 
	DC.B	%00011000 
	DC.B	%00000000 

	DC.B	%00000000  	; ','
	DC.B	%00000000 
	DC.B	%00000000 
	DC.B	%00000000 
	DC.B	%00000000 
	DC.B	%00011000 
	DC.B	%00011000 
	DC.B	%00110000 

	DC.B	%00011000  	; '!'
	DC.B	%00011000 
	DC.B	%00011000 
	DC.B	%00011000 
	DC.B	%00011000 
	DC.B	%00000000 
	DC.B	%00011000 
	DC.B	%00000000 

	DC.B	%00000000  	; '-'
	DC.B	%00000000 
	DC.B	%00000000 
	DC.B	%00111110 
	DC.B	%00111110 
	DC.B	%00000000 
	DC.B	%00000000 
	DC.B	%00000000 

	DC.B	%00001100  	; '('
	DC.B	%00011000 
	DC.B	%00110000 
	DC.B	%00110000 
	DC.B	%00110000 
	DC.B	%00011000 
	DC.B	%00001100 
	DC.B	%00000000 

	DC.B	%00110000  	; ')'
	DC.B	%00011000 
	DC.B	%00001100 
	DC.B	%00001100 
	DC.B	%00001100 
	DC.B	%00011000 
	DC.B	%00110000 
	DC.B	%00000000 

	DC.B	%00111000  	; '(C)'
	DC.B	%01000100 
	DC.B	%10111010 
	DC.B	%10100010 
	DC.B	%10111010 
	DC.B	%01000100 
	DC.B	%00111000 
	DC.B	%00000000 

	DC.B	%00000000  	; ' '
	DC.B	%00000000 
	DC.B	%00000000 
	DC.B	%00000000 
	DC.B	%00000000 
	DC.B	%00000000 
	DC.B	%00000000 
	DC.B	%00000000 

