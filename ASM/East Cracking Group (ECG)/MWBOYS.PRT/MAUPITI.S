;-------------------------------------------------------------------------------
; The East Cracking Group
; ~~~~~~~~~~~~~~~~~~~~~~~
; - how to break standard sync-protections on Atari ST
;   example: Medway Boys protection on Maupiti Island
;            (hacked in 30 minutes on real hardware)
;
; This protection does code modifying of the trace-routine,
; therefore our trace-routine is updated each call.
; --> crccode_start:    <$7700C>
;
; Turboassembler & Bugaboo used!
;-------------------------------------------------------------------------------

                OPT D+
Begin:

*    jsr     instr_cycle


L0000           EQU Begin-$0100
                TEXT
                bra     L0001
                DC.B '* LITTLE'
                DC.B ' PROTECT'
                DC.B 'ION NUMB'
                DC.B 'ER 2.05 '
                DC.B 'BY GL! *'
L0001:          lea     L0000(PC),A6
                move.l  SP,L0009
                move    SR,D0
                btst    #13,D0
                bne     L0008
                clr.l   -(SP)
                move.w  #$0020,-(SP)
                trap    #1
                move.l  D0,L0009

                move.l  $00000010.w,old10

                bra     L0008
L0002:          move.l  A6,$0000043A.w
                lea     L000B(PC),A0
                move.b  $FFFFFA07.w,(A0)+
                move.b  $FFFFFA09.w,(A0)+
                move.l  $00000070.w,(A0)+
                move.b  #2,$FFFF820A.w
                move    #$2700,SR
                clr.b   $FFFFFA07.w
                clr.b   $FFFFFA09.w
                lea     L0007(PC),A0
                move.l  A0,$00000070.w
                lea     L0004(PC),A0
                lea     L0008(PC),A1
                lea     $00077000,A2
L0003:          move.w  (A0)+,(A2)+
                cmpa.l  A1,A0
                bne.s   L0003
                rts

L0004:          add.w   (SP),D7
                sub.b   (A0),D7
                movea.l $00000024.w,A1
                lea     L0008(PC),A2
L0005:          move.w  (A1)+,D0
                eor.w   D0,D7
                ror.l   #3,D7
                add.l   A0,D7
                add.l   A2,D7
                sub.l   A3,D7
                add.l   A4,D7
                move.l  A1,D1
                eor.l   D1,D7
                eor.l   D0,D7
                eor.l   D2,D7
                eor.l   D3,D7
                eor.l   D4,D7
                eor.l   D5,D7
                eor.l   D6,D7
                not.l   D7
                cmpa.l  A2,A1
                bne.s   L0005
                add.l   $00000010.w,D6
                eor.l   D6,D7
                rol.l   #7,D6
                eor.l   D6,$00000010.w
                eor.l   D7,D6
                eor.l   D7,D5
                eor.l   D7,D4
                eor.l   D7,D3
                eor.l   D7,D2
                eor.l   D7,D1
                eor.l   D7,D0
                adda.l  D7,A3
                suba.l  A3,A4
                sub.b   (A0),D0
                andi.w  #$00FF,D0
L0006:          dbra    D0,L0006
                eor.l   D7,(A5)
                ror.l   #7,D7
                movea.l 2(SP),A6
                add.b   (A0),D7
                move    SR,D0
                eor.b   D0,D7
                eor.l   D7,(A6)
                movea.l A6,A5
L0007:          rte
L0008:          lea     0,SP
L0009           EQU *-4
                bsr     L0002

*    move.l  #$00077000,$00000024.w

                move.l  #my_trace,$00000024.w

                move.l  #$12345678,$00000010.w
                movem.l L000A(PC),D0-A6
                stop    #$2300
                stop    #$2300
                DC.B 'F',$FC,$27,$00,$12,$10,'g',$FC
                DC.B $90,$01,$E1,'(K',$FA,$FF,$CA
                DC.B 'F',$FC,$A7,$00,'`<'
L000A:          DC.B $00,$00,$00,$10,'ENJO'
                DC.B 'Y THE TR'
                DC.B 'ACE/SYNC'
                DC.B ' ROUTINE'
                DC.B $FF,$FF,$82,$09,'AND '
                DC.B 'HAVEA NI'
                DC.B 'CE DAY!!'
                DC.B '*GL*',$D3,$A3,$A2,$EF
                DC.B $09,$B8,$E9,'#$',$D0,$D2,$10
                DC.B '{',$A8,$08,'(',$9A,$BB,$A9,$1B
                DC.B $07,'2',$BB,$F8,$A5,$AB,$AD,$01
                DC.B $02,'z',$02,'G',$A7,';Wh'
                DC.B $10,$FA,'Uo:',$B8,':',$03
                DC.B $BD,$E9,'?',$A5,$F8,$E2,'1ž'
                DC.B 'ZE',$F8,$A2,'I',$0D,$F9,$C9
                DC.B 'A"',$0D,'j',$A8,$A8,$1C,'C'
                DC.B '[',$B9,$CB,'8',$8A,$E8,'>',$B5
                DC.B $D6,$1C,$BE,$A7,$11,'W2',$90
                DC.B '[l9',$8B,$C7,$9C,$C0,$A1
                DC.B 'C',$B1,$A8,$B7,'(',$A3,$1F,$D3
                DC.B 'pJ5',$FB,'0HpL'
                DC.B $C1,$86,'[',$AA,$EB,$B0,$BB,'{'
                DC.B 'pBX',$D8,$E5,$EB,$FA,')'
                DC.B ',',$D6,$10,$13,'p',$16,$02,$E5
                DC.B 'U',$E1,'j&',$E4,$B5,'pD'
                DC.B $19,$07,'|v74Ai'
                DC.B $C6,'I]',$AE,'Z',$83,'?',$E0
                DC.B 't',$A3,$E3,$EF,$DF,$F3,';',$C5
                DC.B 'v#BQ',$07,$1B,'e',$08
                DC.B $C3,$8E,$E8,'Lb',$03,$85,$F2
                DC.B 'U',$CA,$D3,'c',$80,$D9,$C0,'|'
                DC.B $16,'%',$1D,$A0,$C5,$0D,$B1,'#'
                DC.B 'ŽBZ',$FE,'p',$94,$BB,$E6
                DC.B $1C,'B',$AA,$F3,$90,$B6,$B8,'~'
                DC.B $16,'Y',$C0,'#',$EF,$A3,$AD,$9C
                DC.B $05,$A0,$BE,'!@aM',$AB
                DC.B $A1,$DD,$ED,'[',$E3,$16,'P',$C8
                DC.B $A0,$F8,$A7,'<',$A1,$D5,$7F,'s'
                DC.B $8E,$B8,'>',$B0,$0F,'Y3',$8D
                DC.B $AA,$D5,$AF,$83,$9E,'b',$E1,$D8
                DC.B $8F,$DB,$04,'ZE',$F8,$98,'y'
                DC.B $EB,'~',$16,'(G',$08,$EC,'i'
                DC.B $F9,$02,$81,$ED,$80,$A7,$E8,$CC
                DC.B 'b',$8F,$C9,$AF,$DD,$CE,$07,$F4
                DC.B $AE,$BB,$1A,':',$CF,$DD,'N',$FE
                DC.B 'v',$DF,$EF,';#A>x'
                DC.B $C0,$DC,$1D,'N',$18,'|D',$9C
                DC.B '1',$96,$91,$7F,$CE,$85,'[s'
                DC.B '&WQ>t',$C4,'Ni'
                DC.B ';',$F9,'k',$F6,$09,'OUq'
                DC.B $07,$F4,$94,'X',$9B,',',$D9,$A8
                DC.B $A1,$FD,'9',$F8,$0F,$DD,$08,$9D
                DC.B $F7,$1D,'w',$95,'k',$9F,'R:'
                DC.B 'V',$BF,'x',$D5,'@',$D3,$EA,$18
                DC.B '_',$B8,$95,$B2,$B1,'W',$C4,'['
                DC.B $CF,$15,'5',$ED,$F4,$80,$99,$D1
                DC.B $FF,$D6,$12,$F3,$7F,'x',$E6,'e'
                DC.B $AA,$A2,'(Y',$AD,$F6,'#',$84
                DC.B $82,'0',$A8,$12,$0F,$FE,$A9,$11
                DC.B $1F,'1z',$BC,$A9,'1',$CB,$0F
                DC.B '"F',$A8,$18,'#H',$9A,$C9
                DC.B $0A,$19,$FE,$CB,$84,$16,$F3,$1B
                DC.B $9A,$C6,'`',$1D,$89,$1D,$DE,$80
                DC.B $A8,$1A,$D9,'EE8',$19,$AC
                DC.B $BC,$E8,$AF,'P',$A9,$F5,$E6,'2'
                DC.B $C5,$A0,$9D,'q',$9A,$83,$A8,$CB
                DC.B $C8,$EA,$94,'Jš{',$CE,'B'
                DC.B '3',$8A,';',$C0,'Qlj',$BE
                DC.B $92,'q',$0C,$1B,$01,$8B,$CD,'z'
                DC.B $91,',i',$C1,$D2,'L',$C3,$13
                DC.B $97,$B9,'2',$15,'6',$C4,'%',$EB
                DC.B $D8,$0F,$CA,'Eu`',$FA,$08
                DC.B 'Il',$A4,'4',$ED,$A7,$C8,$E2
                DC.B $B2,$E4,'[d',$08,'}=',$19
                DC.B $03,$03,$1A,$BC,$F9,$E8,'Bg'
                DC.B $C4,'(I',$1A,$E4,$C0,$9C,'('
                DC.B 'I',$94,$96,$96,$C5,$10,$FB,'Y'
                DC.B 'zLR}4',$95,'AY'
                DC.B $DB,$12,$98,$A1,$B8,$E0,'dm'
                DC.B $C7,$DA,'/(',$D9,$E5,$D4,$A7
                DC.B $F9,'u=',$91,'HA',$95,$8C
                DC.B $9C,$CB,$B6,$97,$88,')j',$D8
                DC.B $AF,'_',$CC,$F4,$8B,'Vc',$B2
                DC.B $09,$BE,$BD,'J',$17,$E0,$A8,$0C
                DC.B $AB,$AF,$A3,'0',$95,'v',$08,$ED
                DC.B $AF,$F3,$03,$87,$09,$06,$C7,$13
                DC.B $94,$B9,$CB,'I',$B9,'c',$15,$E9
                DC.B '\L=',$E3,$E5,$BC,$91,$B4
                DC.B $88,'<',$A0,$B3,'3D',$89,$19
                DC.B $8B,'n)”<C',$89,','
                DC.B $27,$BB,$DB,'V',$C6,'$',$18,$C6
                DC.B '`',$A1,$C2,$E0,$B0,$8D,$AB,$BA
                DC.B $27,'%',$9D,'P^',$D3,'?4'
                DC.B $A0,$1D,'b',$1F,'dt',$95,';'
                DC.B $AC,$D3,$D2,$AA,$B0,$E0,$A1,$DE
                DC.B $D6,'V',$E9,'Z',$B7,$B1,$E9,'m'
                DC.B $AB,'M}',$86,$95,$11,$A2,'['
                DC.B 'a',$DA,$F8,'/',$F8,$06,'j',$B9
                DC.B $F0,$9F,$EE,$B4,$EB,'FG3'
                DC.B $1E,'nL',$BD,'YO',$F8,'4'
                DC.B $AB,$CF,$FF,'0',$B0,$15,'vh'
                DC.B $07,'Zdw+',$DF,$AC,$D3
                DC.B $B3,$CB,$B0,$E7,'#',$0A,$D6,'T'
                DC.B $82,'>',$B7,$B6,'h',$EA,$AC,$BD
                DC.B $D9,'m',$9D,$C0,$1A,'Fg',$CB
                DC.B 'n3',$F8,$07,'S',$F7,$F0,$9C
                DC.B '-',$F9,$EB,'F',$E1,$14,$1E,'i'
                DC.B $99,$A3,'YMn',$BD,$AB,$C8
                DC.B $09,$94,'l',$15,$9F,$27,$FB,'L'
                DC.B $F4,$BF,$A3,$F6,'Tb',$08,$BE
                DC.B $DF,$DE,$EC,$A6,$8C,'"xI'
                DC.B $9A,$FB,$B9,'b',$B7,$81,$B4,$CD
                DC.B $E9,$CE,$12,$95,$85,'p',$A8,$8E
                DC.B $A3,$99,'<',$A0,'A,',$05,'t'
                DC.B 'Pl',$82,'~',$C4,$84,$AD,'.'
                DC.B $D8,'p',$B1,$0F,$BC,$F1,'tG'
                DC.B $F0,'{',$A0,$F0,$9D,'Wn',$8C
                DC.B $C3,$B8,$85,$BC,$9D,$AB,'O',$8B
                DC.B $04,$1F,$80,'r',$C8,'J',$83,$D9
                DC.B '\A',$E8,'2',$80,$CA,$8C,$BC
                DC.B $B1,$DD,$0B,'x',$15,$00,$A3,$99
                DC.B $AA,'N',$A2,$1D,$1E,$A8,$F9,$C2
                DC.B $AB,$D2,$D2,$D7,$9B,$7F,$B8,$B7
                DC.B '5v',$CB,$BA,$BF,$8E,$C4,$9B
                DC.B '5',$87,$B4,$81,'?',$10,$FB,'Y'
                DC.B 'vo9',$95,';',$B7,$14,$BE
                DC.B $E7,'k',$CE,'k$',$D9,'k',$9E
                DC.B $1D,$EA,'5',$A9,'V',$C4,'f',$95
                DC.B $05,$88,$C2,$0F,'4',$A4,$A8,$0D
                DC.B $CF,$19,$1D,$93,'D',$1C,$EA,$EB
                DC.B $AF,'Z',$C5,$E4,$8B,'V',$93,$82
                DC.B $09,$B9,$B0,$DD,$8F,$E0,$A8,$0C
                DC.B $AB,$AF,$96,$F2,$D7,$FD,'<',$C4
                DC.B '{[+',$B6,'-',$AC,$F3,$12
                DC.B $D4,$B8,$E8,$E1,$B8,$A8,'b8'
                DC.B '^M',$CA,$05,$15,'(',$B9,'N'
                DC.B $F4,$AC,$E7,'qd',$F7,$D9,'F'
                DC.B 'AR'
L000B:          DS.W 8
                DC.B $A7,'#',$0A,$89,$8D,$F0,$F8,$A2
                DC.B $EF,$81,$0A,$A1,$BC,'X',$27,'!'
                DC.B $AB,$F8,')',$0A,$81,'#{|'
                DC.B $97,$8A,$BD,$01,'7',$BD,$91,$1C
                DC.B $9A,$94,$0B,$C3,'Xa',$BA,'x'
                DC.B $81,$AB,'~',$F7,$8A,$C9,'$',$0F
                DC.B $F8,$12,$18,$AB,$9A,$BC,$D8,$A8
                DC.B 'j”U',$81,$B8,$C7,'5&'
                DC.B $16,'4,',$0E,$E0,$AA,$91,'('
                DC.B '"[',$A6,$CE,'{4',$86,$F9
                DC.B '4',$81,$B7,$EA,'8',$03,'w',$BA
                DC.B 'w',$AB,'4',$1B,'1',$1F,$E9,'0'
                DC.B $92,'4',$AE,$01,'V',$B7,$83,$B4
                DC.B $04,$EC,'r',$A5,$01,$A8,$B8,'w'
                DC.B $B2,$DD,$92,$96,$18,$AA,$92,$01
                DC.B '@',$1B,$8A,$9C,$A7,$80,$1B,$C3
                DC.B $17,$AF,$BE,$8D,$9A,$BB,$1F,'7'
                DC.B '7',$1F,$AA,$81,'7',$A0,$A9,$12
                DC.B $8F,$F8,'(',$A1,'!e',$F8,$FF
                DC.B $18,'j',$83,$8C,$BC,'~qH'
                DC.B $91,$8A,$17,$0F,$F8,$E8,$12,':'
                DC.B 'V4',$BA,$8C,$14,$9A,$04,$EE
                DC.B $8E,$A0,'\',$DD,$D6,'*',$A3,$00
                DC.B $99,$D8,$FC,$E8,$A7,$AD,')',$C5
                DC.B $05,$08,$F1,$04,$C6,'-',$B4,'f'
                DC.B $F6,$D4,'@',$9D,$06,'3',$BD,'^'
                DC.B $A1,$DE,'x*U',$DB,$DB,'`'
                DC.B $FC,$A2,$1A,$B2,$0E,$A4,$B9,$F8
                DC.B '8',$D3,$E5,$05,'&',$01,$7F,'O'
                DC.B $C0,'q',$EC,$1A,$E9,$15,'@&'
                DC.B $FE,'n',$F6,'X',$E8,'e',$A1,$F8
                DC.B $00,'A',$95,$C3,$97,$D3,$87,$C2
                DC.B $FE,$89,$D9,'.',$E3,'9rP'
                DC.B $F4,$11,'8`',$A6,$B7,'#',$A7
                DC.B $0F,'c ',$0F,$AB,$8A,'Bp'
                DC.B $C2,'Gu',$FE,$F6,$CF,'(',$97
                DC.B '?',$9C,'<',$17,$10,'Z',$C4,'h'
                DC.B $ED,$B6,$05,$19,'nGvO'
                DC.B 'f',$97,$1F,$AC,$B6,$96,'"%'
                DC.B 'Q',$D3,'/',$D2,'N',$A7,'z',$BD
                DC.B '%',$18,'`^',$97,'*F8'
                DC.B $A7,$B9,$1E,$9C,'^',$81,$BB,'2'
                DC.B 'v',$9D,$D0,'/y}',$85,$BC
                DC.B 'p',$EC,$1E,$E6,$B1,'1',$CC,$19
                DC.B 'p*5',$A3,$09,$F6,$A9,$B7
                DC.B 'UaU&',$16,$13,$97,$B3
                DC.B $CE,$D3,$89,'z',$B6,$9B,$AD,'l'
                DC.B 'k|',$0E,$FA,$15,'m',$D7,'G'
                DC.B ':',$B3,'jx',$EE,'f#?'
                DC.B $D5,$1C,$1F,$B5,$DA,'3',$DC,$B2
                DC.B $96,$E9,'2',$B0,'4%pW'
                DC.B '03',$BE,$89,'n',$AB,'t5'
                DC.B $BE,$F1,$CF,'C!j=<'
                DC.B $8E,$BE,',',$8B,$01,'q',$93,'3'
                DC.B $19,$EE,'/D\',$99,$B7,' '
                DC.B '|y',$CE,$02,$D8,'*',$16,$E3
                DC.B '>?',$D5,'F',$B1,'z?',$AA
                DC.B $82,$14,$EF,$0F,$A9,'(',$E0,';'
                DC.B $F1,$96,'`',$12,$D7,$BA,$D3,$B4
                DC.B $97,$E7,$8F,'2',$CF,'5',$06,'@'
                DC.B $1F,'O',$CF,$95,':J',$01,'u'
                DC.B $B8,$FB,$CC,$A6,$C5,$C7,$C3,$F9
                DC.B $97,$18,$87,$AB,$DB,$0F,'y?'
                DC.B 'c',$8F,$8E,$E2,$B3,$E7,$AF,'-'
                DC.B $8F,'p_W',$18,$27,$92,'z'
                DC.B 'c',$88,'6S',$F5,$FE,$C7,'K'
                DC.B $B4,'U',$C8,$00,$BC,' EW'
                DC.B $D6,'gtQtKK',$D3
                DC.B $1A,$E4,$0E,$9D,' )',$04,$AA
                DC.B $B4,'=',$87,'[',$0A,$EA,'yg'
                DC.B $AC,';',$C1,$AD,$09,'-',$1D,'7'
                DC.B $FF,'x{',$FA,$17,'s>',$D9
                DC.B $EC,$A7,'Pa',$96,$B5,'U',$12
                DC.B '&8',$89,'h',$BB,$F7,$FC,$D7
                DC.B $B4,$D8,$96,'+',$1F,'g7',$97
                DC.B $DD,$1E,$EE,$D4,'c',$0C,$DF,'['
                DC.B '^',$83,$DE,'}9%',$F2,$AE
                DC.B '+',$1B,$AA,$FA,$F5,']',$7F,$BC
                DC.B $BC,$BF,$D7,'lR',$A4,$1B,$FF
                DC.B $F1,' hv',$C9,$8F,'B',$F2
                DC.B $9E,$14,$DB,$AA,$18,$18,'}',$04
                DC.B $A4,'<',$D0,']',$94,$E1,$0C,'u'
                DC.B $88,$01,$BF,$01,'++',$AA,$13
                DC.B 'Uu',$19,'|',$0E,$D0,$D3,']'
                DC.B $98,'U',$1A,'{',$FC,$AC,';',$99
                DC.B $91,$02,$8C,'&u',$B5,')',$96
                DC.B $C7,$F2,$13,$A5,'j',$F9,'W',$9A
                DC.B $9A,$AC,'5}?&',$EF,$02
                DC.B $BF,$94,$C4,$C6,$9E,'H',$80,$E4
                DC.B $06,$EE,$B9,'$S9',$1E,$CA
                DC.B $F3,$D8,'8',$02,'4',$E0,$B1,'2'
                DC.B 'w',$D1,$9A,$EC,'SKw0'
                DC.B $BB,$D1,$8C,$CD,']@?',$B5
                DC.B 'P',$08,$05,'51U',$11,')'
                DC.B $CF,'m',$C8,$9C,$09,'"@',$D3
                DC.B $F1,'w',$F1,$F7,$0D,$B2,$12,':'
                DC.B $FD,'^',$F9,$13,'d{',$FE,$E8
                DC.B $DE,'f',$1F,$D8,$EE,$94,'3\'
                DC.B $F8,$97,$1F,$0E,$EE,$D4,$82,$D8
                DC.B $8C,'|4',$AE,$CE,'Z',$D5,$8C
                DC.B $C8,$81,$A3,'d!',$D2,$05,$FC
                DC.B $A8,'s=',$AA,$DD,'KT',$A9
                DC.B $D9,$ED,'K',$16,'f',$D2,$9C,$07
                DC.B ' ',$7F,$14,$E3,$0D,$04,$A8,'Z'
                DC.B $00,$1E,$F7,'P%',$C7,'-',$1A
                DC.B 'U',$0A,'<',$04,$A5,$FB,'##'
                DC.B 'D',$CC,$EC,'bt',$D6,'On'
                DC.B $8D,$95,'C',$C0,'K',$DE,$D3,'>'
                DC.B $F3,$9C,$10,'b',$88,'f',$E1,$E7
                DC.B 'Sžd',$07,'y',$FF,$E2,$99
                DC.B 'm',$FF,$AD,$7F,$FE,$87,$A3,$1B
                DC.B 'E',$89,$EE,'&',$88,$13,$96,$AF
                DC.B $05,$16,$0D,'Z2',$EC,'\k'
                DC.B '.',$81,$E7,'q8',$17,$91,'š'
                DC.B 'v',$BE,$D9,$1E,'#b',$0D,$05
                DC.B $95,$88,$8C,':',$C8,$C2,'Q',$87
                DC.B $03,$D6,'=Z',$C6,$E4,'.',$B1
                DC.B $98,$19,$B8,$14,$B7,'u',$DC,$F6
                DC.B 'n}',$0D,$CB,$A6,'M',$0C,$1F
                DC.B '}u',$93,$F4,'7',$9D,$CC,$CF
                DC.B $CA,$D6,$AA,$FB,$0E,$B7,'(',$FE
                DC.B 'F^',$CA,'/',$9D,$0D,$A1,$0F
                DC.B 'v',$C0,$84,'M~+',$8B,'3'
                DC.B $9E,$A1,'p',$D6,'j',$FE,$A1,'v'
                DC.B $A1,$EA,$AD,'i',$A9,$E6,$C2,$8B
                DC.B 'm',$DC,$C1,$D5,$B4,$C4,$8A,$97
                DC.B '>O',$E6,'+',$DF,'S*',$BB
                DC.B 'a',$0B,'n5g.18'
                sub.b   D2,(A6)
                roxr.b  D1,D4
                move.w  $9532(A2),-(SP)
                sub.l   (A6),D6
                jsr     $9500(A4)
                DC.B $92,'ld',$B6,$16,$1D,'x',$1B
                DC.B 'O',$D8,'^',$C9,']2U)'
                DC.B $F9,$FD,'B',$AE,'#',$B8,'q',$F9
                DC.B 'h}',$F5,'2',$E2,$C7,$8D,$C2
                DC.B '!',$CD,$D1,$B2,$B9,'p\',$11
                DC.B $CD,$DD,$8A,$8E,$D1,$C1,$16,'A'
                DC.B 'V',$AA,'Hm{',$B1,$F2,$89
                DC.B 'f',$9E,$09,'k',$87,$C3,$AD,$A6
                DC.B '-',$0E,$A9,';',$8A,$D6,$C8,$FF
                DC.B $B2,'P',$F9,$80,$F2,$A5,$DA,$DA
                DC.B $83,'P',$F5,$18,$B1,$CA,'{',$1A
                DC.B $14,'0^',$C5,'<',$92,$C3,$89
                DC.B 'JBb',$C4,'S',$AB,$E5,$C4
                DC.B $B3,$B0,'e',$F1,$1C,'š{n'
                DC.B $F1,'~',$F2,$98,$81,$0C,$83,'#'
                DC.B $91,'`”>!',$8F,$06,$91
                DC.B 'g',$E5,'v',$86,';',$00,'Rr'
                DC.B $A1,$12,$91,'kM',$90,$1C,$82
                DC.B '.#',$B7,$10,$D2,'&',$C0,$CB
                DC.B $0E,$91,'*',$87,'4',$F1,'G',$F9
                DC.B 'd',$05,'J?',$0A,$A6,'H',$FA
                DC.B '[',$8D,'b',$13,$82,'I',$27,$E5
                DC.B $84,'rSn',$DD,$C7,$FE,$AC
                DC.B $E4,$D0,$04,$0E,$E5,$09,'x>'
                DC.B 'žZa',$86,'=',$82,$84,$AA
                DC.B 'Z-v',$91,'RSFI'
                DC.B '7HV',$EE,$8D,$CD,$BD,$84
                DC.B 'g',$C0,'B',$A6,$F2,$0B,'8V'
                DC.B $91,'9mE%c',$E0,$A6
                DC.B 'Y',$CD,$0A,' (^e',$CD
                DC.B $A7,'6[m',$BD,$8B,$15,$F7
                DC.B $E9,$AF,$8D,$1D,$87,$05,$F7,'M'
                DC.B $F4,$F5,$96,$BC,'\',$CE,$0B,'Y'
                DC.B '(c',$9D,'n',$0F,'z',$C1,$B9
                DC.B 'I',$09,$9E,$95,'dr',$8C,'f'
                DC.B '{}w',$A4,$92,$27,$D3,'i'
                DC.B $D8,$B2,$DE,$F3,'si_',$D3
                DC.B $B7,$F2,'ot',$EE,$86,'@)'
                DC.B $1B,$E3,$A1,$D4,',Y',$0F,'V'
                DC.B '}=?K',$AD,'"',$B3,$05
                DC.B $DB,'r',$C6,$F2,$93,$95,$E2,$C6
                DC.B '5',$82,'as',$CE,$82,$C0,$99
                DC.B $AD,$B5,$AB,$13,$D4,'H',$8D,'F'
                DC.B $7F,$FD,$E7,$12,'H>',$92,'A'
                DC.B $D3,'1',$CE,$F1,$B3,'1v',$F8
                DC.B $B4,$92,$03,$7F,$AD,'Ž?',$08
                DC.B $7F,$8F,$AE,'S\7',$04,$B5
                DC.B 'A',$BC,$AF,$B9,'S?r}'
                DC.B $B6,$FD,$F5,$F8,$D4,']Y',$F3
                DC.B '3"',$95,$0D,$83,'i',$A3,$F5
                DC.B $02,'b',$B1,$92,$04,$FE,$FB,','
                DC.B $F4,$0E,$19,'Om:R',$99
                DC.B $8A,'\',$A1,'>',$0C,$88,$E3,$E6
                DC.B $B1,$B2,$A7,$8B,'Ss',$02,$A1
                DC.B $AC,'5',$BB,$D1,$CC,$E5,$BA,$04
                DC.B 'w',$DE,$E3,$12,$08,'61',$B5
                DC.B $8D,'<',$AD,'}',$A4,'3v',$98
                DC.B '@P',$BB,$0A,'#}a',$0D
                DC.B $7F,$0F,$FE,'Y',$FB,$E3,'z|'
                DC.B $FA,$AD,$AD,$B9,$13,$D7,$ED,$B0
                DC.B $8D,$9C,$D9,$B3,$DB,'^Y',$13
                DC.B $8F,'W',$BB,$8A,$F3,$87,$E0,$FD
                DC.B $01,$E2,$01,'H',$F9,$E3,':T'
                DC.B $FD,'m',$15,'P0',$93,$E5,$AF
                DC.B $90,'y',$8B,'K',$FB,';',$9C,'"'
                DC.B '#',$12,$0E,'!',$81,$A4,'.',$94
                DC.B $F3,$C1,$CC,$C4,$E1,'p',$95,'F'
                DC.B $B6,'g',$13,'>>U',$F4,'&'
                DC.B $BD,$CC,$CE,$B0,'R',$86,'~',$D9
                DC.B 'I',$8E,$CB,$19,$E1,'w',$DF,$DD
                DC.B ',',$A2,'T',$9C,'^vE',$14
                DC.B $8F,$15,$85,'?',$CA,$DD,'5',$0D
                DC.B $9E,$16,$89,'F]B',$1B,'C'
                DC.B $14,$F2,'i',$83,$BE,$96,$BC,$B6
                DC.B $17,$04,']',$D7,'CH',$CB,$C2
                DC.B 'L@',$AE,$D5,$A9,'y{J'
                DC.B $D6,'<',$FA,'u',$E5,$B3,'e',$B5
                DC.B 'G',$C4,' ',$F0,$C9,$96,$F8,'n'
                DC.B '==',$9A,$F3,'1<',$E3,$93
                DC.B '*',$D5,'&&Azf',$93
                DC.B ',Ž.',$19,$AA,$02,$1E,$A1
                DC.B $17,'$,',$FC,']n',$E8,$00
                DC.B $9A,$FB,'_JI9E',$B1
                DC.B $AA,$CF,$A3,$88,$9F,'^\x'
                DC.B $AB,' p',$B2,'P',$D3,$A0,'"'
                DC.B $0A,'tC',$BB,$93,'O',$87,$05
                DC.B $BA,'D',$9F,$8F,$1F,$DD,$A2,'!'
                DC.B $13,$C8,'F',$98,$11,$27,$B0,'R'
                DC.B 'Q',$AD,':{',$02,$CF,$CD,$AE
                DC.B '4',$14,'q',$AF,'j6',$0A,$B8
                DC.B '>',$85,$AB,$1B,$D0,'7|',$18
                DC.B $1C,$EE,$18,$D7,$DA,$BF,$F1,'3'
                DC.B $13,$09,'+',$8D,$FE,$9A,$81,'J'
                DC.B 'F',$90,$03,$DF,'9@H',$EA
                DC.B '#',$C7,$BB,$A0,'[',$B7,$D4,'O'
                DC.B ' 8',$9F,$DF,$BF,$C4,'o',$80
                DC.B $EB,$D8,'q',$E8,$12,$C5,',]'
                DC.B $88,$97,'#',$9B,$91,$AB,$BB,'X'
                DC.B $D5,$1C,' D',$DA,$A7,$B2,'#'
                DC.B 'S',$FA,$C7,'v',$AC,$E2,'k',$C0
                DC.B 'c',$A7,'@',$E2,'1',$A1,$E8,$C5
                DC.B $95,$96,$C3,$A7,$D8,$C4,'8',$C8
                DC.B $C7,$BA,',C',$18,$EE,'X`'
                DC.B '[',$83,'O',$0A,'Y|',$90,$C1
                DC.B $10,'W_',$ED,'Q',$F2,';P'
                DC.B $B7,$AD,'C',$A8,'b',$C6,$BA,$B8
                DC.B 'i',$15,'Pv',$A6,$13,'f',$10
                DC.B '_x',$F7,'3$',$80,'t?'
                DC.B '&',$90,$CF,$E0,'7v',$B4,$B6
                DC.B 'f',$AE,$D6,$BA,'J',$C4,$0A,$12
                DC.B $C4,'em',$D5,$0D,$1F,$87,'D'
                DC.B $16,$C6,$D8,$DF,$8D,'>',$C8,$83
                DC.B $D8,'>O',$A7,$A2,')*',$DD
                DC.B '(<o',$02,$EA,$B8,$8D,$AB
                DC.B $CF,$99,$F1,$D9,$CB,$E2,'M',$85
                DC.B $A2,$8C,'ia',$A2,$1B,$13,$14
                DC.B '9q�&',$AE,$80,$E4,$8C
                DC.B $E6,'W',$8C,$F2,'6',$9B,'rC'
                DC.B 'G[',$B8,$AA,'<',$E4,'A',$E4
                DC.B ',V',$FE,$1D,'T',$C4,$F2,$F2
                DC.B ':U',$81,$9B,$CA,$D5,$19,$00
                DC.B '4',$9D,'{',$8F,$D4,$E2,$BE,$9C
                DC.B 'm',$B3,'Q',$DB,'T',$80,$CB,$C1
                DC.B 'P#',$07,$A2,'P7',$90,'j'
                DC.B ' -',$A0,$E5,$B8,$8D,$D8,$F7
                DC.B $B1,$B2,'OGt',$FB,'P',$FD
                DC.B '/Z',$B1,'-*-',$A3,'!'
                DC.B ';J~9Y:',$80,$F9
                DC.B '#',$AC,$BF,'[]',$B6,$1C,$EE
                DC.B '9',$03,$C1,'@',$E4,'?',$90,$B1
                DC.B $AA,'4',$F2,$EE,'3',$10,'4”'
                DC.B '=',$14,$B5,$E9,'h0',$A2,$C0
                DC.B $BB,$7F,$8C,'j',$D5,'w',$10,$9A
                DC.B $A0,'t',$D6,$FF,$C4,$87,$D0,$E4
                DC.B $FB,$09,$9F,$99,$C2,$92,$D4,'u'
                DC.B '@',$EF,$C7,$AA,'!',$EB,'M',$0F
                DC.B '^',$C4,$C1,$C4,$B4,$02,':',$17
                DC.B '=',$1B,$F5,$B2,$DE,'/B',$85
                DC.B $11,$82,'O',$FD,$E0,$0E,$BA,$93
                DC.B $D2,'4/',$CE,$0C,'ZEZ'
                DC.B $F8,$9D,'h',$C3,$EC,$DC,$F0,'a'
                DC.B $CE,'s',$88,$91,'8s',$BA,$CD
                DC.B $C2,'Z',$ED,'7',$B9,$EB,'K',$15
                DC.B 'F',$E2,$1B,$7F,$D9,'OgI'
                DC.B $A7,$85,$A4,$EE,$04,$F8,'2',$96
                DC.B 'L',$95,$1E,'ŽAŽd['
                DC.B 'G',$CC,$C3,$16,'3',$B8,$F2,'9'
                DC.B $CA,$E9,'$',$06,$27,$EB,$A9,$BE
                DC.B $95,$B2,$F3,$CE,$C5,$AE,$00,$04
                DC.B '=E!',$DA,'S',$92,$17,$B4
                DC.B $E7,$E6,'/',$0D,$9F,$DD,$1B,$7F
                DC.B $AC,$A3,$BD,$01,'4p',$E8,$C4
                DC.B $E3,$D3,$16,$B3,'Z',$EF,$1D,'M'
                DC.B $17,$9D,$C1,'Fgc',$CD,$94
                DC.B 'v',$8E,$B2,$86,'A',$80,$16,'c'
                DC.B $8E,$12,'u',$05,$AF,'g',$9B,$DC
                DC.B '{GMEj',$F2,'n!'
                DC.B $09,']',$E1,'"�NL4'
                DC.B 'H',$93,'V',$0F,$98,'e™G'
                DC.B '1,:',$AC,$96,$8D,$A8,'8'
                DC.B $0C,$CA,$F1,'V',$C8,'^',$F2,$AC
                DC.B ':M�n',$E5,$A4,$95,$E9
                DC.B $8C,'=\',$8F,$27,'y8',$CA
                DC.B $D1,'z',$E5,$0D,$1A,$8E,$BB,'x'
                DC.B $CA,'d6O=',$B4,$95,'R'
                DC.B $1A,$15,$A1,$94,$09,$8C,'m0'
                DC.B $BF,'[6',$0E,$D1,$FC,$BA,'Z'
                DC.B $C3,'(',$AD,'fq',$8D,$BA,$FE
                DC.B '>_',$9F,$B7,$DB,'Z',$FB,$A5
                DC.B 'x',$85,'A',$1B,' ',$E3,$BF,$FC
                DC.B 'An',$18,'Nb',$A4,$0E,$06
                DC.B $C5,$93,$93,'6',$B7,'y',$87,$93
                DC.B $DB,$8D,'`',$B0,$C8,'F',$04,$CA
                DC.B $E8,'d',$E2,'u|',$AE,'^`'
                DC.B 'R',$08,$9E,$E3,$FB,$B9,$8F,$02
                DC.B $C7,$D3,$DB,$A1,$A0,$9D,$DE,$99
                DC.B $BC,'2',$EE,$F3,')bS*'
                DC.B 'v',$CA,'z',$8D,$A8,$98,$BC,$DC
                DC.B $A5,$D8,$ED,$01,'$D',$F6,'r'
                DC.B $BB,$E3,$96,$DC,$A7,'^',$C5,$96
                DC.B '(^',$05,'n:=',$0A,$C2
                DC.B $14,$10,$BB,$AE,$0F,'E',$DF,'E'
                DC.B 's',$F6,'[Xv',$0E,$B8,$9A
                DC.B $DB,')',$CD,'J2',$A5,$82,$8F
                DC.B $CC,$BC,'?',$A3,$A4,'d',$89,$B7
                DC.B $14,'j',$BE,'d',$DC,$07,$D8,$C3
                DC.B $BF,$A3,$C8,$F3,$F0,'`D#'
                DC.B $9D,$8E,$CF,'|',$1E,'s',$FD,'M'
                DC.B $8B,$AB,$08,$D7,'J6ku'
                DC.B $F3,$A5,':l',$FD,$FE,'X|'
                DC.B $AA,'yKd',$D2,']',$8B,'F'
                DC.B $8E,$E4,$82,$1D,'4',$C9,$8D,$AE
                DC.B $EF,$0D,'N',$A0,$D0,$B8,$1C,$86
                DC.B 't',$0B,$FB,$B3,$EE,'7',$D7,$12
                DC.B $90,$DB,'~',$8A,$A0,'k@p'
                DC.B $F0,$01,$27,$8B,$1C,'u',$CE,'r'
                DC.B $C4,$F4,'WH',$B2,$90,$0B,'4'
                DC.B 'žP',$F1,$8F,$8E,$AA,'!F'
                DC.B '#',$DC,$B1,'<',$9B,$07,'Ž',$27
                DC.B $1A,'|',$82,'I',$E1,'Gb:'
                DC.B $DD,$12,'2V',$D2,'(',$B1,$04
                DC.B 'q+?',$B7,$03,$B0,'+',$84
                DC.B $F1,'@',$B0,'R',$82,'H',$A2,'+'
                DC.B 'U}1',$CC,'o',$A4,$D1,$A3
                DC.B $F5,$B6,'w&',$0D,'i',$03,$A1
                DC.B $BA,'o',$D8,'UP',$B0,$B6,'B'
                DC.B $C5,'d',$8C,'OB',$87,$B7,$03
                DC.B 'W9',$13,'5',$19,$CA,'"',$AE
                DC.B 'y',$27,'y',$14,'5',$8F,'|',$CB
                DC.B $8F,'ZZ',$DE,'d',$08,$D9,'L'
                DC.B 'eVN',$04,$F0,$EC,$A4,$B8
                DC.B '(',$FB,$C7,'HWEB',$FE
                DC.B $06,'*F',$0B,$16,$EA,$E9,$E9
                DC.B $0F,$96,$12,'.',$AA,$96,'\',$CA
                DC.B $09,'?',$FC,$B2,$16,$C5,'M',$19
                DC.B $02,$C3,$0F,$AC,'8Y',$84,$0B
                DC.B 'X',$FA
                moveq   #$B1,D2
                move.l  A4,-(A3)
                cmpa.w  -(A4),A1
                moveq   #$DE,D0
                jsr     $BFB0(A4)
                DC.B 'C',$82,$D9,$07,'@',$CD,$82,'|'
                DC.B $E4,$E5,$F2,'=',$FF,$F5,$1C,$BF
                DC.B 'e',$BB,$99,$FC,$F4,$F0,'|',$90
                DC.B $A7,$E9,$F2,$DB,'e',$C9,$E2,'g'
                DC.B $11,$1C,$BC,'W',$B7,'vi',$C3
                DC.B $E2,'+',$E4,$FE,$B1,'š5',$FA
                DC.B $E0,$C5,'JP',$A2,$C4,$CC,$D4
                DC.B '5wA',$B6,'"',$F1,$1F,'5'
                DC.B $F6,$90,'/)',$BA,$9B,$80,'"'
                DC.B $BD,$9B,'V',$E4,$97,'+ ',$89
                DC.B $C1,$AB,$A6,$CF,';',$07,'?',$99
                DC.B $AF,'!',$FB,$08,$E5,$94,$10,'E'
                DC.B $1A,$C7,'2',$C5,$FD,'x',$F5,$DD
                DC.B $0D,'H',$EF,$BF,'E',$99,$8F,'"'
                DC.B $05,$82,$A7,'9',$D5,$B5,$B2,'('
                DC.B $9A,$AC,'BqK',$C4,'R',$D8
                DC.B 'k',$D6,'8',$E0,$BA,$9B,')',$F1
                DC.B $94,$EF,$DC,'3',$C9,'/X',$1D
                DC.B 'R',$92,'PN7S',$1A,$07
                DC.B '=',$F0,$90,$F7,$A6,$CE,$AE,$AC
                DC.B $CC,'D',$A1,'P3',$C1,'*',$9E
                DC.B $F1,$CF,$9C,$AA,'(',$94,$06,$EF
                DC.B '}H',$E8,$F6,'_`',$C5,$08
                DC.B $12,$ED,$9F,'t',$B6,$8A,$D0,$A7
                DC.B 'h0',$E7,$FF,'D',$D1,$A5,'i'
                DC.B $AE,$BB,'H',$13,$8D,$FC,'r',$D0
                DC.B $87,$1F,$84,$8A,'X',$AB,'JV'
                DC.B $EF,$DF,$11,$DB,$0C,'[',$CC,$C2
                DC.B '"',$E4,$EE,'5',$AC,' ',$9B,$8E
                DC.B $9C,$8D,$BA,'i',$8B,'n&',$EB
                DC.B 'mj',$B5,$14,'6',$A3,$18,$EA
                DC.B 'O',$27,$BC,$EE,$93,$EC,$96,'.'
                DC.B 'X-',$12,$03,'bH',$E7,$B7
                DC.B $09,$27,$DE,'(t',$DB,'s',$E8
                DC.B 'e',$9E,$83,$E0,'h',$9B,'bZ'
                DC.B $01,$B5,'n',$AA,$EF,'%',$D1,$D0
                DC.B '(',$0D,$AF,'d',$88,$F6,'š~'
                DC.B $87,$FB,'.',$F0,$EA,'u',$86,$EC
                DC.B $E3,$E1,$8B,'4R',$1C,$B1,$BD
                DC.B $9E,$CE,$A7,'DD',$F4,'\',$BE
                DC.B $B9,'N',$B2,'z',$94,$B7,$01,$AA
                DC.B '7}',$CE,$07,$1B,$1D,$00,'Z'
                DC.B 'f',$87,$C5,$97,$E9,$AF,$F8,$98
                DC.B '@2kq',$FA,$9C,$05,'3'
                DC.B $BF,'ODfjt',$CE,$FB
                DC.B $95,'I',$BC,$E4,$CF,$AA,$DC,'V'
                DC.B 'DZrD',$8D,',68'
                DC.B $EC,'$',$A0,'D',$E9,'0<',$E9
                DC.B 'QG$?',$D6,$B5,$DE,'O'
                DC.B $AF,$CA,$A0,'NA',$ED,$D7,$DD
                DC.B $D7,$B3,$AB,'>',$F4,'9%',$E2
                DC.B $80,$F0,'kjW',$CA,$B6,$A8
                DC.B $83,$B0,' ',$7F,$A1,'4p5'
                DC.B $AE,'=G',$E2,$FB,'1',$E4,$A8
                DC.B 'M',$8D,'94',$A3,'1',$84,$B6
                DC.B $CF,$DE,$8C,'S',$AF,'2[w'
                DC.B $E2,$1C,'t',$B9,$F4,$B6,$92,'Q'
                DC.B '= ',$08,$82,$85,$A0,$05,$F8
                DC.B $87,$AF,$17,$A8,$F5,$BF,$8C,$EE
                DC.B '(=',$AC,$F1,$E8,$D9,$B8,$B6
                DC.B 'aA',$CF,$98,$DA,'r',$18,$86
                DC.B $13,$87,$14,$BE,$93,'7',$CA,$90
                DC.B '>',$B9,$A2,$0D,$96,$02,'+',$82
                DC.B $FD,'&',$A0,$95,'s',$D7,'Bp'
                DC.B $EB,$81,$A1,$F5,$9B,'4',$12,$C5
                DC.B '37',$E9,$0E,$93,$03,$BB,'Z'
                DC.B 'c',$FD,$A6,$FE,$DC,$C2,'m('
                DC.B $8D,$96,$19,')-',$1F,'$',$03
                DC.B $FB,'#_',$C7,$DE,$FC,'E',$1D
                DC.B $D7,'U~',$DD,'c@iu'
                DC.B $EE,$D6,$1A,$86,$C3,'s',$E9,'W'
                DC.B 'boG`',$8A,$C4,' ',$C6
                DC.B $CE,$E4,'-!',$E1,']o',$C7
                DC.B 'gg',$87,'E%4',$EC,'{'
                DC.B $EF,$11,$ED,$FE,$8B,$08,$C3,$FE
                DC.B $B9,$A1,$BA,$D8,$A9,'}',$B4,$8E
                DC.B $AB,'h',$DC,$FC,$EC,$A6,'J',$0C
                DC.B '+',$F1,'Ap',$BD,$E8,$11,$19
                DC.B $DB,$0A,'<(',$90,'p',$A1,$A1
                DC.B $BD,'4',$D2,'>',$00,'b',$9D,'X'
                DC.B 'c',$ED,$C6,'("',$04,$B3,'p'
                DC.B $A0,$D7,$F3,'.',$1D,$8E,$FC,$A5
                DC.B $AB,$9D,$E1,$B9,$B4,$C0,$15,'M'
                DC.B $A3,$B6,$D9,$DE,'$&',$E8,$27
                DC.B $AB,$15,'6„D',$CB,$C2,'f'
                DC.B $E2,$B4,$A1,'jH',$F2,'NO'
                DC.B $A5,'E.P',$05,$DE,'U\'
                DC.B $1F,$FC,$D4,'>_',$F2,'n',$A8
                DC.B $C6,'8',$19,$82,'y',$C7,$FE,$D6
                DC.B 'Bšf',$80,':',$FB,']',$80
                DC.B $0F,'3',$AD,$27,$97,$00,$83,'e'
                DC.B $A5,$F2,$C5,$AE,'<',$BA,$95,'*'
                DC.B $BF,$1E,$EB,$AF,'g',$AD,$B1,$C6
                DC.B $C4,$05,$B0,$90,$96,$A4,$B2,$02
                DC.B $9E,'gr',$14,'?',$CE,$BF,$B3
                DC.B $9F,$FA,$A5,$F5,$C6,$82,'E>'
                DC.B $09,$9C,$10,'Ži',$CA,$E0,$13
                DC.B '|',$18,'j',$E4,$E2,$09,$1E,$EA
                DC.B $C7,'G',$EC,'5a',$F4
                move.l  -(A2),D3
                cmpi.l  #$04862125,(A3)
                move.w  A6,$68CF(A6)
                jsr     $0000115E.w
                DC.B '~K',$D4,'O',$A3,'@',$0D,'L'
                DC.B '$',$D4,'4',$C4,$F6,$D4,';b'
                DC.B $18,'7',$E3,'gh',$F6,$B5,$E5
                DC.B $CD,$EC,$D3,'<',$A9,'5XI'
                DC.B $01,$7F,$02,$E4,$B3,'j',$0E,$F0
                DC.B 'B',$EE,'E',$A3,$AD,$92,'x',$D7
                DC.B 'z',$12,'9m',$D8,$C0,'P&'
                DC.B '5',$A4,'?,{',$1F,$9E,'K'
                DC.B $C0,$BF,'.&',$FC,$F5,$EC,'s'
                DC.B $EC,'K',$AF,$FA,$8E,$ED,'B',$A3
                DC.B $C1,$E2,$18,$11,'l',$B5,$BE,$EB
                DC.B $87,'v™f',$08,$CF,$E1,$DC
                DC.B $DE,$C0,$B6,$A1,'!',$16,$9A,$BE
                DC.B 'H',$06,$CB,$D8,$D7,$0F,'X',$A3
                DC.B $BB,$F3,$EE,$82,$0E,'DA',$F6
                DC.B $E6,'e',$05,$0A,$CC,'zL',$0E
                DC.B $09,$EF,')„>',$B5,$DB,'f'
                DC.B $A9,$90,$C6,$F9,$D7,$80,$EC,'<'
                DC.B '\',$15,$CB,$10,$FB,$98,$87,'e'
                DC.B $FD,'hb',$A0,$0A,$ED,$82,$BE
                DC.B $B9,'fbb',$E9,$C7,$84,'2'
                DC.B $DB,$BF,$17,'>',$B9,$92,$DA,'W'
                DC.B $7F,$B2,$94,$CE,$9C,'?',$1E,$F2
                DC.B $01,$D2,'.',$F4,'4',$E5,'@',$D2
                DC.B $FC,'Z',$89,'T',$88,$BE,$D4,$D9
                DC.B 'K',$14,'7z',$AD,'R',$F0,$CF
                DC.B $B1,$DD,')',$11,$E2,'R',$1C,$F2
                DC.B '^&',$CE,$F6,'=',$E8,$D4,'`'
                DC.B $AC,'C)',$9E,$86,$1C,$0C,'v'
                stop    #$F922
                DC.B 'R',$14,$87,'U',$07,$01,$E6,$8B
                DC.B 'J',$ED,$9C,$E8,'Y ',$13,$B2
                DC.B 'e',$11,'s2',$F2,'_',$E9,$CE
                DC.B $C2,$A7,'&',$86,$C9,'q',$11,'o'
                DC.B '>,&',$F0,$09,$E3,$93,'~'
                DC.B $FB,$13,'|',$FD,'~D',$FC,$06
                DC.B $90,$BD,$FF,$BB,$F5,'n',$12,$B8
                DC.B $E5,'D',$F2,$E6,$CA,'pi',$C9
                DC.B $C3,$9F,$06,$A7,'4',$A9,'EB'
                DC.B $AE,$7F,$1F,'w-[}',$F2
                DC.B $BB,$D6,'_',$98,$C6,$D4,'%',$90
                DC.B $DD,$95,$9D,'W7',$12,$DC,$9B
                DC.B 'y',$D4,$E7,$D7,$C3,'5',$AD,$07
                DC.B 'Ž_',$83,'N',$1F,$F2,$E9,'l'
                DC.B 'B+',$AE,'k',$A3,$08,'cw'
                DC.B $B8,$BF,'j1',$E4,$EF,'%',$B5
                DC.B $E9,'5T',$B6,$CA,$11,$83,'A'
                DC.B '*K',$F6,$92,'.',$80,$16,$80
                DC.B 'a',$84,$CC,'m',$0E,$E0,'cC'
                DC.B $9A,$9E,$E4,$E2,$D9,'b%',$99
                DC.B $FE,$80,'4',$CF,'a',$D8,'J',$87
                DC.B $EC,$C2,$07,$9B,$A0,$8F,$D7,$14
                DC.B $87,' ',$CE,$9F,$FF,$BE,'_g'
                DC.B $FB,$C7,'A',$87,$C9,$CC,'PA'
                DC.B '[j',$A4,$09,$12,'@',$8B,'F'
                DC.B $EE,$82,$1D,$13,$F5,'kjN'
                DC.B 'O',$89,$9C,']',$C9,$86,$A7,$02
                DC.B $9F,$A3,'{',$EF,$D4,$CF,$12,$B3
                DC.B $BC,$F2,$B2,'3aiz',$F7
                DC.B $B9,'Q[',$D2,$AD,$0F,'X',$CA
                DC.B '=',$A9,$9C,'+',$B8,'Yq',$13
                DC.B $07,'X~',$92,$E1,$C8,$A8,$01
                DC.B '2<|',$86,$D4,$D8,$A1,']'
                DC.B ':',$E1,$8D,'1>',$FB,$F5,'h'
                DC.B $ED,'_',$D8,$9C,$EA,'šM',$E0
                DC.B $90,$F4,$C3,'?',$E6,$CA,$8D,$CD
                DC.B 'f0lG',$D4,$86,'%',$17
                DC.B 'kžT',$87,'%\',$B1,$BD
                DC.B $F2,$E4,'3',$05,'o00',$19
                DC.B $C9,$16,$C5,$17,$FC,$A2,$BF,'g'
                DC.B '~WKA9',$84,$DB,$8F
                DC.B 'E',$11,$DA,$07,$DB,'R',$B5,'s'
                DC.B $A5,$88,$EE,$CF,'U',$8A,$91,$89
                DC.B 'q',$BF,'W',$A1,'#',$DF,' ',$D5
                DC.B ',%',$B7,$01,$E4,'jL',$C3
                DC.B $84,$19,$E0,$A9,$ED,'@',$A4,$D9
                DC.B '>',$86,$A4,'a',$E6,$EE,'`',$00
                DC.B 'D',$DA,'XC',$12,'š^',$AE
                DC.B 'I',$B1,'h',$B6,$9C,$27,$AE,$A1
                DC.B $F4,$C4,$BE,'V',$1B,$D0,$9A,$CF
                DC.B $C7,$BA,$1E,'%',$92,$96,'T',$CF
                DC.B $B5,'R$w3qR',$96
                DC.B $02,$8B,';H',$1D,$0C,$0E,$F7
                DC.B $9C,$9A,$F4,$F0,'w$',$95,$92
                DC.B $8A,'`',$0B,$ED,$80,$27,$FF,$D5
                DC.B $C8,$A4,'*',$A6,'1yB',$90
                DC.B $27,$97,'&',$C4,';',$EE,'w',$DB
                add.l   D0,D1
                adda.w  A1,A4
                sub.w   D5,$6007(A4)
                jsr     $7026(SP)
                DC.B $87,$82,$B2,'t',$02,$E0,$DB,$AE
                DC.B $B5,$BA,'y',$DE,$82,'\z',$CD
                DC.B $CF,$1E,$DA,$A8,$EA,$86,'L',$BB
                DC.B 'KCIM',$FC,'#',$CE,']'
                DC.B '!',$DE,$86,$E9,$0F,$D3,$00,$85
                DC.B 'mp u',$FE,$19,$B9,'"'
                DC.B $A4,$D8,$B0,'-.',$CE,$BC,$C0
                DC.B $F5,'.',$B2,$EA,$1A,'lV',$0B
                DC.B $11,$F2,'$',$9E,$8C,'[',$0F,$DB
                DC.B '1s!X',$94,$C7,$81,'='
                DC.B $04,$C5,'`',$A9,$F2,$A6,$18,$DC
                DC.B $F2,$EF,$B2,$91,$AA,$F4,'<',$ED
                DC.B '/0',$18,';',$0D,$86,$A5,$B6
                DC.B $E9,'5',$01,$AA,$9B,$1A,$ED,'r'
                DC.B '<',$A8,'2',$1E,$E7,$B7,$D7,'<'
                DC.B ' 2t',$D2,'+T',$8E,$9B
                DC.B $D4,'fp',$FF,'G',$BA,'M)'
                DC.B $C2,'M',$FC,$C5,$FC,'|',$DC,$F1
                DC.B $1C,'I',$AB,$14,$C6,'3',$AE,$A9
                DC.B $AF,$83,$86,$FB,$CC,$90,'>',$DC
                DC.B 'R',$DB,$DB,'!',$90,$08,'a)'
                DC.B '/',$AA,'8',$EC,$B6,'=',$95,$17
                DC.B $8D,'Fw',$F2,$D8,'u',$1E,$D1
                DC.B $DE,$87,'Ce',$FE,$FA,'x',$C6
                DC.B 'U',$A5,$11,'{',$86,$1B,$97,'%'
                DC.B $19,'p',$FD,$05,'d',$8D,$A6,'|'
                DC.B 'k',$27,'x*',$C3,'3',$E9,'='
                DC.B '„@',$8C,$92,$D9,$99,'v.'
                DC.B 'YP',$18,'Y*S',$A8,$95
                DC.B $EF,$EB,$F8,'8+',$C5,$CB,'p'
                DC.B $17,$1B,$D9,'%',$8F,$B6,$AF,$D2
                DC.B $09,$E9,$FE,$C1,$9C,$E1,'{',$D1
                DC.B $19,'8',$DB,$91,$11,$84,'C',$E5
                DC.B $BA,$91,$AC,$89,'X',$BC,$A9,$CF
                DC.B 'cj',$EF,$EB,$BA,'N',$BF,'K'
                DC.B $1F,'\0',$89,'šRE|'
                DC.B $CA,$98,$9A,$89,$1C,$CB,$19,$F2
                DC.B $F5,$EA,$F8,'|^p',$13,'m'
                DC.B $D1,$8B,$8C,'W',$89,$F7,$0F,$E0
                DC.B ' ',$BD,$F9,$A0,',%',$19,$C5
                DC.B $AA,$89,'uz',$0E,$15,$E3,'R'
                DC.B $90,$E7,$AB,'Ht',$85,'Dz'
                DC.B $BB,'(J',$C9,$89,'i',$BF,$0F
                DC.B $C5,$E6,'\5',$D8,$D8,$0C,$ED
                DC.B '@Z@wp',$B6,$9B,$C8
                DC.B $89,$D7,$9F,'em',$14,'Xt'
                DC.B $CE,'Q.',$9E,$98,$FF,'h<'
                DC.B $AF,$DD,$E6,$FD,$81,$12,'Y',$DE
                DC.B ';Zn',$B6,$E0,'c"',$A6
                DC.B $A5,$B4,$96,$0C,'Y',$BD,'<',$B1
                DC.B $ED,'/',$8C,$88,$8C,'4',$7F,'8'
                DC.B 'a',$DD,'_QH',$8F,$AC,'1'
                DC.B $16,$BE,$91,'e',$D9,$C7,$A0,$F8
                DC.B $19,'vW(a',$07,'l',$E8
                DC.B $F3,'U',$90,$AC,'!',$05,$CF,'%'
                DC.B 'a',$AD,$B5,$D7,$8D,$F7,'X',$CD
                DC.B $BF,$BB,'i',$FA,',',$1D,$8A,'}'
                DC.B $04,'u',$A7,$C7,$FE,']',$9C,'['
                DC.B $8D,$EB,'zUs',$0D,'B5'
                DC.B $FC,'C',$14,$80,$9E,$F7,'co'
                DC.B 'Hlp',$D8,$9B,'p',$D4,$1C
                DC.B $81,$89,'w',$F9,$12,$9D,$8C,$9D
                DC.B $B9,'S',$98,'O',$E6,$0C,$D5,' '
                DC.B $AE,$C1,$F3,$DA,';',$90,'e',$89
                DC.B $D5,$A1,$17,'1 ',$D7,$06,$C9
                DC.B $9C,'$G',$12,$CB,'-',$B6,$EE
                DC.B 'r',$C1,'$P',$95,$AB,$E8,'j'
                DC.B 'Hp7H',$FB,$05,$9F,':'
                DC.B '}',$0B,$B7,$AC,$D3,$D3,$B1,$93
                DC.B '6',$B9,$E3,$00,$B0,'+',$80,'5'
                DC.B $80,'YK',$C1,'`K',$FE,$B2
                DC.B $E4,$A9,$84,$A1,$15,$13,$A2,$E4
                DC.B 't',$17,'V',$CF,$DD,$C1,'{3'
                DC.B 'N',$0C,$03,'"',$ED,'E',$8A,'h'
                DC.B $C4,$E0,$9E,$DA,$98,$17,$FC,$F3
                DC.B 'V',$AD,$E4,$0C,$DB,$CE,$A5,$A5
                DC.B $07,$13,$F6,$D9,$E0,'K%',$D8
                DC.B $AD,$01,$A3,'5E',$BB,$B4,$D2
                DC.B $D4,$E6,'"',$CC,$F1,$E1,$F2,'3'
                DC.B '!',$BF,$27,$97,$19,$ED,$E0,'n'
                DC.B '$6',$95,$B5,'<',$9B,'T{'
                DC.B $A8,'2',$7F,'M',$D1,$95,'~',$94
                DC.B $AF,'7',$F1,'[=>',$87,'|'
                DC.B $11,'PF',$FA,$F1,$BE,$E6,$C9
                DC.B '/',$95,$0C,$83,$F8,'C',$92,$D6
                DC.B $8C,'4/n9',$93,'fQ'
                DC.B $BE,'k-E',$CA,$84,$17,'f'
                DC.B $81,$08,'fv',$08,$8A,' ',$D8
                DC.B '+',$BC,$83,$82,$ED,$FE,$E0,'t'
                DC.B 'P=',$D4,'gU',$BF,$9B,$F9
                DC.B 'RK',$19,'9jI',$D8,$C4
                DC.B $BA,$AE,'y',$EE,'AH',$D4,'<'
                DC.B '5',$DA,$1D,'v',$97,'`T',$E6
                DC.B $B8,$02,$D5,'G',$D1,'/m',$83
                DC.B '; ',$F6,$06,'k',$C9,$C8,$06
                DC.B $E2,$83,$1E,$02,$BE,'u',$D1,'<'
                DC.B 'u',$D2,$BE,$82,$05,$92,$EA,'O'
                DC.B $AB,$00,$D5,$27,']`&L'
                DC.B $04,'E',$BA,$0D,'lI8x'
                DC.B $0B,'x',$9F,$92,$CC,$97,$CD,'='
                DC.B $B5,$EA,$D7,$AD,$02,$D2,$A2,$D8
                DC.B $9D,$06,$D5,$07,$B9,$9C,'7N'
                DC.B $E4,$99,'_',$11,'m',$C9,$A8,'J'
                DC.B 'Ip #Z',$A9,$C8,'='
                DC.B $F5,$A2,$D0,'M>',$13,'za'
                DC.B $88,$04,$D5,$E7,$A5,$1D,$07,'H'
                DC.B $C4,'=3',$1E,'nI',$98,'L'
                DC.B $89,'h',$A1,$B3,$A8,$D3,$C5,'>'
                DC.B '5',$BA,$D1,'m:S2',$CA
                DC.B $FB,$0A,$D6,$C7,$A1,$9D,$17,'J'
                DC.B $A4,'Q',$F8,'e_',$CB,$88,'N'
                DC.B $C9,'`"',$C3,$C6,$F8,$82,'6'
                DC.B 'v',$B2,$D2,$0D,'6”J#'
                DC.B $E0,'g',$D9,$A8,$AE,$1E,$E7,'T'
                DC.B $85,'5T',$92,$9D,'3',$F5,'?'
                DC.B $03,'W',$A4,'S4',$A6,$87,$96
                DC.B 'B',$F4,':',$D2,'+',$D5,$82,$9C
                DC.B $F5,$E9,$0A,$B2,'K',$A2,$DE,'Q'
                DC.B 'e',$89,$81,$E8,$D0,$9C,'bq'
                DC.B $AC,'L%',$E3,'b',$0C,'|g'
                DC.B $9C,$0D,'C',$FB,'(',$15,$DA,$F5
                DC.B $DA,'.2',$93,'g',$C5,$D2,'R'
                DC.B 'Em}',$F5,$F1,$18,$92,$EB
                DC.B $DD,'B',$A6,'s',$D0,':',$FA,'w'
                DC.B $DE,'%',$80,$83,'%V',$12,'.'
                DC.B $BF,'b9',$F4,'ce',$A6,'\'
                DC.B '&',$C1,$EA,$83,$1B,$83,$7F,'p'
                DC.B $0C,'8',$27,$83,$0E,'_',$96,$D4
                DC.B $AA,$07,$C4,$AB,'"',$96,$AA,$B7
                DC.B $B2,$E1,'i~t',$83,$BA,']'
                DC.B $06,'e',$9E,$89,'\k\',$F4
                DC.B '<>',$A7,$13,'\',$89,$8C,$B5
                DC.B '&',$18,$05,$B3,$1F,$CF,'_',$E5
                DC.B $98,'f™@q#',$8E,$F7
                DC.B 'Q+u',$96,$9D,$D3,'Iv'
                DC.B 'l',$D4,'tm',$B1,$B6,$89,$15
                DC.B 'r',$12,'F',$DB,$EC,'m',$93,'^'
                DC.B $8D,$E4,$C9,'*~D',$C2,'p'
                DC.B '!�"',$9C,$DE,';',$B6,$E7
                DC.B $9E,$CA,'5',$85,$EE,$DB,$86,$F6
                DC.B 'NS',$8E,$E4,$E9,$8D,$27,$A8
                DC.B $EF,'h',$FA,',',$9E,$F8,$D3,$F2
                DC.B $F1,$D7,$A8,$EB,$10,'$3',$D7
                DC.B $D8,$C2,$F6,$DD,$03,$00,'{G'
                DC.B 'X',$95,$96,$85,$E5,'.[',$05
                DC.B $C4,$AB,'"5',$BB,'|',$A3,'|'
                DC.B 'B',$AD,$C5,$E0,'/',$81,$9F,$CC
                DC.B $19,$BA,$B7,'up',$EE,$C0,$DE
                DC.B ')',$B7,$92,$A5,$E1,'N',$8F,'{'
                DC.B $E9,$88,'f',$BD,$AC,$FE,$B3,$FE
                DC.B $92,$13,$B0,'n b',$FB,$C0
                DC.B 'Z',$B2,'x',$CE,$A5,$14,$BD,'O'
                DC.B $B7,$CA,$9B,'F',$9D,$DF,$C1,$D4
                DC.B $DE,'N',$DE,$88,$CA,'r„8'
                DC.B 'j',$EA,'ms',$81,$B6,'e1'
                DC.B $84,$A7,'Zj',$11,'"7',$80
                DC.B $80,$0C,'#',$0F,$16,'p',$16,'Ž'
                DC.B '3',$B1,$FF,$EC,$E6,$15,'h',$C3
                DC.B '3?',$93,'J',$04,'&',$93,$AB
                DC.B $F5,$85,$FE,$BE,$27,'„+A'
                DC.B $D8,'%`',$97,$83,$A2,$CC,$13
                DC.B $06,$B3,$1F,$F0,$E3,$B5,'<',$8D
                DC.B $9C,$F4,'3',$C0,'uj~',$D2
                DC.B $DA,$84,$80,$B1,'j',$AD,'U',$0C
                DC.B $0F,';',$A1,$9F,$84,$E2,$04,$CC
                DC.B $BB,'B',$FD,$CC,$E2,'U ',$8C
                DC.B '|H',$F9,$05,$0B,$A5,$83,$AD
                DC.B $15,'y',$FF,$1E,$BB,'uQL'
                DC.B $17,'>',$E1,$A7,$81,'"',$FC,'Q'
                DC.B $AE,'@]',$D8,$E0,$F5,$CB,'q'
                DC.B '#',$03,'T',$F4,'s',$0A,'r',$D1
                DC.B $BA,$90,'~P',$F6,$80,$AD,'s'
                DC.B $A0,$CA,$DD,$90,'E',$9C,'K',$C5
                DC.B $16,$27,'0',$B2,'_',$91,'ap'
                DC.B $0E,$15,$AE,$8F,'L',$06,$1E,'J'
                DC.B '.',$A4,$D8,'9',$D8,$DA,$A1,'='
                DC.B $D8,'M',$94,$97,$C3,$CF,'_D'
                DC.B $FE,$A2,$BE,'h',$B4,'u',$83,'U'
                DC.B $F4,$F7,'s{',$07,'PD”'
                DC.B '/',$9F,'4zB',$F4,$EE,'Z'
                DC.B 'R',$A5,'!',$CF,'I',$1A,$B2,'}'
                DC.B '5',$DF,'o',$C4,$AF,$F4,$17,','
                DC.B $C8,$CE,'Fs',$CC,'"',$D3,'y'
                DC.B 'M',$C3,$F9,'!s]',$90,$BA
                DC.B '~',$0A,$B5,'H[',$CB,$C3,'F'
                DC.B $13,'ZRc',$C2,$A3,$DA,$F0
                DC.B $A1,$D2,$A3,$A3,$AC,$C2,'5y'
                DC.B 'Q',$A8,'x',$82,$A9,'[',$9C,'+'
                DC.B $D2,',',$F8,$17,'p',$E5,'k',$E0
                DC.B 'z',$D8,$0E,$D0,$D1,'p$b'
                DC.B '8',$F5,$01,$13,$02,$C8,$AC,$06
                DC.B $CF,'x',$F9,'?',$00,'L',$F7,'{'
                DC.B $DF,$EB,$9E,'p',$00,'l',$DA,'!'
                DC.B 'v',$84,$CA,$C6,$84,$DA,$11,$C8
                DC.B $91,$F7,$83,$0F,'Ah8',$86
                DC.B $D3,$D1,$D1,$8A,'Nz',$FA,$DF
                DC.B 'a',$B9,$C0,'+',$94,$CA,'b',$96
                DC.B '@-/',$A8,'šp',$08,'q'
                DC.B '&',$17,$14,$1C,$9A,$A6,'(',$CB
                DC.B 'f',$BF,$0F,$B6,$C7,$A1,'Ya'
                DC.B $17,$7F,'#c',$B9,$98,'ND'
                DC.B 'G0y1,',$F1,$1F,$0E
                DC.B 'Qmo',$95,$89,$A7,'3',$C3
                DC.B $0D,']',$84,$95,$DA,$FA,$0D,$16
                DC.B $81,$1D,$86,'e',$EB,$0F,'#%'
                DC.B '5',$8D,$B1,$AB,$EC,$80,$94,'='
                DC.B $C5,$DE,'\',$8A,'=�1<'
                DC.B $06,$D9,$0D,'Xd>^',$8E
                DC.B $93,'1',$AD,$AF,$11,$C5,$87,$BE
                DC.B $83,$CE,$C0,'7;',$F4,$C3,'g'
                DC.B 'G',$A3,$1C,'ZA',$C1,$FC,$CB
                DC.B $DF,$04,$80,'Q',$13,$A4,'=|'
                DC.B $12,$01,'/',$83,'S',$D5,$CB,$CF
                DC.B $E2,$8F,$8B,'2',$BF,$F2,$C9,'q'
                DC.B 'Eo',$97,$C3,'+F',$F1,$C9
                DC.B $F4,$D0,$FC,$C0,$F8,$DF,$D7,$FC
                DC.B $BC,$10,$E5,$F2,'HZ',$D3,'|'
                DC.B 'K',$FA,$A7,$98,$C7,$D3,$04,'l'
                DC.B 'bA',$1A,$F7,$EB,'b0',$F5
                DC.B $1E,$A0,'U',$8C,$8A,'q%',$02
                DC.B $8E,$E7,$D7,$C7,'Z',$18,'2',$CD
                DC.B $0D,$FD,$F4,$A4,$AF,'@',$16,$BC
                DC.B $FE,$08,$C0,$9C,'U',$FF,$B1,$E8
                DC.B $9F,$C8,$DF,'q]Q',$1C,'>'
                DC.B $92,'p',$DA,$AE,'s/',$BF,'-'
                DC.B ';',$95,$8A,'r',$B1,']r',$BD
                DC.B $09,'.',$D2,$E3,'w',$00,'B',$B8
                DC.B ':',$C6,'F',$90,$F7,$FD,'n',$AF
                DC.B $12,'Z',$1D,$DB,'@P',$AD,$9F
                DC.B $1C,$EE,$C4,'Q',$E2,'nj',$E4
                DC.B $D1,$AB,$EB,$9B,$12,$06,'q',$F1
                DC.B '>',$E0,$B4,'w',$B2,'X8',$01
                DC.B $92,'P',$D0,$CF,$B0,$06,'Zg'
                DC.B $0A,$F6,$89,$E4,$E7,$D7,$B2,'`'
                DC.B $01,'g',$E1,$8A,$1F,'a',$EB,'Y'
                DC.B $A0,'M',$85,$D0,'D',$C6,'E',$E6
                DC.B 'u',$A0,'s',$BB,$EC,$9D,$B5,$F0
                DC.B '?<',$D9,'a',$0E,$88,'z',$83
                DC.B $0D,$C3,$E8,'a',$C2,' ',$13,$E5
                DC.B 'y',$D8,'CKAž$',$86
                DC.B $85,$A4,'gm@',$B5,$F4,'{'
                DC.B $04,$10,'4',$D9,$E2,'}',$A6,$05
                DC.B '%',$F7,$F9,$03,'8',$1D,$C7,$ED
                DC.B 'd',$19,'6',$E7,'Q',$DC,$8B,$DF
                DC.B $06,';x',$D6,$C8,$07,'L{'
                DC.B $A4,'-4',$1D,$A1,$27,$89,'Y'
                DC.B '*„e8b6a',$97
                DC.B $B4,$AD,$92,$AC,$B2,'t',$8C,$17
                DC.B 'B',$D6,'`S2',$92,'v',$19
                DC.B $D2,$A9,'&',$F1,$C4,$9F,$B9,$19
                DC.B 'Z',$D7,'_',$B3,$99,'o',$DB,$95
                DC.B $15,$F7,'rUzc',$91,$D2
                DC.B $17,$13,'(',$8E,$8F,'š>',$C9
                DC.B $DF,'*',$95,$ED,'H',$0C,$D2,$DF
                DC.B $BA,$9E,$F9,'g)',$E4,'M%'
                DC.B ',',$BE,$D1,$9E,'M|',$80,$D4
                DC.B '$y',$11,$CE,'9q',$DA,$15
                DC.B $E9,'&',$D3,$C3,'vX',$D8,$83
                DC.B $F5,$FC,'}G',$8D,$CE,$BF,':'
                DC.B $C5,';',$10,'B',$F9,$F3,$A3,$E2
                DC.B $D6,$DD,'*',$D2,$0F,'i4',$8C
                DC.B $C4,'!',$B3,$8F,'.d',$C8,$A5
                DC.B $14,$8A,$83,$86,$04,'/NW'
                DC.B $B5,'NO',$DA,'L',$CD,$F4,$D9
                DC.B 'k',$C0,'L',$B2,$01,$0E,'A',$06
                DC.B $BB,'$',$C1,'%',$04,$A2,$9E,$17
                DC.B $D0,'šz',$95,$D0,$16,'(',$FC
                DC.B $8A,$E9,$FA,'r',$27,$FA,'D',$AF
                DC.B 'RJ',$01,$AD,$05,$D4,'L',$05
                DC.B $0E,$0C,'q',$98,'*',$8F,$1C,$97
                DC.B '8',$E6,'\',$18,'*',$B0,$D8,$89
                DC.B $03,'g',$BC,':',$17,'~',$BF,'!'
                DC.B 'Ie',$B0,$95,'7H',$C7,'T'
                DC.B 'C',$87,'|pQ',$BC,$D4,$97
                DC.B $C1,'m',$D1,$E8,$8F,'=?9'
                DC.B 'E',$11,'h',$E4,$85,$FE,$04,$DA
                DC.B $E9,')',$80,$89,$08,$C7,$A6,$FE
                DC.B $D9,$DC,'m',$96,'sŽ]',$F9
                DC.B 'v',$A5,$FC,$1F,$00,$CF,$AA,$C6
                DC.B 'S',$DB,$89,'J',$E7,$10,$DF,'w'
                DC.B $88,$01,$9A,$80,'w',$B3,$90,$7F
                DC.B $17,$CB,'F',$BB,$1F,$D0,$EF,$1B
                DC.B 'g',$DC,'[',$A9,'w9',$BA,'K'
                DC.B '+',$E6,$0F,$F2,'S+JB'
                DC.B $BC,'<V',$27,$0A,$10,'RZ'
                DC.B $11,$CD,$E9,$B6,'9',$B0,$09,$BF
                DC.B ',:',$B4,$8C,'Z',$94,$EA,$03
                DC.B $04,$D4,$CD,'"',$F4,$F1,$C3,$0E
                DC.B $AD,'+%',$DA,'_',$87,'xy'
                DC.B '.4',$C5,$91,$02,$DD,$05,','
                DC.B 'o',$F0,'*Dl(',$F2,$9C
                DC.B $94,'s',$0E,$13,'b',$E0,$9D,'W'
                DC.B '\`',$FB,$D6,'<h',$94,$07
                DC.B $E8,$80,$9B,$C3,':',$D0,'H',$BA
                DC.B $CD,$C5,$8D,'@H)',$C2,'!'
                DC.B $99,$D6,'t',$8F,$AC,'2',$87,$FC
                DC.B 'oe',$E0,$1D,'0',$C4,$F0,$8F
                DC.B $B4,'K',$F1,$13,'7!',$10,$CC
                DC.B 'r',$A5,$C8,'i%',$10,$12,$A5
                DC.B ':',$B3,$BB,$D8,'E',$B5,$AB,$A1
                DC.B $12,$FF,$B3,$A1,'K9',$17,$D2
                DC.B 'A',$DD,'N',$FF,'a',$C5,$16,$04
                DC.B $CE,$FF,'u@',$C8,$C7,'K',$86
                DC.B $A3,$B3,'p',$AF,$08,'^',$88,$BD
                DC.B $CB,$F1,'~',$AA,$13,$CC,$0E,$BF
                DC.B 'G',$F0,'?',$BA,$80,$05,'Lx'
                DC.B 'Smou',$C3,'?',$19,'H'
                DC.B $13,$81,'j',$F8,$94,$81,$FC,$B6
                DC.B $8F,'u',$C9,'Ub',$00,'*',$E9
                DC.B 'y#o',$D4,$87,'g?='
                DC.B $87,$E5,'8',$04,'|',$F3,$03,$D8
                DC.B $F6,$0F,$C9,$84,'h',$C6,'H',$8F
                DC.B $B1,$AC,$B1,$DC,$C0,$E2,'V',$BC
                DC.B $CE,$88,$DA,$14,'Q',$BE,'r',$DB
                DC.B $B8,$03,'j',$D5,$27,$14,$F5,'q'
                DC.B $B6,'C-',$E2,$9A,$09,$15,$F4
                DC.B $B6,':',$99,$FE,$9F,$C0,$A3,$F6
                DC.B $FC,$0A,'F',$A1,$7F,$19,'Y',$02
                DC.B 'C',$D9,'V',$BD,'Q?A',$82
                DC.B ')',$F3,'e',$C1,$84,'rP.'
                DC.B $FC,$D6,$A9,$D7,$C7,'&3E'
                DC.B $E9,'ŽZ',$93,$CC,$E8,'L|'
                DC.B $11,$F4,$FB,$82,'6L',$F7,'`'
                DC.B $EB,'`',$96,$FE,$84,$0A,$85,$C9
                DC.B $FC,$16,$11,$CA,'B',$F6,$C9,$9C
                DC.B $F4,$83,'Z',$93,'=#',$8B,$F5
                DC.B $BA,'o',$14,'eT?A',$D2
                DC.B $95,$F9,'\%',$02,$0F,'Y',$07
                DC.B $E3,$EB,$1F,$F3,$F8,$C1,'r',$9D
                DC.B $C2,'|',$0F,$09,$CD,$1E
L000C:          DC.B $EC,$1C,$AB,$C4,'8',$12,') '
                DC.B $CC,$EE,$CD,'[',$B1,']',$83,$03
                DC.B 'lz',$99,$D6,'I',$FF,$87,'q'
                DC.B 'n',$07,$86,$B8,$D7,$CB,$8A,$E6
                DC.B '[',$D1,$C2,'0nN',$CF,'M'
                DC.B $0C,$DE,$FE,$A9,'q|'
L000D:          DC.B $A9,'G',$9F,$D4,'>9',$D0,'-'
                DC.B $E4,'b',$B1,$9E
                sub.w   D5,-(SP)
                cmpa.l  $815B(SP),A1
                bra.s   L000C
                DC.B '+6Mu',$07,$BE,$D1,$E4
                DC.B $00,$AF,$DB,'NB',$9B,$B2,'$'
                DC.B $14,$A0,'3',$E1,$D0,$DA,':',$D9
                DC.B $A5,'+',$D6,'[hL;',$AD
                DC.B $98,$F8,$89,'K',$FB,$E8,'5™'
                DC.B 'x:',$1E,$1C,'^',$AC,$A5,'P'
                DC.B $FB,$B7,$93,'a',$E0,$F2,$86,$F8
                DC.B $C0,$0B,'6',$F3,$E2,$FD,'>^'
                DC.B '9',$DD
                st      D3
                move.l  (A4)+,$4DE7(A5)
                ror.w   #7,D0
                move.b  (A2)+,(A4)
                bsr.s   L000D
                DC.B $BD,'?D”9',$C6,$14,$E6
                DC.B 'q',$D0,$E0,$E7,$15,$03,$80,$11
                DC.B 'X',$0F,$EE,$FA,$D4,$D6,$AC,$F3
                DC.B '6',$95,'r',$89,$C1,$88,$F5,'('
                DC.B $D0,',',$0A,$E5,'^',$14,$14,$D8
                DC.B 'g',$07,$EE,'()x™y'
                DC.B '%',$8C,$03,$8B,$F0,'**',$C5
                DC.B 'tUB',$13,$8B,' c',$14
                DC.B $F7,$16,'5r',$C4,'L',$18,$F3
                DC.B $95,$D0,$F3,'(',$14,$1B,$84,$B7
                DC.B 'Q',$06,'M^',$C7,'b',$A9,$F5
                DC.B '*n',$14,$27,'d',$81,$11,$B6
                DC.B $A2,$15,'<',$D9,$A2,$89,'k\'
                DC.B $D3,'J',$92,'K',$F3,$0F,$9C,$AC
                DC.B $80,':',$E4,$F1,'Y',$F8,'7f'
                DC.B $1A,'V',$DD,'e%',$17,$C5,'l'
                DC.B $C5,$94,$E5,$AC,'\',$B4,$EE,'%'
                DC.B $CE,$07,$B9,'*',$DF,$00,$A0,$FE
                DC.B $89,$B8,'z',$02,'v',$8D,$B1,$F6
                DC.B $F1,$97,$F0,$95,$C6,$F1,$AB,'w'
                DC.B 'e',$96,'~.E4m',$E7
                DC.B '|F',$06,'7',$AC,'E',$E3,$FB
                DC.B $A9,$19,$10,'E',$0F,$9B,' ',$90
                DC.B '_',$0E,$9F,$C8,'g!B',$16
                DC.B $FE,'^[',$17,$1D,$D2,'e',$FE
                DC.B ';',$F7,$11,$CD,'!',$D6,'\}'
                DC.B 'T3',$B1,$EE,$DA,$14,$C1,$E2
                DC.B $19,'3š#',$12,$BC,$F6,'t'
                DC.B $DF,$11,$DF,'e',$BD,'2Že'
                DC.B 'B',$D9,$1F,$18,'~ARB'
                DC.B $0C,'H',$81,$9D,$1F,$06,'B',$18
                DC.B $11,'Y',$80,'Ek',$DA,$87,$06
                DC.B '"2',$8B,'I',$D8,$F1,$F4,'$'
                DC.B $BF,$DA,'w',$DF,$0A,$08,' �'
                DC.B '.',$DD,$07,$AF,$CC,'`',$81,$94
                DC.B $19,'*l4',$AA,'@B',$06
                DC.B $FA,':',$B5,'N',$05,$E5,$99,$C0
                DC.B $CA,$C5,'bC^',$A8,$B6,'i'
                DC.B 'o_ ',$AF,$07,$14,$C4,$F4
                DC.B $8C,$13,'@3',$EA,'1(E'
                DC.B '=',$9D,$87,$8F,$FD,'*Z',$A6
                DC.B $90,$A6,$19,'t',$0D,$8B,$B5,$92
                DC.B 'Q',$E6,'sa',$AB,$ED,$D2,'r'
                DC.B ' ',$9F,'33%',$87,$1F,$B1
                DC.B '8',$07,$C6,$B1,$A3,$E3,$E9,'Ž'
                DC.B 'a',$1D,'@7',$FE,$C2,'c',$DB
                DC.B $81,'{',$AC,'Lo',$D6,$DF,$95
                DC.B $E2,$EE,$12,$DC,$82,'7',$F8,$F1
                DC.B $95,'wY',$FE,$A7,$DE,'s�'
                DC.B ':X%',$B8,'k',$F7,'n',$F1
                DC.B $AD,'n',$C6,$DE,$81,$95,$AC,'a'
                DC.B 'Z@N',$0C,$E7,'?',$CC,$A7
                DC.B $11,'AC',$97,' ',$1F,$E4,'<'
                DC.B $95,$F7,'+',$AE,$C9,$F4,':j'
                DC.B $A4,$FF,$FC,$85,',',$C5,' ',$FF
                DC.B ']|\',$0E,'B)',$93,':'
                DC.B 'o',$93,'0z',$83,$19,'f~'
                DC.B $DF,$8A,$09,$C2,$C6,$95,$8D,$0A
                DC.B $A4,$F4,'0_',$BD,$E9,$0F,$1D
                DC.B $94,$F6,'g;',$A2,$C7,$A7,$17
                DC.B 'w',$1A,'D',$1D,$EF,$10,$E9,$C8
                DC.B $09,$94,'!',$B3,$96,$27,$15,$B7
                DC.B $AA,'4Z',$D7,$C2,'B',$EB,$BC
                DC.B 'c)a',$91,'N',$AC,'02'
                DC.B $1A,'I',$D8,'M',$CC,$82,$CC,'Y'
                DC.B $82,$C0,$01,$A5,'i.^',$A3
                DC.B 'c*',$EA,$E6,$1D,$0D,'p',$CA
                DC.B $10,'%',$D6,$88,$9C,$F5,$E0,$9E
                DC.B $C0,$00,'rk',$D1,$8B,$D0,':'
                DC.B $BB,$17,'+',$E0,$DA,'4i',$D6
                DC.B '4',$D2,'mX',$B9,'/',$1D,'K'
                DC.B $C8,'Z',$88,$8B,$1F,$B3,$DE,$19
                DC.B 'K?',$11,'T',$94,$B9,$C4,'%'
                DC.B $07,'*',$D7,'q',$08,$FF,$8D,$07
                DC.B $F2,$DF,$AB,$F5,$86,$EB,$0D,$B9
                DC.B 'Y',$DA,$D2,$F0,$DC,',',$D6,$F9
                DC.B '_',$F3,'q',$D9,$E8,'5',$D7,'p'
                DC.B ')',$A3,'Y!\\%?'
                DC.B $8B,$A7,$C7,'1XT}Y'
                DC.B $C9,$EF,'<',$A1,$1E,$84,$08,$9E
                DC.B $BC,'NSn',$CC,$18,$02,$8A
                DC.B 'P',$0D,$EE,$98,')',$B3,$C5,$E3
                DC.B 'R0',$94,$96,$E3,$B4,$19,$AD
                DC.B '?',$F8,$8F,$E5,$9F,'5',$DA,'!'
                DC.B $08,$A5,'qd0',$BF,'=\'
                DC.B '5',$FA,$99,'ln',$E4,$F4,$D0
                DC.B $FA,$1D,'šq',$B1,$B1,$1B,'e'
                DC.B $8D,'N',$80,$B9,$7F,$DA,'h',$7F
                DC.B 'R',$EB,$17,$9A,$E9,$D0,$C4,$CD
                DC.B $81,$14,$B1,'!',$08,$C4,$E5,'['
                DC.B $1E,$10,$27,'U',$9C,'M|I'
                DC.B 'H',$EA,'R',$91,$9E,'~D',$EC
                DC.B 'U>',$11,$CC,$CC,$9C,$C8,'h'
                DC.B $AF,$C7,'V]',$09,$C4,$B4,$B6
                DC.B $11,'-J+',$07,$F5,' F'
                DC.B $D9,'šZ',$CA,';l',$00,'0'
                DC.B $AA,$E1,'q$',$B9,'3',$DB,'b'
                DC.B 'C',$F8,$10,$A7,'O',$DB,'E',$BA
                DC.B $07,' ',$BA,$14,'U',$0D,$8F,$15
                DC.B $0F,$9E,'V',$C4,$F0,';',$E3,'h'
                DC.B '}',$B1,'eE',$92,$EB,$27,$12
                DC.B $88,'/',$1E,$16,$C6,$F8,'d('
                DC.B 'o',$8D,'g',$EB,$E4,$D8,$A3,$FA
                DC.B '>5)',$DF,$F5,$C6,$05,$A2
                DC.B '~',$CA,')Xt',$D7,$A5,$E7
                DC.B $86,$DE,$05,$8B,$B6,$AE,$EB,$F9
                DC.B $97,'\8B',$9C,'T9',$0C
                DC.B $03,'[',$01,$F7,'1',$8D,$06,$15
                DC.B 'uG',$8F,$0F,$F2,'e,',$9D
                DC.B $D0,$F3,$14,$14,$A6,$95,'n@'
                DC.B $13,':',$EF,$F0,'+=$['
                DC.B 'v#',$DA,$F2,'@',$B3,$F0,$9A
                DC.B $A2,'J',$B1,$BF,'Gw>4'
                DC.B $08,'Gi',$B0,'DY',$E2,$17
                DC.B $CA,$9E,'y',$0E,$F3,$FD,$B4,$FF
                DC.B $CF,'}',$DF,'>',$C2,'XuQ'
                DC.B $11,$08,$B2,$B9,$9F,$CD,$0F,'f'
                DC.B 'Y',$ED,'v',$13,$16,$F1,$D9,$FB
                DC.B $12,$27,'$',$FA,$CC,'e',$A1,$AB
                DC.B 'Z',$BC,$1D,$1C,'i',$0E,$B9,$06
                DC.B 'zi',$D9,'-F',$E8,'L',$12
                DC.B $93,$95,'D',$BE,$E5,$EF,$C3,$8F
                DC.B 'O',$AB,$FD,$DA,'o',$16,'ot'
                DC.B $D4,$85,$F4,'XS)',$D3,$FD
                DC.B $9A,$D0,'o?bz',$1D,'/'
                DC.B $87,$F4,'o|',$BD,$F8,$27,'5'
                DC.B 'R',$00,$B5,$9C,'&',$02,$88,$0A
                DC.B '@',$9D,$B6,'R',$CD,$16,$D4,$11
                DC.B '7f',$1E,'_I”i',$A7
                DC.B $AE,$9C,'qy',$EB,'6Z',$F9
                DC.B $1C,$D1,$DD,$1A,'I”-',$AD
                DC.B $06,$BD,$A4,$7F,$A6,$EE,$F0,$EE
                DC.B $27,$F6,$D8,$CF,'-',$97,$F7,$14
                DC.B $0D,'n!',$AC,'cO',$C1,'e'
                DC.B $0C,$81,$19,'G',$95,$8C,$F8,$9C
                DC.B $04,$1F,'PW',$17,$18,$F3,$E5
                DC.B $C1,$D8,'.',$CD,$F4,$B0,'c',$F8
                DC.B 'GG?',$B5,')V>',$C5
                DC.B $97,$F9,'4',$E8,$97,$94,$E0,'5'
                DC.B $A5,'J',$19,'R!',$DA,' L'
                DC.B 'b',$F8,$0C,$C5,$ED,'d',$1B,$EC
                DC.B '%5',$15,'q1',$AD,'A',$0E
                DC.B 'Spy',$84,$C7,$AF,$AF,$E9
                DC.B $A9,$F0,$B1,$86,$D2,'5t',$D2
                DC.B $88,$E5,'0<',$19,$F0,$D5,$0D
                DC.B 'w',$A7,$CF,$C2,'<',$90,'[*'
                DC.B $13,$CF,$8B,$D4,$19,$B7,$FA,'+'
                DC.B $AA,$8E,$A8,'|!',$95,$81,$80
                DC.B $D5,'*',$1A,$B2,$1B,'R',$BC,'e'
                DC.B $01,$E0,$E8,$B0,$F0,$8D,$0C,'!'
                DC.B $89,$19,'+',$0C,'v',$E8,'5k'
                DC.B $9C,$83,$BB,$82,$DC,$FC,'v',$80
                DC.B $BA,$EF,$E4,$E3,$DA,$87,$D4,$F0
                DC.B 'I',$04,'F%',$90,$81,$10,'p'
                DC.B $A5,$1E,'K',$EA,'L',$D1,$B4,$E9
                DC.B 'MHP',$8F,'\,`',$93
                DC.B $EC,$BB,$AC,$97,$F7,$AB,$C7,'l'
                DC.B $87,$D2,'\',$C3,$BF,'Fs*'
                DC.B '&{:',$BF,$BC,$17,'F',$B1
                DC.B $A3,$15,$95,$03,$A2,$0B,$D0,$B8
                DC.B $E8,'o',$86,$DF,$AC,$16,$A4,$B6
                DC.B $DB,'C',$93,'N',$B9,$10,'j',$D8
                DC.B $C0,'r',$03,$AB,'hq',$A5,$C8
                DC.B $B6,$B8,$D5,$02,$00,$A1,$CC,$86
                DC.B $C0,$80,$C5,'Vn',$83,'W',$A7
                DC.B 'a',$CC,$A3,$9E,$7F,$F6,'N',$06
                DC.B $92,$DC,$A3,'U/',$03,$C4,'B'
                DC.B $B9,$80,$06,$F0,'}',$11,$9E,$BF
                DC.B $AD,'3',$F3,'O',$BB,$89,'K™'
                DC.B '+',$9F,$17,$F7,$0E,$88,'_',$8F
                DC.B ' m',$C0,$DE,'A',$82,$0F,$09
                DC.B $BA,'Z1',$B3,$FA,$0E,'2M'
                DC.B $F1,'y',$FD,'b',$AA,$0D,'F',$1B
                DC.B $93,'\(r',$FE,$83,$12,'I'
                DC.B '0H2',$87,$FD,'gA',$CE
                DC.B '^',$08,'c',$A4,'>',$8A,$92,$E2
                DC.B $CB,'q',$AB,$0B,$07,$D5,'B',$18
                DC.B $95,'b<',$EC,$AC,$A8,$86,$A7
                DC.B $F8,$A9,'Ie',$1F,$17,$8F,$03
                DC.B $DE,'tr',$ED,$B5,$1A,$85,':'
                DC.B $12,$8A,'i',$F9,'-',$D5,'E',$FD
                DC.B 'A&%',$87,$D9,'a',$ED,'y'
                DC.B $E7,'6#',$9C,$A0,'po',$A3
                DC.B $FF,'}',$95,'Q_',$15,'6',$C6
                DC.B $97,'*',$1F,$A8,$E2,$D1,'H',$83
                DC.B '[',$BF,'0',$13,'}a{',$92
                DC.B $13,'w6o',$CE,$7F,'M',$EF
                DC.B '&',$F5,$0D,$A6,$E8,$02,$18,$BF
                DC.B $18,$A5,$CE,$B8,'C%ZG'
                DC.B $12,$06,$CD,'d',$18,$CC,$EC,$F4
                DC.B $B4,$03,$B5,'KB|K]'
                DC.B $1B,$DF,$F1,$F7,':',$98,$AA,'l'
                DC.B 'QN',$FE,$B9,'`',$12,'fX'
                DC.B $FB,$17,$A6,$1F,$FD,$AE,'pe'
                DC.B 'Ha',$81,$D6,$F6,')H',$EF
                DC.B $8E,$B0,$B6,$CF,$F6,$1E,'}O'
                DC.B $14,$E4,$AE,'I.',$B1,$A1,$E8
                DC.B $A1,$BE,$F3,'k',$B9,'CS',$E1
                DC.B '~',$A1,$B9,'R',$DD,'$',$B6,'p'
                DC.B $0A,$B7,'u',$D7,'_',$82,$0F,'!'
                DC.B $13,'o^7$',$91,'%',$B8
                DC.B 'mG',$AC,'fqp',$10,'m'
                DC.B 'u',$F0,$FB,$FD,'m',$D1,'W*'
                DC.B $96,'MK',$D2,$B6,'w',$D2,$FC
                DC.B '$',$E4,$0E,$FD,$9B,$88,$A8,$07
                DC.B $DA,$F7,$BC,'d;',$96,$09,$CC
                DC.B $93,'\',$08,$A8,$27,$DE,'X',$CD
                DC.B $AA,$CC,$1B,$FC,$11,'#',$BC,$17
                DC.B '_m=',$FB,'[',$80,$27,$D8
                DC.B $A3,$9A,$97,$07,$F7,$8D,$0C,','
                DC.B 'oe',$A1,$D3,'JQ',$27,'d'
                DC.B $BD,'J+',$DE,'u',$8F,'O',$E9
                DC.B 'b',$8C,$E1,$E2,$1A,$F8,$AA,$A7
                DC.B 'n!',$A2,$81,$C7,$AB,$10,$89
                DC.B $9B,$DB,$D8,'~',$9D,'K',$E6,$FC
                DC.B $10,$DD,$F9,$E8,$D3,'{',$11,$C4
                DC.B 'e,',$15,$C0,$DE,'01v'
                DC.B $D8,$D7,$C0,$0D,$98,'"',$1F,$EA
                DC.B $B7,' ',$09,'(',$17,$BC,$DC,$1D
                DC.B 'tQ',$8A,$CA,$17,'#',$FC,$9F
                DC.B 'P',$AE,$85,$CE,$9D,$A8,'$',$D8
                DC.B $A3,'z',$EB,$0A,'XZ',$12,'I'
                DC.B 'cf',$A1,'S',$FA,$A7,$D9,$BD
                DC.B $08,$E0,'`',$D5,'v',$8F,$8F,'1'
                DC.B '[-',$B5,$8C,'u',$9B,$A6,$A8
                DC.B 'm',$01,$86,$05,$17,'Qq',$05
                DC.B 'l',$A5,$D9,$FE,$0D,'Y',$A8,$D3
                DC.B $8B,'0&',$DD,$D5,'{Q',$0C
                DC.B $9E,'U',$BC,'Km',$FA,'*w'
                DC.B $D8,$B7,$94,$27,$F3,'MT',$81
                DC.B $9C,$1B,$10,$A5,'H',$D1,'7b'
                DC.B $1D,'>',$E5,$E5,$B4,$D7,'F',$EA
                DC.B $A2,$94,'d2d',$D9,$AE,$87
                DC.B $0A,'-',$A1,'!',$D3,'i8',$0E
                DC.B $8B,'YHP',$92,$CC,$B6,$F2
                DC.B $EF,$C4,$BC,$F0,$12,$83,$F0,$E0
                DC.B $A1,$D4,',',$19,$C7,$0D,'8U'
                DC.B 'TH',$AD,'"',$B3,$05,$BB,$DE
                DC.B $DF,'z',$F1,$8D,$EC,$8B,'9',$0C
                DC.B $EA,'Z',$1F,'4Gd',$AA,'A'
                DC.B $A2,'t',$DC,$E8,$AD,$80,$0C,$DB
                DC.B $A7,'m@6',$94,$E7,'5',$EA
                DC.B $1A,$E7,$AB,'C',$0F,$BE,$B0,'i'
                DC.B $87,$FC,$EF,'V',$88,$A2,'M}'
                DC.B $AD,$E8,'_r',$1F,$8B,$0D,$B0
                DC.B 'nWP',$F4,'p',$DE,$14,'t'
                DC.B $09,$D0,$DC,'F_',$EB,'2',$D8
                DC.B $14,$00,$B8,$F2,$CB,$D3,$10,$F5
                DC.B $B0,$E9,$05,$DB,$D2,'^',$19,'O'
                DC.B $D9,'{q',$27,'S',$95,$EA,'%'
                DC.B 'Q',$EA,$0D,$C9,$D7,'0',$B1,'z'
                DC.B $27,'&',$11,$E9,$05,$89,$FC,$A0
                DC.B $BC,'G',$CC,'+',$B2,'ek',$A1
                DC.B $A3,$8D,$1B,'H2',$DF,'m',$CC
                DC.B $9F,'%',$A4,$0A,$BA,$BB,'2',$0D
                DC.B '9',$11,$E9,'!d',$CE,$8F,'n'
                DC.B $B7,')',$F4,$9C,$12,$E2,$ED,$9D
                DC.B 'm',$AE,'v',$17,$12,$9B,$ED,'_'
                DC.B $85,$9F,$DC,$DD,$CD,$C0,$B1,'M'
                DC.B ';',$07,$C1,'}',$C4,'cQ5'
                DC.B $BA,'F',$FC,$B5,$F2,$DE,'pm'
                DC.B $D7,'*',$03,'$',$F1,$BD,'p',$CA
                DC.B $B4,$01,$CF,'c$',$9B,'F',$F7
                DC.B $87,'9',$8C,'B',$08,$CE,$A7,$1A
                DC.B $F0,$D6,$AB,'I',$ED,$AA,'d`'
                DC.B $F6,$94,$18,$D8,$AE,'HTA'
                DC.B 'd',$C6,'u)',$B7,'p',$83,'x'
                DC.B 't}',$08,$09,'&5|z'
                DC.B $F2,'[',$D7,$9D,$E1,$C9,$E8,$CC
                DC.B $A1,'?cY',$9E,$C2,'#',$CF
                DC.B $93,'<',$AC,'Tšk',$C2,$A0
                DC.B $27,'"',$84,'š#1',$EA,$D9
                DC.B 'i',$00,$DB,$F2,$D8,$E8,$EE,$0F
                DC.B $8A,$C1,'~',$DC,'N',$FC,$C6,$93
                DC.B $DA,'s',$C3,$FF,'-}',$04,'('
                DC.B 'V',$F5,$FE,$88,$FF,$80,$D0,$9C
                DC.B $F0,$FA,$0F,']',$CF,$AE,'D\'
                DC.B $D3,'xkZ>',$16,$D9,'R'
                DC.B $E2,'v',$E3,'[',$F9,'gA',$D0
                DC.B $89,$11,$C9,'r',$E7,'g',$0F,$BB
                DC.B 'v',$B9,'<[OžF',$1C
                DC.B $1B,$0F,$05,$D5,$ED,$10,$D9,$12
                DC.B $EA,'u',$03,$87,$04,$1A,$90,$D6
                DC.B 'k',$F4,'>',$A0,$FC,'`4',$08
                DC.B '>A:[',$CF,$CE,'P',$DA
                DC.B 'C',$A6,$12,$F7,$E9,$10,$D9,$D2
                DC.B '2p#c`',$96,$9F,$D5
                DC.B $89,$11,$01,'m',$7F,$D0,$A6,$F6
                DC.B 'CP<[O',$BE,'B',$9C
                DC.B $8B,$1D,$27,'1',$F1,$0D,$DC,$92
                DC.B $FA,'wC',$CF,$8B,$89,'>a'
                DC.B '}',$F2,'~',$98,$FD,$C0,'H',$C9
                DC.B $C6,$A0,$E6,'B',$CE,$EE,'L['
                DC.B 's',$A4,'2s',$D9,'*',$E0,'W'
                DC.B $02,'jbk',$DF,$83,$DD,$FD
                DC.B '2',$00,'zCp0',$1A,$A3
                DC.B $A1,'+',$15,'Cs',$D9,'N',$FA
                DC.B ';K',$CD,$0E,$98,$A2,'o',$08
                DC.B $0B,'i',$82,$97,'b',$B6,$DB,$1D
                DC.B '4',$D9,$B9,$B0,$FA,$A0,$AC,'u'
                DC.B 'S',$AE,$85,$AE,$D1,$0F,'X',$D9
                DC.B $E3,$12,$E8,$0A,'X',$DA,$E2,$D7
                DC.B 'Rd',$A1,'3',$F6,$A8,$DA,$BD
                DC.B '*',$0E,$1F,'4a',$0F,$9C,'L'
                DC.B 'S.',$B5,$8D,'I',$FE,$AA,$A7
                DC.B $AE,$B9,$F3,$0B,$18,$D2,$C1,$93
                DC.B $9A,$DB,$D8,'^',$D9,$A3,$D9,$DD
                DC.B 'L',$F8,$FD,$E8,$D3,$FB,$01,'"'
                DC.B 'Y',$AD,$A5,'*',$C1,'-4v'
                DC.B $18,'O',$8D,$06,$D7,$C9,$A4,'_'
                DC.B $A1,$1E,$10,$85,'dV',$A7,'t'
                DC.B '=`p',$D7,$AA,'O^',$F7
                DC.B 'f',$D4,'q',$06,$B0,$14,$AF,$93
                DC.B '^',$FD,$A9,$9C,$B5,$FF,'V;'
                DC.B $A0,'xNw1Ge',$13
                DC.B '^',$AD,$9D,$D3,$FD,$27,$90,$0B
                DC.B $97,'m',$27,'B',$A9,$BA,$A6,'p'
                DC.B '1',$94,$96,$BF,$C1,$13,']',$BA
                DC.B 'a',$BA,'|',$8A,'C',$D2,$F7,'z'
                DC.B 'bJH',$85,'H',$A2,'!',$EC
                DC.B $AA,'>Q',$7F,$A6,$CB,'g8'
                DC.B $1E,'S',$B0,$A3,'c',$7F,'V!'
                DC.B $90,$FC,$94,'5',$D6,$C4,'u*'
                DC.B $16,$BD,$15,'{',$A1,$15,$FE,$BF
                DC.B $AC,$F3,$10,'@',$AE,'b',$FB,$8D
                DC.B $A9,$F9,'[',$C0,$8F,'$_',$A2
                DC.B $E0,'6',$CB,'`',$C0,'B',$05,$08
                DC.B $90,'Xju',$1E,'%(',$A5
                DC.B $E9,'{',$9F,'O',$AD,$82,$C7,'L'
                DC.B $F1,'TP_~^R!'
                DC.B $F0,'8l,WtC',$B0
                DC.B $07,$BF,$95,'k',$83,'1',$FA,$7F
                DC.B $F4,$DA,'K5',$A4,'!s',$1E
                DC.B $BB,$FB,'{',$DC,'.x6',$AD
                DC.B $BF,$7F,'„W:',$7F,'„8'
                DC.B 'z',$AB,$F1,$9F,$DE,'{',$8D,'p'
                DC.B $EF,';w',$F4,$1C,$18,$F6,$EE
                DC.B 'e',$82,'V_',$1E,'r',$15,$09
                DC.B $AB,$BD,$BC,$F2,'Nq',$C3,'`'
                DC.B $1D,$DE,'9',$80,'`',$0D,'_k'
                DC.B $F2,'šc',$B2,$D4,'O',$00,'T'
                DC.B '4,a',$D9,$CE,'l',$F8,$D6
                DC.B $F2,$98,$80,$17,$92,'l',$02,$E8
                DC.B $0C,$02,$A0,$ED,$FF,$93,$E1,']'
                DC.B $F8,$F9,$CF,$9B,'w;',$B2,$E6
                DC.B $E6,'r',$0C,'V',$BD,$06,'{',$86
                DC.B $BC,$DF,$B8,$B2,'f',$16,'O',$8F
                DC.B $E2,'#h',$F6,'R',$0B,$BF,$F7
                DC.B $03,'h',$DD,$87,$16,$17,'5',$B6
                DC.B $B0,$1C,$27,$11,'u=',$FE,'v'
                DC.B $A6,$1E,'p',$C9,$8B,$09,'.#'
                DC.B $17,$84,$CA,$15,'2FL',$C9
                DC.B $86,$98,$83,$8E,$B5,$03,$B7,$C6
                DC.B 'b',$A2,'2',$D3,'M\r%'
                DC.B $B0,'`',$A1,'s',$DE,$03,$0D,$A7
                DC.B $85,$AF,$97,$CB,'w',$0F,$1F,$A3
                DC.B $09,$87,'Bv',$AC,$A2,$A3,$A8
                DC.B '-I',$CD,$EE,'L|V',$A1
                DC.B $80,$BA,$DC,$9E,'a6',$0B,$27
                DC.B $F7,'[',$D5,'`',$C3,$19,$A3,'v'
                DC.B $13,$86,$02,'>',$A3,$C1,'o',$7F
                DC.B $97,' ',$E2,$E9,'L',$9C,'*0'
                DC.B $8E,$F9,$F4,'y',$9D,'+',$0A,$A7
                DC.B '%{',$AD,'n#e',$14,'D'
                DC.B $15,$86,$C2,'&',$02,'5',$F1,$CE
                DC.B $C1,$D6,$00,$D5,'M',$BC,$AE,$00
                DC.B $8C,'9,$',$18,$1B,$10,'&'
                DC.B $D7,$DF,$A5,'i„1',$04,$02
                DC.B '=',$81,$82,'.a9r',$9E
                DC.B $0B,$CD,$1D,$F8,'J',$DC,'"',$8F
                DC.B $BB,$7F,'D',$8F,$A3,$EE,$12,$A6
                DC.B $C5,$C7,'|x',$E1,$BD,$A9,'U'
                DC.B '7',$82,'B',$16,$C8,'n',$FC,'m'
                DC.B $F5,$94,'x',$FC,'J',$FC,$C6,'S'
                DC.B $C2,$B2,'{*7',$00,'-#'
                DC.B $B7,$13,$DE,$84,'`-{',$AF
                DC.B 'i',$95,$06,'^O^',$FE,'-'
                DC.B '^9',$C0,'-T',$19,$DA,$12
                DC.B ')',$B2,$9F,'V',$1A,';',$AC,$B3
                DC.B $84,$F7,$BB,$90,$DE,$9C,$0D,$81
                DC.B 'n',$D2,$CA,'E',$CE,$8E,$C8,$EB
                DC.B $86,$C7,$D6,'015',$DD,$D2
                DC.B $F1,$AA,$B2,$F2,'O',$8D,'>A'
                DC.B $9B,$14,$1E,']Y',$0C,$DF,$DB
                DC.B $C8,$1F,$F3,'DN~',$DA,$A9
                DC.B '-i',$C9,$CE,$10,'1',$DD,$92
                DC.B 'Z',$A3,$D9,$1E,'q',$B8,$BC,'Q'
                DC.B '{',$F2,$FE,$C8,$D7,$FB,'a',$8E
                DC.B $CE,'_',$FB,'C',$CE,$AE,'$x'
                DC.B $97,$C0,$DE,$D0,$ED,'0',$DD,'R'
                DC.B 'b',$E6,$F1,$F9,$AD,$0D,'ŽW'
                DC.B $99,$14,'z',$CC,':g',$D8,$DC
                DC.B $08,'G',$FA,'O',$AE,$9A,$A6,$C8
                DC.B $C1,'v',$CC,$EE,$EC,'0',$DD,$12
                DC.B 'j%)',$A4,'h5',$8B,'W'
                DC.B '{',$F2,'>',$E0,$94,$D3,$C6,'z'
                DC.B $14,'F',$FA,'C',$CE,$CE,'0',$96
                DC.B $0C,$ED,$F9,$EC,$EC,'0',$DD,$D2
                DC.B $B2,$A0,'Y',$0E,'3@',$85,'X'
                DC.B $9E,$17,$04,'*',$17,$04,$8D,'2'
                DC.B 'TZ',$E7,'BN',$BE,'"x'
                DC.B $F7,'4D]',$DE,'*',$E0,$97
                DC.B 'z',$E7,'q',$A9,$07,'z',$C4,$00
                DC.B '1',$D9,'y',$D8,'5',$27,'<',$87
                DC.B $ED,$1B,$93,$B0,$D4,$EF,$AC,$C7
                DC.B $A2,$DA,'_',$E0,$8B,'d',$F7,'U'
                DC.B $82,'Z',$A8,$D4,$AA,$CD,$16,$06
                DC.B $90,$EC,$DF,$E4,$94,$9D,$C1,$D6
                DC.B $27,$0C,$1D,'ŽZ',$DF,$CF,$97
                DC.B 'laJ',$FE,$8A,'$',$FF,$16
                DC.B $8A,$99,$E0,'{}',$F7,$13,$06
                DC.B $F1,$E1,$C0,$E1,'to',$93,'t'
                DC.B '3',$02,$92,$90,$F8,$CC,$B0,'&'
                DC.B $DE,$17,'h',$FA,$8A,$E4,$87,$DB
                DC.B $B1,$E0,$11,'%',$F8,$E7,$11,$06
                DC.B 'P',$95,$93,$CA,$B7,$D9,$89,'='
                DC.B '4',$0E,$1C,$EE,$B7,$A9,$A9,$82
                DC.B $00,$05,$02,$F3,$8C,$A0,$8C,$BE
                DC.B '|',$27,$A8,$90,$02,'š ',$04
                DC.B $B1,$09,'c',$D5,$16,$83,'0',$08
                DC.B '~',$09,$91,$F0,'|',$9C,'&X'
                DC.B 'S',$A8,$11,$97,$85,'c',$97,$19
                DC.B 'ie',$E1,$1B,'Q',$14,$EF,$1B
                DC.B $15,$9F,'1',$DF,'u',$E0,$E3,$FE
                DC.B 'e',$B8,$07,$BE,'3',$F3,$A9,$27
                DC.B $9E,$FF,';T]šj',$E8
                DC.B $97,$DC,$18,'F<',$1F,$D0,$BE
                DC.B '(\',$09,$FA,$D1,'[',$95,$14
                DC.B '?!6',$BC,$93,'g;',$F5
                DC.B $C8,$95,$18,'x',$1A,$92,$E9,$B8
                DC.B $DD,$13,'O0',$B6,$F0,$D3,$DE
                DC.B '-',$1F,$E0,$04,$10,$0E,$8F,'}'
                DC.B '=',$AC,'(',$B4,'}V3X'
                DC.B $18,$1C,'dq',$D1,$81,'f',$02
                DC.B $C1,$98,$F6,'3',$FD,$E0,$DA,'y'
                DC.B 'G',$D0,$BD,$16,'HluU'
                DC.B '2',$27,'R',$DC,$DB,$93,$06,'7'
                DC.B $81,$82,'v{',$9A,$02,$1B,'j'
                DC.B $E7,$16,$AF,$F4,$CE,$E1,$D1,$9E
                DC.B 'gWH',$10,$8E,$1D,'P&'
                DC.B $DB,$A1,$C6,$C6,$9E,$88,$08,$93
                DC.B ',)',$01,'uY:',$1E,$CA
                DC.B $13,$8C,$DE,$1E,$11,$9C,$E0,'<'
                DC.B 'x',$D2,$1A,'<',$C9,$FA,$E1,$1E
                DC.B $80,'8',$F7,$C4,'^',$80,$07,'t'
                DC.B $98,$7F,'+R',$1D,'2',$1D,'*'
                DC.B $EF,$15,$0F,'H',$FB,$07,$CD,'_'
                DC.B '}W+',$1C,$07,$AD,$81,$BC
                DC.B $05,$AA,$07,$C2,$1E,$F8,$0A,$D3
                DC.B 'd',$02,$C6,'m',$DC,'* ',$8F
                DC.B $1B,$8B,$BE,$F2,$0E,'9',$CC,$FF
                DC.B $D0,$C5,$FC,'(K',$0A,'_',$8B
                DC.B $0E,$27,$16,' ',$C2,'-',$14,$B2
                DC.B '0',$AC,$D1,'o',$9C,$A2,$AF,'`'
                DC.B '(',$0D,'n',$0C,'S4',$CB,$1F
                DC.B '6',$BF,'5?',$89,$BD,$E5,'s'
                DC.B $19,$AA,$8D,'$(y',$1E,$17
                DC.B $F9,$F7,$FF,'n]',$DA,$C3,$EF
                DC.B 'W',$84,$9D,$B6,'&>',$CC,$BF
                DC.B $C8,'H',$0B,'Z',$C5,$19,$BD,$97
                DC.B $0F,$27,$B6,$EC,$99,$E8,'l',$FF
                DC.B $A7,$9A,$D7,'o',$1C,$D2,$01,'K'
                DC.B $83,$FA,$B4,$D1,'J1',$CB,$DF
                DC.B 'M',$DF,$D8,'f$',$95,$B1,'l'
                DC.B $12,$A6,$A6,$AA,'Q',$DF,$EE,'O'
                DC.B $D1,'8',$E3,'i',$DC,$CA,$E4,$17
                DC.B $8A,'9',$EC,'\™+',$CA,$7F
                DC.B $E0,$E3,$C0,'a',$84,$F1,$02,'B'
                DC.B $15,'&',$D6,$88,$F5,$CB,'p',$1E
                DC.B $1B,$CF,$FD,'l',$9C,'Bs',$C5
                DC.B $B4,$80,$1D,$86,'$>',$CC,$9F
                DC.B $85,$27,$87,'I',$C7,'U',$A5,'y'
                DC.B $10,$A6,'Fv',$EC,$AA,'d',$00
                DC.B 'zc',$EA,'j\zVA'
                DC.B 'dF',$85,'w',$FE,$27,$C9,'?'
                DC.B $18,'>EQ',$E6,$1D,$9D,'3'
                DC.B $1B,'%v4',$E4,$89,$E8,$EF
                DC.B '%',$0A,$85,'e',$1B,'r5',$CD
                DC.B $93,$BC,$BC,$92,$02,$DA,$D8,']'
                DC.B $9F,$C7,$1B,'|A',$86,'!',$08
                DC.B 'Q',$A6,'o',$FB,'T',$87,'a',$C5
                DC.B $E6,$D1,$A2,$00,$D7,$88,$18,'*'
                DC.B 'oE',$A5,'3',$96,'L',$A6,$F4
                DC.B 'oT*^e',$0D,$FF,$DF
                DC.B 'h',$CB,')',$D9,$1F,$F8,$EA,$AF
                DC.B $AD,'yK',$9E,$A6,$07,$1B,$8A
                DC.B $9B,$BB,$DC,'^ywc',$8C
                DC.B 'c',$D9,$FB,'i',$C7,$F4,'Ž}'
                DC.B '}d',$D0,$CA,$D2,'<zt'
                DC.B $1E,$18,'o',$1C,'s9',$1D,$E8
                DC.B $B6,$00,',@',$FC,'g!$'
                DC.B 'uQ',$8A,'J',$07,'A',$98,'3'
                DC.B '{',$89,$81,$CE,$9D,$A8,'d`'
                DC.B '6',$0C,$05,$95,'E[',$12,'I'
                DC.B 'c',$C6,'u',$89,$03,$1A,$F0,$BA
                DC.B $0A,$EB,'aW,',$AA,'"',$08
                DC.B $B1,':',$B2,$82,'}',$9C,$E0,$D5
                DC.B $E0,$D1,'"',$B0,$E1,$AE,'t',$05
                DC.B 'l',$85,$BD,'2',$96,$8C,'~i'
                DC.B 'ž.',$27,']E',$09,$FF,$DF
                DC.B $C8,$FF,'oql',$FA,'j',$BF
                DC.B $AF,'y',$CB,'N',$C0,'kX',$82
                DC.B $9C,$FB,$D4,']y',$B7,$FB,$F9
                DC.B 'r=',$E7,'g',$AE,$FA,$8C,$7F
                DC.B $DF,'5',$9D,'Yx',$DC,$E8,$0A
                DC.B $1D,$0C,$E7,'H',$A0,$06,'g',$07
                DC.B $8C,'9',$0C,$88,$83,$AA,'z',$09
                DC.B $D2,'%',$A8,'n',$03,$A1,',E'
                DC.B $D5,'~',$1F,$9F,$17,'7q',$DE
                DC.B $E3,$D2,$00,$B5,'a',$1F,$FA,$F6
                DC.B $B6,$80,$BD,'2',$16,$9C,$80,$B8
                DC.B $E9,'i',$91,'IG',$06,$F1,$12
                DC.B $E1,'H9',$9B,$B7,$A3,'c',$C0
                DC.B $A2,'z+',$92,$E5,$0F,'|',$A6
                DC.B $80,'Z',$A8,'T',$FA,$07,'mk'
                DC.B $FE,$A2,$D8,$E4,$94,$93,$8E,$B1
                DC.B $8B,$F7,$F0,$84,'V',$DF,'.',$97
                DC.B 'l',$01,$C6,$AD,$04,'3',$FD,$16
                DC.B $8A,$99,$E0,$FB,$0D,'9',$EC,'['
                DC.B $FE,$EC,$C1,$E3,'tc^',$82
                DC.B $81,$B9,$E5,$8D,$FD,$C1,$B9,'.'
                DC.B $D9,$B1,$D1,$AB,$A7,'%~',$C6
                DC.B $B4,$01,$11,$A5,'H1k',$0B
                DC.B $F2,'!',$88,$CA,$B7,$D7,'Fj'
                DC.B $92,'v',$A0,$8A,$95,$A7,$A3,$88
                DC.B $09,'-',$E1,$A9,$C4,'K',$F4,$B5
                DC.B '~',$27,'I',$10,$92,',',$EA,'{'
                DC.B $A1,'en',$D4,$1C,$8C,$FE,$81
                DC.B $91,'6',$D8,'g',$0A,$96,'%X'
                DC.B 'SH',$ED,$AA,'d',$BF,$CE,'t'
                DC.B 'ff',$E1,$9B,$E1,'&i+'
                DC.B $B6,'iO',$D2,'v',$EF,$A3,'6'
                DC.B $9B,$F5,$90,'p',$8C,$86,$A7,'('
                DC.B $9D,$1F,$87,$A5,$83,'c',$D7,'1'
                DC.B 'n',$A5,$19,$C6,$0C,$D9,$F8,$19
                DC.B $11,'r-',$DE,$D5,'T[',$01
                DC.B $D2,$B6,$0D,'7',$0B,$F2,'/',$F2
                DC.B $CC,$B6,$96,'F_{',$AA,$00
                DC.B 'l%I',$B0,'FR',$C7,$C0
                DC.B ')<%',$DD,$15,$03,'@',$EA
                DC.B $E2,$1C,'3<c',$F9,'*W'
                DC.B $14,'0',$A4,$C1,$0F,$94,')',$90
                DC.B $9A,$9B,$00,$87,$84,'J',$06,$C8
                DC.B '%',$F2,$FC,$EA,$F3,'R;',$C5
                DC.B $EA,'w52',$CB,'*',$B2,$E3
                DC.B 'B',$A5,$B0,'B',$FF,'o',$AC,'`'
                DC.B $A8,$DD,'8b',$E0,'FEp'
                DC.B '?',$BA,'5',$FF,'Q',$CB,$A7,$B6
                DC.B $EB,$DB,$EB,'!"q9',$B5
                DC.B $90,' B',$DD,$AE,$A8,'0',$ED
                DC.B $D7,$14,$EF,'|',$1D,'{',$84,$F8
                DC.B $DF,'C',$09,$1E,$88,'|',$1F,$88
                DC.B $E6,'1',$1E,$08,$A1,$E7,$0E,$17
                DC.B $DF,$D5,'aY',$9E,$C3,'?',$AE
                DC.B $1F,$8B,$1E,'&',$98,'k',$C2,' '
                DC.B $F5,'A',$EC,'&',$CC,$DA,$05,'B'
                DC.B $F5,$9A,$83,$0E,$05,$D5,$0D,$F3
                DC.B $08,$CD,'}',$DC,'N\',$B2,'}'
                DC.B $05,$0A,'N',$90,'"~',$04,$A8
                DC.B $86,$0F,$C3,'!',$0C,$82,$B0,$98
                DC.B $F0,$FA,'O',$F5,$FC,$CC,$10,'R'
                DC.B 'ThiZ>v',$95,$D9
                DC.B '1',$90,$FF,$1A,$F1,'hBP'
                DC.B $1B,$9E,$91,$0B,'O',$EA,'cN'
                DC.B $F6,'Z{',$B3,$B4,$A3,$03,'4'
                DC.B $A0,$BA,'s',$DB,$EE,'pu',$A5
                DC.B $00,'j',$A2,'S',$DA,'c�X'
                DC.B $9D,$BE,$D7,$A3,'|',$9D,$01,'/'
                DC.B $F4,$B3,'orM',$C2,'O',$9B
                DC.B 'kA',$0E,'V',$DD,'jX"'
                DC.B $10,'l',$C2,$FF,'m',$15,$CF,$FF
                DC.B 'p',$B1,$16,$BB,$F9,$80,$D0,$FC
                DC.B $04,'(',$95,'P',$B0,'c[Y'
                DC.B $D3,$F8,';',$14,$95,$E1,'g',$A7
                DC.B '`f',$E1,'[9',$1F,$B0,$12
                DC.B $CC,$AB,'Y',$D6,'v',$E1,$8E,$1E
                DC.B $B4,'[',$15,$97,'P',$99,$A3,','
                DC.B $1E,$8D,$14,'7',$90,$1D,$FA,$16
                DC.B 'j',$A5,$19,$86,'D',$92,'?',$A1
                DC.B $E5,$E3,'@',$D1,$D6,'[5',$E8
                DC.B $C2,$A0,$C6,$86,$F6,$8B,'(',$F7
                DC.B 'H%"qY:~',$C6
                DC.B $94,$1C,'Pm',$9F,$8B,$DE,'='
                DC.B $F8,'"',$08,$FA,$B1,'7',$1A,$C3
                DC.B 'E0',$F8,$83,$96,'g',$BB,$05
                DC.B ':',$CB,'=',$B4,$E1,'/',$00,'K'
                DC.B $E3,'V',$87,$97,'"',$9E,$80,$F8
                DC.B 'P',$D5,'Z',$14,$EE,$9E,$AD,$15
                DC.B $FF,'9',$17,$E0,'Z',$A0,$83,$E4
                DC.B $E6,$92,$18,'X',$9E,$A2,$0F,$AC
                DC.B $FF,$D7,$B7,'1',$B6,'p',$C3,' '
                DC.B $B9,'Ik',$16,'"',$04,$80,'r'
                DC.B $FF,$9B,$83,$EE,$15,$98,$86,'D'
                DC.B $1E,$12,'h',$DA,'B',$DC,$02,$0B
                DC.B $E7,'T',$E7,';',$F9,'j',$02,$A8
                DC.B 'J',$D7,': `lsP'
                DC.B $FB,$FB,'O',$D5,$EC,$C9,$9C,'"'
                DC.B 'R',$87,'v[2',$F6,'%',$CF
                DC.B '?',$D1,$17,$E5,$DC,'fAP'
                DC.B $D7,$C6,$9C,$0E,$A3,$D4,$E6,'<'
                DC.B $F0,'X{',$11,'D',$BE,$82,$86
                DC.B $86,$FF,$1B,$DA,$E2,$F0,$C5,$91
                DC.B $F6,'VGO',$B7,'o',$82,'Z'
                DC.B 'P',$F4,'~',$1A,$E1,$BE,$89,'S'
                DC.B $FB,$BB,'gP',$DC,$EF,$8C,'a'
                DC.B 'z',$85,'vY',$D2,$EB,$E8,'Z'
                DC.B $0D,$CA,'v',$EB,$C3,'a',$C1,$02
                DC.B '!',$9D,$D1,'#',$1C,'&\+'
                DC.B $D4,$19,$13,$C0,$BE,$C4,$8F,$C3
                DC.B $09,'*',$01,$D5,$8D,'$',$9F,':'
                DC.B '#I',$A6,$13,$12,$1C,$10,$06
                DC.B 'A',$11,$A2,'-k',$8E,$EF,$1D
                DC.B 'n',$10,$94,$D0,$80,'%',$93,$A2
                DC.B $C5,'q,2',$91,$E1,$A7,$BF
                DC.B '=',$CF,$D6,$BD,$E5,$86,$BD,$11
                DC.B $E3,$05,'d5',$AA,'v',$B2,$B8
                DC.B $E2,'_',$1B,$1F,'I',$19,$96,$02
                DC.B 'q',$E7,$DA,$D0,'m ?',$0E
                DC.B $05,'M',$06,'g',$C0,$02,$8D,$17
                DC.B $C3,$C1,'<@',$E8,$DE,'%',$A6
                DC.B $27,'G',$9A,$0F,$C5,'M',$A0,$E8
                DC.B $85,'^',$CF,$EE,'l`',$B7,$DD
                DC.B 'q',$A8,':',$C2,'l5',$8B,$17
                DC.B $9F,$8D,$93,$AB,'[L',$D7,'|'
                DC.B $14,'F',$1A,$FF,$BB,'$',$D3,$AA
                DC.B $CD,$F5,$FC,$EC,'l',$A0,$8F,$BC
                DC.B '=',$AF,'Z',$AE,$27,'>',$8C,$17
                DC.B $B3,$09,'c',$B5,$DA,'<',$B9,$97
                DC.B $0F,'G',$9A,$EF,'y',$1C,$D6,$15
                DC.B $A4,$BC,$D7,$EF,$FF,$E0,$87,$1B
                DC.B ')',$AD,'z',$CA,'S1',$8B,$17
                DC.B 'c',$95,'2',$BF,'Y',$AC,'Ki'
                DC.B '"F',$1A,$DF,'?t',$D9,')'
                DC.B 'M#',$E2,$E9,'B ',$9F,$FA
                DC.B 'U',$A4,$99,'f',$AC,$0B,$8A,$17
                DC.B $C0,$11,$02,$D9,$E5,$1B,$1D,'C'
                DC.B $15,'F',$9A,$CF,$D3,$EC,',',$F7
                DC.B $18,$C9,$FD,$EC,'l`',$97,'Y'
                DC.B $81,$1A,$D0,$9D,'!>',$8C,$17
                DC.B '#',$9D,$D1,$E3,$B4,$F7,$A2,$96
                DC.B '?G',$1A,$BF,$B3,$C3,$AF,$07
                DC.B $AD,$9F,$D7,$EF,'Y',$A0,'o('
                DC.B $A1,'Y',$08,$C8,'{1',$8B,$17
                DC.B '3Y',$A9,$EE,'/',$A2,'Li'
                DC.B $12,'F',$9A,$AF,'+61',$D6
                DC.B 'd"',$E2,$E9,'Y',$E1,$E7,$F7
                DC.B $85,$A1,$B9,'r',$AD,'*',$8A,$17
                DC.B $DF,'e',$90,$CB,'W',$0B,$1F,'C'
                DC.B $15,'F',$1A,$9F,$B7,$A3,'#',$B8
                DC.B '/',$C9,$FD,$EC,'l ',$7F,$A6
                DC.B $80,$FA,$D4,$9D,'!>',$8C,$17
                DC.B $F3,$A1,$D8,'d',$A4,$F5,$A2,$96
                DC.B $0F,'G',$9A,$8F,'U',$DF,$EE,$0F
                DC.B $99,$9F,$D7,$EF,'l`',$F7,$15
                DC.B $8A,'9',$0C,$C8,'K1',$8B,$17
                DC.B $9F,$ED,$BF,'p',$0E,$A1,'Li'
                DC.B $1E,'F',$1A,$7F,$C7,$0E,'x',$DD
                DC.B 'o"',$E2,$E9,'`',$A0,$CF,$D4
                DC.B $DE,'t',$A3,'s',$92,'+',$8A,$17
                DC.B $BF,$E9,$1F,$9C,'q',$10,$1E,'C'
                DC.B $19,'FšoE',$FE,'J',$9B
                DC.B $27,$C9,$FD,$EC,'`',$E0,$C7,$93
                DC.B $16,'k',$C2,$9F,'->',$8C,$17
                DC.B 'c',$F5,$FE,$A8,$FB,$00,$A0,$96
                DC.B '?G',$1A,'_',$CF,'.TZ'
                DC.B $A3,$A0,$D2,$EF,'B ',$DF,'R'
                DC.B '"n',$E2,'{n3',$8B,$17
                DC.B 's',$F1,'^',$B4,'Op',$12,'d'
                DC.B $11,'FšOz',$1E,'V',$1A
                DC.B $EC,'W',$F0,$EB,'l`',$D7,$11
                DC.B '*m',$02,$27,$D8,'#',$89,$17
                DC.B '/',$FD,'=',$C0,$F8,$E0,$04,'"'
                DC.B '%E',$1A,'?',$C3,'M`',$E0
                DC.B ':N',$8D,$E6,'Q',$A0,$AF,$E0
                DC.B 'x',$C7,'5�X',$D6,$97,$16
                DC.B '3',$B9,'uW',$1A,'D',$B8,$F7
                DC.B $1F,'Eš/',$1B,$90,$E5,'P'
                DC.B $8E,$1D,$A7,$E1,'k',$E1,$27,'o'
                DC.B 't',$82,'}',$CA,$A2,$C8,$96,$16
                DC.B $FA,'ELRF',$A9,'K',$C9
                DC.B $0F,'D',$1A,$1F,$87,$85,'g@'
                DC.B '[',$A4,$B2,$E3,'L ',$BF,'>'
                DC.B 'mEek',$F6,$C3,$95,$16
                DC.B $F3,$01,'$]B-',$1B,$A3
                DC.B $0D,'C',$9A,$0F,'e',$F9,$EA,'/'
                DC.B $14,'KM',$FE,'A`7',$8D
                DC.B $B5,$BB,$9C,$96,'R',$F6,$93,$16
                DC.B $BD,$ED,$FB,'hs',$99,$AD,'u'
                DC.B $03,'B',$1A,$FF,$DB,'0q',$FE
                DC.B $D7,$12,'h',$FA,'D',$A0,$0F,$EC
                DC.B $B7,$00,$8D,'8',$C5,$E8,$92,$16
                DC.B $B3,'I',$8B,'J)atP'
                DC.B $07,'B',$9A,$EF,$99,$A8,'d',$E0
                DC.B 'h',$86,'v',$FB,'A',$E0,$07,'K'
                DC.B 'J',$C6,'5',$E1,$F7,$E4,$91,'6'
                DC.B 'z',$D5,'ZT&',$C5,$E8,'='
                DC.B $15,'A',$1A,$DF,'_',$A0,$E3,'P'
                DC.B $DD,$F4,$1C,$F8,'M ',$1F,$AA
                DC.B $7F,$87,'}',$AA,$8E,$EE,$92,$16
                DC.B 'sQjVa)',$BB,'W'
                DC.B $13,'B',$9A,$CF,$1D,$98,'f@'
                DC.B $B2,$9C,'w',$FB,'M`',$17,$09
                DC.B 'BEe',$CB,$E1,$E1,$91,$16
                DC.B $00,$DC,'9`d',$AD,'K)'
                DC.B ':A',$1A,$BF,$D3,$CF,$F0,'.'
                DC.B '}#',$02,$F5,'i',$A0,$EF,$D8
                DC.B $B6,$C1,$95,'u',$1E,$9B,$A0,$14
                DC.B '3',$99,$91,'K',$8A,$17,$1E,$03
                DC.B 'VK',$99,$AF,$9B,$A1,$E3,$90
                DC.B $05,$CB,$1D,$98,'f',$DF,'b',$A7
                DC.B $A6,$98,$E0,$9B,$A1,'nb',$AC
                DC.B $D5,$A7,$D8,$E4,'t',$EF,$A3,'V'
                DC.B 'w',$EA,'M',$95,'X',$E0,$AB,$27
                DC.B $9E,$9F,'w',$1B,'6',$F5,$05,$AB
                DC.B $9F,$DB,$18,$C6,$CC,'a!D'
                DC.B 'YV',$EA,$E6,$CE,'[U,'
                DC.B 'b',$09,'q',$D4,'6',$D1,'-',$F7
                DC.B $D0,'5',$04,$95,$13,$F3,'%o'
                DC.B $94,$1A,'P',$AD,$16,$1A,$F0,'Z'
                DC.B $D0,'F',$CC,$E2,$B8,'7:',$07
                DC.B $B1,$B1,'h',$11,$84,$C4,$AF,$07
                DC.B $B6,$DA,$1F,$B8,$AE,$E5,$C7,'3'
                DC.B $82,'[',$88,$D8,$A5,$EC,'r',$0A
                DC.B '^w',$AE,$EE,$1F,$E1,$C4,'Z'
                DC.B $B4,'p Z',$03,'41',$D6
                DC.B $08,'l',$09,$B6,$CD,$0A,$DC,$F2
                DC.B $BA,$A2,'9',$02,'x',$9A,$00,'H'
                DC.B 'vr',$8E,$CA,'[Iw',$10
                DC.B $F3,'x',$FF,'C',$82,$A6,'#',$B8
                DC.B 'C',$85,$16,'W',$F1,',',$E0,$B7
                DC.B 'r',$E6,'Q',$ED,'C',$11,'O',$EF
                DC.B $C2,'ho',$D6,$BA,'5Z',$EB
                DC.B $0E,$E9,$AD,'i',$05,$96,$A5,$08
                DC.B '5+!',$11,$B9,$C7,$C3,'s'
                DC.B 'j',$27,$89,$18,$9D,$0C,'.',$83
                DC.B 'MwN',$D2,$0E,$E1,$E4,$DE
                DC.B $84,$15,'TX',$97,$84,$27,$D8
                DC.B $8F,$7F,$CB,'.',$8C,$03,$DB,'2'
                DC.B 'vg!Cd7',$AB,$93
                DC.B '{q.',$DE,'mM',$97,'t'
                DC.B $8B,'V',$DC,'G',$16,$F4,$A9,$A7
                DC.B $C2,$14,$E8,'*l?',$DE,$F2
                DC.B $9A,$DE,'X.',$FB,'**#'
                DC.B 'yq',$0E,$FA,$DD,'9yO'
                DC.B $9A,$97,$84,'N�f;u'
                DC.B $B4,$B9,$F3,'+XY',$D2,$B1
                DC.B $D2,$12,$8F,'X',$D5,'!',$A9,$B3
                DC.B $0B,$7F,$ED,$06,$1C,$E3,$04,'"'
                DC.B $95,$D4,'L5',$08,'W=',$D5
                DC.B $08,'N',$8D,'&?t',$B5,'}'
                DC.B $C9,$93,'?',$82,'h',$D7,'7B'
                DC.B $99,$0E,$F3,$01,'PK',$87,$F8
                DC.B $A4,$14,'Z',$F4,$FC,'L@',$BC
                DC.B 'O',$E5,$91,'$',$13,'q',$95,$D9
                DC.B $F1,$F8,'zm?',$DF,$96,'Q'
                DC.B $1B,$9E,$A1,'k',$A3,'5',$9A,$13
                DC.B $DF,']U',$B3,$B4,'#',$DD,$0E
                DC.B '9',$8B,$BE,$C7,$EF,'pu',$A5
                DC.B $C0,'2',$8B,$98,'AR',$87,'X'
                DC.B $9C,$AE,$D7,$83,' ',$E5,'$',$E6
                DC.B $E1,$BC,'gr',$82,'B',$FF,$CD
                DC.B $81,'^',$AF,'B',$F4,'jX"'
                DC.B $D0,'4+',$C4,$EC,'E',$C5,$00
                DC.B 'Q',$B5,$16,$9B,$9D,'T',$D6,$BC
                DC.B $EC,$1B,$13,'`',$84,$E2,$CB,$8B
                DC.B $C9,$F5,'\',$E0,$A0,$A4,'O',$A4
                DC.B ' .J',$B0,$A6,$CE,$16,$06
                DC.B $B1,$A9,'g',$B3,$1A,$04,$F0,$DA
                DC.B '(',$03,$BC,'p',$AC,$02,$D7,'J'
                DC.B $11,'pg',$FE,$8A,'dW!'
                DC.B '00',$C5,$BC,'e',$F6,'=',$06
                DC.B $11,$BD,$A5,$8B,$9F,'t',$B2,'x'
                DC.B '4',$02,'<@',$AE,$A2,$C3,$0C
                DC.B 'Y',$E7,'z',$FC,$8A,'$_',$A2
                DC.B $00,$0A,$0E,'h?',$FF,$14,$06
                DC.B 'q',$B1,$D6,'#',$0C,'"',$9C,$93
                DC.B '/',$03,$92,'P',$9E,$C3,$0F,$D3
                DC.B '$',$8A,'U',$FF,$A1,$E4,'g',$27
                DC.B $10,$8C,$BE,$92,'B',$F2,'=',$06
                DC.B $D1,$A5,$18,'<y',$8A,'/e'
                DC.B '1',$02,$12,$A0,'|',$7F,$1A,$B1
                DC.B $F0,'Tp',$FB,$8A,$A4,$EF,$98
                DC.B 'Y',$03,'m,',$D7,$E4,$11,$06
                DC.B $01,$99,$F1,'G',$B8,'2',$FA,'?'
                DC.B $12,$01,$92,$B0,'4S',$1D,$11
                DC.B $95,$FB,$1B,$F8,$8A,'dwe'
                DC.B 'c',$81,$9D,'V',$91,$EF,$12,$06
                DC.B $B6,$AD,$B7,'O',$C7,$99,$8D,'Q'
                DC.B $13,$02,$12,$80,'6',$B3,'a',$00
                DC.B $1A,$8F,'u',$FB,$8A,'$',$7F,$E6
                DC.B 'xG',$05,$87,$C4,$E2,$11,$06
                DC.B $F1,$A1,'HX',$E5,']',$05,'('
                DC.B ':',$01,$BC,$90,$D8,$F0,$E9,$EF
                DC.B 'E&+',$F5,$89,$E4,$07,$EB
                DC.B $97,$BC,$17,'b ',$9E,$0B,$04
                DC.B 'QU-zA',$C9,$A7,$16
                DC.B $7F,$09,'5',$E0,'šh|',$BD
                DC.B $8F,$9D,$17,$97,$85,$A3,$0F,'L'
                DC.B $C3,$F2,'S',$CD,'K',$11,$EF,$1B
                DC.B $B4,$C9,$DB,$84,$C0,$B9,'I',$E9
                DC.B $82,$B8,$87,$EE,'w`{}'
                DC.B 'w$"Qt',$DA,$02,$AB
                DC.B $DF,$F3,'si',$9F,$0B,$CE,$BF
                DC.B 'HX',$E9,$86,'g)',$1B,$C3
                DC.B $05,'(',$B5,$AC,'5W}='
                DC.B '?',$CB,'=',$14,$15,$D1,$E1,'w'
                DC.B $C6,$F2,$93,$95,'"',$1E,$B0,$D2
                DC.B $FB,'h',$CF,$82,$F0,$99,$AD,$15
                DC.B $91,'Q',$BC,'k',$89,'F',$7F,$FD
                DC.B $CC,$92,$18,'8',$F2,$CD,$C4,'3'
                DC.B $E0,$F1,$B3,'1',$B6,$F0,'3b'
                DC.B 'mv',$AE,'Ž?',$08,$7F,'o'
                DC.B $9C,$92,'dR>',$B7,'A',$BC
                DC.B $84,'9c9',$D2,$E9,$E8,$F8
                DC.B $F5,$F8,$D4,']',$99,$EB,$B2,$F2
                DC.B $13,$1C,$81,'i',$A3,$F5,$02,'B'
                DC.B $B5,$D2,',',$B9,$F3,'+',$F4,$0E
                DC.B '.',$CF,'}<',$B2,$85,'kH'
                DC.B $A3,'>',$0C,$88,'#',$FE,'4',$82
                DC.B '!',$DB,'Yt',$02,$A1,$AC,$95
                DC.B $AF,$13,$D4,$A8,'Q',$1F,'v',$DE
                DC.B $E3,$92,'X@',$9F,$C2,$E3,$17
                DC.B $AA,'}',$A4,'3',$B6,'P',$C7,$A0
                DC.B $E1,$E7,'@qI',$0D,$7F,$EF
                DC.B $D2,$9C,'C',$96,$DC,$0C,$F8,$AD
                DC.B $86,'9',$A3,$C1,'}',$FC,$86,$DB
                DC.B $F5,$B4,$DB,'^',$B2,'K',$06,'('
                DC.B 'e',$95,$12,$9B,$F9,$FC,$01,$C2
                DC.B $CE,$FC,$0F,$DD,$8D,$E4,$CB,'k'
                DC.B '1',$D0,$C0,'Mk',$1B,$9A,$BA
                DC.B '-',$AB,$FA,':1',$BC,$FC,$B9
                DC.B 'X',$14,$C9,$A5,'tl',$D7,$A0
                DC.B $F9,'?',$1C,$DC,'W',$DC,$EA,'+'
                DC.B 'mG',$E5,'N',$08,$17,$BD,$1A
                DC.B '9',$A9,'1',$E6,'X',$B8,'X',$C9
                DC.B 'Z',$94,$99,$AF,$F3,$DC,'A',$8E
                DC.B $FE,$7F,$14,$DB,$17,'4',$F5,$EA
                DC.B $B5,$BE,$F8,'O(3',$B9,$FA
                DC.B $05,$B0,$10,'Bt',$B3,$DF,'Y'
                DC.B 'p',$12,$82,$89,'_N',$17,'d'
                DC.B $DD,$BE,$E7,$C2,$FE,$AE,$C4,$AC
                DC.B $DB,'U',$F0,'K',$F8,'/',$A0,'_'
                DC.B $E1,$B6,'[.',$DB,$A4,'y',$E9
                DC.B $CE,$88,'S',$93,$C6,'<',$F9,'?'
                DC.B $CA,$FD,$AF,$E9,$AA,$84,$C7,'l'
                DC.B $A3,$FC,$9B,'H',$D8,$CB,$84,';'
                DC.B $E7,$B5,'{J',$B7,$AF,$FA,'y'
                DC.B 'D',$13,'"',$9D,']',$AC,$8B,'Q'
                DC.B $F3,'>',$D7,$C8,'}',$FC,$CA,'+'
                DC.B 'Y',$83,$F6,'K„G',$93,$99
                DC.B '=',$AB,$9A,$F6,$CE,$A1,'y',$89
                DC.B '&',$9F,$F1,$A7,$F8,$1C,']+'
                DC.B $DA,'}_',$B7,$10,$D3,$CD,$EB
                DC.B '%*�E[~ve'
                DC.B ',',$A9,$BA,$12,$12,'\H/'
                DC.B $B2,$AD,$B7,$AF,'[',$8C,$EF,$1D
                DC.B $04,$E4,$0E,'}+2',$D1,$AA
                DC.B $C9,'q',$AC,'b',$1F,$96,'I',$E4
                DC.B $1C,$AF,$DA,$BE,$E5,$C6,'U',$CE
                DC.B $8C,$AC,'w',$B7,$FC,'|',$B1,$B8
                DC.B ',c>{',$0D,$12,$D5,'j'
                DC.B 'U',$E8,'Y',$80,$C1,$8F,'Ld'
                DC.B $0E,$AD,$FA,$1A,$B1,'Pgl'
                DC.B $B2,$AA,';',$BB,'Y',$EC,'c',$EE
                DC.B 'b',$EC,$ED,'a2v',$D9,')'
                DC.B $85,'>',$A3,$01,$B7,$A5,'O',$E4
                DC.B 'T',$A3,$15,'B',$90,'K>',$00
                DC.B $B1,$A9,$F7,$C7,$D4,'\',$19,$C0
                DC.B 'i',$0C,$9D,'t,R',$DD,$E9
                DC.B $C9,$D7,$C0,$8D,$88,'dWa'
                DC.B '^',$A1,'3&',$13,$BF,$1C,$05
                DC.B $1D,$BD,$B9,$CB,'W',$CB,$07,$82
                DC.B 'M',$0F,$11,'@6',$B6,'!',$B8
                DC.B $03,$CC,$DD,$90,$85,'#_',$E2
                DC.B 't',$E7,']',$89,$AF,$0E,$E2,$1F
                DC.B 'z',$B5,'v',$D7,$B6,$B7,$AA,$D5
                DC.B $8B,$B8,$89,'J7',$96,$A5,$08
                DC.B $F5,$92,'8TQ[Ra'
                DC.B 'b!',$89,'89!',$C9,$BF
                DC.B ',',$C0,'<',$E0,$14,'ct0'
                DC.B $1B,'%',$B6,$0C,$C5,$CD,'0',$D6
                DC.B 'D',$06,$86,'e',$1B,'R',$B1,$DD
                DC.B $B1,$A0,'9',$E2,$10,$DC,$D8,$CD
                DC.B '(',$B0,$92,$CB,'W',$CB,$E7,$1E
                DC.B '`',$AC,$A5,$CA,$BD,$A4,'#',$B8
                DC.B $8F,'}',$AB,$02,$D7,'I',$94,$B9
                DC.B '}',$E7,'QM',$FB,'G',$A5,'t'
                DC.B '8',$1E,'a',$D5,$B6,$B7,$8A,$B1
                DC.B 'k',$CB,'i',$B1,'t',$9B,$A6,$08
                DC.B 'y',$03,'F',$9D,$A6,'gw',$05
                DC.B 'l%',$89,$F8,$0D,'yd',$06
                DC.B '5',$0D,$27,$DD,$15,'cT',$8C
                DC.B 'nk',$1D,$7F,'k',$FA,'*',$D7
                DC.B $C4,$B6,'T',$1F,'v',$9D,'J',$84
                DC.B $9C,$9B,'@',$AF,'Gr#',$A4
                DC.B $8C,'+',$E7,$E5,$F4,'?9g'
                DC.B 'q',$8A,$C1,'fj',$DA,$AE,'g'
                DC.B $B6,'\ošF',$BB,'N',$04
                DC.B $8C,$D9,'x',$CA,$EB,'e',$E1,'1'
                DC.B $11,$0A,$A7,$ED,'S',$AB,$CB,'9'
                DC.B '|)',$F5,'dj:26'
                DC.B $80,$FE,$1B,$18,$16,$B1,'M',$84
                DC.B $BC,$1F,'0A',$BC,'o',$A2,'T'
                DC.B $97,'*g',$F5,'2G',$98,'S'
                DC.B 'wJ',$F9,'cj',$1A,$B6,'V'
                DC.B $9E,$AC,'u',$9B,$E6,$AF,'P',$01
                DC.B $AC,']h',$8C,$C3,'ba',$EC
                DC.B ' @,',$FE,$91,$B3,'*%'
                DC.B 'y',$E9,$AD,$09,$05,'u9',$15
                DC.B $FC,'S',$10,$17,$B5,'E',$B3,$FD
                DC.B $D5,$94,$9F,'6V',$14,'/',$83
                DC.B $A5,$0F,$03,$19,$CD,$1A,$FD,$FF
                DC.B $A3,$18,'S',$F8,$FB,$EC,$0C,$F3
                DC.B $83,$F9,';',$D4,$8D,$84,$8B,'\'
                DC.B '%',$0A,$CE,'`g',$12,$0F,$87
                DC.B $A1,$8B,$D3,'#',$27,$C2,'(',$E5
                DC.B $01,$08,$D1,$E8,$9D,$C4,$0F,'S'
                DC.B $D3,'T0',$93,$85,$C3,$83,';'
                DC.B '&',$89,'~*',$D7,$04,$ED,$9B
                DC.B 'c',$17,$A2,'-K*',$FB,$BF
                DC.B $A7,$B7,'H',$D5,$80,'%',$13,'2'
                DC.B $EE,$F6,$DC,$B0,'!',$F7,$A5,$BF
                DC.B $1A,$0F,'.',$A4,$83,$8D,'~I'
                DC.B $DA,$06,'d5',$A4,$D2,$C6,$DA
                DC.B $C8,$7F,$7F,$13,'O',$1A,$16,$92
                DC.B $27,'m',$C9,'N',$00,$93,'I',$04
                DC.B $02,$8D,'^',$0E,'T',$B8,$FC,$D9
                DC.B $88,',',$27,'=',$C9,$BA,'i',$8D
                DC.B $E6,$BF,$27,'zkz',$1A,'q'
                DC.B $D3,$B3,$D4,'O',$E0,$8F,'L„'
                DC.B '\',$03,$8D,$B8,'c',$B2,'{i'
                DC.B $BE,'*',$E7,'E',$08,'b4h'
                DC.B $F8,$FE,$EF,'ajZ',$1E,$D1
                DC.B 'i&',$E2,'I',$C0,$AB,'P',$81
                DC.B $18,$A7,'=b',$84,$AD,$FA,$F9
                DC.B ';>',$A5,'MG',$C9,$A7,'V'
                DC.B $D7,'>',$17,'@G',$B9,'b',$C0
                DC.B $82,$9E,$F7,'K',$A0,$27,'_',$82
                DC.B '[D%',$C3,$CC,$A1,'y',$09
                DC.B 'r1fUfMW,'
                DC.B $DA,'}',$9F,'Om',$9A,$E6,$B0
                DC.B $E0,'9',$83,'E',$7F,'^R',$01
                DC.B '\',$04,$ED,'\',$19,'[H',$AF
                DC.B '!?%]',$85,$F1,$02,$02
                DC.B $1D,$E5,'N5B',$F9,'j',$1F
                DC.B $1B,$CF,$9D,'h<v5',$8D
                DC.B $BF,'{',$04,$87,$A4,'.JO'
                DC.B $9A,$CE,$FB,'h',$E3,']',$B5,'X'
                DC.B $18,'e~',$F3,$DC,'0',$F1,$EE
                DC.B 'ue',$8A,'f',$FB,'n',$18,$EA
                DC.B $87,$C3,'5a',$80,$CA,'V',$EE
                DC.B 'KW',$8A,'J',$27,$C5,'(',$C5
                DC.B '%',$E4,'.',$D9,$B8,$AB,$E4,'P'
                DC.B $F4,$D4,$C0,'m',$BC,$06,$1B,'J'
                DC.B 'J',$85,'}*',$17,'<L',$8F
                DC.B 'b',$D3,'ZTF)',$FB,$9F
                DC.B $10,'f',$DE,$C7,'^',$A0,'c@'
                DC.B $82,'}',$EB,'j|>',$1E,$AA
                DC.B 'OFeK',$FB,$27,'I/'
                DC.B 'TQjVf',$AD,$8B,'1'
                DC.B $1B,$E5,$8E,$CD,'9',$98,$E6,'0'
                DC.B $80,$1E,$87,'e;V',$11,$09
                DC.B 'M',$05,'-',$C4,$0C,$D9,'X',$CD
                DC.B $0A,$E0,'@Q',$86,'QV',$0C
                DC.B '^m',$BD,$8B,$F5,$8B,'h',$9F
                DC.B $CB,$B5,$94,$07,$F7,'Mt',$C5
                DC.B $94,'|D',$AF,'GR',$27,'d'
                DC.B $91,'.',$07,'y',$E1,'=9',$E7
                DC.B 'm',$8C,'ar',$E6,'j',$FC,'m'
                DC.B $B5,'\',$AF,$82,$CD,'kXB'
                DC.B $CC,$B2,'{',$CA,$EB,'E',$E5,$FC
                DC.B 'p1',$C6,$81,'h',$AD,$CB,$B9
                DC.B 'd+',$95,'P',$F8,'K',$00,$D4
                DC.B 'L',$E6,'Z ',$9B,$E1,'g',$C7
                DC.B $FC,$98,'@o',$BF,$CF,$B6,$12
                DC.B $D5,'%',$88,$EA,$F3,'?',$99,$D3
                DC.B $A1,'T',$1C,$9F,$9F,$27,$B3,'f'
                DC.B '6',$8C,$B5,'#{',$1D,$FA,$B6
                DC.B $B4,$DF,'x',$8A,$C3,$C2,'5',$A2
                DC.B $E5,'cp',$F7,'R',$AB,'+',$A5
                DC.B $A3,$93,$C4,$86,'6',$13,'56'
                DC.B $0A,'nI>X9~f'
                DC.B $A2,$1D,'0',$01,'~',$F8,$B4,'2'
                DC.B $FB,$A1,'8',$00,'PKw',$90
                DC.B $A3,$D3,$8C,$8D,$D5,'O@',$BC
                DC.B 'C',$85,'V?2U',$F1,$D5
                DC.B $FE,$F8,'T',$ED,'O',$F1,'3',$C2
                DC.B $85,$F0,$9E,'l',$A3,'5Zk'
                DC.B $BE,$12,$B4,'LM>',$F2,$0E
                DC.B '5+a9',$12,'Q',$D1,$91
                DC.B $B6,'?',$8C,$18,$91,$EC,$B2,$D2
                DC.B $07,$00,$08,'}',$19,$EB,$E4,'^'
                DC.B $B4,'[',$BC,$0B,$E9,'c|',$DD
                DC.B $8F,$7F,$0B,'6',$FD,'O4M'
                DC.B $CF,'r#Cd',$9D,'?a'
                DC.B $81,$CE,$DB,$84,$90,'[',$96,$F4
                DC.B $D0,$AA,'f',$F2,'Cj{',$9D
                DC.B $C7,$14,'(r',$CA,'`',$18,$AA
                DC.B $FE,'yC/',$E2,$82,$DE,$FD
                DC.B '@Q',$EA,$86,$00,$01,$80,$D2
                DC.B 'w0',$98,$CF,$1D,'X~]'
                DC.B '#',$90,'8',$B4,'Q_',$12,$09
                DC.B $CB,'q',$E3,';',$05,$A0,'y',$A9
                DC.B $06,$DF,$B9,$90,'Npr0'
                DC.B $EB,$FD,'O',$B5,$D4,$8F,'H',$1B
                DC.B 'k',$07,$86,'E',$0F,'v',$F5,$D5
                DC.B '"l',$02,$E7,$10,'\HO'
                DC.B $AA,$EE,$1F,$BC,$C9,$E0,$E4,$1E
                DC.B $10,'d~sL~Z',$D9
                DC.B $B3,'~',$AB,'b',$CB,'n',$D8,$92
                DC.B 'jc!C',$FC,$C7,'U',$EE
                DC.B '^',$F4,$FE,$C8,'wO',$97,$B4
                DC.B $1B,$E3,'.Y',$CF,$AE,$A4,$A8
                DC.B $FD,$15,'H~',$8A,$06,$DB,'R'
                DC.B 'b',$A6,'Y.G',$F8,'TŽ'
                DC.B 'V',$F3,'^',$D4,$D6,';y',$8F
                DC.B '.c',$DE,'GNž&x'
                DC.B $B7,$BC,'S',$7F,'z>',$DE,$12
                DC.B 'j',$E5,'qI[',$F3,'S.'
                DC.B 'v',$F1,'>',$E0,'4',$A7,$0C,'a'
                DC.B '1',$E2,'ŽM',$CD,$CE,$B0,$C6
                DC.B 'bBnz:V',$D1,$F1
                DC.B $87,'@',$A1,$F3,$EE,$E5,'Q',$CE
                DC.B $BD,$00,$A4,$CD,'w',$0F,$DF,';'
                DC.B '<a',$BE,$0B,'e',$B9,$A2,$A8
                DC.B '-',$E9,$19,'x',$FA,'N4',$8D
                DC.B '{',$A7,$D9,$1E,$B1,$F0,'Sn'
                DC.B $A7,$CE,'{',$D8,$D5,$FB,'an'
                DC.B $05,$E2,'n',$F1,$DC,$F0,')w'
                DC.B $A1,'?cy',$BA,'f',$17,$E9
                DC.B $AB,$1C,$10,'E',$9C,$EB,'R',$0E
                DC.B ')]',$09,$FA,$B1,'W',$16,'D'
                DC.B '5b',$1E,$BF,$93,'g',$BB,$85
                DC.B $CA,$D5,$80,'e{',$9E,$EA,$B8
                DC.B $DD,'SG/',$17,$DC,'X',$AD
                DC.B '&',$1B,$E1,$05,$F0,'?',$F9,$1F
                DC.B '`',$EC,$CD,$A5,'r[',$BE,'e'
                DC.B $B6,'|',$AB,$02,'7',$B5,'m',$08
                DC.B $CB,$D1,'wI',$FB,'G%D'
                DC.B '9',$DA,$B9,$10,'.',$A6,$8C,$B1
                DC.B 'k',$0B,$F1,$A4,$D2,$8F,$88,$C3
                DC.B 'b',$02,'F',$9D,$06,$B3,$ED,$D8
                DC.B $11,'L',$A6,$F3,$0E,'y',$E4,'\'
                DC.B '<',$9A,$11,';i',$0E,'_',$8B
                DC.B 'n',$AB,$E5,$A2,$B2,'c',$9B,$A1
                DC.B '.',$A9,'Q',$1F,$D6,$A9,'p',$A5
                DC.B '`',$C6,$D5,$1D,'Qt',$A3,$F4
                DC.B $B4,$B0,'VS',$A6,$F5,$E2,'~'
                DC.B 't',$CA,$A9,'I',$AD,$82,$E7,$10
                DC.B $9C,$FF,'{',$9C,$A6,'GS!'
                DC.B 'p',$88,$1E,'F<',$7F,'d',$8C
                DC.B $02,$BF,$95,'+',$CB,'Z',$95,$94
                DC.B 'ok]7',$A4,'!',$13,$FE
                DC.B $F3,$B5,'X s}6',$AD
                DC.B $83,$0F,'N0',$B6,$D0,'7"'
                DC.B $AE,'Mk6',$0A,$02,$80,$F2
                DC.B $A3,$94,$04,$FE,$1B,$18,$16,'R'
                DC.B $14,$10,$A8,'"S',$99,$0A,$0C
                DC.B '+',$8D,$FE,':',$F5,$C8,$B6,$B2
                DC.B $9E,$CB,';@Hjs',$D0
                DC.B $90,$D4,$CC,$E5,$DA,'P',$1D,'1'
                DC.B 'V',$82,$B6,'#3',$B5,$0D,'l'
                DC.B 'p',$02,$AD,$F4,$CE,$C1,'5B'
                DC.B $8D,'J',$CB,'B',$88,$12,'^',$AB
                DC.B $AA,$13,$F4,$E4,'šH ',$98
                DC.B '+)A=',$12,$B1,$0D,$CC
                DC.B 'sh',$C2,$1F,$11,$FC,$B4,'R'
                DC.B $BB,$CA,$9B,$AC,$FB,$00,$E0,$9E
                DC.B $B0,'R',$FC,$E3,'Z@_Y'
                DC.B $93,$80,'v;',$F2,$AD,$10,')'
                DC.B 'Oa',$E1,$FB,$CD,$E1,'1',$E2
                DC.B $0D,'`',$B0,$CF,'woS,'
                DC.B $BA,$91,$A4,$8A,'5',$B3,$A1,'('
                DC.B $DD,'7',$04,'5',$D1,'It',$E5
                DC.B 'x',$A7,$19,$A6,',',$99,$C0,$80
                DC.B $81,$AF,'w',$D7,$F2,$DB,'E',$0A
                DC.B $DA,$19,'Sx+',$92,'%',$F8
                DC.B $18,$AE,$11,$D7,$8D,$84,'Kd'
                DC.B 't',$E5,'1',$01,'T',$14,$0F,$87
                DC.B $16,$AB,'7',$DF,'5G',$F8,$FF
                DC.B $04,$08,$D1,'h)',$F2,$A9,'G'
                DC.B $B2,$FC,';',$94,$85,$C3,'C',$E3
                DC.B $98,'[hL;',$1F,$F0,'š'
                DC.B 's',$B7,$F6,$E7,$94,$B3,$8A,$11
                DC.B $8B,$B1,'HU0',$D3,'-',$17
                DC.B 'K',$83,$16,$B7,'!',$F7,'eg'
                DC.B $B1,$99,$A0,$F3,'N',$91,$7F,'I'
                DC.B $E1,$A6,$B8,$F0,'r',$0F,'_',$EB
                DC.B $C2,$80,'b',$92,$D8,$10,$B5,$A6
                DC.B '.)!',$F1,$C9,$EC,$08,'l'
                DC.B $A7,$DE,$D8,$1E,$91,$8C,$1E,$E5
                DC.B $AD,'LK',$F2,$D2,$FB,$E1,$DE
                DC.B 'q',$8F,'!',$FA,$9B,$08,'8u'
                DC.B $98,$7F,$CB,$8E,$C8,$8C,$0C,$CC
                DC.B $E4,$14,$0F,'H{',$B7,$1B,'e'
                DC.B $88,$CA,$1B,$1C,$0D,$A2,$8C,'q'
                DC.B 'S',$8E,$E1,$E2,'Z',$00,'7',$D6
                DC.B 'd',$02,$E6,$89,$C8,$AC,$10,')'
                DC.B $9B,$9D,$C0,$FF,$8D,$A9,$1A,$E5
                DC.B $0D,'`0',$FF,$F1,$7F,'QL'
                DC.B 'd',$8E,$A1,$8A,'5s',$B9,'e'
                DC.B $D6,$B8,$F3,$8B,$C8,'Lt',$E5
                DC.B $D8,$D3,$F7,'Y',$D9,$A3,$19,'e'
                DC.B $AD,$AE,$F7,$07,'0',$E7,$04,'"'
                DC.B 'Y',$8D,'ar,R',$BD,$C5
                DC.B $02,'N',$8D,$86,$C7,'kXb'
                DC.B $C8,'Q',$27,$83,'dV',$E7,$FC
                DC.B 'p',$B1,$B6,$0F,'oN',$B7,$F8
                DC.B 'd,',$95,'P0',$B3,$81,$A4
                DC.B 'N',$E5,$BA,$04,$97,$E1,'g',$E7
                DC.B $F8,$D7,'Wm?_',$A8,$13
                DC.B 'j',$A5,'x',$18,$AD,'6',$9A,$13
                DC.B $9F,'U',$1C,$9F,$D7,$EF,$8C,$03
                DC.B ':',$8B,$95,$27,'s',$1D,$FA,'V'
                DC.B '7J',$86,$97,'B',$D2,'7',$A2
                DC.B $E5,$E3,$E0,'%',$EC,$9E,'-',$E5
                DC.B $91,$94,$C4,$86,'v',$DB,$8E,$E3
                DC.B $E6,'R',$B0,'#S9~',$06
                DC.B $0C,$C9,$B6,'1',$D6,$C4,$B5,'2'
                DC.B $CF,$01,$A8,'.+',$06,$00,$C2
                DC.B $A5,$D4,$8C,$8D,$15,'7',$91,'B'
                DC.B $AB,$F0,$C0,'-4U',$F1,$F5
                DC.B '6P',$E7,';',$15,'<,',$C3
                DC.B $89,'p',$8E,$0A,'on',$F3,$A0
                DC.B $89,$17,$B4,'L',$8D,$A6,$83,'$'
                DC.B '^G',$CE,'.',$14,'Q',$D1,$B1
                DC.B $FE,$D7,$17,$E5,'p8',$AC,$D4
                DC.B '/',$80,'t',$17,$AE,$D6,'f',$8E
                DC.B $A9,'W',$BC,$0B,'%',$91,$85,$84
                DC.B $A1,$BD,$D3,'/',$F4,'M4m'
                DC.B $C9,'VGO[3+c'
                DC.B $AD,'NK',$12,$EE,$BE,$09,'a'
                DC.B $BA,$96,'d',$F2,$9C,$88,$88,'c'
                DC.B 'QD',$EE,'*',$D4,'i',$18,$CA
                DC.B '7',$CC,'v',$E9,$EF,'%',$A9,$F3
                DC.B 'F',$D4,$1A,'<)&',$DC,';'
                DC.B $B1,$D5,',',$D9,'_',$80,$87,$C4
                DC.B $12,$EA,$99,'(',$B4,$05,$1B,'*'
                DC.B $DA,'U',$A7,$13,$B2,'0+',$83
                DC.B 'VS*',$1E,'mŽom'
                DC.B $A0,$16,$D4,$C8,$1D,$F8,$8A,$A3
                DC.B $C0,'1',$E4,')”A',$13,$89
                DC.B $1B,$CB,$D6,$BD,$85,'*',$AA,$93
                DC.B $0F,$DF,$F9,'(',$AB,'v2H'
                DC.B $96,'V\',$B7,$D4,'/',$94,$02
                DC.B 'Z',$A7,$F2,'+t}',$F6,'U'
                DC.B '"N',$06,'g',$E0,'&)#'
                DC.B $95,$ED,'_4',$EA,$DE,$A5,'6'
                DC.B $9B,$95,$04,'~K',$1E,$96,$E2
                DC.B $86,$1E,$87,'%S',$99,$CA,$14
                DC.B '*',$CD,'6',$C1,$0C,$D9,$B8,$B1
                DC.B $A7,$EB,'?@(FX',$0B
                DC.B $ED,$DD,$CB,'e',$F8,'N',$A0,'H'
                DC.B $02,$AC,$91,$C7,'/',$B8,$CE,$D4
                DC.B 'B(j',$0C,'ST',$87,'8'
                DC.B $B8,$EA,$9F,$AC,$9B,$B4,$EA,$FD
                DC.B $D4,'<',$F7,'dd>',$D2,$0A
                DC.B $C9,$F3,$BC,'D',$1F,$B2,$CD,$94
                DC.B $11,'/',$8A,$B8,'%^',$C8,'_'
                DC.B $BC,$EA,$7F,$B8,$19,'d',$B4,$18
                DC.B $09,$A4,$E6,'b',$ED,'n',$DC,$C9
                DC.B 'hf',$AA,'b',$DB,$AA,$D0,'Q'
                DC.B 'f")d',$00,$FA,$D4,$FE
                DC.B '6',$FD,$DD,$C4,$BC,$D4,'&',$86
                DC.B $0B,'#',$16,'@l^',$DE,$89
                DC.B $AD,$DD,'_',$80,$A5,'#',$DF,$12
                DC.B 'n!I',$D0,$B5,'M',$E6,$1C
                DC.B 'U',$F1,$A1,$D0,'7',$83,$D0,$DC
                DC.B 'h',$AB,$85,'N',$CD,'Ž(W'
                DC.B $F0,'{K',$1E,'VY',$D2,$D1
                DC.B $92,$9C,$00,$A7,'Hq',$A3,$B4
                DC.B $07,$FF,$1D,$FC,$F1,$DF,'Ej'
                DC.B 'r',$CA,'I5D}',$BA,$E5
                DC.B $06,'.a™&w',$B5,$9D
                DC.B $D9,$D3,'7',$01,$94,'lbL'
                DC.B $B3,$8E,$F3,$07,'0G',$F8,'_'
                DC.B 'xi}',$F3,'<T',$BD,'E'
                DC.B $9B,'{',$0B,$16,$F5,'m',$98,'z'
                DC.B $C5,'RgK{',$17,'/',$E3
                DC.B 'm',$14,$C2,$01,'p',$AF,$8B,$F1
                DC.B $83,$98,'#',$DA,$FF,'L',$C0,','
                DC.B '}',$03,'&',$D1,$CD,$0C,$9C,$DA
                DC.B $F1,$B8,$9C,$F6,$8E,$09,$0E,'g'
                DC.B '}',$92,$92,'k',$C3,$19,']',$CB
                DC.B $06,$88,$E1,$C2,$BE,'$s',$FE
                DC.B $0A,$AA,'1',$93,$C5,'+',$A0,$BF
                DC.B $BD,$FF,$B4,$11,$D2,$04,$ED,$FB
                DC.B $D0,$05,'du"',$85,$F0,$C0
                DC.B $85,'8',$17,' b',$19,$F6,'N'
                DC.B 'Q',$C8,'=T',$9D,$A2,'/',$10
                DC.B $AA,'=',$EC,$9C,'!',$1E,$D0,$1E
                DC.B $13,$F9,'=',$80,$A0,$F5,$A2,$16
                DC.B '?',$A1,$86,'.',$E8,'M',$00,'4'
                DC.B $8B,$9A,$17,'wY',$DA,$A2,$DF
                DC.B $DF,$18,$B0,$D1,'z',$91,$DF,$BD
                DC.B $E4,$88,$93,$EB,'3',$87,'P',$EC
                DC.B 'B0',$B8,$EB,$B9,'$',$B3,'F'
                DC.B $D2,'8#',$B1,$E1,$CF,$84,$BB
                DC.B $93,'_',$E8,'\',$A9,$8B,'~i'
                DC.B 'o',$16,'b',$F5,$92,$F3,$02,$C2
                DC.B $F5,$00,'R',$D8,$7F,$1C,'6',$16
                DC.B '2',$CF,'=',$F4,$89,$04,$9B,$1A
                DC.B $80,$9D,' ',$83,'$ž „'
                DC.B 'K',$93,'2',$FF,'XO',$B7,$18
                DC.B $AA,$18,$D3,$C8,'=t',$B9,$A5
                DC.B 'Ne*',$D2,$8D,'D',$93,$F9
                DC.B $FE,$D4,'Wm',$FF,$07,$0D,$87
                DC.B ',',$1F,$01,$19,$AD,'6',$9A,$B3
                DC.B $0B,$07,'R',$B8,$F3,$EB,$8C,$03
                DC.B ':',$0B,$C5,$ED,$8C,$84,'kH'
                DC.B '*J',$86,$97,$02,':',$0C,$87
                DC.B $0B,$DB,$D9,'$',$C2,$9E,'-',$85
                DC.B $0D,$07,$D2,$A8,'Q',$DF,$8E,$E3
                DC.B $CA,$D2,$E0,$E9,$BC,$C4,$E3,$17
                DC.B $0A,$C9,$B6,'1',$96,',',$0A,$87
                DC.B $EF,$E7,$C0,'!,',$06,$00,'b'
                DC.B $11,$06,'R',$98,$F7,$CB,$90,'B'
                DC.B $12,'P',$F0,$EB,$8C,$04,'{',$C6
                DC.B '4P',$E7,';',$D5,'$',$09,$87
                DC.B $E1,'#',$88,$0A,'on',$F3,'@'
                DC.B $15,$06,$D2,$88,$95,$A7,$83,'$'
                DC.B '^',$C7,$FE,$EC,$8C,'D',$F3,$B5
                DC.B $FE,$D7,$17,$E5,'0@',$05,$88
                DC.B $99,'oo',$16,$B1,$D6,'f',$AE
                DC.B $C8,'{_w+',$96,$85,$84
                DC.B $8A,'=C]~~',$D6,'q'
                DC.B $E6,'VGO',$1B,'{D0'
                DC.B $0C,'}M',$12,$CE,$BE,$09,$81
                DC.B $C9,$DB,$0B,'=',$A4,$85,$87,'d'
                DC.B 'v',$C4,'^',$E0,'+',$98,$AA,'@'
                DC.B $E4,$D6,'w',$E9,$AF,$CD,$96,$B6
                DC.B '>;E',$11,'3&',$DC,$DB
                DC.B $08,$C3,$CA,'%',$FB,$89,$88,$C3
                DC.B '"jI',$FE,'*',$B8,'.',$D0
                DC.B $12,'L',$A6,$13,'r',$F8,$94,'6'
                DC.B '.',$F9,$1D,'<wŽo',$8D
                DC.B $0C,$C3,$8A,'-d}',$9A,$A1
                DC.B $EE,$B1,'T',$FF,'*',$D8,$A2,$9F
                DC.B 'Y',$C3,$D5,$BD,'E',$F2,$93,$B6
                DC.B $DA,$87,$F4,'G',$89,'v2h'
                DC.B $16,$C2,'J',$15,$01,'R',$9D,$01
                DC.B 'Z',$27,'b',$F9,'*',$F8,'Fc'
                DC.B 'HA',$05,'g',$A0,$EE,$92,'6'
                DC.B 'I',$B5,$B6,'O',$C5,$DD,$A5,'V'
                DC.B $12,$C2,$0A,']',$05,$B2,$E1,$F0
                DC.B $A8,$9D,'w',$FB,$0E,$18,'Z',$E2
                DC.B '_',$07,'M',$D0,$E6,$E1,$91,$B6
                DC.B 'E',$B3,'vW �P,'
                DC.B $13,$C1,$CA,'E',$00,$92,'e`'
                DC.B $D6,'8',$03,$F5,')8^b'
                DC.B 'h',$C5,$F5,'Y',$19,$9B,$A0,'4'
                DC.B 'U',$B1,'6_',$03,$E5,$04,$02
                DC.B 'T',$C9,$89,'M',$01,$F2,$E9,$CF
                DC.B $01,$CE,$1D,$98,'&WQ',$E1
                DC.B $98,';,',$84,$A4,'nb',$CC
                DC.B $05,$C0,$FC,'h',$83,'Q',$B6,'X'
                DC.B 'wi',$BD,$0B,$CA,'-tž'
                DC.B 'De',$0A,$16,$FA,'M',$B4,']'
                DC.B $AE,'~Do',$7F,$17,'/c'
                DC.B $89,'ŽSs',$F6,'=',$99,$F3
                DC.B $97,$98,'c',$F2,$A8,$04,$F7,'n'
                DC.B '!',$0C,'%',$D1,$CD,'l',$98,':'
                DC.B $B9,$BD,'|',$8A,$97,$0A,$0E,$E7
                DC.B '`',$14,'"}A',$A9,'+',$C5
                DC.B $08,$88,'!',$DA,'r|z='
                DC.B $F2,$D3,'@',$9D,$CB,$0B,$9C,$9A
                DC.B $D4,$F3,$93,'5',$16,'|',$E4,'|'
                DC.B $92,$8F,$F3,$87,$C0,$19,$FD,$9F
                DC.B 'b*U',$F8,')T}',$FD
                DC.B $B5,'zk',$1A,$84,$81,$8B,'|'
                DC.B $D7,$F2,$B3,'Q',$FA,'g',$A1,$94
                DC.B $B2,$0B,$C3,$81,'@',$89,$8F,'1'
                DC.B 'jI',$D9,$E7,$FA,'L',$80,$A4
                DC.B $7F,$01,$06,$95,'t',$BF,$8E,$DC
                DC.B $E0,$D8,$D8,$FE,$0D,$19,'p*'
                DC.B $A4,$89,$93,$EB,$CD,'{Q',$0C
                DC.B $AC,$F1,$90,$F0,$AE,'$3v'
                DC.B $CC,$B7,$14,$B7,$A1,'c',$97,$B9
                DC.B $A9,$1F,$10,$A5,'\',$91,$FF,$19
                DC.B $02,$1D,'a',$F5,$B2,$D7,'F',$EA
                DC.B $C8,$C0,$0A,$BD,'s',$1B,$B6,$86
                DC.B $1C,'-!',$F1,'#',$98,'j',$08
                DC.B $AB,']H',$10,$92,$8C,$9E,$B5
                DC.B '1',$DB,'9',$00,'0',$87,$F0,$E0
                DC.B 'K',$D0,$CC,$A5,$D2,'O',$C0,'L'
                DC.B '[H-2',$27,$B5,$ED,$D8
                DC.B $FB,'8',$EC,$9C,$F7,$86,'=A'
                DC.B $0E,$9A,$91,'k',$83,$F1,$A2,$B6
                DC.B $CB,$1F,$F3,$A4,$87,'#s',$1E
                DC.B $9B,$1F,$C7,$CD,$10,$B1,'m',$A8
                DC.B $8C,$7F,$04,$C7,$0C,$B9,$BC,'Q'
                DC.B $0C,'Ziv',$E2,']U',$8C
                DC.B $CE,'_',$FB,$A3,$27,$17,$F5,$EE
                DC.B $C5,$B6,$D4,$CF,$F0,$AD,$F0,'u'
                DC.B $95,$BE,'<',$A2,'H',$B1,';',$E1
                DC.B $BC,'pNrB',$C9,'Gj'
                DC.B $D2,$9E,$A3,'J',$8D,$06,'w',$BE
                DC.B $0F,'-',$E1,$C9,$D0,'I',$D4,'1'
                DC.B $AE,$FD,'T',$0D,$93,$AC,$BA,'q'
                DC.B ')~-~',$94,$B5,$EA,']'
                DC.B $EB,$DD,'k15u',$F9,$0D
                DC.B $F9,'s',$8C,$C6,$AF,'h',$B8,$FE
                DC.B $D5,'4',$8B,$B8,'eV',$87,$F8
                DC.B $C5,$01,$04,$99,$1D,'d',$B4,$F8
                DC.B $E4,'<',$97,$10,$DB,$EA,$CC,$CB
                DC.B 'A',$E6,$BA,'D',$9F,$E2,'GC'
                DC.B '5**d@R',$C7,' '
                DC.B 'c5',$C6,$A1,$9C,$D4,'&',$E6
                DC.B $E1,$9C,$03,'^',$D5,$CA,$D0,$8A
                DC.B $B1,']',$AF,$C2,'O',$1C,'Z',$C2
                DC.B '40K',$D0,$D6,'E',$05,$A8
                DC.B '\3',$86,$89,$1F,$84,$D0,$BC
                DC.B $EC,$FB,$CF,'E',$EE,$AA,$C4,'L'
                DC.B $D1,$F8,'[`;6]B'
                DC.B $E4,'6',$EB,'\',$B9,$CF,'VN'
                DC.B '@2F',$91,$9E,$F4,$82,$D2
                DC.B $27,'d',$FE,'C',$D6,$8A,$C8,$0B
                DC.B $19,$8F,$B5,'c',$FB,'.`',$C7
                DC.B '!,',$0A,$88,$C3,$C2,'U',$EE
                DC.B $E8,'(',$07,$B9,'>',$A4,',',$A5
                DC.B $00,$E3,$AE,'i',$CE,'j',$DC,$C9
                DC.B $C8,'RP',$7F,$94,$C6,'CC'
                DC.B 'D"',$A9,'4K',$F7,'SŽ'
                DC.B 'B7',$C6,$C1,$87,$17,$FE,$7F
                DC.B '4b^W',$D1,'H',$E0,$90
                DC.B $AC,$F9,'{|X',$FD,'f',$C7
                DC.B 'Y',$88,$DE,'^9',$FF,'T.'
                DC.B $FB,'%',$88,'*',$CB,$FA,$81,$92
                DC.B $04,$E3,$0E,$9D,$97,$27,$13,'r'
                DC.B '3',$8F,'U',$7F,':',$16,$F9,$B6
                DC.B $17,$0F,$0E,$88,'C',$F2,'S',$CE
                DC.B $C3,'dp7',$0A,$A2,',e'
                DC.B $16,'b>',$9B,$1E,$13,$15,$D2
                DC.B $E4,'Rp{',$FA,$0E,'|f'
                DC.B $06,$86,$BE,'2',$D6,$E4,'Qn'
                DC.B $CE,$B6,'8@x',$1E,$FF,'?'
                DC.B $0C,$F5,$DE,$95,$E6,'[ ',$B8
                DC.B $9F,$ED,$1B,'x',$8A,'2',$FF,$D6
                DC.B 'r',$E8,$D2,']',$A3,$EB,'R',$0E
                DC.B $F2,$E1,$A0,$AD,$A0,$FC,$81,'R'
                DC.B '7b',$9E,$8F,'h?Rz'
                DC.B $17,$90,'x|XZr',$85
                DC.B $18,$EB,$F2,'95',$00,'m',$AB
                DC.B $86,'/g',$B5,':hs',$B0
                DC.B $9D,$F7,'Fx}',$1A,'V:'
                DC.B 'I',$07,$C6,$AD,$92,$83,'K',$04
                DC.B ',',$ED,$12,$E5,$1E,'<',$EC,$9B
                DC.B $A4,'+',$27,$BD,$B6,$D8,$E5,$9E
                DC.B $90,$B6,$C8,'e{zZ',$F9
                DC.B $87,'~',$EB,$AA,'2',$B7,'M„'
                DC.B 'M',$E3,'1A',$FC,$27,'iK'
                DC.B 'ž*',$E7,$C5,'8H',$97,'4'
                DC.B $B9,'u',$00,$9E,'w[^',$B9
                DC.B $ED,$15,$88,$A6,'C',$1B,'z',$06
                DC.B 'n',$E1,'Q-w',$D8,$F8,$B9
                DC.B $CA,'$',$A8,$CE,$B7,'7z',$0F
                DC.B $FF,'=7',$9C,'5',$B7,$A1,$08
                DC.B $9F,$BB,$93,'G6',$12,$F9,$F6
                DC.B 'T9',$8A,'XYS',$C7,$E0
                DC.B $FC,'d',$90,$AB,$1B,$E4,$04,$E2
                DC.B $EE,$9C,'#',$9A,$B7,'#',$D3,$CA
                DC.B $0E,'N',$AD,$C2,$CF,$0C,'|',$A6
                DC.B 'N")',$84,$E4,'F',$05,'h'
                DC.B $F0,$A2,$D8,$C4,$98,'T',$B6,$B8
                DC.B $E6,$FB,$EF,$81,'V_',$DE,$89
                DC.B 'C',$E5,'Z`',$AD,'&',$FF,$16
                DC.B '@0Ip',$BE,$CF,'V',$0E
                DC.B $F7,$E1,$C4,$C1,$10,$08,$A7,$D6
                DC.B $27,'d',$9E,$8F,$F0,'K',$E4,'P'
                DC.B $9C,$AC,$B5,'c{^r',$C5
                DC.B 'q',$88,$FA,'z',$D5,$CF,'R',$AE
                DC.B $86,'/',$87,')Nj',$17,$A4
                DC.B '!',$EF,'Iu',$EC,'*',$14,'2'
                DC.B $E5,'RT',$7F,'2zRA'
                DC.B $27,$0E,$AD,'4S',$F4,'WN'
                DC.B $12,'2B1',$8E,$12,$FD,$7F
                DC.B '1bz3',$EC,$05,$1F,$91
                DC.B $AF,$F9,'x|',$FF,'n<',$CE
                DC.B '[',$88,$DA,'^=',$FF,'W',$EE
                DC.B $EB,$C4,$18,'\',$CC,$E1,$89,$92
                DC.B ',',$E3,'-',$19,'B',$FD,'n',$7F
                DC.B $1E,$88,'P',$80,$A3,$07,$B8,$9E
                DC.B $9C,$FB,$F0,'9',$BC,'Ho',$8C
                DC.B $E1,$83,$F7,'g!ep',$F0
                DC.B 'jt',$D5,$07,'"',$D1,$EE,$CF
                DC.B 'D',$06,$A2,$01,'t==n'
                DC.B $86,':,',$E4,$95,'L"$'
                DC.B $F1,'A',$CF,'b',$86,$D1,$E6,$DE
                DC.B 'm',$8B,$85,$0E,$86,$C5,'l',$9F
                DC.B $8A,'}KžC[',$B6,'='
                DC.B $89,'yGOyw',$E3,$BC
                DC.B $8D,$10,$A6,'m',$E5,'U',$8C,'q'
                DC.B 'r*',$B5,$CC,'x<',$F6,'n'
                DC.B 'r',$EC,'c',$19,$14,'Q',$91,$99
                DC.B $BC,$BF,'x',$EA,$85,$81,$A7,$D4
                DC.B $0A,$A0,'xxD)_K'
                DC.B '}',$A2,$BC,$8B,$D7,'o|='
                DC.B ':',$AE,'u',$9B,$EA,'O',$F0,'U'
                DC.B $D0,$F2,$93,$15,$D7,'del'
                DC.B $93,$EE,$DB,$84,$D2,$99,$ED,'='
                DC.B 'y',$EC,'iqB^z',$FD
                DC.B $F5,$F2,$1C,$18,$A6,'e',$D3,$11
                DC.B $C5,$F1,$B7,$B1,$B7,'n"',$04
                DC.B $14,$F8,$B9,$90,'2',$08,$BB,'W'
                DC.B 'e',$0A,$11,'@',$CB,'ŽL',$BB
                DC.B $A2,$99,'s',$9B,$94,'#',$DF,$D2
                DC.B $17,$E9,$D6,$DD,$C7,'a',$E5,$1C
                DC.B 'f',$F1,$1E,$BC,$A9,$F8,'E*'
                DC.B 'u',$A9,$81,'N\~Zy'
                DC.B $12,'0',$00,$15,'VY',$D1,$91
                DC.B '[',$E3,$F1,$B9,$00,$1A,$B4,$B2
                DC.B $03,$FF,$FE,$C8,'5g4',$08
                DC.B $BB,$D1,'H5',$C7,$AD,$A7,$C8
                DC.B '@',$A6,$12,'74u',$B1,']'
                DC.B 'e&*db',$96,'?A'
                DC.B $9C,'ŽW',$D3,$95,$D3,$AF,$F6
                DC.B $C2,' v',$F4,$B9,$84,'#',$98
                DC.B $8F,$1D,'.q',$1B,'r',$95,'9'
                DC.B 'heE',$CF,$88,$89,$D7,']'
                DC.B $1D,$1E,'!',$DD,$F0,$BF,'M',$C9
                DC.B '_',$B0,'a',$B1,'v',$FB,$AA,'g'
                DC.B '~P5',$B3,$A9,'kp',$85
                DC.B $9D,$DB,'xj',$DF,'w}',$09
                DC.B $92,'!',$E7,$E5,'V+',$1B,$A3
                DC.B $C9,$8B,$1F,$7F,'k',$D6,'.7'
                DC.B 'AF',$CE,'N',$80,'wK',$04
                DC.B $8C,$15,'0',$E1,'r',$B8,$FC,$99
                DC.B $A4,$DF,$A7,$ED,'3',$CB,'h',$8D
                DC.B $CF,$BF,$C7,'fj',$CE,$B2,'F'
                DC.B $F2,$B8,$D4,'Ob',$BF,'N',$84
                DC.B $BC,$AB,'h',$AC,'G',$BE,'{)'
                DC.B $B7,')g',$F5,$92,$C7,':g'
                DC.B $D1,$F2,$8F,'m}',$1A,'6',$16
                DC.B $BF,'[',$EC,'JU',$DB,'K',$03
                DC.B $BA,$9D,$A9,$D3,$EE,$A5,$FA,$B9
                DC.B '_8,',$FD,'i',$8F,$C6,'9'
                DC.B $DF,'=',$B4,',ty',$B3,$A5
                DC.B 'x',$E1,$93,'H9',$D7,'"',$8F
                DC.B $C1,$D3,$DE,'}',$A6,$AF,'s',$C9
                DC.B $C9,$C8,$F8,$08,$AA,'v',$96,'T'
                DC.B $D2,$8A,$BA,$EB,$DD,$B0,$82,$04
                DC.B $DF,$97,$FC,'L',$05,$07,$00,$EB
                DC.B $F4,'X',$0B,'(2',$C0,$F1,'Z'
                DC.B 'Y',$A2,$8F,$EA,$0A,'#',$7F,$AF
                DC.B $AF,$B3,'l',$D1,$A5,$D5,'6',$D6
                DC.B $A7,':@',$BD,$A7,$E7,'#',$AF
                DC.B $BA,'k',$C5,'_',$1D,$FB,'w',$0A
                DC.B $D7,'Eh',$F6,$F7,$0B,$04,$82
                DC.B $AE,'s#',$1A,$02,$15,$B1,'f'
                DC.B $13,'$e',$B9,$DB,$0B,$BF,'~'
                DC.B $A0,$DE,$FC,':',$90,$18,$F7,'z'
                DC.B $05,':A',$F1,'^k',$F7,'`'
                DC.B $A3,'2X7',$E1,$09,'<5'
                DC.B 'mBj',$BA,'p',$7F,'6',$CD
                DC.B $D6,$11,$AB,$F4,$E0,$E5,'u*'
                DC.B $84,$CD,$1B,$1C,$9D,$12,$DA,';'
                DC.B $B3,$F1,$14,$00,'w',$F9,$0A,$93
                DC.B ')',$EC,$1D,$B8,'Ž#;',$8E
                DC.B $09,$8B,$DE,$1E,$B4,$F0,$F7,$1A
                DC.B $F9,$C1,$F8,'(',$D9,$FA,'an'
                DC.B $B7,$B7,$8C,$0D,$CB,'-',$10,'r'
                DC.B $8A,'?c',$B9,'2W',$B5,']'
                DC.B '.',$0E,$0A,'H',$8A,$EB,'r',$CA
                DC.B $95,$81,'X3*',$A7,$08,'A'
                DC.B $B4,'r',$C0,$C6,$A1,$0B,$1D,$D2
                DC.B 'D',$C1,'z',$BC,'@;ž:'
                DC.B '2',$9C,$B4,$F2,$0E,$F8,$F0,':'
                DC.B 'y',$12,'"=V',$05,$D5,$9B
                DC.B $90,'1',$FC,$C3,'||',$1A,$B1
                DC.B '/}c',$BA,$C2,'*',$A4,$9F
                DC.B 'X',$03,'m',$0C,$EC,$E7,'x',$EA
                DC.B $EE,$8B,$F7,'G',$8A,$B2,'jM'
                DC.B $A9,$E3,$BA,$EC,$19,'Q',$19,$11
                DC.B $FD,$B3,'t',$BB,$1D,$DC,$8B,'{'
                DC.B 'e',$81,$99,$B6,$C4,$E2,$F1,$DA
                DC.B 'R',$18,$CB,'A',$CD,$1A,'9',$27
                DC.B $B8,$B1,$A8,$A9,$EF,'K*',$F8
                DC.B $A2,'Z',$0B,$B6,$A3,$C7,'c',$C7
                DC.B 'j',$EB,$B8,$D1,'o',$96,'{',$89
                DC.B $C3,$27,$88,$AA,'%',$8B,$C5,$F9
                DC.B $C1,$83,'F',$96,'š(T',$BA
                DC.B 'q',$E4,'0',$F4,'L',$F9,$02,'K'
                DC.B '"',$EE,$D2,'}#š*$'
                DC.B 'P',$D0,'^',$B4,$B8,'x',$91,$14
                DC.B 'a',$89,$0B,$DE,'Z Wz'
                DC.B $D6,$98,$17,$97,'[',$1B,$10,$AA
                DC.B ':',$EF,$F6,$D9,'K',$11,$EF,$BB
                DC.B 'vT`',$B6,'?',$E8,'G',$EA
                DC.B $83,'87',$DC,$01,$18,'\:'
                DC.B $1A,'/%Q',$1F,$12,$19,$0A
                DC.B '5',$EE,$18,$05,$91,$0F,$CA,$DF
                DC.B 'm',$D4,':',$C0,$A6,'[',$FF,$E0
                DC.B $04,$AB,'!',$DA,$DD,'P]',$F9
                DC.B 'YC$',$12,$D0,$0C,$18,'j'
                DC.B 'F',$E2,'1',$E1,$EE,$0D,$A4,'s'
                DC.B 'zW',$CE,$C2,':',$C8,'g',$CE
                DC.B $98,$D8,$E1,$C1,$9B,'Hd',$C0
                DC.B $83,$BE,'3',$D3,$B3,'(*',$CF
                DC.B 'vH"C',$DE,$03,$8D,$F7
                DC.B $EE,$C4,$92,',JA',$1E,$A4
                DC.B '(',$D4,$A3,$E9,'xO',$96,$A1
                DC.B $EF,'F',$D9,$EF,$8D,$DE,$0D,'+'
                DC.B 'n',$D0,'\-v!',$82,'w'
                DC.B '~N',$A3,'N',$85,'!',$F3,$7F
                DC.B '6',$DE,'c',$D1,$02,$AA,$E8,$10
                DC.B $9D,$F7,$F0,$EC,$AC,$E8,'(',$F0
                DC.B 'U',$88,$9E,'V',$1B,'0',$80,$F7
                DC.B '/|',$8D,'*',$E8,$99,$8D,$91
                DC.B '.',$D6,'&9',$83,'%',$13,$F2
                DC.B 'K',$84,$D6,$EF,$8E,$9C,$A0,$C0
                DC.B '4',$10,$CF,$00,$90,',',$97,'v'
                DC.B $1E,'6',$8E,$09,'*Bu',$EF
                DC.B $01,$C4,$EA,'!',$C3,$A6,$08,'T'
                DC.B $92,'<',$AE,$E1,$88,$AB,'0M'
                DC.B $C2,$87,'sJ',$BC,$CB,$9B,$F6
                DC.B $AC,$D5,'Z',$14,'l',$BE,$07,$C1
                DC.B $0D,$C4,$A7,$C9,'y\',$03,'4'
                DC.B $A1,$D2,$B4,$E4,'ŽH',$19,$A9
                DC.B $DC,$17,'/',$C4,$0D,$D2,$94,'u'
                DC.B '9^d',$16,$AD,'Q',$D6,$1C
                DC.B 'A',$DD,'e',$B1,'3',$97,$08,$94
                DC.B $EF,'p',$AC,$82,$85,'s',$FB,'u'
                DC.B $CE,$96,'R',$AE,$C3,$BA,'e',$0C
                DC.B $B3,'aD',$12,$E7,':',$BA,$B7
                DC.B 'Hk',$1D,$7F,$AA,$89,$0B,'t'
                DC.B $92,$1B,'D',$1D,'U',$9E,$CA,'4'
                DC.B $CF,$04,$83,$D8,'#{',$27,$A4
                DC.B $86,'n/',$1E,'/',$F6,'H',$8A
                DC.B 'E',$83,$C2,'f.',$0A,$09,$D3
                DC.B '%',$A2,'Z',$9F,'o',$BB,$CD,$F4
                DC.B '5',$8C,'>',$02,'u{',$EF,'<'
                DC.B $92,'j',$0C,':jI',$F7,$80
                DC.B 'L:',$F9,'d',$A0,'d',$18,$B1
                DC.B 's',$CD,'] 1',$A5,$C1,$B4
                DC.B 'u',$0B,$EE,$9C,$85,'2',$B6,'R'
                DC.B $B3,'f',$E8,'F',$A9,$FE,$A9,$D6
                DC.B $AF,$A0,$FB,'c',$0A,'Z',$1A,$11
                DC.B $BD,$93,$BC,'#',$F3,'Y',$D7,'q'
                DC.B 'F',$8E,$1A,$C6,$CF,$C1,'6',$E2
                DC.B ',',$8C,$DF,'C',$C8,'VR',$AC
                DC.B $AE,$93,$A7,$0A,$84,'M',$14,$F1
                DC.B $C8,'9C=',$D1,'I7-'
                DC.B 'n',$0D,'F',$B0,$06,$F6,$B3,'r'
                DC.B $86,'N',$A8,'N&',$0D,'K',$8A
                DC.B $AB,$D3,'h',$F1,$1F,$B8,'a`'
                DC.B '7',$BC,'_?',$B7,'e',$13,$89
                DC.B $7F,$C7,$F6,$B9,'d',$FE,'8',$02
                DC.B $14,$DD,'}X&e7h'
                DC.B $93,$1E,$1F,$C0,$DB,$F0,$ED,$CF
                DC.B 'X&a9',$B3,'-',$14,$EA
                DC.B $BB,'<,d',$8D,$EE,$B1,$12
                DC.B 'CQ',$09,'z',$AD,'/',$A6,'V'
                DC.B $9A,$AC,$9F,$CF,$AD,$96,$7F,$9D
                DC.B $A5,$9D,'w;]]',$11,'I'
                DC.B $F2,'r@',$CF,$CB,$E1,'1',$A2
                DC.B '7!',$DA,$84,' �Q,'
                DC.B 'ŽoH',$B6,'T_~]'
                DC.B $E0,$C6,$03,'5d',$87,$FA,$15
                DC.B $CA,'q',$E3,'[*e',$C0,'@'
                DC.B $AD,$10,$B3,$90,'~',$F0,$02,$02
                DC.B $CE,$E7,'st',$F9,'pD',$1B
                DC.B $1B,$CF,$1D,$D8,'=',$8A,$D5,$D1
                DC.B '&',$92,$0E,$87,$92,$90,$0D,'H'
                DC.B ')',$00,$1D,$BC,$CC,$9E,$B8,'X'
                DC.B $CF,$87,'p3w',$83,'Z',$D9
                DC.B 'w',$9F,$06,'V',$C5,$90,$B7,$9E
                DC.B 'jf!c',$B5,$F3,'B',$EF
                DC.B $D7,'z',$FB,$C7,'K',$D5,'&',$C6
                DC.B '1',$11,'!',$19,$1D,$AF,'R',$99
                DC.B $B8,$D8,'?',$14,$80,$FC,'7n'
                DC.B '|',$9C,'N',$CF,$18,$18,'0',$82
                DC.B $D5,$BD,$C0,$C2,$C4,'>',$C7,$19
                DC.B $F3,$DE,$D6,$08,$B0,$BB,'SY'
                DC.B 'Nš,r',$AA,$BC,$B3,'='
                DC.B 'y',$9F,'mk',$C9,'y',$D2,$9D
                DC.B $B7,$F1,$A3,$CD,'B',$D1,$97,$B3
                DC.B 'uQJ',$F6,'OB',$A2,'('
                DC.B $09,$08,$C9,$0D,$1A,$84,$99,$99
                DC.B 'J',$A4,$99,$96,'7',$B9,$D0,'='
                DC.B '[`~',$D7,$E5,$98,'-',$85
                DC.B 'y',$D6,'y',$B4,$0B,'m*',$F8
                DC.B $D4,$D7,$E0,$09,'-',$8B,'ye'
                DC.B '(',$1B,$BE,'1',$A5,$A9,$DA,']'
                DC.B $A8,'P;',$DF,'t',$F9,$0F,'b'
                DC.B 'bPer',$19,$0C,$A5,'G'
                DC.B $12,$AE,$FF,$0B,$EB,$94,'X',$E2
                DC.B $AC,$A5,$E4,'<',$E3,'V',$C9,$FD
                DC.B 'CO',$F6,$E7,$A1,$8D,$FE,'@'
                DC.B 'b',$DC,$85,'P',$03,'--',$17
                DC.B 'h>',$F2,$0C,$A0,$10,'wg'
                DC.B $BB,$9C,' ',$E3,$05,'9',$D9,$1E
                DC.B $ED,'W',$A8,$F0,'A',$CA,'g',$AE
                DC.B $1E,'Z',$0A,$9E,$ED,$FD,$A8,$A5
                DC.B $BD,'8C}o',$E3,$F6,$D6
                DC.B $E9,'&GM(',$FE,$D4,$BE
                DC.B $DC,$1A,',',$1D,$91,'D',$1A,$81
                DC.B $1E,$DD,'6',$9C,'B',$05,$86,$03
                DC.B 'G1N',$80,'4',$ED,'y',$86
                DC.B '(',$B5,$8A,$F7,$98,$BF,$F6,$DC
                DC.B $DF,$DA,$E8,'&',$D9,$E0,$D1,$DB
                DC.B 'VY5š$)',$8D,$E3
                DC.B $12,'iE',$1E,$94,$FB,$EC,'v'
                DC.B '5',$C9,$B6,$11,'G{',$A8,'t'
                DC.B $BC,$90,$C0,'#',$1F,$85,'p',$90
                DC.B '[2',$E5,$81,$89,'1',$9F,'C'
                DC.B 'a',$8D,'U',$9F,$93,$DE,'s&'
                DC.B 'P',$BE,$F6,$9B,'rwc',$0C
                DC.B $C6,'_',$14,'<(',$1C,'3f'
                DC.B 'B',$94,$9D,$8F,'`',$81,$96,'!'
                DC.B $9E,$AD,$7F,$1A,'E',$A3,$F2,$95
                DC.B $1E,'7',$1F,$C5,$AA,'e3',$A4
                DC.B $C2,$E3,$F1,'H',$E2,$A1,$DC,'<'
                DC.B '|',$89,'Av',$84,$A2,$EA,$90
                DC.B $86,$01,$16,$98,$0D,'{',$C7,'Q'
                DC.B '+',$8A,'S',$AE,$A7,'n',$E2,$C3
                DC.B $18,$FE,']',$AB,$C6,'9',$B9,$A8
                DC.B '[',$D4,'u4ice',$80
                DC.B 'šgt',$1B,':',$8D,$B5,$1D
                DC.B 'D',$B9,$C6,$DF,$F9,$9D,$A2,'T'
                DC.B $B5,'p3_',$CA,$03,'B*'
                DC.B 'K',$B7,'z',$F3,'<',$0A,$E9,'o'
                DC.B $27,$CC,$07,$95,$C5,$91,$99,$FA
                DC.B $D9,'B',$F5,$BA,'U',$E4,'t',$EA
                DC.B ':',$EA,$01,'y',$0C,$97,':',$08
                DC.B $EF,$0F,'4',$DC,$AA,$92,$7F,'='
                DC.B $11,'Y',$1B,$B7,'S',$ED,$9D,'Z'
                DC.B $97,$0C,$10,'e/h',$F6,$D9
                DC.B '?j',$D6,$83,$97,$27,$A6,$F6
                DC.B $9B,'>%',$D9,$EF,$BA,'{',$FD
                DC.B $D3,$E0,'$',$F1,$F0,$F6,$93,':'
                DC.B $9C,$0F,'7',$C1,$D9,'w',$9D,'u'
                DC.B '%',$EC,$AD,$8D,'m',$B6,'S',$CC
                DC.B $10,'.',$EF,$C1,'%BM',$BC
                DC.B $9C,'K03',$E6,$DB,$9C,$9A
                DC.B $A5,$09,'Y',$AD,$99,'|=',$01
                DC.B '.ov',$97,$E3,$C6,'3',$A7
                DC.B $A9,$E1,$97,$D0,'!cB|'
                DC.B $B7,$A2,$CF,$CE,$90,$1F,$A7,$1F
                DC.B $E9,$0B,'s',$C9,'kK',$BB,$EE
                DC.B $D3,'{4`=V',$CB,$86
                DC.B $D4,'^',$1B,'f',$27,$F4,'IA'
                DC.B $7F,'B',$FA,$CF,'p',$BF,':K'
                DC.B $17,$E4,$92,$D3,'>',$0E,'<',$A2
                DC.B $E5,$F1,$0C,$0F,$B9,$1C,$9D,$93
                DC.B $CF,$9F,$C3,$06,$86,'e[',$F8
                DC.B $27,$8A,$D5,$CF,'=X',$CB,$CE
                DC.B '4',$97,$D8,$A0,'B',$B2,$A0,'W'
                DC.B $EC,'D',$C4,$E5,$18,$A8,$0F,'E'
                DC.B $F1,$FE,$DF,'e',$00,'y',$13,$DC
                DC.B $8B,'&',$91,$B2,$10,$17,'^t'
                DC.B '8',$C1,$81,'O',$B0,$D7,'\',$AF
                DC.B $FD,$DA,$B7,$F0,$96,'W',$D2,'`'
                DC.B $F5,'>',$93,$B2,$A3,$EE,$DB,'v'
                DC.B $27,$B9,$80,$B2,'n/o',$17
                DC.B $19,'Xw',$96,'Q',$C3,$C2,$AF
                DC.B 'u',$1E,'Z',$D9,$1B,$03,$FC,$BB
                DC.B $F0,'~',$9B,$AB,$95,$A3,$07,$F8
                DC.B $03,'J',$A4,$8B,$A5,$1D,'=q'
                DC.B '9H',$EB,'@',$BE,$E9,'t%'
                DC.B $97,$A4,$9D,$A6,'[',$B0,'Nm'
                DC.B $F6,$BE,'C1',$DE,'C0',$F1
                DC.B $8E,$D5,$D4,$AA,$BE,$0D,'x',$E4
                DC.B ')',$0E,$A4,$DB,$E5,$C0,$C0,$D1
                DC.B '5',$FD,$86,$93,$A1,$8A,'=',$08
                DC.B $FA,$FD,$0B,'y',$8F,'b',$10,'+'
                DC.B ':O',$E8,$AB,$CE,'d|q'
                DC.B '%',$14,$91,'wx9',$EC,'W'
                DC.B $1D,$CB,'6',$9C,'<',$A1,$AC,$14
                DC.B '*',$CE,$E7,$15,$C6,$8B,$D8,$07
                DC.B $F9,$1E,$C6,$87,$8B,'@',$01,$D4
                DC.B $80,$BC,'}#',$92,$E7,$FA,$83
                DC.B $BB,$88,'1',$9C,$A0,'{',$FA,$C2
                DC.B 'N',$B1,$8A,'Z',$89,'uR',$93
                DC.B $A3,'fB',$F3,$CB,$A6,' ',$03
                DC.B $DE,'Od_',$18,$9D,$B4,$13
                DC.B '3',$C5,$F3,$EB,'{l',$EF,$F9
                DC.B 'J',$A7,'J=',$D9,$C8,'Fx'
                DC.B 'p',$E2,'9c',$BC,$80,$06,$CF
                DC.B 'uj',$88,'O™p',$D4,$9B
                DC.B $0F,$15,'I',$A2,$1E,$00,$06,$97
                DC.B $0B,$B8,$09,$F0,'4',$F3,$85,'J'
                DC.B '8s',$D2,$E4,$D5,$A7,$8F,$17
                DC.B 'E',$CF,'m',$C6,$B1,'ml�'
                DC.B 'gz"',$B9,$F6,$AF,$97,$BF
                DC.B $0B,$00,$FD,$D0,$93,$F8,$08,$D3
                DC.B $B9,'K/,V',$DF,$17,$BC
                DC.B $F6,'op!',$14,$19,'D',$08
                DC.B $15,$B8,'w',$98,$BB,$BA,$FE,$19
                DC.B $16,$F8,$E4,'Ž&',$1A,$C8,'`'
                DC.B 'Zl',$10,$FC,'4',$FB,$D6,$A2
                DC.B $EA,'s',$E1,$9E,$E2,$0C,$91,$9C
                DC.B $A7,$9E,'šz',$CF,'|2?'
                DC.B $1E,$0A,$DA,$0A,$C3,$A3,$F0,$8C
                DC.B 'C',$8A,$15,'re',$BA,$B2,'}'
                DC.B $C2,$97,$C4,'1',$A5,$01,$CD,$B8
                DC.B 'k™.4Z',$EE,$99,'3'
                DC.B 'U,',$D6,'Y,',$FC,$F2,'h'
                DC.B 'r',$BC,$15,$F9,$9F,$C5,$A9,'~'
                DC.B $85,'&',$88,$BB,'H',$10,$07,$00
                DC.B $AB,$E2,'Q{M',$8D,$CB,$F3
                DC.B $0C,$80,$1E,'dE',$81,$A5,$03
                DC.B $ED,$FA,';y',$9B,$88,'(',$87
                DC.B 'q',$AD,'o',$AC,'"',$16,')',$09
                DC.B '2',$DA,$92,'B',$8C,'78',$08
                DC.B 'Rk1',$06,'O',$A5,$AD,$EC
                DC.B $BE,']',$01,$EB,$A6,$CD,'.',$17
                DC.B '|0f',$C3,$EE,$1E,$96,'p'
                DC.B $D1,$89,$D6,'A',$9F,'W',$14,'M'
                DC.B 'x',$C2,$E4,$0D,'BW',$E3,'B'
                DC.B $C4,$B3,$0A,'h?',$B7,$27,$90
                DC.B $18,$EE,'W',$C3,'&2',$C2,$94
                DC.B '$',$D8,$03,'EY',$C3,$EC,$ED
                DC.B $18,$A3,':uFv',$E7,$B1
                DC.B $0B,$0D,$04,$BA,'O„E',$09
                DC.B 'G:',$86,$1A,$90,'G',$07,'%'
                DC.B $B6,$C3,'Klb',$03,$F0,']'
                DC.B '[XM',$B3,$AB,'5',$FE,$D5
                DC.B 'A{%s',$9A,$9F,'e',$0D
                DC.B '3',$E2,$B1,$F4,'rqC',$CC
                DC.B $A7,'F',$C6,$0B,$CE,$D6,'[i'
                DC.B $C8,$E3,$04,$95,$EF,' ',$C5,'z'
                DC.B $B9,$BB,'mQ',$A4,$EC,',',$A5
                DC.B $00,$08,'y',$A1,$C5,$8A,$DE,$17
                DC.B $92,$B9,$F2,$C8,'~',$C0,$E0,'S'
                DC.B $B5,$A5,$84,$84,'4`',$AF,$BB
                DC.B $04,$11,'y',$16,$96,$94,'(',$0C
                DC.B '!N',$DE,'X^',$E3,'P!'
                DC.B $D7,'&',$D9,$AD,$F2,'3',$FF,$90
                DC.B $A0,'E',$E5,$83,'<',$CC,'M',$92
                DC.B '&}M',$18,$EA,'Bu',$E6
                DC.B $14,$13,$E1,$B7,$C5,$E5,$AB,$7F
                DC.B 'x',$B8,'T',$8B,$9C,$9B,'D',$A2
                DC.B 'l',$90,'l',$CF,$BA,$99,$C9,'G'
                DC.B $F9,'ŽV',$CD,$0F,$B9,$C7,'X'
                DC.B $81,$DA,$E3,$1C,'&',$DA,$D2,$BD
                DC.B 'M',$F8,$F1,$82,'8',$07,$B3,'`'
                DC.B $97,$D0,'T',$9A,$C7,$A6,'WC'
                DC.B $C0,$B3,'9R',$D3,$F4,$12,'V'
                DC.B $F1,'g',$CE,'O',$C8,$0E,$BD,$FE
                DC.B '_%',$D7,$90,'My',$FE,$0C
                DC.B $8D,'d',$D9,$A2,$1C,'c',$D9,'/'
                DC.B 'a0',$1E,$BF,$FC,$B7,$8A,$98
                DC.B $D8,'@',$96,'R',$99,$04,'"',$FD
                DC.B $B1,$02,$B0,$AA,$19,$16,'S5'
                DC.B $8F,$0E,'-',$F6,$98,$D6,$C2,'E'
                DC.B '}',$E8,$04,'Qs',$9A,$F4,$D2
                DC.B $0B,$C2,'j',$C6,$A4,$0C,' D'
                DC.B 'wl',$0D,$A0,$F6,$B6,$84,'G'
                DC.B $DC,$B1,'j',$AB,$1A,$B0,$06,$9A
                DC.B $F2,$8A,';',$B1,'H8',$E3,'u'
                DC.B $1C,$C2,'G$',$B6,'b',$ED,$D6
                DC.B $04,$ED,$12,$B8,'Z3',$B8,'b'
                DC.B $D7,'^E',$B5,'I',$91,$89,'&'
                DC.B '\',$E8,'U3',$7F,'~',$FF,$DA
                DC.B $F8,'9',$0F,$AC,$B7,$0A,$A4,'Ž'
                DC.B 'Mvg',$F3,$9C,$C3,'X@'
                DC.B $89,$F8,'Q',$BF,$9B,'LZz'
                DC.B 'Žsq',$F7,$A1,'c',$E8,'z'
                DC.B $AE,$F4,$BF,'R?gdG'
                DC.B $0E,$E5,$B3,'s',$A0,'r',$93,$98
                DC.B '$',$A9,$C0,$C8,$B4,'Iv',$93
                DC.B $88,$80,'T',$E1,$E5,'C',$C1,'I'
                DC.B $A8,'1',$AE,'@3w',$8C,$94
                DC.B $BE,'a„I}',$AB,'^',$80
                DC.B $AD,$18,'cH',$07,$D7,'"$'
                DC.B $98,'1Q ',$F8,$A8,'"',$F9
                DC.B $94,$E4,$1A,'X',$A3,'$',$A9,'v'
                DC.B 'G',$92,']*mC',$95,$9F
                DC.B 'H',$D5,$EF,'X',$A4,$CD,'N',$13
                DC.B $8E,$B9,$8B,'Px',$FB,$A8,'U'
                DC.B $0C,'CH',$84,$DC,$E5,$BB,$9D
                DC.B $BB,$EB,$A1,'F',$E9,$BC,$E6,$BC
                DC.B '$N',$C6,$84,$DC,$B7,'/',$E7
                DC.B 'd',$08,$A7,'.q',$BC,$F2,'^'
                DC.B $7F,$FD,'~z',$1B,$DD,$D6,$D0
                DC.B '#l',$C9,'H',$B9,$9A,$0D,$E4
                DC.B '=',$C4,$85,$C3,$1F,$1B,'s',$1C
                DC.B $81,$93,$B7,'`',$B6,$A4,$01,$E4
                DC.B 'Hj',$EA,$98,'!',$C0,$B2,$0B
                DC.B $85,$0F,'HT',$7F,$16,'>e'
                DC.B '=Z',$BD,$ED,'g`|',$A1
                DC.B '!',$06,$8B,'n',$F6,'-',$81,$10
                DC.B $06,$EF,'P',$1B,$80,$DC,$BF,$EC
                DC.B $F1,$0A,'<Fj',$BE,$C8,'v'
                DC.B '4',$C6,'$',$18,$EB,'c',$1D,$BF
                DC.B $F4,$C9,$81,'`+T',$F6,$19
                DC.B 'ku',$8D,$19,$AD,$D7,$F9,'Y'
                DC.B 'm',$0C,'DP',$EE,'RaE'
                DC.B '/HUSe',$18,'|b'
                DC.B $F5,'y',$9A,$0D,$1A,'%',$DA,$DD
                DC.B '6',$F6,'xG,6',$87,'5'
                DC.B $BB,'}b/',$A0,$BD,'%',$85
                DC.B $00,'!',$1C,$D3,$98,$85,$1F,$94
                DC.B $27,'(',$C2,$F0,$8A,$0E,$EC,'z'
                DC.B $E0,$F0,'9',$E3,$88,$27,$0B,$87
                DC.B 'N',$F0,$BB,$10,'Oe',$CB,$DE
                DC.B $05,$8C,'A',$BC,$92,$B7,$86,'+'
                DC.B $D4,'xg|',$D8,'a',$BB,'T'
                DC.B $EC,'T',$09,$EC,'b',$0D,'.',$89
                DC.B 'F^',$E3,'8',$D3,$F8,$1E,$C0
                DC.B 'I',$01,$DB,$C5,':N',$17,'{'
                DC.B $0F,$D0,'r',$F8,$E9,'c',$E7,$F6
                DC.B $99,$1E,$E8,$1B,'~',$1C,$97,$F4
                DC.B 'a',$ED,'Q',$10,$97,'dnC'
                DC.B $06,$C2,'*',$96,'Pz',$91,$80
                DC.B $02,'>g',$17,';',$18,$18,$04
                DC.B $CF,$D8,$9C,$E6,$8D,'F',$C2,'F'
                DC.B $F6,$CE,'\_5',$E1,$C6,'F'
                DC.B '[',$AE,'{',$18,'J',$06,'Y',$CD
                DC.B $9D,'~|',$F3,'F',$E3,' ',$8B
                DC.B $B6,$D3,$F2,'7',$7F,$15,' ',$B8
                DC.B $CF,$DF,$84,$A7,$A1,$17,$08,'0'
                DC.B $D4,$14,'9VX=]',$11
                DC.B '8',$E9,'q™oUxO'
                DC.B $E6,$F1,$F3,$99,'Z',$F4,$E4,'|'
                DC.B 'V',$CB,$D8,$ED,'Z',$9A,$03,$89
                DC.B $A7,'`>AM',$C7,'$O'
                DC.B $BF,'9@',$87,$87,$14,$0F,$CD
                DC.B $F7,$F2,$19,$80,$94,$F1,$EF,'4'
                DC.B $BB,'<',$EA,$07,$83,'1',$B3,$C8
                DC.B '),',$0D,$96,$F8,$12,$D4,$C0
                DC.B $A6,$FF,$D6,$9D,$B5,$03,'}+'
                DC.B $D0,'[l',$C7,$C7,'g',$1A,$C7
                DC.B 'N',$B8,'5',$15,'fh',$AE,$BD
                DC.B $A6,$D9,$1E,$F2,'_*~',$1B
                DC.B 'k',$04,$BE,$CF,'$ax',$C7
                DC.B $9F,$1B,$81,$CF,$00,'U',$9F,$BE
                DC.B $08,'nJ/',$07,$1E,$B9,'r'
                DC.B $99,$E6,'D',$BC,'~k',$93,$0E
                DC.B '*',$86,$93,$D8,$88,$27,'Xx'
                DC.B $CE,$DC,'h',$0F,'.UK',$F9
                DC.B $03,$BE,$1A,$E4,$89,$AE,'NH'
                DC.B $BF,'X',$CE,$C2,$DE,'P',$FD,$ED
                DC.B $85,$1A,'?',$90,$F8,'#*e'
                DC.B $CD,$BA,'1',$C8,$E6,'-',$E9,$FB
ZUEND:

;-------------------------------------------------------------------------------
instr_cycle:    >PART

                pea     ic_super
                move.w  #$0026,-(SP)
                trap    #14
ic_super:
                move.l  #svbl,$00000070.w
                move    #$2300,SR
sloop:
                move    #$2300,SR
                clr.b   $FFFF8201.w
                clr.b   $FFFF8203.w

                bsr     wait_vbl_cc
                move    #$2700,SR

                moveq   #0,D0
                moveq   #0,D1

;movea.l screen1(PC),A0
                lea     mem_free,A0

                lea     (A0),A1
                lea     (A0),A2
                lea     (A0),A3
                lea     (A0),A4
                lea     (A0),A5
                lea     (A0),A6

;get synced
                move.l  D0,resd0+2
sts:            move.b  $FFFF8209.w,D0
                beq.s   sts
                not.w   D0
                lsl.w   D0,D0

;sync to $0 - $A0 Position!
w:              move.b  $FFFF8209.w,D0
                bne.s   w

resd0:          move.l  #$00000000,D0
                DS.W 40,$00004E71

uzi:
;Sync_Pos should be Zero now!!   (1 nop before --> Sync_pos=2 !)
                move.b  $FFFF8209.w,_1st+3 ;3
;--------------------------------------------------------------------
your_code_here:

                subq.l  #1,cnt
                bmi.s   es              ;...9
                nop

es:
;--------------------------------------------------------------------
                move.b  $FFFF8209.w,_2nd+3 ;3            move.b (a3),d4 [2]
;Maximum_Count_Cycles = (160 - 6)/2 = 77 Nops!

_2nd:           move.b  #0,D0
_1st:           sub.b   #0,D0
                sub.b   #12,D0
                lsr.b   #1,D0           ;/2 = nop's
                and.l   #$000000FF,D0

                DC.L $4AFC4E71

                move.w  #$0700,$FFFF8240.w
                move.w  #$0000,$FFFF8240.w
                jmp     sloop

svbl:           addq.l  #1,$00000466.w
                rte
wait_vbl_cc:
                clr.l   $00000466.w
wv_cc:          tst.l   $00000466.w
                beq.s   wv_cc
                rts

                ENDPART

regs:           DS.L 16

cnt:            DC.L 91         ; amount of instructions until trace-shell stop

my_trace:
L0004_trace:    add.w   (SP),D7         ; sr
                sub.b   (A0),D7         ; sync

o               SET 0

                movem.l A1-A2,regs      ; 8
o               SET o+8

; update trace routine(code modifying stuff)

                lea     $0007700C,A1    ;  3
                lea     crccode_start,A2 ; 3
o               SET o+3+3

                REPT 20
                move.l  (A1)+,(A2)+     ;5
                ENDR
o               SET o+20*5

                movem.l regs,A1-A2      ; 9
o               SET o+9

                jsr     nops+o*2        ; resync


;     movea.l $00000024.w,A1  ; 4
;     lea     L0008(PC),A2    ; 2

                lea     $00077000,A1    ; 3
                lea     $0007706C,A2    ; 3

crccode_start:                          ; $7700C
L0005_crc:      move.w  (A1)+,D0
                eor.w   D0,D7
                ror.l   #3,D7
                add.l   A0,D7
                add.l   A2,D7
                sub.l   A3,D7
                add.l   A4,D7
                move.l  A1,D1
                eor.l   D1,D7
                eor.l   D0,D7
                eor.l   D2,D7
                eor.l   D3,D7
                eor.l   D4,D7
                eor.l   D5,D7
                eor.l   D6,D7
                not.l   D7
                cmpa.l  A2,A1
                bne.s   L0005_crc

                add.l   $00000010.w,D6
                eor.l   D6,D7
                rol.l   #7,D6
                eor.l   D6,$00000010.w
                eor.l   D7,D6
                eor.l   D7,D5
                eor.l   D7,D4
                eor.l   D7,D3
                eor.l   D7,D2
                eor.l   D7,D1
                eor.l   D7,D0
                adda.l  D7,A3
                suba.l  A3,A4
                sub.b   (A0),D0
                andi.w  #$00FF,D0
L0006_:         dbra    D0,L0006_
crccode_end:
                eor.l   D7,(A5)         ; previous
                ror.l   #7,D7
                movea.l 2(SP),A6        ; curr_pc
                add.b   (A0),D7
                move    SR,D0
                eor.b   D0,D7
                eor.l   D7,(A6)         ; decrypt instruction
                movea.l A6,A5

;;;  rte
;;;  move.l  old10,$00000010.w
;;;  DC.L $4AFC4E71

; write decrypted instruction to <dec> buffer
                movem.l A1/A6,regs
                movea.l A6,A1
                adda.l  #dec-L000A,A1
                move.l  (A6)+,(A1)+
                move.l  (A6)+,(A1)+
                move.l  (A6)+,(A1)+
                move.l  (A6)+,(A1)+
                movem.l regs,A1/A6      ; ...2A

o               SET $002A
o               SET o+9

                jsr     nops+o*2        ; resync

                subq.l  #1,cnt          ;   execute until done
                bmi.s   _stop_trace_shell ; ...9
                rte

_stop_trace_shell:
                move.l  old10,$00000010.w
                movea.l 2(SP),A0        ; normal instructon stream from here
                DC.L $4AFC4E71
                DC.L $4AFC4E71
                DC.L $4AFC4E71

old10:          DC.L 0

nops:
                DS.W 313*128-9,$00004E71 ; full vbl, minus jsr+rts
                rts

                BSS

dec:            DS.L 65536/4    ; buffer for decrypted instructions

mem_free:       DS.B 4*32000
;-------------------------------------------------------------------------------
                END
