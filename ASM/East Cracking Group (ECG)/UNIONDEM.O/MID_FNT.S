DC.L   $00183C18,$183CFFE7,$017E1818,$F0F005A0,$7C067C7C,$C67C7C7C
DC.L   $7C7C0078,$07F01104,$00186600,$18003818,$0E700000,$00000002
DC.L   $3C183C7E,$0C7E3C7E,$3C3C0000,$0600603C,$3C187C3C,$787E7E3E
DC.L   $663C0666,$60C6663C,$7C3C7C3C,$7E6666C6,$66667E1E,$40781000
DC.L   $00006000,$06001C00,$60181860,$38000000,$00000000,$00000000
DC.L   $0000000E,$18700000,$00660C18,$66301800,$18663066,$18606618
DC.L   $0C003F18,$66301830,$66666618,$1C661C1E,$0C0C0C0C,$34340000
DC.L   $000000C6,$C6001BD8,$34340200,$007F3034,$34660C00,$7A7E7EF1
DC.L   $66F60000,$00000000,$00006000,$00600000,$00000000,$00000000
DC.L   $00000000,$000E0066,$001C0000,$FE000000,$3C00001C,$0C003E3C
DC.L   $0018300C,$00181800,$38380000,$38387800,$003C241C,$3899FFC3
DC.L   $03C33C1C,$C0C005A0,$C6060606,$C6C0C006,$C6C60060,$0FF80B28
DC.L   $0018666C,$3E666C18,$1C386618,$00000006,$6638660C,$1C606006
DC.L   $66661818,$0C003066,$663C6666,$6C606060,$6618066C,$60EE7666
DC.L   $66666666,$186666C6,$66660618,$60183800,$C0006000,$06003000
DC.L   $60000060,$18000000,$00000000,$18000000,$00000018,$18186018
DC.L   $3C001866,$00181800,$66001800,$66300000,$18007866,$00186618
DC.L   $00000018,$3A663630,$18181818,$58583C3C,$180000CC,$CC18366C
DC.L   $58583C02,$00D81858,$58001810,$CAC3C35B,$0066667C,$1E7E7C1C
DC.L   $1E7E6E3C,$3E7E6C1C,$3E367E66,$3E78D67C,$1C3EFE7E,$361B10F7
DC.L   $0036FE00,$661E0000,$183C3C36,$18107066,$7E181818,$0E181832
DC.L   $6C7C0000,$6C6C0CFE,$006624F6,$6FC3FE99,$06D33C16,$FEDF05A0
DC.L   $C6060606,$C6C0C006,$C6C63C78,$1FEC0DD8,$001866FE,$606C3818
DC.L   $18183C18,$0000000C,$6E180618,$3C7C600C,$66661818,$187E1806
DC.L   $6E666660,$66606060,$66180678,$60FE7E66,$66666660,$186666C6
DC.L   $3C660C18,$30186C00,$603C7C3C,$3E3C7C3E,$7C381866,$18EC7C3C
DC.L   $7C3E7C3E,$7E6666C6,$66667E18,$1818F218,$66000000,$3C00003C
DC.L   $003C0000,$00001818,$7E7ED800,$00000000,$663C663C,$303C667C
DC.L   $00000000,$00000666,$000000D8,$D8006C36,$0000663C,$7ED80000
DC.L   $3C003038,$CABDBD5F,$E666760C,$060C060C,$0C36660C,$06063E0C
DC.L   $36366666,$060CD66C,$0C066666,$363C3899,$766666FE,$30386C7E
DC.L   $3C666678,$387C6066,$007E0C30,$1B18004C,$3838000F,$6C183800
DC.L   $00C3E783,$C1E7FC3C,$8CD33C10,$D8DB0DB0,$00007C7C,$7C7C7C00
DC.L   $7C7C0660,$18040628,$0018006C,$3C187000,$1818FF7E,$007E0018
DC.L   $76180C0C,$6C067C18,$3C3E0000,$30000C0C,$6A667C60,$667C7C6E
DC.L   $7E180670,$60D67E66,$7C667C3C,$186666D6,$183C1818,$1818C600
DC.L   $30066660,$66663066,$6618186C,$18FE6666,$66666660,$186666C6
DC.L   $3C660C30,$180C9E34,$60663C3C,$063C3C60,$3C663C38,$38383C3C
DC.L   $601BDE3C,$3C3C6666,$66666660,$7C187C30,$3C383C66,$7C663E66
DC.L   $183E7C36,$3618D81B,$3C3C6E6E,$DBDE1818,$66000010,$CAB1A555
DC.L   $66663C0C,$0E0C660C,$0636660C,$0606660C,$3636763C,$360CD66C
DC.L   $0C066676,$1C666C99,$DC7C626C,$186C6C18,$667E66DC,$54D67E66
DC.L   $7E181818,$1B187E00,$00000018,$6C300C00,$00E7C383,$C1C3F999
DC.L   $D8DB7E10,$DEFF0DB0,$C606C006,$0606C606,$C6067E7E,$180407D0
DC.L   $0018006C,$0630DE00,$18183C18,$00000030,$66181806,$7E066630
DC.L   $66061818,$18001818,$6E7E6660,$66606066,$66180678,$60C66E66
DC.L   $60766C06,$186666FE,$3C183018,$0C180000,$003E6660,$667E3066
DC.L   $66181878,$18D66666,$6666603C,$186666D6,$18661818,$18180C34
DC.L   $66667E06,$3E060660,$7E7E7E18,$18186666,$7C7FF866,$66666666
DC.L   $66666660,$303C6630,$06186666,$66766666,$30300C6B,$6E186C36
DC.L   $06667676,$DFD83C3C,$66000010,$7AB1B951,$66666E0C,$1E0C660C
DC.L   $06366600,$0606660C,$3636060E,$360CD66C,$0C066606,$0C66C6EF
DC.L   $C866606C,$306C6C18,$666666CC,$54D66066,$0018300C,$18D80032
DC.L   $000018D8,$6C7C7800,$002466F6,$6F99F3C3,$70C31070,$181E1998
DC.L   $C606C006,$0606C606,$C6066618,$10042E10,$000000FE,$7C66CC00
DC.L   $1C386618,$30001860,$66183066,$0C666630,$660C1818,$0C7E3000
DC.L   $60666666,$6C606066,$6618666C,$60C66666,$606C6666,$18663CEE
DC.L   $66186018,$06180000,$00666660,$6660303E,$6618186C,$18C66666
DC.L   $66666006,$18663C7C,$3C3E3018,$18180062,$3C66607E,$667E7E3C
DC.L   $60606018,$18187E7E,$60D8D866,$66666666,$3E66663C,$30186630
DC.L   $7E186666,$666E3E3C,$60300CC3,$D618366C,$7E666666,$D8D86666
DC.L   $66000010,$0ABDAD00,$F6F6667E,$360C660C,$06367E00,$3E0E6E3C
DC.L   $1C7E7E7E,$340CFEEC,$0C067E06,$0C3C8266,$DC66606C,$666C6C18
DC.L   $3C6624EC,$38D67066,$7E000000,$18D8184C,$00001870,$00000000
DC.L   $00243C1C,$383CE7E7,$20C338F0,$181B799E,$7C067C7C,$067C7C06
DC.L   $7C7C3C1E,$1E3C39E0,$0018006C,$18467600,$0E700000,$30001840
DC.L   $3C7E7E3C,$0C3C3C30,$3C380030,$06006018,$3E667C3C,$787E603E
DC.L   $663C3C66,$7EC6663C,$6036663C,$183E18C6,$66187E1E,$027800FE
DC.L   $003E7C3C,$3E3C3006,$663C1866,$3CC6663C,$7C3E607C,$0E3E186C
DC.L   $66067E0E,$1870007E,$083E3C3E,$3E3E3E08,$3C3C3C3C,$3C3C6666
DC.L   $7E7EDF3C,$3C3C3E3E,$063C3E18,$7E187C60,$3E3C3C3E,$66660000
DC.L   $66300C86,$9F181BD8,$3E3C3C3C,$7E7F7E7E,$66000000,$0AC3C300
DC.L   $06060000,$00000000,$00000000,$00000000,$00000000,$30000000
DC.L   $0C060006,$0CD80000,$767C606C,$FE387F18,$183C6678,$307C3E66
DC.L   $007E7E7E,$18701800,$00000030,$00000000,$003C1818,$18000000
DC.L   $007E1060,$0000718E,$00000000,$00000000,$00000000,$17543800
DC.L   $00000000,$00000000,$00000000,$60000000,$00000000,$00000000
DC.L   $00000000,$00000000,$00000000,$00000000,$00000000,$00000000
DC.L   $00000000,$00000000,$00000000,$00000000,$00000000,$0000007C
DC.L   $00007000,$00000000,$60060000,$00000000,$007C0000,$18000000
DC.L   $38000000,$00000018,$00000000,$00000000,$00000000,$00000000
DC.L   $7C000018,$00006000,$00000000,$00003C3C,$3C00000F,$06180000
DC.L   $00004040,$00006666,$3C000000,$0A7E7E00,$1C1C0000,$00000000
DC.L   $00000000,$00000000,$00000000,$00000000,$00000000,$00700000
DC.L   $0060F848,$0000C010,$3C000000,$601000