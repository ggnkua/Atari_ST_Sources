move.l 4(a7),a0
move.l $c(a0),d0
move.l $14(a0),d0
move.l $1c(a0),d0
add.l #$100,d0
add.l #5000,d0
move.l a0,a7
add.l d0,a7
move.l d0,-(a7)
move.l a0,-(a7)
clr.w -(a7)
move.w #$4a,-(a7)
trap #1
lea 12(a7),a7

bsr entersup
bclr #5,$fffa09
move.w #$2300,sr
move.w #$00,$ff820a
bsr initb
bsr exitsup

jmp s
initb:
move.l #tim_b,$120
or.b #1,$fffa07
or.b #1,$fffa13
move.l $70,old4+2
move.l #new4,$70
move.b #0,$fffa1b
rts
new4:
move.b #0,$fffa1b
move.b #175,$fffa21 ;lijn 180
move.b #8,$fffa1b
move.w #$00,$ff8240
old4:
jmp $0

tim_b:
move.w #$20,$ff8240
move.l a4,-(sp)
move.l #$fffffa1b,a4
move.b #175,6(a4)
bclr #0,$fffa0f
move.l (sp)+,a4
rte
delay=0
links=$f8000
first=180*160

s:
move.l #stack,a7
move.l #s,-(a7)
bsr cls
bsr printfile
BEGIN:
clr.l d6;bit teller in char.def.
move.l #tekst,a6;pointer naar char. 
move.l #char,a5;pointer naar char.def.memory
move.l #alfabet,a4
clr.l d2;reken register

lus:
move.l #links+first,a0
move.w #20-1,d0
move.w #delay,d1
del:dbra d1,del
next:
move.w 8(a0),d1
lsl.w #1,d1
roxl #1,(a0)+
addq.l #6,a0
move.w 8(a0),d1
lsl.w #1,d1
roxl #1,(a0)+
addq.l #6,a0
move.w 8(a0),d1
lsl.w #1,d1
roxl #1,(a0)+
addq.l #6,a0
move.w 8(a0),d1
lsl.w #1,d1
roxl #1,(a0)+
addq.l #6,a0
move.w 8(a0),d1
lsl.w #1,d1
roxl #1,(a0)+
addq.l #6,a0
move.w 8(a0),d1
lsl.w #1,d1
roxl #1,(a0)+
addq.l #6,a0
move.w 8(a0),d1
lsl.w #1,d1
roxl #1,(a0)+
addq.l #6,a0
move.w 8(a0),d1
lsl.w #1,d1
roxl #1,(a0)+
addq.l #6,a0
move.w 8(a0),d1
lsl.w #1,d1
roxl #1,(a0)+
addq.l #6,a0
move.w 8(a0),d1
lsl.w #1,d1
roxl #1,(a0)+
addq.l #6,a0
move.w 8(a0),d1
lsl.w #1,d1
roxl #1,(a0)+
addq.l #6,a0
move.w 8(a0),d1
lsl.w #1,d1
roxl #1,(a0)+
addq.l #6,a0
move.w 8(a0),d1
lsl.w #1,d1
roxl #1,(a0)+
addq.l #6,a0
move.w 8(a0),d1
lsl.w #1,d1
roxl #1,(a0)+
addq.l #6,a0
move.w 8(a0),d1
lsl.w #1,d1
roxl #1,(a0)+
addq.l #6,a0
move.w 8(a0),d1
lsl.w #1,d1
roxl #1,(a0)+
addq.l #6,a0
move.w 8(a0),d1
lsl.w #1,d1
roxl #1,(a0)+
addq.l #6,a0
move.w 8(a0),d1
lsl.w #1,d1
roxl #1,(a0)+
addq.l #6,a0
move.w 8(a0),d1
lsl.w #1,d1
roxl #1,(a0)+
addq.l #6,a0

 move.l (a5),d1
 lsl.l #1,d1
 roxl #1,(a0)
 move.l d1,(a5)+
 add.l #8,a0
dbra d0,next

 move.l #char,a5
 tst.w d6
bne no_new
CLR.L D2
 move.b (a6)+,d2
 sub.w #64,d2;eerste letter is een '@' (64 dec) spatie
bmi last_char
 mulu #80,d2;point to eerste byte char.def.
 add.l d2,a4
 move.l (a4)+,(a5)+;move to shift memory
 move.l (a4)+,(a5)+
 move.l (a4)+,(a5)+
 move.l (a4)+,(a5)+
 move.l (a4)+,(a5)+
 move.l (a4)+,(a5)+
 move.l (a4)+,(a5)+
 move.l (a4)+,(a5)+
 move.l (a4)+,(a5)+
 move.l (a4)+,(a5)+
 move.l (a4)+,(a5)+
 move.l (a4)+,(a5)+
 move.l (a4)+,(a5)+
 move.l (a4)+,(a5)+
 move.l (a4)+,(a5)+
 move.l (a4)+,(a5)+
 move.l (a4)+,(a5)+
 move.l (a4)+,(a5)+
 move.l (a4)+,(a5)+
 move.l (a4)+,(a5)+
 move.l #alfabet,a4;restore pointer
 move.w #32,d6
 move.l #char,a5
no_new:
 subq.w #1,d6

bra lus
last_char:BRA BEGIN
end:
illegal


cls:
 move.l #$f8000,a0
 move.w #8000-1,d7
cl1:
 clr.l (a0)+
 dbra d7,cl1
rts

printfile:
move.l #begscreen,a0
bsr open
move.l #$f0000,a1
bsr read
bsr close
move.l #sound,a0
bsr open
move.l #$bef3c,a1
bsr read
bsr close
;move.l a7,save_st
jsr $bef3c
;move.l save_st,a7
bsr toscreen
rts
 

toscreen:
move.l #$f8000,a5
move.l #$f0000+34,a6
move.l #[32000/4]-1,d0
toscr1:move.l (a6)+,(a5)+
dbra d0,toscr1
rts
entersup:
clr.l -(sp)
move.w #$20,-(sp)
trap #1
addq.l #6,sp
move.l d0,savest
rts
exitsup:move.l savest,-(sp)
move.w #$20,-(sp)
trap #1
addq.l #6,sp
rts
;a0 heeft begin adres filename
open:move.w #$2,-(sp)
move.l a0,-(sp)
move.w #$3d,-(sp)
trap #1
addq.l #8,sp
move.w d0,handle
rts
;a1 heeft begin adres
read:move.l a1,-(sp)
move.l #$fffff,-(sp)
move.w handle,-(sp)
move.w #$3f,-(sp)
trap #1
add.l #12,sp
rts
close:move.w handle,-(sp)
move.w #$3e,-(sp)
trap #1
addq.l #4,sp
rts

begscreen:
dc.b 'PIC.PI1',0
even
sound:
dc.b 'SOUND.MUS',0


even
handle:blk.w 1
stspace:blk.l 1000
stack:blk.l 4,0
savest:blk.l 1,0
save_st:blk.l 1,0


alfabet:
blk.l 20,0;letter spatie ingeven als '@'
;LETTER 'A'
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000011111111000000000000
dc.l  %00000000001100000000110000000000
dc.l  %00000000001100000000110000000000
dc.l  %00000000001100000000110000000000
dc.l  %00000000001111111111110000000000
dc.l  %00000000001100000000110000000000
dc.l  %00000000001100000000110000000000
dc.l  %00000000001100000000110000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
;LETTER 'B'
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000001111111100000000000000
dc.l  %00000000001100001100000000000000
dc.l  %00000000001100001100000000000000
dc.l  %00000000001100001100000000000000
dc.l  %00000000001111111111100000000000
dc.l  %00000000001100000000110000000000
dc.l  %00000000001100000000110000000000
dc.l  %00000000001111111111100000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
;LETTER 'C'
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000001111111111000000000000
dc.l  %00000000001100000000000000000000
dc.l  %00000000001100000000000000000000
dc.l  %00000000001100000000000000000000
dc.l  %00000000001100000000000000000000
dc.l  %00000000001100000000000000000000
dc.l  %00000000001100000000000000000000
dc.l  %00000000001111111111000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
;LETTER 'D'
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000001111111111000000000000
dc.l  %00000000001100000000110000000000
dc.l  %00000000001100000000110000000000
dc.l  %00000000001100000000110000000000
dc.l  %00000000001100000000110000000000
dc.l  %00000000001100000000110000000000
dc.l  %00000000001100000000110000000000
dc.l  %00000000001100000000110000000000
dc.l  %00000000001111111111000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
;LETTER 'E'
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000001111111111110000000000
dc.l  %00000000001111111111110000000000
dc.l  %00000000001100000000000000000000
dc.l  %00000000001100000000000000000000
dc.l  %00000000001100000000000000000000
dc.l  %00000000001111111111000000000000
dc.l  %00000000001111111111000000000000
dc.l  %00000000001100000000000000000000
dc.l  %00000000001100000000000000000000
dc.l  %00000000001111111111110000000000
dc.l  %00000000001111111111110000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
;LETTER 'F'
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000001111111111110000000000
dc.l  %00000000001111111111110000000000
dc.l  %00000000001100000000000000000000
dc.l  %00000000001100000000000000000000
dc.l  %00000000001100000000000000000000
dc.l  %00000000001111111111000000000000
dc.l  %00000000001111111111000000000000
dc.l  %00000000001100000000000000000000
dc.l  %00000000001100000000000000000000
dc.l  %00000000001100000000000000000000
dc.l  %00000000001100000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
;LETTER 'G'
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000001111111111110000000000
dc.l  %00000000001111111111110000000000
dc.l  %00000000001100000000000000000000
dc.l  %00000000001100000000000000000000
dc.l  %00000000001100000000000000000000
dc.l  %00000000001100001111110000000000
dc.l  %00000000001100001111110000000000
dc.l  %00000000001100000000110000000000
dc.l  %00000000001100000000110000000000
dc.l  %00000000001111111111110000000000
dc.l  %00000000001111111111110000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
;LETTER 'H'
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000001100000000110000000000
dc.l  %00000000001100000000110000000000
dc.l  %00000000001100000000110000000000
dc.l  %00000000001100000000110000000000
dc.l  %00000000001111111111110000000000
dc.l  %00000000001100000000110000000000
dc.l  %00000000001100000000110000000000
dc.l  %00000000001100000000110000000000
dc.l  %00000000001100000000110000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
;LETTER 'I'
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000001111111111110000000000
dc.l  %00000000001111111111110000000000
dc.l  %00000000000000011000000000000000
dc.l  %00000000000000011000000000000000
dc.l  %00000000000000011000000000000000
dc.l  %00000000000000011000000000000000
dc.l  %00000000000000011000000000000000
dc.l  %00000000000000011000000000000000
dc.l  %00000000000000011000000000000000
dc.l  %00000000001111111111110000000000
dc.l  %00000000001111111111110000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
;LETTER 'J'
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000011000000000000000
dc.l  %00000000000000011000000000000000
dc.l  %00000000000000011000000000000000
dc.l  %00000000000000011000000000000000
dc.l  %00000000000000011000000000000000
dc.l  %00000000000000011000000000000000
dc.l  %00000000000000011000000000000000
dc.l  %00000000000000111000000000000000
dc.l  %00000001111111110000000000000000
dc.l  %00000001111111100000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
dc.l  %00000000000000000000000000000000
;LETTER 'K'
dc.l  %00000000001100000000000000000000
dc.l  %00000000001100000000000000000000
dc.l  %00000000001100000000000000000000
dc.l  %00000000001100000000000000000000
dc.l  %00000000001100000000000000000000
dc.l  %00000000001100001110000000000000
dc.l  %00000000001100011100000000000000
dc.l  %00000000001100111000000000000000
dc.l  %00000000001101110000000000000000
dc.l  %00000000001111000000000000000000
dc.l  %00000000001101110000000000000000
dc.l  %00000000001100111000000000000000
dc.l  %00000000001100011100000000000000
dc.l  %00000000001100000000000000000000
dc.l  %00000000001100000000000000000000
dc.l  %00000000001100000000000000000000
dc.l  %00000000001100000000000000000000
dc.l  %00000000001100000000000000000000
dc.l  %00000000001100000000000000000000
dc.l  %00000000001100000000000000000000
;LETTER 'L'
dc.l  %00000000011110000000000000000000
dc.l  %00000000011110000000000000000000
dc.l  %00000000011110000000000000000000
dc.l  %00000000011110000000000000000000
dc.l  %00000000011110000000000000000000
dc.l  %00000000011110000000000000000000
dc.l  %00000000011110000000000000000000
dc.l  %00000000011110000000000000000000
dc.l  %00000000011110000000000000000000
dc.l  %00000000011110000000000000000000
dc.l  %00000000011110000000000000000000
dc.l  %00000000011110000000000000000000
dc.l  %00000000011110000000000000000000
dc.l  %00000000011110000000000000000000
dc.l  %00000000011110000000000000000000
dc.l  %00000000011110000000000000000000
dc.l  %00000000011110000000000000000000
dc.l  %00000000011111111111111111111000
dc.l  %00000000011111111111111111111000
dc.l  %00000000011111111111111111111000
;LETTER 'M'
dc.l  %00001111000000000000000111100000
dc.l  %00001111100000000000001111100000
dc.l  %00001111110000000000011111100000
dc.l  %00001110111000000000111011100000
dc.l  %00001110011100000001110011100000
dc.l  %00001110001110000011100011100000
dc.l  %00001110000111000111000011100000
dc.l  %00001110000011111110000011100000
dc.l  %00001110000001111100000011100000
dc.l  %00001110000000111000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
;LETTER 'N'
dc.l  %00001111000000000000000011100000
dc.l  %00001111100000000000000011100000
dc.l  %00001111110000000000000011100000
dc.l  %00001110111000000000000011100000
dc.l  %00001110011100000000000011100000
dc.l  %00001110001110000000000011100000
dc.l  %00001110000111000000000011100000
dc.l  %00001110000011100000000011100000
dc.l  %00001110000001110000000011100000
dc.l  %00001110000000111000000011100000
dc.l  %00001110000000011100000011100000
dc.l  %00001110000000001110000011100000
dc.l  %00001110000000000111000011100000
dc.l  %00001110000000000011100011100000
dc.l  %00001110000000000001110011100000
dc.l  %00001110000000000000111011100000
dc.l  %00001110000000000000011111100000
dc.l  %00001110000000000000001111100000
dc.l  %00001110000000000000000111100000
dc.l  %00001110000000000000000011100000
;LETTER 'O'
dc.l  %00000000011111111111111000000000
dc.l  %00000000111111111111111100000000
dc.l  %00000001111111111111111110000000
dc.l  %00000011100000000000000111000000
dc.l  %00000111000000000000000011100000
dc.l  %00001110000000000000000001110000
dc.l  %00001110000000000000000001110000
dc.l  %00001110000000000000000001110000
dc.l  %00001110000000000000000001110000
dc.l  %00001110000000000000000001110000
dc.l  %00001110000000000000000001110000
dc.l  %00001110000000000000000001110000
dc.l  %00001110000000000000000001110000
dc.l  %00001110000000000000000001110000
dc.l  %00001110000000000000000001110000
dc.l  %00000111000000000000000011100000
dc.l  %00000011100000000000000111000000
dc.l  %00000001111111111111111110000000
dc.l  %00000000111111111111111100000000
dc.l  %00000000011111111111111000000000
;LETTER 'P'
dc.l  %00000111111111111111111100000000
dc.l  %00001111111111111111111111100000
dc.l  %00001111111111111111111111100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001111111111111111111111100000
dc.l  %00001111111111111111111111100000
dc.l  %00001110000000000000000000000000
dc.l  %00001110000000000000000000000000
dc.l  %00001110000000000000000000000000
dc.l  %00001110000000000000000000000000
dc.l  %00001110000000000000000000000000
dc.l  %00001110000000000000000000000000
dc.l  %00001110000000000000000000000000
dc.l  %00001110000000000000000000000000
dc.l  %00001110000000000000000000000000
;LETTER 'Q'
dc.l  %00000111111111111111111111000000
dc.l  %00001111111111111111111111100000
dc.l  %00001111111111111111111111100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000011100000011100000
dc.l  %00001110000000001110000011100000
dc.l  %00001110000000000111000011100000
dc.l  %00001110000000000011100011100000
dc.l  %00001110000000000001110011100000
dc.l  %00001110000000000000111111100000
dc.l  %00001111111111111111111111100000
dc.l  %00000111111111111111111111000000
;LETTER 'R'
dc.l  %00000111111111111111111100000000
dc.l  %00001111111111111111111111100000
dc.l  %00001111111111111111111111100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001111111111111111111111100000
dc.l  %00001111111111111111111111100000
dc.l  %00001111110000000000000000000000
dc.l  %00001110011100000000000000000000
dc.l  %00001110000111000000000000000000
dc.l  %00001110000001110000000000000000
dc.l  %00001110000000111000000000000000
dc.l  %00001110000000001110000000000000
dc.l  %00001110000000000011100000000000
dc.l  %00001110000000000000111000000000
dc.l  %00001110000000000000001110000000
;LETTER 'S'
dc.l  %00000111111111111111111100000000
dc.l  %00001111111111111111111111100000
dc.l  %00001111111111111111111111100000
dc.l  %00001110000000000000000000000000
dc.l  %00001110000000000000000000000000
dc.l  %00001110000000000000000000000000
dc.l  %00001110000000000000000000000000
dc.l  %00001110000000000000000000000000
dc.l  %00001110000000000000000000000000
dc.l  %00001111111111111111111111100000
dc.l  %00001111111111111111111111100000
dc.l  %00000000000000000000000011100000
dc.l  %00000000000000000000000011100000
dc.l  %00000000000000000000000011100000
dc.l  %00000000000000000000000011100000
dc.l  %00000000000000000000000011100000
dc.l  %00000000000000000000000011100000
dc.l  %00001111111111111111111111100000
dc.l  %00001111111111111111111111100000
dc.l  %00000111111111111111111111000000
;LETTER 'T'
dc.l  %00000111111111111111111111000000
dc.l  %00001111111111111111111111100000
dc.l  %00001111111111111111111111100000
dc.l  %00000000000000111000000000000000
dc.l  %00000000000000111000000000000000
dc.l  %00000000000000111000000000000000
dc.l  %00000000000000111000000000000000
dc.l  %00000000000000111000000000000000
dc.l  %00000000000000111000000000000000
dc.l  %00000000000000111000000000000000
dc.l  %00000000000000111000000000000000
dc.l  %00000000000000111000000000000000
dc.l  %00000000000000111000000000000000
dc.l  %00000000000000111000000000000000
dc.l  %00000000000000111000000000000000
dc.l  %00000000000000111000000000000000
dc.l  %00000000000000111000000000000000
dc.l  %00000000000000111000000000000000
dc.l  %00000000000000111000000000000000
dc.l  %00000000000000111000000000000000
;LETTER 'U'
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001111111111111111111111100000
dc.l  %00001111111111111111111111100000
dc.l  %00000111111111111111111111000000
;LETTER 'V'
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00000111000000000000000111000000
dc.l  %00000111000000000000000011100000
dc.l  %00000111000000000000000011100000
dc.l  %00000011100000000000000111000000
dc.l  %00000011100000000000000111000000
dc.l  %00000011100000000000000111000000
dc.l  %00000001110000000000001110000000
dc.l  %00000001110000000000001110000000
dc.l  %00000001110000000000001110000000
dc.l  %00000000111000000000011100000000
dc.l  %00000000111000000000011100000000
dc.l  %00000000011111111111111000000000
dc.l  %00000000001111111111110000000000
dc.l  %00000000000111111110000000000000
;LETTER 'W'
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000111000000011100000
dc.l  %00001110000001111100000011100000
dc.l  %00000111000001111100000111000000
dc.l  %00000111000011101110000111000000
dc.l  %00000111000111000111000111000000
dc.l  %00000111001110000011100111000000
dc.l  %00000111011100000001110111000000
dc.l  %00000111111000000000111111000000
;LETTER 'X'
dc.l  %00000111111111111111111100000000
dc.l  %00001111111111111111111111100000
dc.l  %00001111111111111111111111100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001111111111111111111111100000
dc.l  %00001111111111111111111111100000
dc.l  %00001110000000000000000000000000
dc.l  %00001110000000000000000000000000
dc.l  %00001110000000000000000000000000
dc.l  %00001110000000000000000000000000
dc.l  %00001110000000000000000000000000
dc.l  %00001110000000000000000000000000
dc.l  %00001110000000000000000000000000
dc.l  %00001110000000000000000000000000
dc.l  %00001110000000000000000000000000
;LETTER 'Y'
dc.l  %00000111111111111111111100000000
dc.l  %00001111111111111111111111100000
dc.l  %00001111111111111111111111100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001111111111111111111111100000
dc.l  %00001111111111111111111111100000
dc.l  %00001110000000000000000000000000
dc.l  %00001110000000000000000000000000
dc.l  %00001110000000000000000000000000
dc.l  %00001110000000000000000000000000
dc.l  %00001110000000000000000000000000
dc.l  %00001110000000000000000000000000
dc.l  %00001110000000000000000000000000
dc.l  %00001110000000000000000000000000
dc.l  %00001110000000000000000000000000
;LETTER 'Z'
dc.l  %00000111111111111111111100000000
dc.l  %00001111111111111111111111100000
dc.l  %00001111111111111111111111100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001110000000000000000011100000
dc.l  %00001111111111111111111111100000
dc.l  %00001111111111111111111111100000
dc.l  %00001110000000000000000000000000
dc.l  %00001110000000000000000000000000
dc.l  %00001110000000000000000000000000
dc.l  %00001110000000000000000000000000
dc.l  %00001110000000000000000000000000
dc.l  %00001110000000000000000000000000
dc.l  %00001110000000000000000000000000
dc.l  %00001110000000000000000000000000
dc.l  %00001110000000000000000000000000

char:blk.l 20,0;shift memory van char.def.

tekst:
dc.b 'WELCOME@TO@OUR@NEWEST@PICTURE@SHOW@'
dc.b 'PRESENTED@BY@THE@INTERNATIONAL@CRACKING@'
DC.B 'GROUP@@@@@@@@'
DC.B 'GREETINGS@TO@@@@@THE@MAGICIAN@'
DC.B '@@DMA@@@TEX@@@ACC@@@MEGA@MUGGER@@@'
DC.B '@ELOSOFT@AND@ALL@OTHER@ST@GROUPS@@@@@@@@@@@@@@@@@@@@@@@@@@'
dc.b 'I@NOW@START@WITH@WRITING@SOME@NONSENS@OVER@THE@SCREEN@'
DC.B '@ATARI@@ATARI@ATARI@ATARI@POWER@WITHOUT@THE@PRICE@'
DC.B '@@@@@@@@@@@BY@THE@WAY@@@@@THIS@IS@THE@FASTEST@SCROLLING@'
DC.B '@EVER@SEEN@ON@OUR@FABULOUS@@@@S@@@T@@@@@@@@@@@@@@@@@@@@@@@@@@@@@@',0

