;Palette of SHIP_NEW.IFF: Saved by NEOchrome V2.25 by Chaos, Inc.
		dc.w	$0000,$0020,$0030,$0050,$0070,$0210,$0320,$0530
		dc.w	$0750,$0012,$0123,$0234,$0345,$0456,$0567,$0777
