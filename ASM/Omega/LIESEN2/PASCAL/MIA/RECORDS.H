/* resource file indicies for RECORDS */

#define ENTER    0	/* form/dialog */
#define HEADLINE 1	/* BOXTEXT in tree ENTER */
#define ARTIST   2	/* FTEXT in tree ENTER */
#define NAME     3	/* FTEXT in tree ENTER */
#define COMPANY  4	/* FTEXT in tree ENTER */
#define B23      5	/* BUTTON in tree ENTER */
#define PRODUCER 6	/* FTEXT in tree ENTER */
#define B24      7	/* BUTTON in tree ENTER */
#define IDNR     8	/* FTEXT in tree ENTER */
#define B25      9	/* BUTTON in tree ENTER */
#define COUNTRY  10	/* FTEXT in tree ENTER */
#define B7       11	/* BUTTON in tree ENTER */
#define B15      12	/* BUTTON in tree ENTER */
#define B26      13	/* BUTTON in tree ENTER */
#define B8       14	/* BUTTON in tree ENTER */
#define B16      15	/* BUTTON in tree ENTER */
#define B27      16	/* BUTTON in tree ENTER */
#define YEAR     17	/* FTEXT in tree ENTER */
#define B1       18	/* BUTTON in tree ENTER */
#define B9       19	/* BUTTON in tree ENTER */
#define B17      20	/* BUTTON in tree ENTER */
#define B28      21	/* BUTTON in tree ENTER */
#define TRACKS   22	/* FTEXT in tree ENTER */
#define B2       23	/* BUTTON in tree ENTER */
#define B10      24	/* BUTTON in tree ENTER */
#define B18      25	/* BUTTON in tree ENTER */
#define B29      26	/* BUTTON in tree ENTER */
#define PLAYTIME 27	/* FTEXT in tree ENTER */
#define B3       28	/* BUTTON in tree ENTER */
#define B11      29	/* BUTTON in tree ENTER */
#define B19      30	/* BUTTON in tree ENTER */
#define B4       31	/* BUTTON in tree ENTER */
#define B12      32	/* BUTTON in tree ENTER */
#define B20      33	/* BUTTON in tree ENTER */
#define B30      34	/* BUTTON in tree ENTER */
#define RATING   35	/* FTEXT in tree ENTER */
#define B5       36	/* BUTTON in tree ENTER */
#define B13      37	/* BUTTON in tree ENTER */
#define B21      38	/* BUTTON in tree ENTER */
#define B31      39	/* BUTTON in tree ENTER */
#define B6       40	/* BUTTON in tree ENTER */
#define B14      41	/* BUTTON in tree ENTER */
#define B22      42	/* BUTTON in tree ENTER */
#define B32      43	/* BUTTON in tree ENTER */
#define LEND     44	/* BUTTON in tree ENTER */
#define OKEY     45	/* BUTTON in tree ENTER */
#define CANCEL   46	/* BUTTON in tree ENTER */
#define MEDVERK  47	/* FTEXT in tree ENTER */
#define NOTE     48	/* FTEXT in tree ENTER */

#define LENTAD   1	/* form/dialog */
#define LENDNAME 2	/* FTEXT in tree LENTAD */
#define LENDTIME 3	/* FTEXT in tree LENTAD */
#define LENDOK   4	/* BUTTON in tree LENTAD */
#define NOTLEND  5	/* BUTTON in tree LENTAD */

#define MENU     2	/* menu tree */
#define TDESK    3	/* TITLE in tree MENU */
#define TFILE    4	/* TITLE in tree MENU */
#define TEDIT    5	/* TITLE in tree MENU */
#define TGROUP   6	/* TITLE in tree MENU */
#define TSORT    7	/* TITLE in tree MENU */
#define TFIND    8	/* TITLE in tree MENU */
#define TSHOW    9	/* TITLE in tree MENU */
#define MABOUT   12	/* STRING in tree MENU */
#define MLOAD    21	/* STRING in tree MENU */
#define MSAVEAS  23	/* STRING in tree MENU */
#define MSAVE    24	/* STRING in tree MENU */
#define MQUIT    26	/* STRING in tree MENU */
#define MINSTER  28	/* STRING in tree MENU */
#define MDELETE  29	/* STRING in tree MENU */
#define MALL     31	/* STRING in tree MENU */
#define MFOUND   32	/* STRING in tree MENU */
#define MNOTFOUN 33	/* STRING in tree MENU */
#define MALWAYS  35	/* STRING in tree MENU */
#define MSORTREC 37	/* STRING in tree MENU */
#define MSORTART 38	/* STRING in tree MENU */
#define MSORTSPE 39	/* STRING in tree MENU */
#define MFINDCHA 41	/* STRING in tree MENU */
#define MFINDNEW 42	/* STRING in tree MENU */
#define MSHOW1   44	/* STRING in tree MENU */
#define MSHOW2   45	/* STRING in tree MENU */
#define MSHOW3   46	/* STRING in tree MENU */
#define MSHOW4   47	/* STRING in tree MENU */
#define MSHOW5   48	/* STRING in tree MENU */
#define MEDITS   50	/* STRING in tree MENU */

#define ABOUT    3	/* form/dialog */

#define SHOWEDIT 4	/* form/dialog */
#define ES1      2	/* BUTTON in tree SHOWEDIT */
#define ES2      3	/* BUTTON in tree SHOWEDIT */
#define ES3      4	/* BUTTON in tree SHOWEDIT */
#define ES4      5	/* BUTTON in tree SHOWEDIT */
#define ES5      6	/* BUTTON in tree SHOWEDIT */
#define SEOK     7	/* BUTTON in tree SHOWEDIT */
#define SECANCEL 8	/* BUTTON in tree SHOWEDIT */
#define SENAME   9	/* FTEXT in tree SHOWEDIT */
#define SELEND   10	/* BOXTEXT in tree SHOWEDIT */
#define C1       13	/* BUTTON in tree SHOWEDIT */
#define D1       28	/* BUTTON in tree SHOWEDIT */
#define E1       43	/* BUTTON in tree SHOWEDIT */
#define F1       58	/* BUTTON in tree SHOWEDIT */
#define G1       73	/* BUTTON in tree SHOWEDIT */
#define H1       88	/* BUTTON in tree SHOWEDIT */
#define I1       103	/* BUTTON in tree SHOWEDIT */
#define J1       118	/* BUTTON in tree SHOWEDIT */
#define SI1      133	/* FTEXT in tree SHOWEDIT */
#define SI2      134	/* FTEXT in tree SHOWEDIT */
#define SI3      135	/* FTEXT in tree SHOWEDIT */
#define SI4      136	/* FTEXT in tree SHOWEDIT */
#define SI5      137	/* FTEXT in tree SHOWEDIT */
#define SI6      138	/* FTEXT in tree SHOWEDIT */
#define SI7      139	/* FTEXT in tree SHOWEDIT */
#define SI8      140	/* FTEXT in tree SHOWEDIT */
#define SI9      141	/* FTEXT in tree SHOWEDIT */
#define SI10     142	/* FTEXT in tree SHOWEDIT */
#define SI11     143	/* FTEXT in tree SHOWEDIT */
#define SI12     144	/* FTEXT in tree SHOWEDIT */
#define SI13     145	/* FTEXT in tree SHOWEDIT */
#define SI14     146	/* FTEXT in tree SHOWEDIT */

#define EDITBOX  5	/* form/dialog */
#define Q1       2	/* FBOXTEXT in tree EDITBOX */
#define Q2       3	/* FBOXTEXT in tree EDITBOX */
#define Q3       4	/* FBOXTEXT in tree EDITBOX */
#define Q4       5	/* FBOXTEXT in tree EDITBOX */
#define Q5       6	/* FBOXTEXT in tree EDITBOX */
#define Q6       7	/* FBOXTEXT in tree EDITBOX */
#define Q7       8	/* FBOXTEXT in tree EDITBOX */
#define Q8       9	/* FBOXTEXT in tree EDITBOX */
#define Q9       10	/* FBOXTEXT in tree EDITBOX */
#define Q10      11	/* FBOXTEXT in tree EDITBOX */
#define Q11      12	/* FBOXTEXT in tree EDITBOX */
#define Q12      13	/* FBOXTEXT in tree EDITBOX */
#define Q13      14	/* FBOXTEXT in tree EDITBOX */
#define Q14      15	/* FBOXTEXT in tree EDITBOX */
#define Q15      16	/* FBOXTEXT in tree EDITBOX */
#define Q16      17	/* FBOXTEXT in tree EDITBOX */
#define Q17      18	/* FBOXTEXT in tree EDITBOX */
#define Q18      19	/* FBOXTEXT in tree EDITBOX */
#define Q19      20	/* FBOXTEXT in tree EDITBOX */
#define Q20      21	/* FBOXTEXT in tree EDITBOX */
#define Q21      22	/* FBOXTEXT in tree EDITBOX */
#define Q22      23	/* FBOXTEXT in tree EDITBOX */
#define Q23      24	/* FBOXTEXT in tree EDITBOX */
#define Q24      25	/* FBOXTEXT in tree EDITBOX */
#define Q25      26	/* FBOXTEXT in tree EDITBOX */
#define Q26      27	/* FBOXTEXT in tree EDITBOX */
#define Q27      28	/* FBOXTEXT in tree EDITBOX */
#define Q28      29	/* FBOXTEXT in tree EDITBOX */
#define Q29      30	/* FBOXTEXT in tree EDITBOX */
#define Q30      31	/* FBOXTEXT in tree EDITBOX */
#define Q31      32	/* FBOXTEXT in tree EDITBOX */
#define Q32      33	/* FBOXTEXT in tree EDITBOX */
#define BEOKEY   34	/* BUTTON in tree EDITBOX */
#define BECANCEL 35	/* BUTTON in tree EDITBOX */

#define BUSSY    6	/* form/dialog */
#define TIMEBOX  3	/* BOX in tree BUSSY */

