	DC.W $A000
	MOVE.L 4(A1),A1
	MOVE.L 76(A1),A1
	LEA $F8000,A0
	MOVEQ #9,D7
LOT:	MOVEQ #24,D0
LOOP:	MOVEQ #7,D6
	MOVE.L A1,A2
ACHT:	MOVE.B (A2),D1
	ADD.L #$100,A2
	MOVE.B D1,(A0)
	MOVE.B D1,2(A0)
	ADD.L #160,A0
	DBF D6,ACHT
	ADDQ.L #1,A1
	DBF D0,LOOP
	SUB.W #$7CFC,A0
	DBF D7,LOT
	RTS
