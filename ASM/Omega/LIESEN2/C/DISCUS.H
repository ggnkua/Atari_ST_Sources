/* resource file indicies for DISCUS */

#define PATHS    0	/* form/dialog */
#define POK      1	/* BUTTON in tree PATHS */
#define PCANCEL  2	/* BUTTON in tree PATHS */
#define PWORK    4	/* FTEXT in tree PATHS */
#define PTEMP    5	/* FTEXT in tree PATHS */
#define PTRASH   6	/* FTEXT in tree PATHS */
#define PDRIVA   8	/* BUTTON in tree PATHS */
#define PDRIVB   9	/* BUTTON in tree PATHS */

#define FASTBAR  1	/* form/dialog */
#define FBORD    0	/* BOX in tree FASTBAR */
#define FPATH    1	/* IMAGE in tree FASTBAR */
#define FEXEC    2	/* IMAGE in tree FASTBAR */
#define FDEL     3	/* IMAGE in tree FASTBAR */
#define FENCR    4	/* IMAGE in tree FASTBAR */
#define FNEW     5	/* IMAGE in tree FASTBAR */
#define FUP      6	/* IMAGE in tree FASTBAR */
#define FSWAP    7	/* IMAGE in tree FASTBAR */
#define FDOWN    8	/* IMAGE in tree FASTBAR */

#define EXEC     2	/* form/dialog */
#define E1       2	/* BUTTON in tree EXEC */
#define E2       3	/* BUTTON in tree EXEC */
#define EGO      5	/* BUTTON in tree EXEC */
#define ECANCEL  6	/* BUTTON in tree EXEC */

#define MENU     3	/* menu tree */
#define MD2      3	/* TITLE in tree MENU */
#define MF       4	/* TITLE in tree MENU */
#define MT       5	/* TITLE in tree MENU */
#define MS       6	/* TITLE in tree MENU */
#define MI       7	/* TITLE in tree MENU */
#define MDABOUT  10	/* STRING in tree MENU */
#define MFSTART  19	/* STRING in tree MENU */
#define MFLOAD   20	/* STRING in tree MENU */
#define MFSAVE   21	/* STRING in tree MENU */
#define MFQUIT   23	/* STRING in tree MENU */
#define MTUP     25	/* STRING in tree MENU */
#define MTDOWN   26	/* STRING in tree MENU */
#define MTSORT   28	/* STRING in tree MENU */
#define MTOVER   30	/* STRING in tree MENU */
#define MSENCR   32	/* STRING in tree MENU */
#define MSOATH   33	/* STRING in tree MENU */
#define MIEXEC   35	/* STRING in tree MENU */
#define MINEW    36	/* STRING in tree MENU */

#define ABOUT    4	/* form/dialog */
#define AWOW     3	/* BUTTON in tree ABOUT */

#define CLWORK   5	/* form/dialog */
#define CLIWORK  0	/* ICON in tree CLWORK */

#define CLTRASH  6	/* form/dialog */
#define CLITRASH 0	/* ICON in tree CLTRASH */

#define CLDISCUS 7	/* form/dialog */

