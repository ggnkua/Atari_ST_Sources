/* resource set indicies for TRANSGRF */

#define MENU1    0	/* menu tree */

#define FORM2    1	/* form/dialog */

#define FORM3    2	/* form/dialog */

#define FORM4    3	/* form/dialog */

