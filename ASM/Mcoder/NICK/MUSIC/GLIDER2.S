	NOLIST
;
; ROUTINE DE RETRANSCRIPTION DES SONS
;
; PROGRAMME QUI S'AUTOMODIFIE
;
	OPT	O+,OW-

BASE:
	BRA	INITMUS
	BRA	MUSIC50
	BRA	CLRSOUND
MUSIC	DS.W	1
;
	RSRESET
OFF2	RS.L	1	;PTR
OFF6	RS.L	1	;PTR
OFFA	RS.L	1	;PTR
OFF10	RS.L	1	;PTR
OFF14	RS.L	1	;PTR
;OFF20	RS.L	1	;PTR
;OFF24	RS.L	1	;PTR
OFFE	RS.W	1	;COMPTEUR

OFF0	RS.B	1
;
; BITS :
;	7=INDIQUE SI NOTE CALCULEE PRECEDEMMENT
;	6= INUTILISE !!!!
;	5=GLISS UP
;	4=FUNC1 (ON PEUT REMPLACER PAR LE BIT 0 OU 1 !!!)
;	3=GLISS DOWN
;	2=SLIDE ON
;	1=TOGGLE		;NE DOIT PAS BOUGER
;	0=COMPTEUR VIBRATO	;NE DOIT PAS BOUGER (AND #3,D7)
;
;OFF1	RS.B	1	;FLAG SI=0 PAS DE NOISE
OFF18	RS.B	1	;INCREMENT DE SLIDE
OFF19	RS.B	1	;COMPTEUR DE SLIDE
;OFF1A	RS.B	1	;LATCH COMPTEUR OFF1F
OFF1B	RS.B	1	;COMPTEUR DE LONGUEUR DE NOTE
OFF1C	RS.B	1	;LACTH COMPTEUR OFF1B
OFF1D	RS.B	1	;VALEUR DE NOTE LUE
OFF1E	RS.B	1	;VOLUME
;OFF1F	RS.B	1	;COMPTEUR D'ENVELOPPE
;OFF28	RS.B	1	;LATCH VOLUME
OFF29	RS.B	1	;VALEUR MAX DU VIBRATO
OFF2A	RS.B	1	;INCREMENT DU VIBRATO
OFF2B	RS.B	1	;VALEUR DU VIBRATO
OFF2C	RS.B	1	;TYPE DU VIBRATO (PAS DE VIBRATO,1,2)
;OFF2D	RS.B	1	;FLAG INDICATEUR DE BATTERIE
;OFF2E	RS.B	1	;VALEUR DE TRANSPOSITION POUR UNE VOIX
OFF14H	RS.B	1
OFF15H	RS.B	1
OFF16H	RS.B	1
OFF17H	RS.B	1
OFF18H	RS.B	1
OFF19H	RS.B	1

NBOFF	EQU	(__RS+1)&-2	;NB BYTES !!!
;

INITMUS
	MOVEM.L	D0-D7/A0-A6,-(SP)
	LEA	BASE(PC),A6

	MOVE	D0,MUSIC-BASE(A6)	;NUMERO DE MUSIQUE

	CLR.B	CUTMUS-BASE(A6)
	CLR.B	CUTSND-BASE(A6)
	CLR.B	VOLUME-BASE(A6)
;	CLR.B	TRANSPOSE-BASE(A6)
	LEA	STADS(PC),A0
	MULU	#2*3,D0
	ADD	D0,A0
;	MOVE	(A0)+,D0
;	MOVE.B	D0,NO_T-BASE(A6)
	LEA	CHAN_A-BASE(A6),A1
	MOVEQ	#2,D7
	LEA	FIRST(PC),A3

INITIAL:MOVE.B	#1,OFF1B(A1)
	CLR.B	OFF0(A1)
	CLR.B	OFF2C(A1)
;	CLR.B	OFF2D(A1)
;	CLR.B	OFF2E(A1)
	MOVE.L	A3,OFF10(A1)
	MOVE.L	A3,OFF14(A1)
	MOVE	(A0)+,A2
	ADD.L	A6,A2
	MOVE.L	A2,OFF6(A1)
	MOVE	(A2)+,D0
	MOVE.L	A2,OFFA(A1)
	LEA	(A6,D0.W),A2
	MOVE.L	A2,OFF2(A1)
	LEA	NBOFF(A1),A1
	DBF	D7,INITIAL

;	CLR.B	LF66-BASE(A6)

	MOVE.B	#$F8,LATCH7-BASE(A6)
	MOVE.B	#1,L760-BASE(A6)
	CLR.B	REG8-BASE(A6)
	CLR.B	REG9-BASE(A6)
	CLR.B	REG10-BASE(A6)
	ST	REG7-BASE(A6)
	MOVE.L	#$0707FFFF,$FFFF8800.W
	MOVE.L	#$08080000,$FFFF8800.W
	MOVE.L	#$09090000,$FFFF8800.W
	MOVE.L	#$0A0A0000,$FFFF8800.W
	ST	CUTMUS-BASE(A6)
	MOVEM.L	(SP)+,D0-D7/A0-A6
	RTS
CLRSOUND:
	MOVEM.L	D0-D7/A0-A6,-(SP)
	LEA	BASE(PC),A6
	CLR.B	CUTMUS-BASE(A6)
;	CLR.B	LF66-BASE(A6)
	CLR.B	REG8-BASE(A6)
	CLR.B	REG9-BASE(A6)
	CLR.B	REG10-BASE(A6)
	ST	REG7-BASE(A6)
	MOVE.L	#$0707FFFF,$FFFF8800.W
	MOVE.L	#$08080000,$FFFF8800.W
	MOVE.L	#$09090000,$FFFF8800.W
	MOVE.L	#$0A0A0000,$FFFF8800.W
	MOVEM.L	(SP)+,D0-D7/A0-A6
	RTS
MUSIC50:
	MOVEM.L	D0-D7/A0-A6,-(SP)
	LEA	BASE(PC),A6
	BTST	#1,$FFFF820A.W
	BNE.S	PA60HZ
	ADD.B	#256*5/6,FREQ50-BASE(A6)
	BCC	RET
PA60HZ

CUTMUS	EQU	*+1
	MOVEQ	#0,D0
	BEQ.S	RET

	SUBQ.B	#1,L760-BASE(A6)
	BNE.S	WALBOL

;LF66	EQU	*+1
;	MOVEQ	#0,D0
;	BEQ.S	PAECHO
;	CMP.B	#15,VOLUME-BASE(A6)
;	BEQ	TURNOFF
;	SUBQ.B	#1,LF67-BASE(A6)
;	BNE.S	PAECHO
;	ADDQ.B	#1,VOLUME-BASE(A6)
;	CMP.B	#15,VOLUME-BASE(A6)
;	BEQ	TURNOFF
;	MOVE.B	LF66-BASE(A6),LF67-BASE(A6)
;PAECHO
	LEA	CHAN_A-BASE(A6),A0
	MOVEQ	#$09,D3
	BSR	MZ_CH
	LEA	CHAN_B-BASE(A6),A0
	MOVEQ	#$12,D3
	BSR	MZ_CH
	LEA	CHAN_C-BASE(A6),A0
	MOVEQ	#$24,D3
	BSR	MZ_CH
NO_T	EQU	*+3
	MOVE.B	#1,L760-BASE(A6)
WALBOL:
NZ_F	EQU	*+3		;=$1F AU DEBUT
	MOVE.B	#$1F,REG6-BASE(A6)
	LEA	CHAN_A-BASE(A6),A0
	MOVEQ	#$09,D3		;MASQUE
	BSR	MZ_50
	MOVE	D0,REG1-BASE(A6)
	MOVE.B	D0,REG0-BASE(A6)
	MOVE.B	D1,REG8-BASE(A6)
	LEA	CHAN_B-BASE(A6),A0
	MOVEQ	#$12,D3		;MASQUE
	BSR	MZ_50
	MOVE	D0,REG3-BASE(A6)
	MOVE.B	D0,REG2-BASE(A6)
	MOVE.B	D1,REG9-BASE(A6)
	LEA	CHAN_C-BASE(A6),A0
	MOVEQ	#$24,D3		;MASQUE
	BSR	MZ_50
	MOVE	D0,REG5-BASE(A6)
	MOVE.B	D0,REG4-BASE(A6)
	MOVE.B	D1,REG10-BASE(A6)

	MOVEM.L	REGS-BASE(A6),D0-D7/A0-A2
	MOVEM.L	D0-D7/A0-A2,$FFFF8800.W
RET:	MOVEM.L	(SP)+,D0-D7/A0-A6
	MOVE.B	REG6-BASE(A6),D0
	RTS

	IFNE	0
	MOVEQ	#$38,D0
	AND.B	REG7-BASE(A6),D0
	CMP.B	#$38,D0
	BEQ.S	AUCUN
	MOVE.L	#$0E0E0101,$FFFF8800.W	;SELECTE LES 2 DIVERS
	RTS
AUCUN:	MOVE.L	#$0E0E0707,$FFFF8800.W	;DESELECTE LES 2 DRIVES
	RTS
	ENDC

GLISS_IT:
	BTST	#3,OFF0(A0)
	BEQ.S	L24FEA
	BTST	#5,OFF0(A0)
	BEQ.S	GL_DOWN
	ADDQ.B	#1,OFF1D(A0)
	RTS
GL_DOWN:
	SUBQ.B	#1,OFF1D(A0)
L24FEA:	RTS

MZ_CH:	SUBQ.B	#1,OFF1B(A0)
	BNE.S	GLISS_IT
	MOVEQ	#0,D7
	MOVE.L	OFF2(A0),A1
READ:	MOVEQ	#0,D0
	MOVE.B	(A1)+,D0
	BMI.S	EXTEND
	MOVE.B	D0,OFF1D(A0)
;	TST.B	OFF1(A0)
;	BEQ.S	L24F72
;	MOVE.B	D0,NZ_F-BASE(A6)
;L24F72:
;	BCLR	#4,D7
;	BNE.S	PARPCH
;	MOVE.L	OFF24(A0),A2
;	MOVE.B	(A2)+,D0
;	MOVE.L	A2,OFF20(A0)
;	AND	#$7F,D0
;	MOVE.B	D0,OFF28(A0)
;	MOVE.B	OFF1A(A0),OFF1F(A0)
;PARPCH:
;	TAS	D7
	MOVE.B	OFF19H(A0),OFF1E(A0)
	OR	#$C0,D7
	MOVE.B	OFF14H(A0),OFF16H(A0)
	MOVE.B	OFF17H(A0),OFF18H(A0)

VALUED:	MOVE.B	OFF1C(A0),OFF1B(A0)
	MOVE.L	A1,OFF2(A0)
	MOVE.B	D7,OFF0(A0)
;	TST.B	OFF2D(A0)
;	SNE	OFF2D(A0)
	RTS

EXTEND:
	CMP.B	#$B8,D0
	BLO.S	TOKENS
	ADD.B	#$20,D0
	BCS.S	LENGTH
	ADD.B	#$10,D0
	BCS.S	ENVS
	ADD.B	#$10,D0
	BCC.S	CHFREQ2
;	MOVEQ	#$20,D1
;	ADD.B	D1,D0
;	BCS.S	TOKENS
;	ADD.B	D1,D0
;	BCS.S	ENVS
;	ADD.B	D1,D0
;	BCS.S	LENGTH
;	ADD.B	D1,D0
	ADD	D0,D0
;	ADD	D0,D0			;*4 POUR LONG
	LEA	CH_TAB(PC),A2
	CMP	#3,MUSIC-BASE(A6)
	BLO.S	GLIDER1
	LEA	CH_TAB2(PC),A2
GLIDER1
	MOVE	(A2,D0.W),D0
	LEA	(A6,D0.W),A2
	MOVE.L	A2,OFF14(A0)
	MOVE.L	A2,OFF10(A0)
	BSET	#4,D7
	BRA.S	READ
LENGTH:	ADDQ.B	#1,D0
	MOVE.B	D0,OFF1C(A0)		;LONGUEUR DE NOTE
	BRA.S	READ
ENVS:
	MOVE.B	D0,OFF19H(A0)
	MOVE.B	(A1)+,OFF14H(A0)
	MOVE.B	(A1)+,OFF15H(A0)
	MOVE.B	(A1)+,OFF17H(A0)
;	ADD	D0,D0
;	ADD	D0,D0			;*4 POUR LONG
;	MOVE.L	EV_TAB-BASE(A6),A2
;	MOVE.L	(A2,D0.W),A2
;	MOVE.B	(A2)+,OFF1A(A0)
;	MOVE.L	A2,OFF24(A0)
	BRA	READ
CHFREQ2:
	ADD.B	#9,D0
;	MOVE.L	#256,D1
;	DIVU	D0,D1
;	MOVE.B	D1,NO_T-BASE(A6)
	MOVE.B	D0,NO_T-BASE(A6)
	BRA	READ
TOKENS:	ADD.B	D0,D0
	ADD	D0,D0
	JMP	L24E0E(PC,D0.W)
L24E0E:	BRA.W	PAUSE		;$80
	BRA.W	VIBE_0		;$81
	BRA.W	VIBE_1		;$82
	BRA.W	VIBE_2		;$83
	BRA.W	SLIDE		;$84
	BRA.W	GL_DN		;$85
	BRA.W	GL_UP		;$86
	BRA.W	ENDING		;$87
	BRA.W	VIBE_SET	;$88
	BRA.W	NZ_FREQ		;$89
	BRA.W	SQUARE		;$8A
	BRA.W	NOISE		;$8B
	BRA.W	BOTH		;$8C
	BRA.W	TOGGLE		;$8D
	BRA.W	CUTT		;$8E

PAUSE:	CLR.B	OFF1E(A0)
	BRA	VALUED
VIBE_0:	CLR.B	OFF2C(A0)		;PAS DE VIBRATO
	BRA	READ
VIBE_1:	MOVE.B	#$40,OFF2C(A0)		;VIBRATO 1
	BRA	READ
VIBE_2:	MOVE.B	#$C0,OFF2C(A0)		;VIBRATO 2
	BRA	READ
SLIDE:	CLR	OFFE(A0)
;	ADDQ	#4,D7
	BSET	#2,D7
	MOVE.B	(A1)+,OFF18(A0)		;INCREMENT
	MOVE.B	(A1)+,OFF19(A0)		;COMPTEUR
	BRA	READ
GL_UP:
	BSET	#5,D7
GL_DN:
	BSET	#3,D7
;	ADDQ	#8,D7
	BRA	READ
ENDING:
	MOVE.L	OFFA(A0),A2
	MOVE	(A2)+,D0
	BNE.S	SET_MEM
	MOVE.L	OFF6(A0),A2
	MOVE	(A2)+,D0
SET_MEM:
	MOVE.L	A2,OFFA(A0)
	LEA	0(A6,D0.W),A1
	BRA	READ
VIBE_SET:
	MOVE.B	(A1)+,OFF2A(A0)		;INCREMENT DU VIBRATO
	MOVE.B	(A1)+,D0
	MOVE.B	D0,OFF29(A0)		;VALEUR MAX DU VIBRATO
	MOVE.B	D0,OFF2B(A0)		;VALEUR DU VIBRATO
;	MOVE.B	#$40,OFF2C(A0)
	BRA	READ
NZ_FREQ:
	MOVE.B	(A1)+,NZ_F-BASE(A6)
;	MOVE.B	(A1)+,TRANSPOSE-BASE(A6)
	BRA	READ
SQUARE:	MOVEQ	#$38,D0
;	CLR.B	OFF1(A0)
	BRA.S	SETLAT
NOISE:	MOVEQ	#7,D0
;	ST	OFF1(A0)
SETLAT	MOVE.B	LATCH7-BASE(A6),D2
	AND.B	D3,D0
	EOR.B	D2,D0
	AND.B	D3,D0
	EOR.B	D2,D0
	MOVE.B	D0,LATCH7-BASE(A6)
	BRA	READ
BOTH:	MOVE.B	D3,D0
	NOT.B	D0
	AND.B	D0,LATCH7-BASE(A6)
;	ST	OFF1(A0)
	BRA	READ
TOGGLE:
;	ADDQ	#2,D7
	BSET	#1,D7
	BRA	READ
CUTT:
	ADDQ	#4,SP
TURNOFF:
	CLR.B	CUTMUS-BASE(A6)
;	CLR.B	LF66-BASE(A6)
	CLR.B	REG8-BASE(A6)
	CLR.B	REG9-BASE(A6)
	CLR.B	REG10-BASE(A6)
	ST	REG7-BASE(A6)
	MOVE.L	#$0707FFFF,$FFFF8800.W
	MOVE.L	#$08080000,$FFFF8800.W
	MOVE.L	#$09090000,$FFFF8800.W
	MOVE.L	#$0A0A0000,$FFFF8800.W
	MOVEM.L	(SP)+,D0-D7/A0-A6
	RTS
;LBD0:	ST	OFF2D(A0)		;BATTERIE ON
;	BRA	READ
;LBD6:	CLR.B	OFF2D(A0)		;BATTERIE OFF
;	BRA	READ
;LB94:
;	MOVE.B	(A1)+,OFF2E(A0)		;VALEUR DE TRANSPOSITION
;	BRA	READ
;GOTO:	CLR.B	OFF6(A0)
;	MOVE.B	(A1)+,OFF6+1(A0)
;	MOVE.B	(A1)+,OFF6+2(A0)
;	MOVE.B	(A1)+,OFF6+3(A0)
;	MOVE.L	OFF6(A0),OFFA(A0)
;	BRA	READ
;CHFREQ:	MOVE.B	(A1)+,NO_T-BASE(A6)
;	BRA	READ
;ECHO:	MOVE.B	(A1)+,D0
;	MOVE.B	D0,LF66-BASE(A6)
;	MOVE.B	D0,LF67-BASE(A6)
;	BRA	READ
;FUNC1:	BSET	#4,D7
;	BRA	READ

MZ_50:
	BCHG	#0,OFF0(A0)
	MOVE.B	OFF0(A0),D7
	BPL.S	FORM

	MOVE.B	OFF16H(A0),D0
	SUB.B	#$10,D0
	BHS.S	L1A98
	BTST	#6,D7
	BEQ.S	L1A9D
	ADD.B	OFF1E(A0),D0
	BCC.S	L1A7D
	MOVEQ	#0,D0
L1A7D:	ADD.B	#$10,D0
	MOVE.B	D0,OFF1E(A0)
	MOVE.B	OFF18H(A0),D0
	SUB.B	#$10,D0
	BHS.S	L1A93
	BCLR	#6,OFF0(A0)
	MOVE.B	OFF15H(A0),OFF16H(A0)
	BRA.S	L1AB0
L1A93	MOVE.B	D0,OFF18H(A0)
	BRA.S	L1AB0
L1A98	MOVE.B	D0,OFF16H(A0)
	BRA.S	L1AB0
L1A9D	NOT.B	D0
	SUB.B	#$F,D0
	ADD.B	OFF1E(A0),D0
	BCS.S	L1AA6
	MOVEQ	#0,D0
L1AA6	MOVE.B	D0,OFF1E(A0)
	SUBQ.B	#1,OFF18H(A0)
	BNE.S	L1AB0
	BCLR	#7,OFF0(A0)
;	SUBQ.B	#1,OFF1F(A0)
;	BHS.S	EV_DELAY
;	MOVE.B	OFF1A(A0),OFF1F(A0)
;	MOVE.L	OFF20(A0),A2
;	MOVE.B	(A2)+,D0
;	BMI.S	EV_DELAY2
;	MOVE.L	A2,OFF20(A0)
;EV_DELAY2:
;	AND	#$7F,D0
;	MOVE.B	D0,OFF28(A0)
;EV_DELAY:
;	MOVE.B	OFF28(A0),OFF1E(A0)
L1AB0:
FORM:
	MOVEQ	#0,D5
	MOVE.B	OFF1D(A0),D5
	BTST	#4,D7
	BEQ.S	L1AD2

	MOVE.L	OFF14(A0),A1
	MOVE.B	(A1)+,D0
	BPL.S	CH_CALC
	AND	#$7F,D0
	MOVE.L	OFF10(A0),A1
CH_CALC:MOVE.L	A1,OFF14(A0)

	ADD.B	D0,D5

;TRANSPOSE	EQU	*+3	;TRANSPOSITION POUR TOUTES LES VOIX
;	ADD.B	#0,D5		;TRANSPOSE=0 AU DEBUT
L1AD2
;	ADD.B	OFF1D(A0),D5
;	ADD.B	OFF2E(A0),D5
	LEA	NOTE_TAB-BASE(A6),A1
	ADD.B	D5,D5
	MOVE	(A1,D5.W),D0

	MOVE.B	OFF2C(A0),D6
	BTST	#6,D6
	BEQ.S	TWIGGLE
	MOVEQ	#0,D2
	MOVE.B	OFF29(A0),D2
	MOVEQ	#0,D1
	MOVE.B	OFF2B(A0),D1
	TST.B	D6
	BPL.S	VB_NOW
	BTST	#0,D7
	BEQ.S	VB_SAME
VB_NOW:
	BCHG	#5,D6
	BNE.S	VB_UP
	SUB.B	OFF2A(A0),D1
	BHS.S	VB_REACH
	MOVEQ	#0,D1
	MOVE.B	D6,OFF2C(A0)
	BRA.S	VB_REACH
VB_UP:	ADD.B	OFF2A(A0),D1
	ADD.B	D2,D2
	CMP.B	D2,D1
	BLO.S	VB_R1
	MOVE.B	D2,D1
	MOVE.B	D6,OFF2C(A0)
VB_R1:
	LSR.B	#1,D2
VB_REACH:
	MOVE.B	D1,OFF2B(A0)
VB_SAME:
;	AND	#$FF,D2
	SUB	D2,D1
;	SUB.B	D2,D1
;	BHS.S	WARBLE
;	SUB	#$100,D1
;WARBLE:
	ADD.B	#$A0,D5
	BCS.S	HI_VB
	MOVEQ	#$18,D2
	ADD	D1,D1
	ADD.B	D2,D5
	BCS.S	HI_VB
	ADD	D1,D1
	ADD.B	D2,D5
	BCS.S	HI_VB
	ADD	D1,D1
	ADD.B	D2,D5
	BCS.S	HI_VB
	ADD	D1,D1
HI_VB:	ADD	D1,D0
TWIGGLE:
	BTST	#2,D7
	BEQ.S	TG_FORM
	MOVE.B	OFF19(A0),D2
	SUBQ.B	#1,D2
	BNE.S	SL_UP
	MOVE.B	OFF18(A0),D6
	EXT	D6
	ADD	OFFE(A0),D6
	MOVE	D6,OFFE(A0)
	ADD	D6,D0
	BRA.S	TG_FORM
SL_UP:	MOVE.B	D2,OFF19(A0)
TG_FORM:
LATCH7	EQU	*+1
	MOVEQ	#0,D2
	NOT.B	D7
	AND.B	#3,D7
	BNE.S	SET_7
	MOVE.B	NZ_F-BASE(A6),D2
	EOR.B	#8,D2
	MOVE.B	D2,REG6-BASE(A6)
	MOVEQ	#7,D2
SET_7:	MOVE.B	REG7-BASE(A6),D1
	EOR.B	D1,D2
	AND.B	D3,D2
	EOR.B	D1,D2
;	BCLR	#7,OFF2D(A0)
;	BEQ.S	PABATTE
;	MOVEQ	#$38,D1
;	AND.B	D3,D1
;	NOT.B	D1
;	AND.B	D1,D2
;	MOVE.B	#1,REG6-BASE(A6)
;PABATTE:
	MOVE.B	D2,REG7-BASE(A6)
	MOVE.B	OFF1E(A0),D1
VOLUME	EQU	*+3
	SUB.B	#0,D1		;VOLUME=15 AU DEBUT (=0)
	BHS.S	L24BA4
	MOVEQ	#0,D1
L24BA4:
	RTS
;
; LES VARIABLES
;
	EVEN
REGS:	DC.W	0
REG0:	DC.B	0	;BYTE REG 0
	DC.B	0
	DC.W	$101
REG1:	DC.B	0	;BYTE REG 1
	DC.B	0
	DC.W	$202
REG2:	DC.B	0	;BYTE REG 2
	DC.B	0
	DC.W	$303
REG3:	DC.B	0	;BYTE REG 3
	DC.B	0
	DC.W	$404
REG4:	DC.B	0	;BYTE REG 4
	DC.B	0
	DC.W	$505
REG5:	DC.B	0	;BYTE REG 5
	DC.B	0
	DC.W	$606
REG6:	DC.B	0	;BYTE REG 6
	DC.B	0
	DC.W	$707
REG7:	DC.B	0	;BYTE REG 7
	DC.B	0
	DC.W	$808
REG8:	DC.B	0	;BYTE REG 8
	DC.B	0
	DC.W	$909
REG9:	DC.B	0	;BYTE REG 9
	DC.B	0
	DC.W	$A0A
REG10:	DC.B	0	;BYTE REG 10
	DC.B	0
;
; LES TABLEAUX
;
	EVEN
NOTE_TAB:
	DC.W	$EEE,$E17,$D4D,$C8E,$BD9,$B2F,$A8E,$9F7
	DC.W	$967,$8E0,$861,$7E8,$777,$70B,$6A6,$647
	DC.W	$5EC,$597,$547,$4FB,$4B3,$470,$430,$3F4
	DC.W	$3BB,$385,$353,$323,$2F6,$2CB,$2A3,$27D
	DC.W	$259,$238,$218,$1FA,$1DD,$1C2,$1A9,$191
	DC.W	$17B,$165,$151,$13E,$12C,$11C,$10C,$FD
	DC.W	$EE,$E1,$D4,$C8,$BD,$B2,$A8,$9F
	DC.W	$96,$8E,$86,$7E,$77,$70,$6A,$64
	DC.W	$5E,$59,$54,$4F,$4B,$47,$43,$3F
	DC.W	$3B,$38,$35,$32,$2F,$2C,$2A,$27
	DC.W	$25,$23,$21,$1F,$1D,$1C,$1A,$19
	DC.W	$17,$16,$15,$13,$12,$11,$10,$F

FIRST	DC.B	$80
	EVEN

CHAN_A	DS.B	NBOFF
CHAN_B	DS.B	NBOFF
CHAN_C	DS.B	NBOFF

L760	DS.B	1
CUTSND	DS.B	1
FREQ50	DS.B	1
;LF67	DS.B	1
	EVEN

CH_TAB
	DC.W	INST1-BASE,INST2-BASE,INST3-BASE,INST4-BASE,INST5-BASE
	DC.W	INST6-BASE,INST7-BASE,INST8-BASE,INST9-BASE

INST1	DC.B	0,3,$87
INST2	DC.B	0,4,$87
INST3	DC.B	0,3,7,$8C
INST4	DC.B	0,4,7,$8C
INST5	DC.B	7,$C,$8F
INST6	DC.B	7,$C,$90
INST7	DC.B	3,7,$8C
INST8	DC.B	4,7,$8C
INST9	DC.B	0,$8C
	EVEN
CH_TAB2
	DC.W	INST10-BASE,INST20-BASE,INST30-BASE
	DC.W	INST40-BASE,INST50-BASE,INST60-BASE
	DC.W	INST70-BASE,INST80-BASE,INST90-BASE

INST10	DC.B	0,3,7,$87
INST20	DC.B	0,4,7,$87
INST30	DC.B	0,3,7,$C,$87
INST40	DC.B	0,4,7,$C,$87
INST50	DC.B	7,$C,$F,$87
INST60	DC.B	7,$C,$10,$87
INST70	DC.B	3,7,$C,$87
INST80	DC.B	4,7,$C,$87
INST90	DC.B	0,$C,$87

	EVEN
STADS
	DC.W	L1C6E-BASE,L1CAE-BASE,L1CEE-BASE
	DC.W	L1D2E-BASE,L1D6E-BASE,L1DAE-BASE
	DC.W	L1DEE-BASE,L1E2E-BASE,L1E6E-BASE
;
; MUSIQUES DE ELEKTRA GLIDE
;
	DC.W	LC0A-BASE,LCB4-BASE,LCCA-BASE
	DC.W	LC2A-BASE,LCBC-BASE,LCDA-BASE
	DC.W	LC5E-BASE,LCC2-BASE,LCE4-BASE
	DC.W	LC92-BASE,LCC6-BASE,LD36-BASE

L1C6E
	DC.W	L1EAE-BASE,L1EAE-BASE,L1EAE-BASE,L1EAE-BASE
	DC.W	L1EAE-BASE,L1EAE-BASE,L1EAE-BASE,L1EAE-BASE
	DC.W	L1EAE-BASE,L1EAE-BASE,L1EAE-BASE,L1EAE-BASE
	DC.W	L1EAE-BASE,L1EAE-BASE,L1EAE-BASE,L1EAE-BASE
	DC.W	L1EAE-BASE,L1EAE-BASE,L1EAE-BASE,L1EAE-BASE
	DC.W	L1EAE-BASE,L1EAE-BASE,L1EAE-BASE,L1F35-BASE
	DC.W	L1F35-BASE,L1F35-BASE,L1F35-BASE,L1F35-BASE
	DC.W	L1F35-BASE,L1F35-BASE,L1F35-BASE,0
L1CAE
	DC.W	L24F7-BASE,L24DD-BASE,L2023-BASE,L2023-BASE
	DC.W	L1FA2-BASE,L1FCD-BASE,L1FF8-BASE,L2023-BASE
	DC.W	L1FA2-BASE,L1FCD-BASE,L1FF8-BASE,L2023-BASE
	DC.W	L2023-BASE,L1FA2-BASE,L1FCD-BASE,L1FF8-BASE
	DC.W	L2023-BASE,L1FA2-BASE,L1FCD-BASE,L1FF8-BASE
	DC.W	L2023-BASE,L2023-BASE,L24DD-BASE,L204E-BASE
	DC.W	L2079-BASE,L204E-BASE,L2079-BASE,L20A4-BASE
	DC.W	L20A4-BASE,L20A4-BASE,L20A4-BASE,0
L1CEE
	DC.W	L24F7-BASE,L24EA-BASE,L24A0-BASE,L24A0-BASE
	DC.W	L20CF-BASE,L20ED-BASE,L210B-BASE,L2129-BASE
	DC.W	L20CF-BASE,L20ED-BASE,L210B-BASE,L2129-BASE
	DC.W	L24A0-BASE,L2147-BASE,L2175-BASE,L21A3-BASE
	DC.W	L21D1-BASE,L2147-BASE,L2175-BASE,L21A3-BASE
	DC.W	L21D1-BASE,L24A0-BASE,L24EA-BASE,L21FF-BASE
	DC.W	L2222-BASE,L2246-BASE,L2265-BASE,L2280-BASE
	DC.W	L22A1-BASE,L2280-BASE,L22A1-BASE,0
L1D2E
	DC.W	L1EAE-BASE,L1EAE-BASE,L1EAE-BASE,L1EAE-BASE
	DC.W	L1EAE-BASE,L1EAE-BASE,L1EAE-BASE,L1EAE-BASE
	DC.W	L1EAE-BASE,L1EAE-BASE,L1EAE-BASE,L1EAE-BASE
	DC.W	L1EAE-BASE,L1EAE-BASE,L1EAE-BASE,L1EAE-BASE
	DC.W	L1EAE-BASE,L1EAE-BASE,L1EAE-BASE,L1EAE-BASE
	DC.W	L1EAE-BASE,L1EAE-BASE,L1EAE-BASE,L1F35-BASE
	DC.W	L1F35-BASE,L1F35-BASE,L1F35-BASE,L1F35-BASE
	DC.W	L1F35-BASE,L1F35-BASE,L1F35-BASE,0
L1D6E
	DC.W	L24F7-BASE,L24DD-BASE,L2023-BASE,L2023-BASE
	DC.W	L1FA2-BASE,L1FCD-BASE,L1FF8-BASE,L2023-BASE
	DC.W	L1FA2-BASE,L1FCD-BASE,L1FF8-BASE,L2023-BASE
	DC.W	L2023-BASE,L1FA2-BASE,L1FCD-BASE,L1FF8-BASE
	DC.W	L2023-BASE,L1FA2-BASE,L1FCD-BASE,L1FF8-BASE
	DC.W	L2023-BASE,L2023-BASE,L24DD-BASE,L204E-BASE
	DC.W	L2079-BASE,L204E-BASE,L2079-BASE,L20A4-BASE
	DC.W	L20A4-BASE,L20A4-BASE,L20A4-BASE,0
L1DAE
	DC.W	L24F7-BASE,L24EA-BASE,L24A0-BASE,L24A0-BASE
	DC.W	L23F0-BASE,L240C-BASE,L2428-BASE,L2444-BASE
	DC.W	L23F0-BASE,L240C-BASE,L2428-BASE,L2444-BASE
	DC.W	L24A0-BASE,L2460-BASE,L2470-BASE,L2480-BASE
	DC.W	L2490-BASE,L2460-BASE,L2470-BASE,L2480-BASE
	DC.W	L2490-BASE,L24A0-BASE,L24EA-BASE,L22C4-BASE
	DC.W	L230F-BASE,L22C4-BASE,L230F-BASE,L235A-BASE
	DC.W	L23A5-BASE,L235A-BASE,L23A5-BASE,0
L1DEE
	DC.W	L24FF-BASE,L2522-BASE,L24FF-BASE,L2522-BASE
	DC.W	L2545-BASE,L2568-BASE,L24FF-BASE,L2522-BASE
	DC.W	L2545-BASE,L2568-BASE,L24FF-BASE,L2522-BASE
	DC.W	L24FF-BASE,L2522-BASE,L2545-BASE,L2568-BASE
	DC.W	L24FF-BASE,L2522-BASE,L2545-BASE,L2568-BASE
	DC.W	L24FF-BASE,L2522-BASE,L24FF-BASE,L2522-BASE
	DC.W	L2545-BASE,L2568-BASE,L24FF-BASE,L2522-BASE
	DC.W	L2545-BASE,L2568-BASE,L24FF-BASE,0
L1E2E
	DC.W	L258B-BASE,L259C-BASE,L258B-BASE,L259C-BASE
	DC.W	L25AD-BASE,L25BE-BASE,L258B-BASE,L259C-BASE
	DC.W	L25AD-BASE,L25BE-BASE,L258B-BASE,L259C-BASE
	DC.W	L258B-BASE,L259C-BASE,L25AD-BASE,L25BE-BASE
	DC.W	L258B-BASE,L259C-BASE,L25AD-BASE,L25BE-BASE
	DC.W	L258B-BASE,L259C-BASE,L258B-BASE,L259C-BASE
	DC.W	L25AD-BASE,L25BE-BASE,L258B-BASE,L259C-BASE
	DC.W	L25AD-BASE,L25BE-BASE,L258B-BASE,0
L1E6E
	DC.W	L25CF-BASE,L25E6-BASE,L25CF-BASE,L25E6-BASE
	DC.W	L25FD-BASE,L2614-BASE,L25CF-BASE,L25E6-BASE
	DC.W	L25FD-BASE,L2614-BASE,L25CF-BASE,L25E6-BASE
	DC.W	L25CF-BASE,L25E6-BASE,L25FD-BASE,L2614-BASE
	DC.W	L25CF-BASE,L25E6-BASE,L25FD-BASE,L2614-BASE
	DC.W	L25CF-BASE,L25E6-BASE,L25CF-BASE,L25E6-BASE
	DC.W	L25FD-BASE,L2614-BASE,L25CF-BASE,L25E6-BASE
	DC.W	L25FD-BASE,L2614-BASE,L25CF-BASE,0
L1EAE
	DC.B	$BC,$8B,$88,1,1,$82,$DF,0
	DC.B	2,9,$E0,$89,$1F,$8D,0,$DF
	DC.B	0,3,5,$89,1,0,0,0
	DC.B	$DF,0,1,9,$E1,$89,7,$8D
	DC.B	0,$E0,$89,$15,$8D,0,$DF,0
	DC.B	3,5,$89,1,0,$DF,0,2
	DC.B	9,$89,7,$8D,0,$DF,0,3
	DC.B	5,$89,1,0,0,0,$DF,0
	DC.B	1,9,$E1,$89,7,$8D,0,$DF
	DC.B	0,3,5,$E0,$89,1,0,0
	DC.B	$8B,$DF,0,$11,9,$E1,$89,$1F
	DC.B	$8D,0,$DF,0,3,5,$E0,$89
	DC.B	1,0,0,$DF,0,1,9,$E1
	DC.B	$89,7,$8D,0,$89,$15,$8D,0
	DC.B	$89,7,$8D,0,$DF,0,3,5
	DC.B	$E0,$89,1,0,0,$DF,0,1
	DC.B	9,$E3,$89,7,$8D,0,$87
L1F35
	DC.B	$BC
	DC.B	$8B,$DF,0,1,9,$E1,$89,$1F
	DC.B	$8D,0,$DF,0,3,5,$89,1
	DC.B	0,$DF,0,1,9,$89,7,$8D
	DC.B	0,$89,$15,$8D,0,$89,$1F,$8D
	DC.B	0,$DF,0,3,5,$89,1,0
	DC.B	$DF,0,1,9,$89,7,$8D,0
	DC.B	$89,1,0,$8B,$DF,0,1,9
	DC.B	$E1,$89,$1F,$8D,0,$DF,0,3
	DC.B	5,$89,1,0,$DF,0,1,9
	DC.B	$E0,$89,7,0,0,$E1,$89,1
	DC.B	0,$E1,$89,$1F,$8D,0,$DF,0
	DC.B	3,5,$89,1,0,$DF,0,2
	DC.B	5,$E1,$89,7,$8D,0,$E0,$89
	DC.B	1,0,0,$87
L1FA2
	DC.B	$8A,$88,1,1
	DC.B	$82,$DF,0,$11,8,$E0,$E,$E
	DC.B	$E,$1A,$E,$E,$1A,$E,$E,$E
	DC.B	$E,$1A,$E,$E,$1A,$E,$E,$E
	DC.B	$E,$1A,$E,$E,$1A,$E,$E,$E
	DC.B	$1A,$1A,$E,$1A,$26,$32,$87
L1FCD
	DC.B	$8A
	DC.B	$88,1,1,$82,$DF,0,$11,8
	DC.B	$E0,$A,$A,$A,$16,$A,$A,$16
	DC.B	$A,$A,$A,$A,$16,$A,$A,$16
	DC.B	$A,$A,$A,$A,$16,$A,$A,$16
	DC.B	$A,$A,$A,$16,$16,$A,$16,$22
	DC.B	$2E,$87
L1FF8
	DC.B	$8A,$88,1,1,$82,$DF
	DC.B	0,$11,8,$E0,5,5,5,$11
	DC.B	5,5,$11,5,5,5,5,$11
	DC.B	5,5,$11,5,5,5,5,$11
	DC.B	5,5,$11,5,5,5,$11,$11
	DC.B	5,$11,$1D,$29,$87
L2023
	DC.B	$8A,$88,1
	DC.B	1,$82,$DF,0,$11,8,$E0,$C
	DC.B	$C,$C,$18,$C,$C,$18,$C,$C
	DC.B	$C,$C,$18,$C,$C,$18,$C,$C
	DC.B	$C,$C,$18,$C,$C,$18,$C,$C
	DC.B	$C,$18,$18,$C,$18,$24,$30,$87
L204E
	DC.B	$8A,$88,1,1,$82,$DF,0,$11
	DC.B	8,$E0,$B,$B,$B,$17,$B,$B
	DC.B	$17,$B,$B,$B,$17,$17,$B,$17
	DC.B	$23,$2F,$E,$E,$E,$1A,$E,$E
	DC.B	$1A,$E,$E,$E,$1A,$1A,$E,$1A
	DC.B	$26,$32,$87
L2079
	DC.B	$8A,$88,1,1,$82
	DC.B	$DF,0,$11,8,$E0,$12,$12,$12
	DC.B	$1E,$12,$12,$1E,$12,$12,$12,$12
	DC.B	$1E,$12,$12,$1E,$12,$12,$12,$12
	DC.B	$1E,$12,$12,$1E,$12,$12,$12,$1E
	DC.B	$1E,$12,$1E,$2A,$36,$87
L20A4
	DC.B	$8A,$88
	DC.B	1,1,$82,$DF,0,$11,8,$E0
	DC.B	9,9,9,$15,9,9,$21,$15
	DC.B	9,9,$15,$15,9,$15,$21,$2D
	DC.B	$12,$12,$12,$1E,$12,$12,$1E,$12
	DC.B	$12,$12,$1E,$1E,$12,$1E,$2A,$36
	DC.B	$87
L20CF
	DC.B	$8A,$88,1,1,$82,$DF,0
	DC.B	$51,5,$E1,$2D,$29,$26,$E3,$C8
	DC.B	$2E,$E5,$C8,$2D,$E1,$29,$26,$21
	DC.B	$E3,$C8,$3A,$E5,$C8,$39,$87
L20ED
	DC.B	$8A
	DC.B	$88,1,1,$82,$DF,0,$51,5
	DC.B	$E1,$29,$26,$22,$E3,$C8,$2D,$E5
	DC.B	$C8,$2E,$E1,$26,$22,$1D,$E3,$C8
	DC.B	$39,$E5,$C8,$3A,$87
L210B
	DC.B	$8A,$88,1
	DC.B	1,$82,$DF,0,$51,5,$E1,$2D
	DC.B	$29,$24,$E3,$C8,$2E,$E5,$C8,$2D
	DC.B	$E1,$29,$24,$21,$E3,$C8,$3A,$E5
	DC.B	$C8,$39,$87
L2129
	DC.B	$8A,$88,1,1,$82
	DC.B	$DF,0,$51,5,$E1,$2B,$28,$24
	DC.B	$E3,$C8,$2E,$E5,$C8,$2D,$E1,$30
	DC.B	$2E,$2D,$E3,$C8,$39,$E5,$C8,$3A
	DC.B	$87
L2147
	DC.B	$8A,$88,1,1,$82,$DF,0
	DC.B	$41,5,$E3,$C0,$32,$E0,$DF,0
	DC.B	$11,7,$39,$35,$32,$2D,$35,$32
	DC.B	$2D,$29,$32,$2D,$29,$26,$E3,$C0
	DC.B	$3E,$E0,$2D,$29,$26,$21,$29,$26
	DC.B	$21,$1D,$26,$21,$1D,$1A,$87
L2175
	DC.B	$8A
	DC.B	$88,1,1,$82,$DF,0,$41,5
	DC.B	$E3,$C1,$2E,$E0,$DF,0,$11,7
	DC.B	$3A,$35,$32,$2E,$35,$32,$2E,$29
	DC.B	$32,$2E,$29,$26,$E3,$C1,$3A,$E0
	DC.B	$2E,$29,$26,$22,$29,$26,$22,$1D
	DC.B	$26,$22,$1D,$1A,$87
L21A3
	DC.B	$8A,$88,1
	DC.B	1,$82,$DF,0,$41,5,$E3,$C1
	DC.B	$29,$E0,$DF,0,$11,7,$3C,$39
	DC.B	$35,$30,$39,$35,$30,$2D,$35,$30
	DC.B	$2D,$29,$E3,$C1,$35,$E0,$30,$2D
	DC.B	$29,$24,$2D,$29,$24,$21,$29,$24
	DC.B	$21,$1D,$87
L21D1
	DC.B	$8A,$88,1,1,$82
	DC.B	$DF,0,$41,5,$E3,$C1,$24,$E0
	DC.B	$DF,0,$11,7,$3C,$37,$34,$30
	DC.B	$37,$34,$30,$2B,$34,$30,$2B,$28
	DC.B	$E3,$C1,$30,$E0,$30,$2B,$28,$24
	DC.B	$2B,$28,$24,$1F,$28,$24,$1F,$1C
	DC.B	$87
L21FF
	DC.B	$8A,$88,1,1,$82,$DF,0
	DC.B	$21,5,$E1,$2A,$2A,$E0,$28,$E1
	DC.B	$26,$28,$E2,$2A,$E3,$C8,$2A,$E1
	DC.B	$2A,$2A,$E0,$28,$E1,$26,$E4,$2A
	DC.B	$E3,$C8,$2A,$87
L2222
	DC.B	$8A,$88,1,1
	DC.B	$82,$DF,0,$31,5,$E1,$80,$2F
	DC.B	$E0,$2F,$E1,$2F,$E8,$C8,$2D,$E1
	DC.B	$80,$C2,$2F,$E0,$C2,$2F,$E1,$C2
	DC.B	$2F,$E8,$84,4,$A,$C3,$2D,$87
L2246
	DC.B	$8A,$88,1,1,$82,$DF,0,$31
	DC.B	5,$E1,$2A,$2A,$E0,$28,$E1,$26
	DC.B	$28,$E2,$2A,$E3,$C8,$2A,$E1,$32
	DC.B	$2D,$2A,$28,$2A,$E5,$28,$87
L2265
	DC.B	$8A
	DC.B	$88,1,1,$82,$DF,0,$31,5
	DC.B	$EB,$84,4,$10,$2A,$E1,$C8,$2A
	DC.B	$E5,$C8,$25,$E1,$C8,$25,$E9,$C8
	DC.B	$1E,$87
L2280
	DC.B	$8A,$88,1,1,$82,$DF
	DC.B	0,$31,5,$E1,$2D,$2D,$2F,$31
	DC.B	$31,$E0,$32,$E2,$31,$E1,$2F,$E1
	DC.B	$2A,$2A,$2D,$E0,$2A,$E8,$84,5
	DC.B	$10,$2F,$87
L22A1
	DC.B	$8A,$88,1,1,$82
	DC.B	$DF,0,$41,5,$E1,$21,$21,$23
	DC.B	$25,$25,$E0,$26,$E2,$25,$E1,$23
	DC.B	$E1,$1E,$1E,$21,$1E,$2A,$E0,$23
	DC.B	$E1,$2A,$E2,$C8,$2F,$87
L22C4
	DC.B	$8A,$88
	DC.B	1,1,$82,$DF,0,$21,5,$E0
	DC.B	$C0,$47,$C0,$47,$C4,$3B,$C4,$3B
	DC.B	$C6,$3B,$C6,$3B,$C0,$3B,$C0,$3B
	DC.B	$C4,$2F,$C4,$2F,$C6,$2F,$C6,$2F
	DC.B	$C0,$2F,$C0,$2F,$C4,$23,$C4,$23
	DC.B	$C1,$3E,$C1,$3E,$C5,$32,$C5,$32
	DC.B	$C7,$32,$C7,$32,$C1,$32,$C1,$32
	DC.B	$C5,$26,$C5,$26,$C7,$26,$C7,$26
	DC.B	$C1,$26,$C1,$26,$C5,$1A,$C5,$1A
	DC.B	$87
L230F
	DC.B	$8A,$88,1,1,$82,$DF,0
	DC.B	$21,5,$E0,$C0,$4E,$C0,$4E,$C4
	DC.B	$42,$C4,$42,$C6,$42,$C6,$42,$C0
	DC.B	$42,$C0,$42,$C4,$36,$C4,$36,$C6
	DC.B	$36,$C6,$36,$C0,$36,$C0,$36,$C4
	DC.B	$2A,$C4,$2A,$C0,$1E,$C0,$1E,$C6
	DC.B	$1E,$C6,$1E,$C4,$1E,$C4,$1E,$C0
	DC.B	$2A,$C0,$2A,$C6,$2A,$C6,$2A,$C4
	DC.B	$2A,$C4,$2A,$C0,$36,$C0,$36,$C6
	DC.B	$36,$C6,$36,$87
L235A
	DC.B	$8A,$88,1,1
	DC.B	$82,$DF,0,$21,5,$E0,$C1,$45
	DC.B	$C1,$45,$C5,$39,$C5,$39,$C7,$39
	DC.B	$C7,$39,$C1,$39,$C1,$39,$C5,$2D
	DC.B	$C5,$2D,$C7,$2D,$C7,$2D,$C1,$2D
	DC.B	$C1,$2D,$C5,$21,$C5,$21,$C0,$1E
	DC.B	$C0,$1E,$C6,$1E,$C6,$1E,$C4,$1E
	DC.B	$C4,$1E,$C0,$2A,$C0,$2A,$C6,$2A
	DC.B	$C6,$2A,$C4,$2A,$C4,$2A,$C0,$36
	DC.B	$C0,$36,$C6,$36,$C6,$36,$87
L23A5
	DC.B	$8A
	DC.B	$88,1,1,$82,$DF,0,$21,5
	DC.B	$E0,$C1,$45,$C1,$45,$C5,$39,$C5
	DC.B	$39,$C7,$39,$C7,$39,$C1,$39,$C1
	DC.B	$39,$C5,$2D,$C5,$2D,$C7,$2D,$C7
	DC.B	$2D,$C1,$2D,$C1,$2D,$C5,$21,$C5
	DC.B	$21,$C0,$1E,$C0,$1E,$C6,$36,$C6
	DC.B	$36,$C4,$2A,$C4,$2A,$C0,$42,$C0
	DC.B	$42,$C6,$2A,$C6,$2A,$C4,$36,$C4
	DC.B	$36,$C0,$42,$C0,$42,$C6,$4E,$C6
	DC.B	$4E,$87
L23F0
	DC.B	$8A,$88,1,1,$82,$DF
	DC.B	0,$51,5,$E1,$21,$21,$21,$E3
	DC.B	$C8,$22,$C8,$21,$C8,$2E,$C8,$2D
	DC.B	$C8,$3A,$E5,$C8,$39,$87
L240C
	DC.B	$8A,$88
	DC.B	1,1,$82,$DF,0,$51,5,$E1
	DC.B	$21,$21,$21,$E3,$C8,$1F,$C8,$21
	DC.B	$C8,$2B,$C8,$2D,$C8,$37,$E5,$C8
	DC.B	$39,$87
L2428
	DC.B	$8A,$88,1,1,$82,$DF
	DC.B	0,$51,5,$E1,$1D,$1D,$1D,$E3
	DC.B	$C8,$20,$C8,$1F,$C8,$2C,$C8,$2B
	DC.B	$C8,$38,$E5,$C8,$37,$87
L2444
	DC.B	$8A,$88
	DC.B	1,1,$82,$DF,0,$51,5,$E1
	DC.B	$1D,$1D,$1D,$E3,$C8,$1B,$C8,$18
	DC.B	$C8,$27,$C8,$24,$C8,$33,$E5,$C8
	DC.B	$30,$87
L2460
	DC.B	$8A,$88,1,1,$82,$D4
	DC.B	$F1,$F1,$F4,$FF,$84,$FF,$3C,$C0
	DC.B	$26,$87
L2470
	DC.B	$8A,$88,1,1,$82,$D4
	DC.B	$F1,$F1,$F4,$FF,$84,$FF,$3C,$C0
	DC.B	$22,$87
L2480
	DC.B	$8A,$88,1,1,$82,$D4
	DC.B	$F1,$F1,$F3,$FF,$84,$FF,$3C,$C0
	DC.B	$1D,$87
L2490
	DC.B	$8A,$88,1,1,$82,$D4
	DC.B	$F1,$F1,$F3,$FF,$84,$FF,$3C,$C0
	DC.B	$24,$87
L24A0
	DC.B	$8A,$88,1,1,$82,$DF
	DC.B	0,$61,5,$E1,$84,$3C,1,$18
	DC.B	$84,$3C,1,$18,$84,$3C,1,$18
	DC.B	$E3,$84,$3C,1,$14,$E5,$80,$E1
	DC.B	$84,$3C,1,$24,$84,$3C,1,$24
	DC.B	$84,$3C,1,$24,$E3,$84,$3C,1
	DC.B	$24,$E1,$84,$3C,1,$29,$84,$3C
	DC.B	1,$24,$84,$3C,1,$1D,$87
L24DD
	DC.B	$8A
	DC.B	$88,1,1,$82,$DF,0,$F1,1
	DC.B	$FF,$86,0,$87
L24EA
	DC.B	$8A,$88,1,1
	DC.B	$82,$DF,0,$F1,1,$FF,$86,1
	DC.B	$87
L24F7
	DC.B	$8A,$DF,0,$F1,1,$FF,$80
	DC.B	$87
L24FF
	DC.B	$BC,$8A,$88,1,1,$82,$DF
	DC.B	0,$21,9,$E1,$C,$C,$C,$C
	DC.B	$C,$C,$C,$C,$C,$C,$C,$C
	DC.B	$C,$C,$DF,0,$11,9,$E0,$C
	DC.B	$C,$C,$C,$87
L2522
	DC.B	$BC,$8A,$88,1
	DC.B	1,$82,$DF,0,$21,9,$E1,7
	DC.B	7,7,7,7,7,7,7,7
	DC.B	7,7,7,7,7,$DF,0,$11
	DC.B	9,$E0,7,7,7,7,$87
L2545
	DC.B	$BC
	DC.B	$8A,$88,1,1,$82,$DF,0,$21
	DC.B	9,$E1,$11,$11,$11,$11,$11,$11
	DC.B	$11,$11,$11,$11,$11,$11,$11,$11
	DC.B	$DF,0,$11,9,$E0,$11,$11,$11
	DC.B	$11,$87
L2568
	DC.B	$BC,$8A,$88,1,1,$82
	DC.B	$DF,0,$21,9,$E1,$13,$13,$13
	DC.B	$13,$13,$13,$13,$13,$13,$13,$13
	DC.B	$13,$13,$13,$DF,0,$11,9,$E0
	DC.B	$13,$1F,$2B,$37,$87
L258B
	DC.B	$BC,$8A,$88
	DC.B	1,1,$82,$DB,0,$11,1,$84
	DC.B	1,$32,$FF,$C5,$30,$87
L259C
	DC.B	$BC,$8A
	DC.B	$88,1,1,$82,$DB,0,$11,1
	DC.B	$84,1,$32,$FF,$C1,$37,$87
L25AD
	DC.B	$BC
	DC.B	$8A,$88,1,1,$82,$DB,0,$11
	DC.B	1,$84,1,$32,$FF,$C5,$35,$87
L25BE
	DC.B	$BC,$8A,$88,1,1,$82,$DB,0
	DC.B	$11,1,$84,1,$32,$FF,$C5,$37
	DC.B	$87
L25CF
	DC.B	$BC,$8A,$88,1,2,$82,$D8
	DC.B	$12,$81,$15,$E9,$40,$E1,$37,$3C
	DC.B	$40,$E3,$41,$E7,$40,$E3,$41,$87
L25E6
	DC.B	$BC,$8A,$88,1,1,$82,$D8,$12
	DC.B	$81,$15,$E9,$40,$E1,$37,$3B,$3E
	DC.B	$E3,$41,$E7,$40,$E3,$43,$87
L25FD
	DC.B	$BC
	DC.B	$8A,$88,1,1,$82,$D8,$12,$81
	DC.B	$15,$E9,$41,$E1,$35,$39,$3C,$E3
	DC.B	$40,$E7,$41,$E3,$40,$87
L2614
	DC.B	$BC,$8A
	DC.B	$88,1,1,$82,$D8,$12,$81,$15
	DC.B	$E9,$43,$E1,$37,$3B,$3E,$E3,$40
	DC.B	$E7,$41,$E3,$40,$87
	EVEN

L56B
	DC.B	$BC,$8B,$DF,0,$12
	DC.B	6,$E0,$89,$1F,$8D,0,$89,1
	DC.B	0,0,0,$E1,$89,7,$8D,0
	DC.B	$E0,$89,$15,$8D,0,$89,1,0
	DC.B	$89,7,$8D,0,$89,1,0,0
	DC.B	0,$E1,$89,7,$8D,0,$E0,$89
	DC.B	1,0,0,$87
L59C
	DC.B	$8B,$DF,0,$12
	DC.B	6,$E0,$89,$1F,0,$89,1,0
	DC.B	0,0,$E1,$89,7,$8D,0,$E0
	DC.B	$89,$15,$8D,0,$89,1,0,$89
	DC.B	$13,$8D,0,$89,1,0,$E1,$89
	DC.B	7,$8D,0,$8D,0,$E0,0,0
	DC.B	$87
L5C9
	DC.B	$8B,$DF,0,$12,6,$E0,$89
	DC.B	$1F,$8D,0,$89,1,0,0,0
	DC.B	$E1,$89,7,$8D,0,$E0,$89,$15
	DC.B	$8D,0,$89,1,0,$89,$1F,$8D
	DC.B	0,$89,1,0,$DF,0,$71,6
	DC.B	$8A,$E1,$84,$32,1,$1D,$84,$32
	DC.B	1,$24,$84,$32,1,$1D,$87
L5FF
	DC.B	$DF
	DC.B	0,$71,6,$8A,$E1,$84,$32,1
	DC.B	$1A,$84,$32,1,$1C,$84,$32,1
	DC.B	$1E,$E0,$8B,$89,7,$8D,0,$8A
	DC.B	$E1,$84,$32,1,$1C,$E0,$84,$32
	DC.B	1,$1E,$E1,$84,$32,1,$1E,$84
	DC.B	$32,1,$1D,$8B,$89,4,$8D,0
	DC.B	$87
L631
	DC.B	$DF,0,$71,6,$8A,$E1,$84
	DC.B	$32,1,$10,$84,$32,1,$20,$84
	DC.B	$32,1,$24,$E0,$8B,$89,$C,$8D
	DC.B	0,$8A,$E1,$84,$32,1,$20,$E0
	DC.B	$84,$32,1,$24,$E1,$84,$32,1
	DC.B	$24,$84,$32,1,$21,$8B,$89,7
	DC.B	$8D,0,$87
L663
	DC.B	$DF,0,$31,5,$8A
	DC.B	$88,1,1,$83,$E0,$10,$1C,$10
	DC.B	$1C,$10,$1C,$10,$1C,$10,$1C,$10
	DC.B	$1C,$10,$1C,$10,$1C,$10,$1C,$10
	DC.B	$1C,$10,$1C,$10,$1C,$10,$1C,$10
	DC.B	$1C,$10,$1C,$1C,$28,$D,$19,$D
	DC.B	$19,$D,$19,$D,$19,$D,$19,$D
	DC.B	$19,$D,$19,$D,$19,$D,$19,$D
	DC.B	$19,$D,$19,$D,$19,$D,$19,$D
	DC.B	$19,$D,$19,$19,$25,6,$12,6
	DC.B	$12,6,$12,6,$12,6,$12,6
	DC.B	$12,6,$12,6,$12,6,$12,6
	DC.B	$12,6,$12,6,$12,6,$12,6
	DC.B	$12,6,$12,$12,$1E,$B,$17,$B
	DC.B	$17,$B,$17,$B,$17,$B,$17,$B
	DC.B	$17,$B,$17,$B,$17,$87
L6DE
	DC.B	$E1,$B
	DC.B	$B,$B,$B,$B,$B,$B,$E0,$17
	DC.B	$23,$87
L6EA
	DC.B	$E0,$15,$21,$14,$20,$12
	DC.B	$1E,$E3,$17,$E0,$C,$18,$C,$18
	DC.B	$C,$18,$87
L6FB
	DC.B	$DF,0,$31,5,$8A
	DC.B	$88,1,1,$83,$E1,$D,$D,$D
	DC.B	$D,$D,$D,$D,$D,$D,$D,$D
	DC.B	$D,$D,$D,$D,$E0,$19,$25,$E1
	DC.B	$D,$D,$D,$D,$D,$D,$D,$E0
	DC.B	$19,$25,$E1,$E1,$D,$D,$D,$19
	DC.B	$D,$19,$D,$D,$B,$B,$B,$B
	DC.B	$B,$B,$B,$B,$B,$B,$B,$B
	DC.B	$B,$B,$B,$E0,$17,$23,$E1,8
	DC.B	8,8,8,8,8,8,$E0,$14
	DC.B	$20,$E1,8,$14,8,8,$14,8
	DC.B	8,8,$B,$B,$B,$B,$B,$B
	DC.B	$B,$B,$B,$B,$B,$B,$B,$B
	DC.B	$B,$E0,$17,$23,$E1,$D,$D,$D
	DC.B	$D,$D,$D,$D,$E0,$19,$25,$E1
	DC.B	$D,$19,$F,$1B,$10,$1C,$F,$1B
	DC.B	9,9,9,9,9,9,9,$E0
	DC.B	$15,$21,$E1,9,9,9,9,9
	DC.B	$B,$D,$10,4,4,4,4,4
	DC.B	4,4,4,4,4,4,4,4
	DC.B	4,4,$E0,$10,$1C,$E1,$B,$B
	DC.B	$B,$B,$B,$B,$B,$E0,$17,$23
	DC.B	$E1,$D,$D,$D,$E0,$19,$25,$E1
	DC.B	$B,$B,$B,$E0,$17,$23,$87
L7B7
	DC.B	$DF
	DC.B	0,$31,5,$8A,$88,1,1,$83
	DC.B	$E1,$D,$D,$D,$D,$D,$D,$D
	DC.B	$D,$D,$D,$D,$D,$D,$D,$D
	DC.B	$E0,$19,$25,$E1,$D,$D,$D,$D
	DC.B	$D,$D,$D,$E0,$19,$25,$E1,$D
	DC.B	$D,$D,$19,$D,$19,$D,$B,$B
	DC.B	$B,$B,$B,$B,$B,$B,$B,$B
	DC.B	$B,$B,$B,$B,$B,$E0,$17,$23
	DC.B	$E1,8,8,8,8,8,8,8
	DC.B	8,8,8,8,8,8,8,8
	DC.B	$E0,$14,$20,$E1,$B,$B,$B,$B
	DC.B	$B,$B,$B,$E0,$17,$23,$E1,$B
	DC.B	$B,$B,$B,$B,$C,$C,$C,$D
	DC.B	$D,$D,$D,$D,$D,$D,$E0,$19
	DC.B	$25,$E1,$D,$19,$F,$1B,$10,$1C
	DC.B	$F,$1B,9,9,9,9,9,9
	DC.B	9,9,9,$15,$B,$17,$D,$19
	DC.B	$B,$17,4,4,$10,$10,$10,4
	DC.B	4,$10,$10,4,4,$10,$10,4
	DC.B	$10,4,$D,$D,$D,$D,$D,$D
	DC.B	$D,$D,$E0,$19,$25,$E1,$B,$B
	DC.B	$B,$B,$B,$B,$B,$E0,$17,$23
	DC.B	$87
L869
	DC.B	$E1,$10,$10,$10,$10,$10,$10
	DC.B	$10,$10,$10,$10,$10,$10,$10,$10
	DC.B	$10,$E0,$1C,$28,$E1,$D,$D,$D
	DC.B	$D,$D,$D,$D,$D,$D,$D,$D
	DC.B	$D,$D,$D,$D,$E0,$19,$25,$E1
	DC.B	9,9,9,9,9,9,9,9
	DC.B	9,9,9,9,9,9,9,$E0
	DC.B	$15,$21,$E1,$B,$B,$B,$B,$B
	DC.B	$B,$B,$B,$B,$B,$B,$B,$B
	DC.B	$B,$B,$E0,$17,$23,$87
L8B6
	DC.B	$DF,0
	DC.B	$31,5,$8A,$88,1,1,$83,$E1
	DC.B	$13,$13,$13,$13,$13,$13,$13,$13
	DC.B	$13,$13,$13,$13,$13,$13,$13,$E0
	DC.B	$1F,$2B,$E1,$10,$10,$10,$10,$10
	DC.B	$10,$10,$10,$10,$10,$10,$10,$10
	DC.B	$10,$10,$E0,$1C,$28,$E1,9,9
	DC.B	9,9,9,9,9,9,9,9
	DC.B	9,9,9,9,9,$E0,$15,$21
	DC.B	$E1,$E,$E,$E,$E,$E,$E,$E
	DC.B	$E0,$1A,$26,$E1,$E,$E,$E,$E
	DC.B	$10,$10,$10,$10,9,9,9,9
	DC.B	9,9,9,9,9,9,9,9
	DC.B	9,9,9,$E0,$15,$21,$E1,$D
	DC.B	$D,$D,$D,$D,$D,$D,$D,$D
	DC.B	$D,$D,$D,$D,$D,$D,$E0,$19
	DC.B	$25,$E1,$13,$13,$13,$13,$13,$13
	DC.B	$13,$E0,$1F,$2B,$E1,$15,$15,$15
	DC.B	$15,$15,$15,$15,$E0,$21,$2D,$E1
	DC.B	$17,$17,$17,$17,$17,$17,$17,$17
	DC.B	$23,$23,$23,$23,$23,$23,$23,$23
	DC.B	$87
L959
	DC.B	$8A,$88,1,1,$83,$DF,0
	DC.B	$61,4,$E1,$23,$2F,$28,$23,$2F
	DC.B	$28,$23,$2F,$28,$23,$2F,$28,$23
	DC.B	$2F,$31,$2F,$87
L974
	DC.B	$E1,$23,$E0,$2F
	DC.B	$3B,$E1,$28,$23,$E0,$2F,$3B,$E1
	DC.B	$28,$23,$E0,$2F,$3B,$2D,$39,$2C
	DC.B	$38,$28,$34,$E3,$23,$E5,$C8,$24
	DC.B	$87
L991
	DC.B	$8A,$88,1,1,$83,$E1,$DF
	DC.B	0,$71,5,$23,$23,$23,$23,$23
	DC.B	$E3,$84,6,$A,$25,$E1,$20,$23
	DC.B	$23,$23,$23,$23,$E0,$25,$31,$25
	DC.B	$31,$25,$E2,$31,$E1,$25,$28,$2A
	DC.B	$2B,$2A,$28,$2A,$2C,$2F,$2B,$E5
	DC.B	$28,$E3,$84,6,$A,$2A,$E1,$21
	DC.B	$21,$21,$21,$21,$E3,$84,6,$A
	DC.B	$23,$E1,$1E,$21,$21,$21,$21,$21
	DC.B	$E0,$23,$2F,$23,$2F,$23,$E2,$2F
	DC.B	$E1,$20,$23,$E3,$27,$E0,$28,$27
	DC.B	$E1,$25,$27,$28,$27,$25,$E3,$25
	DC.B	$E1,$23,$25,$E0,$23,$22,$E4,$23
	DC.B	$E0,$2F,$23,$25,$E4,$23,$E0,$2F
	DC.B	$23,$25,$E1,$23,$25,$23,$20,$1E
	DC.B	$1C,$E0,$19,$25,$19,$E2,$25,$E5
	DC.B	$28,$E0,$28,$27,$26,$25,$E1,$25
	DC.B	$28,$2A,$2B,$2A,$E5,$28,$E1,$2A
	DC.B	$28,$2B,$2C,$2D,$2E,$2F,$28,$2A
	DC.B	$28,$2C,$2F,$31,$2F,$2B,$2A,$E0
	DC.B	$28,$27,$26,$E2,$25,$E1,$34,$31
	DC.B	$2F,$2C,$2A,$E0,$28,$27,$26,$25
	DC.B	$2C,$2D,$2F,$2D,$2C,$2B,$2C,$2B
	DC.B	$E1,$2A,$28,$25,$28,$E3,$2C,$E1
	DC.B	$2A,$28,$E7,$2A,$E0,$28,$2A,$28
	DC.B	$25,$28,$25,$23,$20,$23,$20,$1E
	DC.B	$1C,$1C,$1E,$1C,$19,$87
LA66
	DC.B	$8A,$88
	DC.B	1,1,$83,$E0,$DF,0,$61,5
	DC.B	$23,$24,$25,$26,$27,$26,$25,$24
	DC.B	$87
LA79
	DC.B	$E0,$23,$22,$21,$20,$1F,$1E
	DC.B	$1D,$1C,$87
LA83
	DC.B	$E0,$1B,$1C,$1D,$1E
	DC.B	$1F,$20,$21,$22,$87
LA8D
	DC.B	$E0,$2F,$30
	DC.B	$31,$32,$33,$32,$31,$30,$87
LA97
	DC.B	$E0
	DC.B	$23,$24,$25,$26,$27,$28,$29,$28
	DC.B	$E7,$C8,$2A,$C8,$27,$E0,$27,$28
	DC.B	$27,$25,$27,$25,$23,$21,$23,$25
	DC.B	$23,$21,$23,$21,$20,$1E,$E7,$C8
	DC.B	$2C,$C8,$2A,$E1,$28,$27,$28,$E3
	DC.B	$C8,$2A,$E0,$29,$28,$27,$26,$25
	DC.B	$24,$23,$22,$23,$25,$27,$26,$27
	DC.B	$28,$2A,$28,$27,$28,$2A,$2C,$2F
	DC.B	$2A,$2F,$2D,$2F,$31,$33,$31,$33
	DC.B	$34,$36,$34,$33,$31,$33,$31,$2F
	DC.B	$31,$87
LAEA
	DC.B	$E0,$34,$31,$2F,$31,$87
LAF0
	DC.B	$E1,$34,$E0,$2D,$2F,$87
LAF6
	DC.B	$E0,$34
	DC.B	$2F,$2D,$2F,$87
LAFC
	DC.B	$E1,$34,$E0,$28
	DC.B	$36,$87
LB02
	DC.B	$E0,$2C,$2A,$28,$2A,$87
LB08
	DC.B	$E1,$2D,$E0,$2C,$2D,$87
LB0E
	DC.B	$E0,$2F
	DC.B	$2D,$2C,$2D,$87
LB14
	DC.B	$E0,$2F,$2D,$2C
	DC.B	$2A,$28,$27,$E9,$84,$FB,$A,$23
	DC.B	$87
LB21
	DC.B	$E1,$2F,$E0,$3B,$47,$E1,$34
	DC.B	$2F,$E0,$3B,$47,$E1,$34,$2F,$E0
	DC.B	$3B,$47,$E1,$34,$2F,$E0,$3B,$47
	DC.B	$E1,$34,$2F,$34,$E0,$3B,$47,$E1
	DC.B	$3D,$87
LB42
	DC.B	$E1,$2F,$E0,$3B,$47,$E1
	DC.B	$34,$2F,$E0,$3B,$47,$E1,$34,$2F
	DC.B	$E0,$3B,$47,$E1,$34,$2F,$E0,$3B
	DC.B	$47,$E1,$34,$2F,$34,$E0,$3B,$3A
	DC.B	$39,$38,$87
LB63
	DC.B	$8A,$88,1,1,$83
	DC.B	$E1,$DF,0,$71,5,$28,$2A,$2B
	DC.B	$2A,$28,$26,$23,$24,$2B,$24,$23
	DC.B	$21,$23,$24,$23,$21,$1F,$21,$1F
	DC.B	$1E,$1F,$21,$1F,$1E,$E7,$C8,$1C
	DC.B	$E1,$1A,$1C,$1F,$1C,$1F,$1E,$1F
	DC.B	$21,$1F,$1E,$1C,$1E,$1C,$1A,$18
	DC.B	$17,$18,$1A,$1C,$1A,$1C,$1E,$1F
	DC.B	$21,$1F,$21,$1F,$21,$23,$21,$1F
	DC.B	$1C,$1F,$21,$1F,$21,$25,$28,$2A
	DC.B	$E3,$2B,$E0,$2C,$2B,$E1,$28,$25
	DC.B	$E0,$28,$27,$26,$24,$E1,$25,$E3
	DC.B	$28,$E1,$25,$28,$25,$21,$20,$21
	DC.B	$20,$1E,$1C,$1E,$1C,$1E,$20,$23
	DC.B	$20,$1E,$1C,$1E,$1C,$E3,$1F,$E1
	DC.B	$23,$26,$26,$23,$1F,$23,$E3,$25
	DC.B	$E1,$21,$25,$28,$25,$21,$25,$87
LBE8
	DC.B	$E0,$17,$1B,$1E,$23,$27,$2A,$2F
	DC.B	$33,$36,$3B,$3F,$42,$47,$4B,$4E
	DC.B	$53,$17,$1B,$1E,$23,$27,$2A,$2F
	DC.B	$2E,$2D,$2C,$2D,$2C,$2B,$2A,$29
	DC.B	$28,$87
	EVEN
LC0A
	DC.W	L56B-BASE,L5C9-BASE,L56B-BASE
	DC.W	L5C9-BASE,L56B-BASE,L5C9-BASE,L56B-BASE
	DC.W	L5FF-BASE,L56B-BASE,L5C9-BASE,L56B-BASE
	DC.W	L5C9-BASE,L56B-BASE,L59C-BASE,L5FF-BASE
	DC.W	L631-BASE
LC2A
	DC.W	L56B-BASE,L56B-BASE,L56B-BASE
	DC.W	L5C9-BASE,L56B-BASE,L59C-BASE,L56B-BASE
	DC.W	L56B-BASE,L5C9-BASE,L5C9-BASE,L56B-BASE
	DC.W	L56B-BASE,L56B-BASE,L56B-BASE,L56B-BASE
	DC.W	L56B-BASE,L56B-BASE,L5C9-BASE,L56B-BASE
	DC.W	L5C9-BASE,L56B-BASE,L5C9-BASE,L56B-BASE
	DC.W	L59C-BASE,L5FF-BASE,L631-BASE
LC5E
	DC.W	L56B-BASE
	DC.W	L56B-BASE,L56B-BASE,L59C-BASE,L5C9-BASE
	DC.W	L56B-BASE,L5C9-BASE,L56B-BASE,L56B-BASE
	DC.W	L5C9-BASE,L56B-BASE,L5C9-BASE,L56B-BASE
	DC.W	L5C9-BASE,L56B-BASE,L5C9-BASE,L56B-BASE
	DC.W	L5C9-BASE,L56B-BASE,L5C9-BASE,L56B-BASE
	DC.W	L5C9-BASE,L56B-BASE,L59C-BASE,L5FF-BASE
	DC.W	L631-BASE
LC92
	DC.W	L56B-BASE,L56B-BASE,L56B-BASE
	DC.W	L59C-BASE,L56B-BASE,L56B-BASE,L56B-BASE
	DC.W	L5C9-BASE,L56B-BASE,L56B-BASE,L56B-BASE
	DC.W	L59C-BASE,L59C-BASE,L5C9-BASE,L631-BASE
	DC.W	L5FF-BASE,0
LCB4
	DC.W	L663-BASE,L6DE-BASE
	DC.W	L663-BASE,L6EA-BASE
LCBC
	DC.W	L6FB-BASE,L663-BASE
	DC.W	L6EA-BASE
LCC2
	DC.W	L7B7-BASE,L869-BASE
LCC6
	DC.W	L8B6-BASE
	DC.W	0
LCCA
	DC.W	L959-BASE,L959-BASE,L959-BASE
	DC.W	L959-BASE,LB21-BASE,LB21-BASE,LB21-BASE
	DC.W	L974-BASE
LCDA
	DC.W	L991-BASE,LB21-BASE,LB21-BASE
	DC.W	LB21-BASE,L974-BASE
LCE4
	DC.W	LA66-BASE,LA66-BASE
	DC.W	LA79-BASE,LA83-BASE,LA8D-BASE,LA66-BASE
	DC.W	LA8D-BASE,LA97-BASE,LAEA-BASE,LAEA-BASE
	DC.W	LAEA-BASE,LAEA-BASE,LAEA-BASE,LAEA-BASE
	DC.W	LAEA-BASE,LAF0-BASE,LAF6-BASE,LAF6-BASE
	DC.W	LAF6-BASE,LAF6-BASE,LAF6-BASE,LAF6-BASE
	DC.W	LAF6-BASE,LAFC-BASE,LB02-BASE,LB02-BASE
	DC.W	LB02-BASE,LB02-BASE,LB02-BASE,LB02-BASE
	DC.W	LB02-BASE,LB08-BASE,LB0E-BASE,LB0E-BASE
	DC.W	LB0E-BASE,LB0E-BASE,LB14-BASE,LB21-BASE
	DC.W	LB21-BASE,LB21-BASE,LB42-BASE
LD36
	DC.W	LB63-BASE
	DC.W	LBE8-BASE,0
