;
; routines d'affichage des lettres en gros
;  plus rapide que des movem.l globalement
;  (code g‚n‚r‚ par GEN24.S)
;
; caract‚ristiques :
;
;	- codes 0 … 9=chiffres
;	- codes 10 … 35=lettres
;	- utilise les registres d0 … d7
;	- a6 pointe sur l'adresse ‚cran
;	- en sortie a6 est incr‚ment‚ de 8
;
; optimisations possibles :
;
;	- d‚placer sprz … la place du bra.w
;
	bra.w	spr0
	bra.w	spr1
	bra.w	spr2
	bra.w	spr3
	bra.w	spr4
	bra.w	spr5
	bra.w	spr6
	bra.w	spr7
	bra.w	spr8
	bra.w	spr9
	bra.w	spra
	bra.w	sprb
	bra.w	sprc
	bra.w	sprd
	bra.w	spre
	bra.w	sprf
	bra.w	sprg
	bra.w	sprh
	bra.w	spri
	bra.w	sprj
	bra.w	sprk
	bra.w	sprl
	bra.w	sprm
	bra.w	sprn
	bra.w	spro
	bra.w	sprp
	bra.w	sprq
	bra.w	sprr
	bra.w	sprs
	bra.w	sprt
	bra.w	spru
	bra.w	sprv
	bra.w	sprw
	bra.w	sprx
	bra.w	spry
	bra.w	sprz
spr0
	move.l	#$EE00EE0,d0
	or.l	d0,(a6)+
	or.l	d0,(a6)+
	move.l	#$3C783C78,d1
	or.l	d1,$98(a6)
	or.l	d1,$9C(a6)
	move.l	#$783C783C,d2
	or.l	d2,$138(a6)
	or.l	d2,$13C(a6)
	or.l	d2,$1D8(a6)
	or.l	d2,$1DC(a6)
	move.l	#$F01EF01E,d3
	or.l	d3,$278(a6)
	or.l	d3,$27C(a6)
	or.l	d3,$318(a6)
	or.l	d3,$31C(a6)
	or.l	d3,$3B8(a6)
	or.l	d3,$3BC(a6)
	or.l	d3,$458(a6)
	or.l	d3,$45C(a6)
	or.l	d3,$4F8(a6)
	or.l	d3,$4FC(a6)
	or.l	d3,$598(a6)
	or.l	d3,$59C(a6)
	or.l	d3,$638(a6)
	or.l	d3,$63C(a6)
	or.l	d3,$6D8(a6)
	or.l	d3,$6DC(a6)
	or.l	d3,$778(a6)
	or.l	d3,$77C(a6)
	or.l	d3,$818(a6)
	or.l	d3,$81C(a6)
	or.l	d3,$8B8(a6)
	or.l	d3,$8BC(a6)
	or.l	d3,$958(a6)
	or.l	d3,$95C(a6)
	or.l	d3,$9F8(a6)
	or.l	d3,$9FC(a6)
	or.l	d3,$A98(a6)
	or.l	d3,$A9C(a6)
	or.l	d3,$B38(a6)
	or.l	d3,$B3C(a6)
	or.l	d2,$BD8(a6)
	or.l	d2,$BDC(a6)
	or.l	d2,$C78(a6)
	or.l	d2,$C7C(a6)
	or.l	d1,$D18(a6)
	or.l	d1,$D1C(a6)
	or.l	d0,$DB8(a6)
	or.l	d0,$DBC(a6)
	rts
spr1
	move.l	#$3C003C0,d0
	or.l	d0,(a6)+
	or.l	d0,(a6)+
	or.l	d0,$98(a6)
	or.l	d0,$9C(a6)
	move.l	#$BC00BC0,d1
	or.l	d1,$138(a6)
	or.l	d1,$13C(a6)
	move.l	#$1BC01BC0,d1
	or.l	d1,$1D8(a6)
	or.l	d1,$1DC(a6)
	move.l	#$33C033C0,d1
	or.l	d1,$278(a6)
	or.l	d1,$27C(a6)
	move.l	#$63C063C0,d1
	or.l	d1,$318(a6)
	or.l	d1,$31C(a6)
	or.l	d0,$3B8(a6)
	or.l	d0,$3BC(a6)
	or.l	d0,$458(a6)
	or.l	d0,$45C(a6)
	or.l	d0,$4F8(a6)
	or.l	d0,$4FC(a6)
	or.l	d0,$598(a6)
	or.l	d0,$59C(a6)
	or.l	d0,$638(a6)
	or.l	d0,$63C(a6)
	or.l	d0,$6D8(a6)
	or.l	d0,$6DC(a6)
	or.l	d0,$778(a6)
	or.l	d0,$77C(a6)
	or.l	d0,$818(a6)
	or.l	d0,$81C(a6)
	or.l	d0,$8B8(a6)
	or.l	d0,$8BC(a6)
	or.l	d0,$958(a6)
	or.l	d0,$95C(a6)
	or.l	d0,$9F8(a6)
	or.l	d0,$9FC(a6)
	or.l	d0,$A98(a6)
	or.l	d0,$A9C(a6)
	or.l	d0,$B38(a6)
	or.l	d0,$B3C(a6)
	or.l	d0,$BD8(a6)
	or.l	d0,$BDC(a6)
	or.l	d0,$C78(a6)
	or.l	d0,$C7C(a6)
	or.l	d0,$D18(a6)
	or.l	d0,$D1C(a6)
	move.l	#$3BFC3BFC,d0
	or.l	d0,$DB8(a6)
	or.l	d0,$DBC(a6)
	rts
spr2
	move.l	#$7EF07EF0,d0
	or.l	d0,(a6)+
	or.l	d0,(a6)+
	move.l	#$E03CE03C,d0
	or.l	d0,$98(a6)
	or.l	d0,$9C(a6)
	move.l	#$C01CC01C,d0
	or.l	d0,$138(a6)
	or.l	d0,$13C(a6)
	move.l	#$801E801E,d0
	or.l	d0,$1D8(a6)
	or.l	d0,$1DC(a6)
	or.l	d0,$278(a6)
	or.l	d0,$27C(a6)
	move.l	#$1E001E,d0
	or.l	d0,$318(a6)
	or.l	d0,$31C(a6)
	or.l	d0,$3B8(a6)
	or.l	d0,$3BC(a6)
	or.l	d0,$458(a6)
	or.l	d0,$45C(a6)
	move.l	#$1C001C,d0
	or.l	d0,$4F8(a6)
	or.l	d0,$4FC(a6)
	move.l	#$3C003C,d0
	or.l	d0,$598(a6)
	or.l	d0,$59C(a6)
	move.l	#$F800F8,d0
	or.l	d0,$638(a6)
	or.l	d0,$63C(a6)
	move.l	#$EE00EE0,d0
	or.l	d0,$6D8(a6)
	or.l	d0,$6DC(a6)
	move.l	#$3C003C00,d0
	or.l	d0,$778(a6)
	or.l	d0,$77C(a6)
	move.l	#$78007800,d0
	or.l	d0,$818(a6)
	or.l	d0,$81C(a6)
	move.l	#$70007000,d0
	or.l	d0,$8B8(a6)
	or.l	d0,$8BC(a6)
	move.l	#$F000F000,d0
	or.l	d0,$958(a6)
	or.l	d0,$95C(a6)
	or.l	d0,$9F8(a6)
	or.l	d0,$9FC(a6)
	or.l	d0,$A98(a6)
	or.l	d0,$A9C(a6)
	move.l	#$F002F002,d0
	or.l	d0,$B38(a6)
	or.l	d0,$B3C(a6)
	move.l	#$F006F006,d0
	or.l	d0,$BD8(a6)
	or.l	d0,$BDC(a6)
	or.l	d0,$C78(a6)
	or.l	d0,$C7C(a6)
	move.l	#$F00EF00E,d0
	or.l	d0,$D18(a6)
	or.l	d0,$D1C(a6)
	move.l	#$FEFEFEFE,d0
	or.l	d0,$DB8(a6)
	or.l	d0,$DBC(a6)
	rts
spr3
	move.l	#$7FE07FE0,d0
	or.l	d0,(a6)+
	or.l	d0,(a6)+
	move.l	#$E078E078,d1
	or.l	d1,$98(a6)
	or.l	d1,$9C(a6)
	move.l	#$C03CC03C,d2
	or.l	d2,$138(a6)
	or.l	d2,$13C(a6)
	move.l	#$801C801C,d3
	or.l	d3,$1D8(a6)
	or.l	d3,$1DC(a6)
	move.l	#$801E801E,d3
	or.l	d3,$278(a6)
	or.l	d3,$27C(a6)
	move.l	#$1E001E,d4
	or.l	d4,$318(a6)
	or.l	d4,$31C(a6)
	or.l	d4,$3B8(a6)
	or.l	d4,$3BC(a6)
	or.l	d4,$458(a6)
	or.l	d4,$45C(a6)
	or.l	d4,$4F8(a6)
	or.l	d4,$4FC(a6)
	move.l	#$3C003C,d5
	or.l	d5,$598(a6)
	or.l	d5,$59C(a6)
	move.l	#$4380438,d6
	or.l	d6,$638(a6)
	or.l	d6,$63C(a6)
	move.l	#$7B007B0,d7
	or.l	d7,$6D8(a6)
	or.l	d7,$6DC(a6)
	or.l	d6,$778(a6)
	or.l	d6,$77C(a6)
	or.l	d5,$818(a6)
	or.l	d5,$81C(a6)
	or.l	d4,$8B8(a6)
	or.l	d4,$8BC(a6)
	or.l	d4,$958(a6)
	or.l	d4,$95C(a6)
	or.l	d4,$9F8(a6)
	or.l	d4,$9FC(a6)
	or.l	d4,$A98(a6)
	or.l	d4,$A9C(a6)
	or.l	d3,$B38(a6)
	or.l	d3,$B3C(a6)
	move.l	#$803C803C,d3
	or.l	d3,$BD8(a6)
	or.l	d3,$BDC(a6)
	or.l	d2,$C78(a6)
	or.l	d2,$C7C(a6)
	or.l	d1,$D18(a6)
	or.l	d1,$D1C(a6)
	or.l	d0,$DB8(a6)
	or.l	d0,$DBC(a6)
	rts
spr4
	move.l	#$2F002F0,d0
	or.l	d0,(a6)+
	or.l	d0,(a6)+
	or.l	d0,$98(a6)
	or.l	d0,$9C(a6)
	move.l	#$6F006F0,d0
	or.l	d0,$138(a6)
	or.l	d0,$13C(a6)
	or.l	d0,$1D8(a6)
	or.l	d0,$1DC(a6)
	move.l	#$CF00CF0,d0
	or.l	d0,$278(a6)
	or.l	d0,$27C(a6)
	or.l	d0,$318(a6)
	or.l	d0,$31C(a6)
	move.l	#$18F018F0,d0
	or.l	d0,$3B8(a6)
	or.l	d0,$3BC(a6)
	or.l	d0,$458(a6)
	or.l	d0,$45C(a6)
	move.l	#$30F030F0,d0
	or.l	d0,$4F8(a6)
	or.l	d0,$4FC(a6)
	or.l	d0,$598(a6)
	or.l	d0,$59C(a6)
	move.l	#$60F060F0,d0
	or.l	d0,$638(a6)
	or.l	d0,$63C(a6)
	or.l	d0,$6D8(a6)
	or.l	d0,$6DC(a6)
	move.l	#$C0F0C0F0,d0
	or.l	d0,$778(a6)
	or.l	d0,$77C(a6)
	move.l	#$C0F2C0F2,d0
	or.l	d0,$818(a6)
	or.l	d0,$81C(a6)
	move.l	#$FEFEFEFE,d0
	or.l	d0,$8B8(a6)
	or.l	d0,$8BC(a6)
	move.l	#$F200F2,d0
	or.l	d0,$958(a6)
	or.l	d0,$95C(a6)
	move.l	#$F000F0,d0
	or.l	d0,$9F8(a6)
	or.l	d0,$9FC(a6)
	or.l	d0,$A98(a6)
	or.l	d0,$A9C(a6)
	or.l	d0,$B38(a6)
	or.l	d0,$B3C(a6)
	or.l	d0,$BD8(a6)
	or.l	d0,$BDC(a6)
	or.l	d0,$C78(a6)
	or.l	d0,$C7C(a6)
	or.l	d0,$D18(a6)
	or.l	d0,$D1C(a6)
	move.l	#$7FE07FE,d0
	or.l	d0,$DB8(a6)
	or.l	d0,$DBC(a6)
	rts
spr5
	move.l	#$FEFEFEFE,d0
	or.l	d0,(a6)+
	or.l	d0,(a6)+
	move.l	#$F00EF00E,d0
	or.l	d0,$98(a6)
	or.l	d0,$9C(a6)
	move.l	#$F006F006,d0
	or.l	d0,$138(a6)
	or.l	d0,$13C(a6)
	or.l	d0,$1D8(a6)
	or.l	d0,$1DC(a6)
	move.l	#$F002F002,d0
	or.l	d0,$278(a6)
	or.l	d0,$27C(a6)
	move.l	#$F000F000,d0
	or.l	d0,$318(a6)
	or.l	d0,$31C(a6)
	or.l	d0,$3B8(a6)
	or.l	d0,$3BC(a6)
	or.l	d0,$458(a6)
	or.l	d0,$45C(a6)
	or.l	d0,$4F8(a6)
	or.l	d0,$4FC(a6)
	or.l	d0,$598(a6)
	or.l	d0,$59C(a6)
	or.l	d0,$638(a6)
	or.l	d0,$63C(a6)
	move.l	#$7EE07EE0,d0
	or.l	d0,$6D8(a6)
	or.l	d0,$6DC(a6)
	move.l	#$F800F8,d0
	or.l	d0,$778(a6)
	or.l	d0,$77C(a6)
	move.l	#$3C003C,d0
	or.l	d0,$818(a6)
	or.l	d0,$81C(a6)
	move.l	#$1C001C,d0
	or.l	d0,$8B8(a6)
	or.l	d0,$8BC(a6)
	move.l	#$1E001E,d0
	or.l	d0,$958(a6)
	or.l	d0,$95C(a6)
	or.l	d0,$9F8(a6)
	or.l	d0,$9FC(a6)
	or.l	d0,$A98(a6)
	or.l	d0,$A9C(a6)
	move.l	#$801E801E,d0
	or.l	d0,$B38(a6)
	or.l	d0,$B3C(a6)
	or.l	d0,$BD8(a6)
	or.l	d0,$BDC(a6)
	move.l	#$C01CC01C,d0
	or.l	d0,$C78(a6)
	or.l	d0,$C7C(a6)
	move.l	#$E03CE03C,d0
	or.l	d0,$D18(a6)
	or.l	d0,$D1C(a6)
	move.l	#$7EF07EF0,d0
	or.l	d0,$DB8(a6)
	or.l	d0,$DBC(a6)
	rts
spr6
	move.l	#$FE00FE0,d0
	or.l	d0,(a6)+
	or.l	d0,(a6)+
	move.l	#$3C383C38,d1
	or.l	d1,$98(a6)
	or.l	d1,$9C(a6)
	move.l	#$781C781C,d1
	or.l	d1,$138(a6)
	or.l	d1,$13C(a6)
	move.l	#$700E700E,d1
	or.l	d1,$1D8(a6)
	or.l	d1,$1DC(a6)
	move.l	#$F000F000,d1
	or.l	d1,$278(a6)
	or.l	d1,$27C(a6)
	or.l	d1,$318(a6)
	or.l	d1,$31C(a6)
	or.l	d1,$3B8(a6)
	or.l	d1,$3BC(a6)
	or.l	d1,$458(a6)
	or.l	d1,$45C(a6)
	or.l	d1,$4F8(a6)
	or.l	d1,$4FC(a6)
	move.l	#$F7E0F7E0,d1
	or.l	d1,$598(a6)
	or.l	d1,$59C(a6)
	move.l	#$F078F078,d1
	or.l	d1,$638(a6)
	or.l	d1,$63C(a6)
	move.l	#$F03CF03C,d1
	or.l	d1,$6D8(a6)
	or.l	d1,$6DC(a6)
	or.l	d1,$778(a6)
	or.l	d1,$77C(a6)
	move.l	#$F01EF01E,d1
	or.l	d1,$818(a6)
	or.l	d1,$81C(a6)
	or.l	d1,$8B8(a6)
	or.l	d1,$8BC(a6)
	or.l	d1,$958(a6)
	or.l	d1,$95C(a6)
	or.l	d1,$9F8(a6)
	or.l	d1,$9FC(a6)
	or.l	d1,$A98(a6)
	or.l	d1,$A9C(a6)
	or.l	d1,$B38(a6)
	or.l	d1,$B3C(a6)
	move.l	#$783C783C,d1
	or.l	d1,$BD8(a6)
	or.l	d1,$BDC(a6)
	or.l	d1,$C78(a6)
	or.l	d1,$C7C(a6)
	move.l	#$3C783C78,d1
	or.l	d1,$D18(a6)
	or.l	d1,$D1C(a6)
	or.l	d0,$DB8(a6)
	or.l	d0,$DBC(a6)
	rts
spr7
	move.l	#$FFFEFFFE,d0
	or.l	d0,(a6)+
	or.l	d0,(a6)+
	move.l	#$E01EE01E,d0
	or.l	d0,$98(a6)
	or.l	d0,$9C(a6)
	move.l	#$C01CC01C,d0
	or.l	d0,$138(a6)
	or.l	d0,$13C(a6)
	move.l	#$803C803C,d0
	or.l	d0,$1D8(a6)
	or.l	d0,$1DC(a6)
	move.l	#$80388038,d0
	or.l	d0,$278(a6)
	or.l	d0,$27C(a6)
	move.l	#$780078,d0
	or.l	d0,$318(a6)
	or.l	d0,$31C(a6)
	move.l	#$700070,d0
	or.l	d0,$3B8(a6)
	or.l	d0,$3BC(a6)
	move.l	#$F000F0,d0
	or.l	d0,$458(a6)
	or.l	d0,$45C(a6)
	move.l	#$E000E0,d0
	or.l	d0,$4F8(a6)
	or.l	d0,$4FC(a6)
	move.l	#$1E001E0,d0
	or.l	d0,$598(a6)
	or.l	d0,$59C(a6)
	move.l	#$1C001C0,d0
	or.l	d0,$638(a6)
	or.l	d0,$63C(a6)
	move.l	#$3C003C0,d0
	or.l	d0,$6D8(a6)
	or.l	d0,$6DC(a6)
	move.l	#$3800380,d0
	or.l	d0,$778(a6)
	or.l	d0,$77C(a6)
	move.l	#$7800780,d0
	or.l	d0,$818(a6)
	or.l	d0,$81C(a6)
	move.l	#$7000700,d0
	or.l	d0,$8B8(a6)
	or.l	d0,$8BC(a6)
	move.l	#$F000F00,d0
	or.l	d0,$958(a6)
	or.l	d0,$95C(a6)
	move.l	#$E000E00,d0
	or.l	d0,$9F8(a6)
	or.l	d0,$9FC(a6)
	move.l	#$1E001E00,d0
	or.l	d0,$A98(a6)
	or.l	d0,$A9C(a6)
	move.l	#$1C001C00,d0
	or.l	d0,$B38(a6)
	or.l	d0,$B3C(a6)
	move.l	#$3C003C00,d0
	or.l	d0,$BD8(a6)
	or.l	d0,$BDC(a6)
	move.l	#$38003800,d0
	or.l	d0,$C78(a6)
	or.l	d0,$C7C(a6)
	move.l	#$78007800,d0
	or.l	d0,$D18(a6)
	or.l	d0,$D1C(a6)
	move.l	#$FC00FC00,d0
	or.l	d0,$DB8(a6)
	or.l	d0,$DBC(a6)
	rts
spr8
	move.l	#$1BF01BF0,d0
	or.l	d0,(a6)+
	or.l	d0,(a6)+
	move.l	#$783C783C,d1
	or.l	d1,$98(a6)
	or.l	d1,$9C(a6)
	or.l	d1,$138(a6)
	or.l	d1,$13C(a6)
	move.l	#$F01EF01E,d2
	or.l	d2,$1D8(a6)
	or.l	d2,$1DC(a6)
	or.l	d2,$278(a6)
	or.l	d2,$27C(a6)
	or.l	d2,$318(a6)
	or.l	d2,$31C(a6)
	or.l	d2,$3B8(a6)
	or.l	d2,$3BC(a6)
	or.l	d2,$458(a6)
	or.l	d2,$45C(a6)
	or.l	d2,$4F8(a6)
	or.l	d2,$4FC(a6)
	or.l	d1,$598(a6)
	or.l	d1,$59C(a6)
	or.l	d1,$638(a6)
	or.l	d1,$63C(a6)
	move.l	#$3BF83BF8,d3
	or.l	d3,$6D8(a6)
	or.l	d3,$6DC(a6)
	or.l	d1,$778(a6)
	or.l	d1,$77C(a6)
	or.l	d1,$818(a6)
	or.l	d1,$81C(a6)
	or.l	d2,$8B8(a6)
	or.l	d2,$8BC(a6)
	or.l	d2,$958(a6)
	or.l	d2,$95C(a6)
	or.l	d2,$9F8(a6)
	or.l	d2,$9FC(a6)
	or.l	d2,$A98(a6)
	or.l	d2,$A9C(a6)
	or.l	d2,$B38(a6)
	or.l	d2,$B3C(a6)
	or.l	d2,$BD8(a6)
	or.l	d2,$BDC(a6)
	or.l	d1,$C78(a6)
	or.l	d1,$C7C(a6)
	or.l	d1,$D18(a6)
	or.l	d1,$D1C(a6)
	or.l	d0,$DB8(a6)
	or.l	d0,$DBC(a6)
	rts
spr9
	move.l	#$FE00FE0,d0
	or.l	d0,(a6)+
	or.l	d0,(a6)+
	move.l	#$3C783C78,d0
	or.l	d0,$98(a6)
	or.l	d0,$9C(a6)
	move.l	#$783C783C,d0
	or.l	d0,$138(a6)
	or.l	d0,$13C(a6)
	or.l	d0,$1D8(a6)
	or.l	d0,$1DC(a6)
	move.l	#$F01EF01E,d0
	or.l	d0,$278(a6)
	or.l	d0,$27C(a6)
	or.l	d0,$318(a6)
	or.l	d0,$31C(a6)
	or.l	d0,$3B8(a6)
	or.l	d0,$3BC(a6)
	or.l	d0,$458(a6)
	or.l	d0,$45C(a6)
	or.l	d0,$4F8(a6)
	or.l	d0,$4FC(a6)
	or.l	d0,$598(a6)
	or.l	d0,$59C(a6)
	move.l	#$781E781E,d0
	or.l	d0,$638(a6)
	or.l	d0,$63C(a6)
	or.l	d0,$6D8(a6)
	or.l	d0,$6DC(a6)
	move.l	#$3C1E3C1E,d0
	or.l	d0,$778(a6)
	or.l	d0,$77C(a6)
	move.l	#$FDE0FDE,d0
	or.l	d0,$818(a6)
	or.l	d0,$81C(a6)
	move.l	#$1E001E,d0
	or.l	d0,$8B8(a6)
	or.l	d0,$8BC(a6)
	or.l	d0,$958(a6)
	or.l	d0,$95C(a6)
	or.l	d0,$9F8(a6)
	or.l	d0,$9FC(a6)
	or.l	d0,$A98(a6)
	or.l	d0,$A9C(a6)
	or.l	d0,$B38(a6)
	or.l	d0,$B3C(a6)
	move.l	#$E01CE01C,d0
	or.l	d0,$BD8(a6)
	or.l	d0,$BDC(a6)
	move.l	#$E03CE03C,d0
	or.l	d0,$C78(a6)
	or.l	d0,$C7C(a6)
	move.l	#$70787078,d0
	or.l	d0,$D18(a6)
	or.l	d0,$D1C(a6)
	move.l	#$3FE03FE0,d0
	or.l	d0,$DB8(a6)
	or.l	d0,$DBC(a6)
	rts
spra
	move.l	#$1000100,d0
	or.l	d0,(a6)+
	or.l	d0,(a6)+
	or.l	d0,$98(a6)
	or.l	d0,$9C(a6)
	or.l	d0,$138(a6)
	or.l	d0,$13C(a6)
	move.l	#$3800380,d0
	or.l	d0,$1D8(a6)
	or.l	d0,$1DC(a6)
	or.l	d0,$278(a6)
	or.l	d0,$27C(a6)
	or.l	d0,$318(a6)
	or.l	d0,$31C(a6)
	move.l	#$1800180,d0
	or.l	d0,$3B8(a6)
	or.l	d0,$3BC(a6)
	move.l	#$5C005C0,d0
	or.l	d0,$458(a6)
	or.l	d0,$45C(a6)
	or.l	d0,$4F8(a6)
	or.l	d0,$4FC(a6)
	move.l	#$DC00DC0,d0
	or.l	d0,$598(a6)
	or.l	d0,$59C(a6)
	move.l	#$DE00DE0,d0
	or.l	d0,$638(a6)
	or.l	d0,$63C(a6)
	move.l	#$CE00CE0,d0
	or.l	d0,$6D8(a6)
	or.l	d0,$6DC(a6)
	move.l	#$1CE01CE0,d0
	or.l	d0,$778(a6)
	or.l	d0,$77C(a6)
	move.l	#$1EE01EE0,d0
	or.l	d0,$818(a6)
	or.l	d0,$81C(a6)
	move.l	#$18F018F0,d0
	or.l	d0,$8B8(a6)
	or.l	d0,$8BC(a6)
	move.l	#$30703070,d0
	or.l	d0,$958(a6)
	or.l	d0,$95C(a6)
	or.l	d0,$9F8(a6)
	or.l	d0,$9FC(a6)
	move.l	#$30783078,d0
	or.l	d0,$A98(a6)
	or.l	d0,$A9C(a6)
	or.l	d0,$B38(a6)
	or.l	d0,$B3C(a6)
	move.l	#$60386038,d0
	or.l	d0,$BD8(a6)
	or.l	d0,$BDC(a6)
	or.l	d0,$C78(a6)
	or.l	d0,$C7C(a6)
	move.l	#$603C603C,d0
	or.l	d0,$D18(a6)
	or.l	d0,$D1C(a6)
	move.l	#$F07EF07E,d0
	or.l	d0,$DB8(a6)
	or.l	d0,$DBC(a6)
	rts
sprb
	move.l	#$FBE0FBE0,d0
	or.l	d0,(a6)+
	or.l	d0,(a6)+
	move.l	#$78F878F8,d0
	or.l	d0,$98(a6)
	or.l	d0,$9C(a6)
	move.l	#$78787878,d0
	or.l	d0,$138(a6)
	or.l	d0,$13C(a6)
	move.l	#$783C783C,d1
	or.l	d1,$1D8(a6)
	or.l	d1,$1DC(a6)
	or.l	d1,$278(a6)
	or.l	d1,$27C(a6)
	or.l	d1,$318(a6)
	or.l	d1,$31C(a6)
	or.l	d1,$3B8(a6)
	or.l	d1,$3BC(a6)
	or.l	d1,$458(a6)
	or.l	d1,$45C(a6)
	or.l	d0,$4F8(a6)
	or.l	d0,$4FC(a6)
	or.l	d0,$598(a6)
	or.l	d0,$59C(a6)
	move.l	#$78F078F0,d2
	or.l	d2,$638(a6)
	or.l	d2,$63C(a6)
	move.l	#$7BF07BF0,d2
	or.l	d2,$6D8(a6)
	or.l	d2,$6DC(a6)
	or.l	d0,$778(a6)
	or.l	d0,$77C(a6)
	or.l	d1,$818(a6)
	or.l	d1,$81C(a6)
	or.l	d1,$8B8(a6)
	or.l	d1,$8BC(a6)
	move.l	#$781E781E,d2
	or.l	d2,$958(a6)
	or.l	d2,$95C(a6)
	or.l	d2,$9F8(a6)
	or.l	d2,$9FC(a6)
	or.l	d2,$A98(a6)
	or.l	d2,$A9C(a6)
	or.l	d2,$B38(a6)
	or.l	d2,$B3C(a6)
	or.l	d1,$BD8(a6)
	or.l	d1,$BDC(a6)
	or.l	d1,$C78(a6)
	or.l	d1,$C7C(a6)
	or.l	d0,$D18(a6)
	or.l	d0,$D1C(a6)
	move.l	#$FBF0FBF0,d0
	or.l	d0,$DB8(a6)
	or.l	d0,$DBC(a6)
	rts
sprc
	move.l	#$EFE0EFE,d0
	or.l	d0,(a6)+
	or.l	d0,(a6)+
	move.l	#$3E1E3E1E,d1
	or.l	d1,$98(a6)
	or.l	d1,$9C(a6)
	move.l	#$7C0E7C0E,d2
	or.l	d2,$138(a6)
	or.l	d2,$13C(a6)
	or.l	d2,$1D8(a6)
	or.l	d2,$1DC(a6)
	move.l	#$F800F800,d3
	or.l	d3,$278(a6)
	or.l	d3,$27C(a6)
	or.l	d3,$318(a6)
	or.l	d3,$31C(a6)
	or.l	d3,$3B8(a6)
	or.l	d3,$3BC(a6)
	or.l	d3,$458(a6)
	or.l	d3,$45C(a6)
	or.l	d3,$4F8(a6)
	or.l	d3,$4FC(a6)
	or.l	d3,$598(a6)
	or.l	d3,$59C(a6)
	or.l	d3,$638(a6)
	or.l	d3,$63C(a6)
	or.l	d3,$6D8(a6)
	or.l	d3,$6DC(a6)
	or.l	d3,$778(a6)
	or.l	d3,$77C(a6)
	or.l	d3,$818(a6)
	or.l	d3,$81C(a6)
	or.l	d3,$8B8(a6)
	or.l	d3,$8BC(a6)
	or.l	d3,$958(a6)
	or.l	d3,$95C(a6)
	or.l	d3,$9F8(a6)
	or.l	d3,$9FC(a6)
	or.l	d3,$A98(a6)
	or.l	d3,$A9C(a6)
	or.l	d3,$B38(a6)
	or.l	d3,$B3C(a6)
	or.l	d2,$BD8(a6)
	or.l	d2,$BDC(a6)
	or.l	d2,$C78(a6)
	or.l	d2,$C7C(a6)
	or.l	d1,$D18(a6)
	or.l	d1,$D1C(a6)
	or.l	d0,$DB8(a6)
	or.l	d0,$DBC(a6)
	rts
sprd
	move.l	#$FBE0FBE0,d0
	or.l	d0,(a6)+
	or.l	d0,(a6)+
	move.l	#$78787878,d1
	or.l	d1,$98(a6)
	or.l	d1,$9C(a6)
	move.l	#$783C783C,d2
	or.l	d2,$138(a6)
	or.l	d2,$13C(a6)
	or.l	d2,$1D8(a6)
	or.l	d2,$1DC(a6)
	or.l	d2,$278(a6)
	or.l	d2,$27C(a6)
	move.l	#$781E781E,d3
	or.l	d3,$318(a6)
	or.l	d3,$31C(a6)
	or.l	d3,$3B8(a6)
	or.l	d3,$3BC(a6)
	or.l	d3,$458(a6)
	or.l	d3,$45C(a6)
	or.l	d3,$4F8(a6)
	or.l	d3,$4FC(a6)
	or.l	d3,$598(a6)
	or.l	d3,$59C(a6)
	or.l	d3,$638(a6)
	or.l	d3,$63C(a6)
	or.l	d3,$6D8(a6)
	or.l	d3,$6DC(a6)
	or.l	d3,$778(a6)
	or.l	d3,$77C(a6)
	or.l	d3,$818(a6)
	or.l	d3,$81C(a6)
	or.l	d3,$8B8(a6)
	or.l	d3,$8BC(a6)
	or.l	d3,$958(a6)
	or.l	d3,$95C(a6)
	or.l	d3,$9F8(a6)
	or.l	d3,$9FC(a6)
	or.l	d3,$A98(a6)
	or.l	d3,$A9C(a6)
	or.l	d2,$B38(a6)
	or.l	d2,$B3C(a6)
	or.l	d2,$BD8(a6)
	or.l	d2,$BDC(a6)
	or.l	d2,$C78(a6)
	or.l	d2,$C7C(a6)
	or.l	d1,$D18(a6)
	or.l	d1,$D1C(a6)
	or.l	d0,$DB8(a6)
	or.l	d0,$DBC(a6)
	rts
spre
	move.l	#$FBFEFBFE,d0
	or.l	d0,(a6)+
	or.l	d0,(a6)+
	move.l	#$781E781E,d1
	or.l	d1,$98(a6)
	or.l	d1,$9C(a6)
	move.l	#$78067806,d1
	or.l	d1,$138(a6)
	or.l	d1,$13C(a6)
	or.l	d1,$1D8(a6)
	or.l	d1,$1DC(a6)
	move.l	#$78027802,d2
	or.l	d2,$278(a6)
	or.l	d2,$27C(a6)
	move.l	#$78007800,d3
	or.l	d3,$318(a6)
	or.l	d3,$31C(a6)
	or.l	d3,$3B8(a6)
	or.l	d3,$3BC(a6)
	or.l	d3,$458(a6)
	or.l	d3,$45C(a6)
	or.l	d3,$4F8(a6)
	or.l	d3,$4FC(a6)
	move.l	#$78407840,d4
	or.l	d4,$598(a6)
	or.l	d4,$59C(a6)
	move.l	#$78C078C0,d5
	or.l	d5,$638(a6)
	or.l	d5,$63C(a6)
	move.l	#$7BC07BC0,d6
	or.l	d6,$6D8(a6)
	or.l	d6,$6DC(a6)
	or.l	d5,$778(a6)
	or.l	d5,$77C(a6)
	or.l	d4,$818(a6)
	or.l	d4,$81C(a6)
	or.l	d3,$8B8(a6)
	or.l	d3,$8BC(a6)
	or.l	d3,$958(a6)
	or.l	d3,$95C(a6)
	or.l	d3,$9F8(a6)
	or.l	d3,$9FC(a6)
	or.l	d3,$A98(a6)
	or.l	d3,$A9C(a6)
	or.l	d2,$B38(a6)
	or.l	d2,$B3C(a6)
	or.l	d1,$BD8(a6)
	or.l	d1,$BDC(a6)
	or.l	d1,$C78(a6)
	or.l	d1,$C7C(a6)
	move.l	#$780E780E,d1
	or.l	d1,$D18(a6)
	or.l	d1,$D1C(a6)
	or.l	d0,$DB8(a6)
	or.l	d0,$DBC(a6)
	rts
sprf
	move.l	#$FBFEFBFE,d0
	or.l	d0,(a6)+
	or.l	d0,(a6)+
	move.l	#$781E781E,d0
	or.l	d0,$98(a6)
	or.l	d0,$9C(a6)
	move.l	#$78067806,d0
	or.l	d0,$138(a6)
	or.l	d0,$13C(a6)
	or.l	d0,$1D8(a6)
	or.l	d0,$1DC(a6)
	move.l	#$78027802,d0
	or.l	d0,$278(a6)
	or.l	d0,$27C(a6)
	move.l	#$78007800,d0
	or.l	d0,$318(a6)
	or.l	d0,$31C(a6)
	or.l	d0,$3B8(a6)
	or.l	d0,$3BC(a6)
	or.l	d0,$458(a6)
	or.l	d0,$45C(a6)
	or.l	d0,$4F8(a6)
	or.l	d0,$4FC(a6)
	move.l	#$78407840,d1
	or.l	d1,$598(a6)
	or.l	d1,$59C(a6)
	move.l	#$78C078C0,d2
	or.l	d2,$638(a6)
	or.l	d2,$63C(a6)
	move.l	#$7BC07BC0,d3
	or.l	d3,$6D8(a6)
	or.l	d3,$6DC(a6)
	or.l	d2,$778(a6)
	or.l	d2,$77C(a6)
	or.l	d1,$818(a6)
	or.l	d1,$81C(a6)
	or.l	d0,$8B8(a6)
	or.l	d0,$8BC(a6)
	or.l	d0,$958(a6)
	or.l	d0,$95C(a6)
	or.l	d0,$9F8(a6)
	or.l	d0,$9FC(a6)
	or.l	d0,$A98(a6)
	or.l	d0,$A9C(a6)
	or.l	d0,$B38(a6)
	or.l	d0,$B3C(a6)
	or.l	d0,$BD8(a6)
	or.l	d0,$BDC(a6)
	or.l	d0,$C78(a6)
	or.l	d0,$C7C(a6)
	or.l	d0,$D18(a6)
	or.l	d0,$D1C(a6)
	move.l	#$FC00FC00,d0
	or.l	d0,$DB8(a6)
	or.l	d0,$DBC(a6)
	rts
sprg
	move.l	#$1EFE1EFE,d0
	or.l	d0,(a6)+
	or.l	d0,(a6)+
	move.l	#$3C1E3C1E,d0
	or.l	d0,$98(a6)
	or.l	d0,$9C(a6)
	move.l	#$78067806,d0
	or.l	d0,$138(a6)
	or.l	d0,$13C(a6)
	or.l	d0,$1D8(a6)
	or.l	d0,$1DC(a6)
	move.l	#$F002F002,d0
	or.l	d0,$278(a6)
	or.l	d0,$27C(a6)
	move.l	#$F000F000,d0
	or.l	d0,$318(a6)
	or.l	d0,$31C(a6)
	or.l	d0,$3B8(a6)
	or.l	d0,$3BC(a6)
	or.l	d0,$458(a6)
	or.l	d0,$45C(a6)
	or.l	d0,$4F8(a6)
	or.l	d0,$4FC(a6)
	or.l	d0,$598(a6)
	or.l	d0,$59C(a6)
	or.l	d0,$638(a6)
	or.l	d0,$63C(a6)
	or.l	d0,$6D8(a6)
	or.l	d0,$6DC(a6)
	or.l	d0,$778(a6)
	or.l	d0,$77C(a6)
	move.l	#$F03EF03E,d0
	or.l	d0,$818(a6)
	or.l	d0,$81C(a6)
	move.l	#$F01EF01E,d0
	or.l	d0,$8B8(a6)
	or.l	d0,$8BC(a6)
	or.l	d0,$958(a6)
	or.l	d0,$95C(a6)
	or.l	d0,$9F8(a6)
	or.l	d0,$9FC(a6)
	or.l	d0,$A98(a6)
	or.l	d0,$A9C(a6)
	or.l	d0,$B38(a6)
	or.l	d0,$B3C(a6)
	move.l	#$783E783E,d0
	or.l	d0,$BD8(a6)
	or.l	d0,$BDC(a6)
	or.l	d0,$C78(a6)
	or.l	d0,$C7C(a6)
	move.l	#$3C7E3C7E,d0
	or.l	d0,$D18(a6)
	or.l	d0,$D1C(a6)
	move.l	#$1EEE1EEE,d0
	or.l	d0,$DB8(a6)
	or.l	d0,$DBC(a6)
	rts
sprh
	move.l	#$FC7EFC7E,d0
	or.l	d0,(a6)+
	or.l	d0,(a6)+
	move.l	#$783C783C,d1
	or.l	d1,$98(a6)
	or.l	d1,$9C(a6)
	or.l	d1,$138(a6)
	or.l	d1,$13C(a6)
	or.l	d1,$1D8(a6)
	or.l	d1,$1DC(a6)
	or.l	d1,$278(a6)
	or.l	d1,$27C(a6)
	or.l	d1,$318(a6)
	or.l	d1,$31C(a6)
	or.l	d1,$3B8(a6)
	or.l	d1,$3BC(a6)
	or.l	d1,$458(a6)
	or.l	d1,$45C(a6)
	or.l	d1,$4F8(a6)
	or.l	d1,$4FC(a6)
	or.l	d1,$598(a6)
	or.l	d1,$59C(a6)
	or.l	d1,$638(a6)
	or.l	d1,$63C(a6)
	move.l	#$7BFC7BFC,d2
	or.l	d2,$6D8(a6)
	or.l	d2,$6DC(a6)
	or.l	d1,$778(a6)
	or.l	d1,$77C(a6)
	or.l	d1,$818(a6)
	or.l	d1,$81C(a6)
	or.l	d1,$8B8(a6)
	or.l	d1,$8BC(a6)
	or.l	d1,$958(a6)
	or.l	d1,$95C(a6)
	or.l	d1,$9F8(a6)
	or.l	d1,$9FC(a6)
	or.l	d1,$A98(a6)
	or.l	d1,$A9C(a6)
	or.l	d1,$B38(a6)
	or.l	d1,$B3C(a6)
	or.l	d1,$BD8(a6)
	or.l	d1,$BDC(a6)
	or.l	d1,$C78(a6)
	or.l	d1,$C7C(a6)
	or.l	d1,$D18(a6)
	or.l	d1,$D1C(a6)
	or.l	d0,$DB8(a6)
	or.l	d0,$DBC(a6)
	rts
spri
	move.l	#$3FDC3FDC,d0
	or.l	d0,(a6)+
	or.l	d0,(a6)+
	move.l	#$33CC33CC,d1
	or.l	d1,$98(a6)
	or.l	d1,$9C(a6)
	move.l	#$3C003C0,d2
	or.l	d2,$138(a6)
	or.l	d2,$13C(a6)
	or.l	d2,$1D8(a6)
	or.l	d2,$1DC(a6)
	or.l	d2,$278(a6)
	or.l	d2,$27C(a6)
	or.l	d2,$318(a6)
	or.l	d2,$31C(a6)
	or.l	d2,$3B8(a6)
	or.l	d2,$3BC(a6)
	or.l	d2,$458(a6)
	or.l	d2,$45C(a6)
	or.l	d2,$4F8(a6)
	or.l	d2,$4FC(a6)
	or.l	d2,$598(a6)
	or.l	d2,$59C(a6)
	or.l	d2,$638(a6)
	or.l	d2,$63C(a6)
	or.l	d2,$6D8(a6)
	or.l	d2,$6DC(a6)
	or.l	d2,$778(a6)
	or.l	d2,$77C(a6)
	or.l	d2,$818(a6)
	or.l	d2,$81C(a6)
	or.l	d2,$8B8(a6)
	or.l	d2,$8BC(a6)
	or.l	d2,$958(a6)
	or.l	d2,$95C(a6)
	or.l	d2,$9F8(a6)
	or.l	d2,$9FC(a6)
	or.l	d2,$A98(a6)
	or.l	d2,$A9C(a6)
	or.l	d2,$B38(a6)
	or.l	d2,$B3C(a6)
	or.l	d2,$BD8(a6)
	or.l	d2,$BDC(a6)
	or.l	d2,$C78(a6)
	or.l	d2,$C7C(a6)
	or.l	d1,$D18(a6)
	or.l	d1,$D1C(a6)
	or.l	d0,$DB8(a6)
	or.l	d0,$DBC(a6)
	rts
sprj
	move.l	#$7E007E,d0
	or.l	d0,(a6)+
	or.l	d0,(a6)+
	move.l	#$3C003C,d0
	or.l	d0,$98(a6)
	or.l	d0,$9C(a6)
	or.l	d0,$138(a6)
	or.l	d0,$13C(a6)
	or.l	d0,$1D8(a6)
	or.l	d0,$1DC(a6)
	or.l	d0,$278(a6)
	or.l	d0,$27C(a6)
	or.l	d0,$318(a6)
	or.l	d0,$31C(a6)
	or.l	d0,$3B8(a6)
	or.l	d0,$3BC(a6)
	or.l	d0,$458(a6)
	or.l	d0,$45C(a6)
	or.l	d0,$4F8(a6)
	or.l	d0,$4FC(a6)
	or.l	d0,$598(a6)
	or.l	d0,$59C(a6)
	or.l	d0,$638(a6)
	or.l	d0,$63C(a6)
	or.l	d0,$6D8(a6)
	or.l	d0,$6DC(a6)
	or.l	d0,$778(a6)
	or.l	d0,$77C(a6)
	or.l	d0,$818(a6)
	or.l	d0,$81C(a6)
	or.l	d0,$8B8(a6)
	or.l	d0,$8BC(a6)
	or.l	d0,$958(a6)
	or.l	d0,$95C(a6)
	move.l	#$F83CF83C,d0
	or.l	d0,$9F8(a6)
	or.l	d0,$9FC(a6)
	move.l	#$F03CF03C,d0
	or.l	d0,$A98(a6)
	or.l	d0,$A9C(a6)
	move.l	#$F078F078,d0
	or.l	d0,$B38(a6)
	or.l	d0,$B3C(a6)
	or.l	d0,$BD8(a6)
	or.l	d0,$BDC(a6)
	or.l	d0,$C78(a6)
	or.l	d0,$C7C(a6)
	move.l	#$78F078F0,d0
	or.l	d0,$D18(a6)
	or.l	d0,$D1C(a6)
	move.l	#$1DC01DC0,d0
	or.l	d0,$DB8(a6)
	or.l	d0,$DBC(a6)
	rts
sprk
	move.l	#$FC7EFC7E,d0
	or.l	d0,(a6)+
	or.l	d0,(a6)+
	move.l	#$783C783C,d1
	or.l	d1,$98(a6)
	or.l	d1,$9C(a6)
	move.l	#$78787878,d2
	or.l	d2,$138(a6)
	or.l	d2,$13C(a6)
	or.l	d2,$1D8(a6)
	or.l	d2,$1DC(a6)
	move.l	#$78F078F0,d3
	or.l	d3,$278(a6)
	or.l	d3,$27C(a6)
	or.l	d3,$318(a6)
	or.l	d3,$31C(a6)
	move.l	#$79E079E0,d4
	or.l	d4,$3B8(a6)
	or.l	d4,$3BC(a6)
	or.l	d4,$458(a6)
	or.l	d4,$45C(a6)
	move.l	#$7BC07BC0,d5
	or.l	d5,$4F8(a6)
	or.l	d5,$4FC(a6)
	or.l	d5,$598(a6)
	or.l	d5,$59C(a6)
	move.l	#$7B807B80,d6
	or.l	d6,$638(a6)
	or.l	d6,$63C(a6)
	or.l	d6,$6D8(a6)
	or.l	d6,$6DC(a6)
	or.l	d6,$778(a6)
	or.l	d6,$77C(a6)
	or.l	d5,$818(a6)
	or.l	d5,$81C(a6)
	move.l	#$79C079C0,d5
	or.l	d5,$8B8(a6)
	or.l	d5,$8BC(a6)
	or.l	d4,$958(a6)
	or.l	d4,$95C(a6)
	move.l	#$78E078E0,d4
	or.l	d4,$9F8(a6)
	or.l	d4,$9FC(a6)
	or.l	d3,$A98(a6)
	or.l	d3,$A9C(a6)
	move.l	#$78707870,d3
	or.l	d3,$B38(a6)
	or.l	d3,$B3C(a6)
	or.l	d2,$BD8(a6)
	or.l	d2,$BDC(a6)
	move.l	#$78387838,d2
	or.l	d2,$C78(a6)
	or.l	d2,$C7C(a6)
	or.l	d1,$D18(a6)
	or.l	d1,$D1C(a6)
	or.l	d0,$DB8(a6)
	or.l	d0,$DBC(a6)
	rts
sprl
	move.l	#$FC00FC00,d0
	or.l	d0,(a6)+
	or.l	d0,(a6)+
	move.l	#$78007800,d0
	or.l	d0,$98(a6)
	or.l	d0,$9C(a6)
	or.l	d0,$138(a6)
	or.l	d0,$13C(a6)
	or.l	d0,$1D8(a6)
	or.l	d0,$1DC(a6)
	or.l	d0,$278(a6)
	or.l	d0,$27C(a6)
	or.l	d0,$318(a6)
	or.l	d0,$31C(a6)
	or.l	d0,$3B8(a6)
	or.l	d0,$3BC(a6)
	or.l	d0,$458(a6)
	or.l	d0,$45C(a6)
	or.l	d0,$4F8(a6)
	or.l	d0,$4FC(a6)
	or.l	d0,$598(a6)
	or.l	d0,$59C(a6)
	or.l	d0,$638(a6)
	or.l	d0,$63C(a6)
	or.l	d0,$6D8(a6)
	or.l	d0,$6DC(a6)
	or.l	d0,$778(a6)
	or.l	d0,$77C(a6)
	or.l	d0,$818(a6)
	or.l	d0,$81C(a6)
	or.l	d0,$8B8(a6)
	or.l	d0,$8BC(a6)
	or.l	d0,$958(a6)
	or.l	d0,$95C(a6)
	or.l	d0,$9F8(a6)
	or.l	d0,$9FC(a6)
	or.l	d0,$A98(a6)
	or.l	d0,$A9C(a6)
	move.l	#$78027802,d0
	or.l	d0,$B38(a6)
	or.l	d0,$B3C(a6)
	move.l	#$78067806,d0
	or.l	d0,$BD8(a6)
	or.l	d0,$BDC(a6)
	or.l	d0,$C78(a6)
	or.l	d0,$C7C(a6)
	move.l	#$780E780E,d0
	or.l	d0,$D18(a6)
	or.l	d0,$D1C(a6)
	move.l	#$FBFEFBFE,d0
	or.l	d0,$DB8(a6)
	or.l	d0,$DBC(a6)
	rts
sprm
	move.l	#$F83EF83E,d0
	or.l	d0,(a6)+
	or.l	d0,(a6)+
	move.l	#$F83CF83C,d0
	or.l	d0,$98(a6)
	or.l	d0,$9C(a6)
	move.l	#$783C783C,d0
	or.l	d0,$138(a6)
	or.l	d0,$13C(a6)
	move.l	#$787C787C,d1
	or.l	d1,$1D8(a6)
	or.l	d1,$1DC(a6)
	or.l	d1,$278(a6)
	or.l	d1,$27C(a6)
	or.l	d1,$318(a6)
	or.l	d1,$31C(a6)
	move.l	#$7AFC7AFC,d1
	or.l	d1,$3B8(a6)
	or.l	d1,$3BC(a6)
	or.l	d1,$458(a6)
	or.l	d1,$45C(a6)
	or.l	d1,$4F8(a6)
	or.l	d1,$4FC(a6)
	move.l	#$7BBC7BBC,d1
	or.l	d1,$598(a6)
	or.l	d1,$59C(a6)
	or.l	d1,$638(a6)
	or.l	d1,$63C(a6)
	or.l	d1,$6D8(a6)
	or.l	d1,$6DC(a6)
	move.l	#$793C793C,d1
	or.l	d1,$778(a6)
	or.l	d1,$77C(a6)
	or.l	d1,$818(a6)
	or.l	d1,$81C(a6)
	or.l	d1,$8B8(a6)
	or.l	d1,$8BC(a6)
	or.l	d0,$958(a6)
	or.l	d0,$95C(a6)
	or.l	d0,$9F8(a6)
	or.l	d0,$9FC(a6)
	or.l	d0,$A98(a6)
	or.l	d0,$A9C(a6)
	or.l	d0,$B38(a6)
	or.l	d0,$B3C(a6)
	or.l	d0,$BD8(a6)
	or.l	d0,$BDC(a6)
	or.l	d0,$C78(a6)
	or.l	d0,$C7C(a6)
	or.l	d0,$D18(a6)
	or.l	d0,$D1C(a6)
	move.l	#$FC7EFC7E,d0
	or.l	d0,$DB8(a6)
	or.l	d0,$DBC(a6)
	rts
sprn
	move.l	#$FC1EFC1E,d0
	or.l	d0,(a6)+
	or.l	d0,(a6)+
	move.l	#$781C781C,d0
	or.l	d0,$98(a6)
	or.l	d0,$9C(a6)
	or.l	d0,$138(a6)
	or.l	d0,$13C(a6)
	or.l	d0,$1D8(a6)
	or.l	d0,$1DC(a6)
	or.l	d0,$278(a6)
	or.l	d0,$27C(a6)
	move.l	#$7A1C7A1C,d0
	or.l	d0,$318(a6)
	or.l	d0,$31C(a6)
	or.l	d0,$3B8(a6)
	or.l	d0,$3BC(a6)
	or.l	d0,$458(a6)
	or.l	d0,$45C(a6)
	move.l	#$7B1C7B1C,d0
	or.l	d0,$4F8(a6)
	or.l	d0,$4FC(a6)
	or.l	d0,$598(a6)
	or.l	d0,$59C(a6)
	or.l	d0,$638(a6)
	or.l	d0,$63C(a6)
	move.l	#$799C799C,d0
	or.l	d0,$6D8(a6)
	or.l	d0,$6DC(a6)
	or.l	d0,$778(a6)
	or.l	d0,$77C(a6)
	or.l	d0,$818(a6)
	or.l	d0,$81C(a6)
	move.l	#$78DC78DC,d0
	or.l	d0,$8B8(a6)
	or.l	d0,$8BC(a6)
	or.l	d0,$958(a6)
	or.l	d0,$95C(a6)
	or.l	d0,$9F8(a6)
	or.l	d0,$9FC(a6)
	move.l	#$787C787C,d0
	or.l	d0,$A98(a6)
	or.l	d0,$A9C(a6)
	or.l	d0,$B38(a6)
	or.l	d0,$B3C(a6)
	or.l	d0,$BD8(a6)
	or.l	d0,$BDC(a6)
	move.l	#$783C783C,d0
	or.l	d0,$C78(a6)
	or.l	d0,$C7C(a6)
	or.l	d0,$D18(a6)
	or.l	d0,$D1C(a6)
	move.l	#$FC3CFC3C,d0
	or.l	d0,$DB8(a6)
	or.l	d0,$DBC(a6)
	rts
spro
	move.l	#$EE00EE0,d0
	or.l	d0,(a6)+
	or.l	d0,(a6)+
	move.l	#$3C783C78,d1
	or.l	d1,$98(a6)
	or.l	d1,$9C(a6)
	move.l	#$783C783C,d2
	or.l	d2,$138(a6)
	or.l	d2,$13C(a6)
	or.l	d2,$1D8(a6)
	or.l	d2,$1DC(a6)
	move.l	#$F01EF01E,d3
	or.l	d3,$278(a6)
	or.l	d3,$27C(a6)
	or.l	d3,$318(a6)
	or.l	d3,$31C(a6)
	or.l	d3,$3B8(a6)
	or.l	d3,$3BC(a6)
	or.l	d3,$458(a6)
	or.l	d3,$45C(a6)
	or.l	d3,$4F8(a6)
	or.l	d3,$4FC(a6)
	or.l	d3,$598(a6)
	or.l	d3,$59C(a6)
	or.l	d3,$638(a6)
	or.l	d3,$63C(a6)
	or.l	d3,$6D8(a6)
	or.l	d3,$6DC(a6)
	or.l	d3,$778(a6)
	or.l	d3,$77C(a6)
	or.l	d3,$818(a6)
	or.l	d3,$81C(a6)
	or.l	d3,$8B8(a6)
	or.l	d3,$8BC(a6)
	or.l	d3,$958(a6)
	or.l	d3,$95C(a6)
	or.l	d3,$9F8(a6)
	or.l	d3,$9FC(a6)
	or.l	d3,$A98(a6)
	or.l	d3,$A9C(a6)
	or.l	d3,$B38(a6)
	or.l	d3,$B3C(a6)
	or.l	d2,$BD8(a6)
	or.l	d2,$BDC(a6)
	or.l	d2,$C78(a6)
	or.l	d2,$C7C(a6)
	or.l	d1,$D18(a6)
	or.l	d1,$D1C(a6)
	or.l	d0,$DB8(a6)
	or.l	d0,$DBC(a6)
	rts
sprp
	move.l	#$FBE0FBE0,d0
	or.l	d0,(a6)+
	or.l	d0,(a6)+
	move.l	#$78787878,d0
	or.l	d0,$98(a6)
	or.l	d0,$9C(a6)
	move.l	#$783C783C,d1
	or.l	d1,$138(a6)
	or.l	d1,$13C(a6)
	or.l	d1,$1D8(a6)
	or.l	d1,$1DC(a6)
	move.l	#$781E781E,d2
	or.l	d2,$278(a6)
	or.l	d2,$27C(a6)
	or.l	d2,$318(a6)
	or.l	d2,$31C(a6)
	or.l	d2,$3B8(a6)
	or.l	d2,$3BC(a6)
	or.l	d2,$458(a6)
	or.l	d2,$45C(a6)
	or.l	d2,$4F8(a6)
	or.l	d2,$4FC(a6)
	or.l	d1,$598(a6)
	or.l	d1,$59C(a6)
	or.l	d1,$638(a6)
	or.l	d1,$63C(a6)
	or.l	d0,$6D8(a6)
	or.l	d0,$6DC(a6)
	move.l	#$7BE07BE0,d0
	or.l	d0,$778(a6)
	or.l	d0,$77C(a6)
	move.l	#$78007800,d0
	or.l	d0,$818(a6)
	or.l	d0,$81C(a6)
	or.l	d0,$8B8(a6)
	or.l	d0,$8BC(a6)
	or.l	d0,$958(a6)
	or.l	d0,$95C(a6)
	or.l	d0,$9F8(a6)
	or.l	d0,$9FC(a6)
	or.l	d0,$A98(a6)
	or.l	d0,$A9C(a6)
	or.l	d0,$B38(a6)
	or.l	d0,$B3C(a6)
	or.l	d0,$BD8(a6)
	or.l	d0,$BDC(a6)
	or.l	d0,$C78(a6)
	or.l	d0,$C7C(a6)
	or.l	d0,$D18(a6)
	or.l	d0,$D1C(a6)
	move.l	#$FC00FC00,d0
	or.l	d0,$DB8(a6)
	or.l	d0,$DBC(a6)
	rts
sprq
	move.l	#$EE00EE0,d0
	or.l	d0,(a6)+
	or.l	d0,(a6)+
	move.l	#$3C783C78,d1
	or.l	d1,$98(a6)
	or.l	d1,$9C(a6)
	move.l	#$783C783C,d1
	or.l	d1,$138(a6)
	or.l	d1,$13C(a6)
	or.l	d1,$1D8(a6)
	or.l	d1,$1DC(a6)
	move.l	#$F01EF01E,d1
	or.l	d1,$278(a6)
	or.l	d1,$27C(a6)
	or.l	d1,$318(a6)
	or.l	d1,$31C(a6)
	or.l	d1,$3B8(a6)
	or.l	d1,$3BC(a6)
	or.l	d1,$458(a6)
	or.l	d1,$45C(a6)
	or.l	d1,$4F8(a6)
	or.l	d1,$4FC(a6)
	or.l	d1,$598(a6)
	or.l	d1,$59C(a6)
	or.l	d1,$638(a6)
	or.l	d1,$63C(a6)
	or.l	d1,$6D8(a6)
	or.l	d1,$6DC(a6)
	or.l	d1,$778(a6)
	or.l	d1,$77C(a6)
	or.l	d1,$818(a6)
	or.l	d1,$81C(a6)
	or.l	d1,$8B8(a6)
	or.l	d1,$8BC(a6)
	move.l	#$F1CEF1CE,d1
	or.l	d1,$958(a6)
	or.l	d1,$95C(a6)
	move.l	#$F2F6F2F6,d1
	or.l	d1,$9F8(a6)
	or.l	d1,$9FC(a6)
	move.l	#$F07AF07A,d1
	or.l	d1,$A98(a6)
	or.l	d1,$A9C(a6)
	move.l	#$F03CF03C,d1
	or.l	d1,$B38(a6)
	or.l	d1,$B3C(a6)
	move.l	#$781E781E,d1
	or.l	d1,$BD8(a6)
	or.l	d1,$BDC(a6)
	move.l	#$782E782E,d1
	or.l	d1,$C78(a6)
	or.l	d1,$C7C(a6)
	move.l	#$3C763C76,d1
	or.l	d1,$D18(a6)
	or.l	d1,$D1C(a6)
	or.l	d0,$DB8(a6)
	or.l	d0,$DBC(a6)
	rts
sprr
	move.l	#$FBE0FBE0,d0
	or.l	d0,(a6)+
	or.l	d0,(a6)+
	move.l	#$78787878,d0
	or.l	d0,$98(a6)
	or.l	d0,$9C(a6)
	move.l	#$783C783C,d1
	or.l	d1,$138(a6)
	or.l	d1,$13C(a6)
	or.l	d1,$1D8(a6)
	or.l	d1,$1DC(a6)
	move.l	#$781E781E,d2
	or.l	d2,$278(a6)
	or.l	d2,$27C(a6)
	or.l	d2,$318(a6)
	or.l	d2,$31C(a6)
	or.l	d2,$3B8(a6)
	or.l	d2,$3BC(a6)
	or.l	d2,$458(a6)
	or.l	d2,$45C(a6)
	or.l	d1,$4F8(a6)
	or.l	d1,$4FC(a6)
	or.l	d1,$598(a6)
	or.l	d1,$59C(a6)
	or.l	d0,$638(a6)
	or.l	d0,$63C(a6)
	move.l	#$7BF07BF0,d2
	or.l	d2,$6D8(a6)
	or.l	d2,$6DC(a6)
	move.l	#$78F878F8,d2
	or.l	d2,$778(a6)
	or.l	d2,$77C(a6)
	or.l	d0,$818(a6)
	or.l	d0,$81C(a6)
	or.l	d1,$8B8(a6)
	or.l	d1,$8BC(a6)
	or.l	d1,$958(a6)
	or.l	d1,$95C(a6)
	or.l	d1,$9F8(a6)
	or.l	d1,$9FC(a6)
	or.l	d1,$A98(a6)
	or.l	d1,$A9C(a6)
	or.l	d1,$B38(a6)
	or.l	d1,$B3C(a6)
	or.l	d1,$BD8(a6)
	or.l	d1,$BDC(a6)
	or.l	d1,$C78(a6)
	or.l	d1,$C7C(a6)
	or.l	d1,$D18(a6)
	or.l	d1,$D1C(a6)
	move.l	#$FC7EFC7E,d0
	or.l	d0,$DB8(a6)
	or.l	d0,$DBC(a6)
	rts
sprs
	move.l	#$1DFE1DFE,d0
	or.l	d0,(a6)+
	or.l	d0,(a6)+
	move.l	#$7C0E7C0E,d0
	or.l	d0,$98(a6)
	or.l	d0,$9C(a6)
	move.l	#$78067806,d0
	or.l	d0,$138(a6)
	or.l	d0,$13C(a6)
	move.l	#$F002F002,d0
	or.l	d0,$1D8(a6)
	or.l	d0,$1DC(a6)
	or.l	d0,$278(a6)
	or.l	d0,$27C(a6)
	move.l	#$F000F000,d0
	or.l	d0,$318(a6)
	or.l	d0,$31C(a6)
	or.l	d0,$3B8(a6)
	or.l	d0,$3BC(a6)
	or.l	d0,$458(a6)
	or.l	d0,$45C(a6)
	or.l	d0,$4F8(a6)
	or.l	d0,$4FC(a6)
	move.l	#$78007800,d0
	or.l	d0,$598(a6)
	or.l	d0,$59C(a6)
	move.l	#$7C007C00,d0
	or.l	d0,$638(a6)
	or.l	d0,$63C(a6)
	move.l	#$1DF01DF0,d0
	or.l	d0,$6D8(a6)
	or.l	d0,$6DC(a6)
	move.l	#$7C007C,d0
	or.l	d0,$778(a6)
	or.l	d0,$77C(a6)
	move.l	#$3C003C,d0
	or.l	d0,$818(a6)
	or.l	d0,$81C(a6)
	move.l	#$1E001E,d0
	or.l	d0,$8B8(a6)
	or.l	d0,$8BC(a6)
	or.l	d0,$958(a6)
	or.l	d0,$95C(a6)
	or.l	d0,$9F8(a6)
	or.l	d0,$9FC(a6)
	or.l	d0,$A98(a6)
	or.l	d0,$A9C(a6)
	move.l	#$801E801E,d0
	or.l	d0,$B38(a6)
	or.l	d0,$B3C(a6)
	or.l	d0,$BD8(a6)
	or.l	d0,$BDC(a6)
	move.l	#$C03CC03C,d0
	or.l	d0,$C78(a6)
	or.l	d0,$C7C(a6)
	move.l	#$E07CE07C,d0
	or.l	d0,$D18(a6)
	or.l	d0,$D1C(a6)
	move.l	#$FDF0FDF0,d0
	or.l	d0,$DB8(a6)
	or.l	d0,$DBC(a6)
	rts
sprt
	move.l	#$7FDE7FDE,d0
	or.l	d0,(a6)+
	or.l	d0,(a6)+
	move.l	#$73CE73CE,d0
	or.l	d0,$98(a6)
	or.l	d0,$9C(a6)
	move.l	#$63C663C6,d0
	or.l	d0,$138(a6)
	or.l	d0,$13C(a6)
	move.l	#$43C243C2,d0
	or.l	d0,$1D8(a6)
	or.l	d0,$1DC(a6)
	or.l	d0,$278(a6)
	or.l	d0,$27C(a6)
	move.l	#$3C003C0,d0
	or.l	d0,$318(a6)
	or.l	d0,$31C(a6)
	or.l	d0,$3B8(a6)
	or.l	d0,$3BC(a6)
	or.l	d0,$458(a6)
	or.l	d0,$45C(a6)
	or.l	d0,$4F8(a6)
	or.l	d0,$4FC(a6)
	or.l	d0,$598(a6)
	or.l	d0,$59C(a6)
	or.l	d0,$638(a6)
	or.l	d0,$63C(a6)
	or.l	d0,$6D8(a6)
	or.l	d0,$6DC(a6)
	or.l	d0,$778(a6)
	or.l	d0,$77C(a6)
	or.l	d0,$818(a6)
	or.l	d0,$81C(a6)
	or.l	d0,$8B8(a6)
	or.l	d0,$8BC(a6)
	or.l	d0,$958(a6)
	or.l	d0,$95C(a6)
	or.l	d0,$9F8(a6)
	or.l	d0,$9FC(a6)
	or.l	d0,$A98(a6)
	or.l	d0,$A9C(a6)
	or.l	d0,$B38(a6)
	or.l	d0,$B3C(a6)
	or.l	d0,$BD8(a6)
	or.l	d0,$BDC(a6)
	or.l	d0,$C78(a6)
	or.l	d0,$C7C(a6)
	or.l	d0,$D18(a6)
	or.l	d0,$D1C(a6)
	move.l	#$FF00FF0,d0
	or.l	d0,$DB8(a6)
	or.l	d0,$DBC(a6)
	rts
spru
	move.l	#$FC7EFC7E,d0
	or.l	d0,(a6)+
	or.l	d0,(a6)+
	move.l	#$783C783C,d0
	or.l	d0,$98(a6)
	or.l	d0,$9C(a6)
	or.l	d0,$138(a6)
	or.l	d0,$13C(a6)
	or.l	d0,$1D8(a6)
	or.l	d0,$1DC(a6)
	or.l	d0,$278(a6)
	or.l	d0,$27C(a6)
	or.l	d0,$318(a6)
	or.l	d0,$31C(a6)
	or.l	d0,$3B8(a6)
	or.l	d0,$3BC(a6)
	or.l	d0,$458(a6)
	or.l	d0,$45C(a6)
	or.l	d0,$4F8(a6)
	or.l	d0,$4FC(a6)
	or.l	d0,$598(a6)
	or.l	d0,$59C(a6)
	or.l	d0,$638(a6)
	or.l	d0,$63C(a6)
	or.l	d0,$6D8(a6)
	or.l	d0,$6DC(a6)
	or.l	d0,$778(a6)
	or.l	d0,$77C(a6)
	or.l	d0,$818(a6)
	or.l	d0,$81C(a6)
	or.l	d0,$8B8(a6)
	or.l	d0,$8BC(a6)
	or.l	d0,$958(a6)
	or.l	d0,$95C(a6)
	or.l	d0,$9F8(a6)
	or.l	d0,$9FC(a6)
	or.l	d0,$A98(a6)
	or.l	d0,$A9C(a6)
	or.l	d0,$B38(a6)
	or.l	d0,$B3C(a6)
	move.l	#$38383838,d0
	or.l	d0,$BD8(a6)
	or.l	d0,$BDC(a6)
	move.l	#$3C783C78,d0
	or.l	d0,$C78(a6)
	or.l	d0,$C7C(a6)
	move.l	#$1EF01EF0,d0
	or.l	d0,$D18(a6)
	or.l	d0,$D1C(a6)
	move.l	#$6C006C0,d0
	or.l	d0,$DB8(a6)
	or.l	d0,$DBC(a6)
	rts
sprv
	move.l	#$F07EF07E,d0
	or.l	d0,(a6)+
	or.l	d0,(a6)+
	move.l	#$603C603C,d0
	or.l	d0,$98(a6)
	or.l	d0,$9C(a6)
	or.l	d0,$138(a6)
	or.l	d0,$13C(a6)
	move.l	#$60386038,d0
	or.l	d0,$1D8(a6)
	or.l	d0,$1DC(a6)
	move.l	#$30783078,d0
	or.l	d0,$278(a6)
	or.l	d0,$27C(a6)
	or.l	d0,$318(a6)
	or.l	d0,$31C(a6)
	or.l	d0,$3B8(a6)
	or.l	d0,$3BC(a6)
	move.l	#$30703070,d0
	or.l	d0,$458(a6)
	or.l	d0,$45C(a6)
	move.l	#$18701870,d0
	or.l	d0,$4F8(a6)
	or.l	d0,$4FC(a6)
	move.l	#$18F018F0,d0
	or.l	d0,$598(a6)
	or.l	d0,$59C(a6)
	or.l	d0,$638(a6)
	or.l	d0,$63C(a6)
	or.l	d0,$6D8(a6)
	or.l	d0,$6DC(a6)
	move.l	#$CE00CE0,d0
	or.l	d0,$778(a6)
	or.l	d0,$77C(a6)
	or.l	d0,$818(a6)
	or.l	d0,$81C(a6)
	or.l	d0,$8B8(a6)
	or.l	d0,$8BC(a6)
	move.l	#$DE00DE0,d0
	or.l	d0,$958(a6)
	or.l	d0,$95C(a6)
	move.l	#$5C005C0,d0
	or.l	d0,$9F8(a6)
	or.l	d0,$9FC(a6)
	or.l	d0,$A98(a6)
	or.l	d0,$A9C(a6)
	or.l	d0,$B38(a6)
	or.l	d0,$B3C(a6)
	or.l	d0,$BD8(a6)
	or.l	d0,$BDC(a6)
	move.l	#$1800180,d0
	or.l	d0,$C78(a6)
	or.l	d0,$C7C(a6)
	or.l	d0,$D18(a6)
	or.l	d0,$D1C(a6)
	or.l	d0,$DB8(a6)
	or.l	d0,$DBC(a6)
	rts
sprw
	move.l	#$FC7EFC7E,d0
	or.l	d0,(a6)+
	or.l	d0,(a6)+
	move.l	#$783C783C,d0
	or.l	d0,$98(a6)
	or.l	d0,$9C(a6)
	or.l	d0,$138(a6)
	or.l	d0,$13C(a6)
	or.l	d0,$1D8(a6)
	or.l	d0,$1DC(a6)
	or.l	d0,$278(a6)
	or.l	d0,$27C(a6)
	or.l	d0,$318(a6)
	or.l	d0,$31C(a6)
	or.l	d0,$3B8(a6)
	or.l	d0,$3BC(a6)
	or.l	d0,$458(a6)
	or.l	d0,$45C(a6)
	or.l	d0,$4F8(a6)
	or.l	d0,$4FC(a6)
	or.l	d0,$598(a6)
	or.l	d0,$59C(a6)
	or.l	d0,$638(a6)
	or.l	d0,$63C(a6)
	move.l	#$793C793C,d0
	or.l	d0,$6D8(a6)
	or.l	d0,$6DC(a6)
	or.l	d0,$778(a6)
	or.l	d0,$77C(a6)
	move.l	#$7BBC7BBC,d0
	or.l	d0,$818(a6)
	or.l	d0,$81C(a6)
	or.l	d0,$8B8(a6)
	or.l	d0,$8BC(a6)
	move.l	#$3BF83BF8,d0
	or.l	d0,$958(a6)
	or.l	d0,$95C(a6)
	move.l	#$3AF83AF8,d0
	or.l	d0,$9F8(a6)
	or.l	d0,$9FC(a6)
	or.l	d0,$A98(a6)
	or.l	d0,$A9C(a6)
	move.l	#$38783878,d0
	or.l	d0,$B38(a6)
	or.l	d0,$B3C(a6)
	or.l	d0,$BD8(a6)
	or.l	d0,$BDC(a6)
	or.l	d0,$C78(a6)
	or.l	d0,$C7C(a6)
	move.l	#$38383838,d0
	or.l	d0,$D18(a6)
	or.l	d0,$D1C(a6)
	or.l	d0,$DB8(a6)
	or.l	d0,$DBC(a6)
	rts
sprx
	move.l	#$F07EF07E,d0
	or.l	d0,(a6)+
	or.l	d0,(a6)+
	move.l	#$603C603C,d0
	or.l	d0,$98(a6)
	or.l	d0,$9C(a6)
	move.l	#$703C703C,d0
	or.l	d0,$138(a6)
	or.l	d0,$13C(a6)
	move.l	#$30783078,d0
	or.l	d0,$1D8(a6)
	or.l	d0,$1DC(a6)
	move.l	#$38783878,d0
	or.l	d0,$278(a6)
	or.l	d0,$27C(a6)
	move.l	#$18F018F0,d0
	or.l	d0,$318(a6)
	or.l	d0,$31C(a6)
	move.l	#$1CF01CF0,d0
	or.l	d0,$3B8(a6)
	or.l	d0,$3BC(a6)
	move.l	#$DE00DE0,d0
	or.l	d0,$458(a6)
	or.l	d0,$45C(a6)
	move.l	#$EE00EE0,d0
	or.l	d0,$4F8(a6)
	or.l	d0,$4FC(a6)
	move.l	#$6C006C0,d0
	or.l	d0,$598(a6)
	or.l	d0,$59C(a6)
	move.l	#$7400740,d0
	or.l	d0,$638(a6)
	or.l	d0,$63C(a6)
	move.l	#$3000300,d0
	or.l	d0,$6D8(a6)
	or.l	d0,$6DC(a6)
	move.l	#$7800780,d0
	or.l	d0,$778(a6)
	or.l	d0,$77C(a6)
	or.l	d0,$818(a6)
	or.l	d0,$81C(a6)
	move.l	#$FC00FC0,d0
	or.l	d0,$8B8(a6)
	or.l	d0,$8BC(a6)
	or.l	d0,$958(a6)
	or.l	d0,$95C(a6)
	move.l	#$1EE01EE0,d0
	or.l	d0,$9F8(a6)
	or.l	d0,$9FC(a6)
	move.l	#$1E701E70,d0
	or.l	d0,$A98(a6)
	or.l	d0,$A9C(a6)
	move.l	#$3C703C70,d0
	or.l	d0,$B38(a6)
	or.l	d0,$B3C(a6)
	move.l	#$3C383C38,d0
	or.l	d0,$BD8(a6)
	or.l	d0,$BDC(a6)
	move.l	#$78387838,d0
	or.l	d0,$C78(a6)
	or.l	d0,$C7C(a6)
	move.l	#$781C781C,d0
	or.l	d0,$D18(a6)
	or.l	d0,$D1C(a6)
	move.l	#$FC3EFC3E,d0
	or.l	d0,$DB8(a6)
	or.l	d0,$DBC(a6)
	rts
spry
	move.l	#$F07EF07E,d0
	or.l	d0,(a6)+
	or.l	d0,(a6)+
	move.l	#$603C603C,d0
	or.l	d0,$98(a6)
	or.l	d0,$9C(a6)
	or.l	d0,$138(a6)
	or.l	d0,$13C(a6)
	move.l	#$30783078,d0
	or.l	d0,$1D8(a6)
	or.l	d0,$1DC(a6)
	or.l	d0,$278(a6)
	or.l	d0,$27C(a6)
	move.l	#$18F018F0,d0
	or.l	d0,$318(a6)
	or.l	d0,$31C(a6)
	or.l	d0,$3B8(a6)
	or.l	d0,$3BC(a6)
	move.l	#$1CE01CE0,d0
	or.l	d0,$458(a6)
	or.l	d0,$45C(a6)
	move.l	#$DE00DE0,d0
	or.l	d0,$4F8(a6)
	or.l	d0,$4FC(a6)
	move.l	#$DC00DC0,d0
	or.l	d0,$598(a6)
	or.l	d0,$59C(a6)
	move.l	#$3C003C0,d0
	or.l	d0,$638(a6)
	or.l	d0,$63C(a6)
	move.l	#$3800380,d0
	or.l	d0,$6D8(a6)
	or.l	d0,$6DC(a6)
	move.l	#$7800780,d0
	or.l	d0,$778(a6)
	or.l	d0,$77C(a6)
	or.l	d0,$818(a6)
	or.l	d0,$81C(a6)
	move.l	#$F000F00,d0
	or.l	d0,$8B8(a6)
	or.l	d0,$8BC(a6)
	or.l	d0,$958(a6)
	or.l	d0,$95C(a6)
	move.l	#$1E001E00,d0
	or.l	d0,$9F8(a6)
	or.l	d0,$9FC(a6)
	or.l	d0,$A98(a6)
	or.l	d0,$A9C(a6)
	move.l	#$3C003C00,d0
	or.l	d0,$B38(a6)
	or.l	d0,$B3C(a6)
	or.l	d0,$BD8(a6)
	or.l	d0,$BDC(a6)
	move.l	#$78007800,d0
	or.l	d0,$C78(a6)
	or.l	d0,$C7C(a6)
	or.l	d0,$D18(a6)
	or.l	d0,$D1C(a6)
	move.l	#$FC00FC00,d0
	or.l	d0,$DB8(a6)
	or.l	d0,$DBC(a6)
	rts
sprz
	move.l	#$FFBEFFBE,d0
	or.l	d0,(a6)+
	or.l	d0,(a6)+
	move.l	#$E03CE03C,d0
	or.l	d0,$98(a6)
	or.l	d0,$9C(a6)
	move.l	#$C03CC03C,d0
	or.l	d0,$138(a6)
	or.l	d0,$13C(a6)
	move.l	#$80788078,d0
	or.l	d0,$1D8(a6)
	or.l	d0,$1DC(a6)
	or.l	d0,$278(a6)
	or.l	d0,$27C(a6)
	move.l	#$F000F0,d0
	or.l	d0,$318(a6)
	or.l	d0,$31C(a6)
	or.l	d0,$3B8(a6)
	or.l	d0,$3BC(a6)
	move.l	#$1E001E0,d0
	or.l	d0,$458(a6)
	or.l	d0,$45C(a6)
	or.l	d0,$4F8(a6)
	or.l	d0,$4FC(a6)
	move.l	#$3C003C0,d0
	or.l	d0,$598(a6)
	or.l	d0,$59C(a6)
	or.l	d0,$638(a6)
	or.l	d0,$63C(a6)
	move.l	#$7800780,d0
	or.l	d0,$6D8(a6)
	or.l	d0,$6DC(a6)
	or.l	d0,$778(a6)
	or.l	d0,$77C(a6)
	move.l	#$F000F00,d0
	or.l	d0,$818(a6)
	or.l	d0,$81C(a6)
	or.l	d0,$8B8(a6)
	or.l	d0,$8BC(a6)
	move.l	#$1E001E00,d0
	or.l	d0,$958(a6)
	or.l	d0,$95C(a6)
	or.l	d0,$9F8(a6)
	or.l	d0,$9FC(a6)
	move.l	#$3C003C00,d0
	or.l	d0,$A98(a6)
	or.l	d0,$A9C(a6)
	move.l	#$3C023C02,d0
	or.l	d0,$B38(a6)
	or.l	d0,$B3C(a6)
	move.l	#$78027802,d0
	or.l	d0,$BD8(a6)
	or.l	d0,$BDC(a6)
	move.l	#$78067806,d0
	or.l	d0,$C78(a6)
	or.l	d0,$C7C(a6)
	move.l	#$F00EF00E,d0
	or.l	d0,$D18(a6)
	or.l	d0,$D1C(a6)
	move.l	#$F7FEF7FE,d0
	or.l	d0,$DB8(a6)
	or.l	d0,$DBC(a6)
	rts
