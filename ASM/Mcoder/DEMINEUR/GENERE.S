	lea	(176-$91-16+4+1)*160+24(a6),a6
;
; affichage du rocher
;
	MOVE.L	#$FFE3FFFF,(A6)+
	MOVE.L	#$FFFF007D,(A6)+
	MOVE.L	#$EDFE9FFE,(A6)+
	MOVE.L	#$FFFFF65F,(A6)+
	MOVE.L	#$181F3C07,(A6)+
	MOVEM.L	L512CA(PC),D0-D7/A0-A3
	MOVE.L	A0,(A6)+
	AND.L	D0,(A6)
	OR.L	D1,(A6)+
	OR.L	D2,(A6)+
	LEA	$80(A6),A6
	MOVE.L	A1,(A6)+
	MOVE.L	#$FFFF003C,(A6)+
	MOVE.L	#$FCF8CFF8,(A6)+
	MOVE.L	#$FFFFF73F,(A6)+
	MOVE.L	#$381F1807,(A6)+
	MOVE.L	A0,(A6)+
	OR	D3,(A6)
	AND.L	D4,(A6)+
	OR.L	D2,(A6)+
	LEA	$80(A6),A6
	MOVE.L	A1,(A6)+
	MOVE.L	#$FFFF001C,(A6)+
	MOVE.L	#$FFF4FFFC,(A6)+
	MOVE.L	#$FFFF677F,(A6)+
	MOVE.L	#$3C1F1C07,(A6)+
	MOVE.L	A0,(A6)+
	AND.L	D0,(A6)
	OR.L	D5,(A6)+
	OR.L	D2,(A6)+
	LEA	$80(A6),A6
	MOVE.L	A1,(A6)+
	MOVE.L	#$FFFF019C,(A6)+
	MOVE.L	#$FFF2FFEE,(A6)+
	MOVE.L	#$FFFF067F,(A6)+
	MOVE.L	#$2E7F163F,(A6)+
	MOVE.L	#$FFFFFFC3,(A6)+
	AND.L	D0,(A6)+
	OR.L	D2,(A6)+
	LEA	$80(A6),A6
	MOVE.L	A2,(A6)+
	MOVE.L	#$FFFF0180,(A6)+
	MOVE.L	#$FFF9FFC7,(A6)+
	MOVE.L	D6,(A6)+
	MOVE.L	#$3F7F077E,(A6)+
	MOVE.L	#$FFFFFF87,(A6)+
	OR	D1,(A6)
	AND.L	#$8FFF0FFF,(A6)+
	OR.L	D2,(A6)+
	LEA	$80(A6),A6
	MOVE.L	A2,(A6)+
	MOVE.L	A3,(A6)+
	MOVE.L	#$FFDFFC3,(A6)+
	MOVE.L	#$FFFFF07E,(A6)+
	MOVE.L	#$BFDF83DA,(A6)+
	MOVE.L	#$FFFFFF27,(A6)+
	OR	D3,(A6)
	AND.L	D4,(A6)+
	OR.L	D2,(A6)+
	LEA	$80(A6),A6
	MOVE.L	A2,(A6)+
	MOVE.L	A3,(A6)+
	MOVE.L	#$CFFF3FCF,(A6)+
	MOVE.L	#$FFFFF07F,(A6)+
	MOVE.L	#$7F93C311,(A6)+
	MOVE.L	#$FFFFBFEF,(A6)+
	OR	D2,(A6)+
	AND	D0,(A6)+
	OR.L	D2,(A6)+
	LEA	$80(A6),A6
	MOVE.L	A2,(A6)+
	MOVE.L	A3,(A6)+
	MOVE.L	#$FFFE0FFF,(A6)+
	MOVE.L	#$FFFFF07F,(A6)+
	MOVE.L	#$BE117E10,(A6)+
	MOVE.L	#$FFFFCFFF,(A6)+
	OR	D3,(A6)+
	AND	#$1FFF,(A6)
	OR.L	D3,(A6)+
	OR	D3,(A6)+
	LEA	$80(A6),A6
	MOVE.L	#$FF3FFFFF,(A6)+
	MOVE.L	#$FFFF03C1,(A6)+
	MOVE.L	#$FFE40FE3,(A6)+
	MOVE.L	#$FFFFF03F,(A6)+
	MOVE.L	#$7C083C10,(A6)+
	MOVE.L	#$FFFFDFFF,(A6)+
	MOVEM.L	L512FA(PC),D0-D1/D3-D4/A0-A1/A3
	AND.L	D3,(A6)+
	OR.L	D5,(A6)+
	LEA	$80(A6),A6
	MOVE.L	#$FF3DFFFF,(A6)+
	MOVE.L	#$FFFF03C3,(A6)+
	MOVE.L	#$FDA40E62,(A6)+
	MOVE.L	#$FFFFF3FF,(A6)+
	MOVE.L	#$78083800,(A6)+
	MOVE.L	#$FFFFF7FF,(A6)+
	AND.L	#$3FFF3FFF,(A6)+
	OR.L	D1,(A6)+
	LEA	$80(A6),A6
	MOVE.L	#$FF39FFFF,(A6)+
	MOVE.L	#$FFFF03C7,(A6)+
	MOVE.L	#$FCD40E32,(A6)+
	MOVE.L	#$FFFFF3FF,(A6)+
	MOVE.L	#$78047800,(A6)+
	MOVE.L	#$FFFFE7FF,(A6)+
	AND.L	#$3FFF3FFF,(A6)+
	OR.L	D1,(A6)+
	LEA	$80(A6),A6
	MOVE.L	#$FF31FFFF,(A6)+
	MOVE.L	#$FFFF03CF,(A6)+
	MOVE.L	#$FC6EFC1A,(A6)+
	MOVE.L	#$FFFFF7FF,(A6)+
	MOVE.L	#$60007C00,(A6)+
	MOVE.L	#$FFFFDFFF,(A6)+
	AND.L	#$3FFF3FFF,(A6)+
	OR.L	D1,(A6)+
	LEA	$80(A6),A6
	MOVE.L	#$FF33FFFF,(A6)+
	MOVE.L	#$FFFF03CF,(A6)+
	MOVE.L	#$FC37FC0F,(A6)+
	MOVE.L	#$FFFFF7F9,(A6)+
	MOVE.L	#$F0009E00,(A6)+
	MOVE.L	A2,(A6)+
	AND.L	D3,(A6)+
	OR.L	D5,(A6)+
	LEA	$80(A6),A6
	MOVE.L	#$FF7FFFFF,(A6)+
	MOVE.L	#$FFFF03CE,(A6)+
	MOVE.L	#$F83FF80E,(A6)+
	MOVE.L	#$FFFF07F7,(A6)+
	MOVE.L	#$F8000F00,(A6)+
	MOVE.L	A2,(A6)+
	LEA	$88(A6),A6
	MOVE.L	#$FF7FFFFF,(A6)+
	MOVE.L	#$FFFF038C,(A6)+
	MOVE.L	#$BC3ECC0E,(A6)+
	MOVE.L	#$FFFF73F7,(A6)+
	AND.L	#$30003,(A6)
	OR.L	#$FC000780,(A6)+
	OR.L	#$FFFCFFFC,(A6)+
	LEA	$88(A6),A6
	MOVE.L	A2,(A6)+
	MOVE.L	#$FFFF0380,(A6)+
	MOVE.L	#$9E3EC60E,(A6)+
	MOVE.L	#$FFFF79F7,(A6)+
	AND.L	#$70007,(A6)
	OR.L	#$7F400380,(A6)+
	OR.L	#$FFF8FFF8,(A6)+
	LEA	$88(A6),A6
	MOVE.L	A2,(A6)+
	MOVE.L	#$FFFF0300,(A6)+
	MOVE.L	#$8F3EC30E,(A6)+
	MOVE.L	#$FFFF7CF7,(A6)+
	AND.L	#$F000F,(A6)
	OR.L	#$3F0003F0,(A6)+
	OR	#$FFF0,(A6)+
	AND	#$F,(A6)
	OR	#$FDF0,(A6)+
	LEA	$88(A6),A6
	MOVE.L	A2,(A6)+
	MOVE.L	#$FFFF0300,(A6)+
	MOVE.L	#$87C2E3FE,(A6)+
	MOVE.L	#$FFFF7C3F,(A6)+
	AND.L	#$1F001F,(A6)
	OR.L	#$1BC00600,(A6)+
	OR	#$FFE0,(A6)+
	AND	#$1F,(A6)
	OR	#$FDE0,(A6)+
	LEA	$88(A6),A6
	MOVE.L	#$FFC7FFFF,(A6)+
	MOVE.L	#$FFFF0438,(A6)+
	MOVE.L	#$C7C0F3F0,(A6)+
	MOVE.L	#$FFFF3C3F,(A6)+
	AND.L	#$1F001F,(A6)
	OR.L	#$34000C00,(A6)+
	OR	#$FFE0,(A6)+
	AND	#$1F,(A6)
	OR	#$FBE0,(A6)+
	LEA	$88(A6),A6
	MOVE.L	#$FBC7FFFF,(A6)+
	MOVE.L	#$FFFF0C78,(A6)+
	MOVE.L	#$E3C0FE70,(A6)+
	MOVE.L	#$FFFF1DBF,(A6)+
	AND.L	#$1F001F,(A6)
	OR.L	#$68001800,(A6)+
	OR	#$FFE0,(A6)+
	AND	#$1F,(A6)
	OR	#$F7E0,(A6)+
	LEA	$88(A6),A6
	MOVE.L	#$FBC5FFFE,(A6)+
	MOVE.L	#$FFFF0CFF,(A6)+
	MOVE.L	#$21C0F070,(A6)+
	MOVE.L	#$FFFFDFBF,(A6)+
	AND.L	#$3F003F,(A6)
	OR.L	#$D0003000,(A6)+
	OR	#$FFC0,(A6)+
	AND	#$3F,(A6)
	OR	#$EFC0,(A6)+
	LEA	$88(A6),A6
	MOVE.L	#$FBC5FFFE,(A6)+
	MOVE.L	#$FFFF0CFF,(A6)+
	MOVE.L	#$A1DF7060,(A6)+
	MOVE.L	#$FFFFDFBF,(A6)+
	AND.L	#$7F007F,(A6)
	OR.L	#$A0006000,(A6)+
	OR	#$FF80,(A6)+
	AND	D6,(A6)
	OR	#$DF80,(A6)+
	LEA	$88(A6),A6
	MOVE.L	#$FFFDFFFE,(A6)+
	MOVE.L	#$FFFF18FF,(A6)+
	MOVE.L	#$A3FF73FF,(A6)+
	MOVE.L	#$FFFFDC0F,(A6)+
	MOVEP.L	D7,0(A6)
	LEA	$90(A6),A6
	MOVE.L	#$FFFDFFFE,D7
	MOVE.L	D7,(A6)+
	MOVE.L	#$FFFF1807,(A6)+
	MOVE.L	#$BFFF7FFF,(A6)+
	MOVE.L	#$FFFFCDFF,(A6)+
	MOVEP.L	D4,0(A6)
	LEA	$90(A6),A6
	MOVE.L	#$FFFCFFFF,(A6)+
	MOVE.L	#$FFFF1007,(A6)+
	MOVE.L	#$7F01C601,(A6)+
	MOVE.L	#$FFFFBDFF,(A6)+
	MOVEP.L	D4,0(A6)
	LEA	$90(A6),A6
	MOVE.L	A2,(A6)+
;
; OPTIMISATION :
;	D4 UTILISE UNE SEULE FOIS !!!
;
	MOVE.L	#$FFFF0007,D4
	MOVE.L	D4,(A6)+

	MOVE.L	#$8F00C600,(A6)+
	MOVE.L	A0,(A6)+
	MOVEP.L	D0,0(A6)
	LEA	$90(A6),A6
	MOVE.L	#$FF9FFFFF,(A6)+
	MOVE.L	#$FFFF00E0,(A6)+
	MOVE.L	#$8FC0C7E0,(A6)+
	MOVE.L	#$FFFF7C7F,(A6)+
	MOVE.L	#$1FF01FF,D0
	MOVE.L	#$FE00FE00,D4
	AND.L	D0,(A6)
	OR.L	#$1E007000,(A6)+
	OR.L	D4,(A6)+
	LEA	$88(A6),A6
	MOVE.L	#$FF1FFFFC,(A6)+
	MOVE.L	A1,(A6)+
	MOVE.L	#$8E00C710,(A6)+
	MOVE.L	A0,(A6)+
	AND.L	D3,(A6)+
	OR.L	D5,(A6)+
	LEA	$88(A6),A6
	MOVE.L	#$FF3FFFDC,(A6)+
	MOVE.L	A1,(A6)+
	MOVE.L	#$8E08E700,(A6)+
	MOVE.L	A0,(A6)+
	AND.L	D3,(A6)+
	OR.L	D5,(A6)+
	LEA	$88(A6),A6
	MOVE.L	#$FF7CFF9F,(A6)+
	MOVE.L	A1,(A6)+
	MOVE.L	#$8600FF80,(A6)+
	MOVE.L	A0,(A6)+
	AND.L	D3,(A6)+
	OR.L	D5,(A6)+
	LEA	$88(A6),A6
	MOVE.L	#$FFFFFF1F,(A6)+
	MOVE.L	#$FFFF11E0,(A6)+
	MOVE.L	#$C600FFC0,(A6)+
	MOVE.L	#$FFFF3DFF,(A6)+
	AND.L	D3,(A6)+
	OR.L	D5,(A6)+
	LEA	$88(A6),A6
	MOVE.L	#$E7FFFF38,(A6)+
	MOVE.L	#$FFFF19E7,(A6)+
	MOVE.L	#$FF007FE0,(A6)+
	MOVE.L	#$FFFF80FF,(A6)+
	AND.L	D3,(A6)+
	OR.L	D5,(A6)+
	LEA	$88(A6),A6
	MOVE.L	#$E7F1FFF0,(A6)+
	MOVE.L	#$FFFF19CF,(A6)+
	MOVE.L	#$FF807FF0,(A6)+
	MOVE.L	#$FFFF807F,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$F7E1FFE0,(A6)+
	MOVE.L	#$FFFF199F,(A6)+
	AND.L	#$10001,(A6)
	OR.L	#$FFC27F7C,(A6)+
	OR	D7,(A6)+
	AND	#1,(A6)
	OR	#$80BE,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FFC3FFC0,(A6)+
	MOVE.L	#$FFFF183F,(A6)+
	AND.L	#$F000F,(A6)
	OR.L	#$EFF06330,(A6)+
	OR	#$FFF0,(A6)+
	AND	#$F,(A6)
	OR	#$9CF0,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FF87FFC0,(A6)+
	MOVE.L	D6,(A6)+
	AND.L	#$3F003F,(A6)
	OR.L	#$E740E100,(A6)+
	OR	#$FFC0,(A6)+
	AND	#$3F,(A6)
	OR	#$3FC0,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FF87FFC1,(A6)+
	MOVE.L	#$FFFF007E,(A6)+
	AND.L	#$7F007F,(A6)
	OR.L	#$E300A100,(A6)+
	OR	#$FF80,(A6)+
	AND	D6,(A6)
	OR	#$7F80,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FF87FFE1,(A6)+
	MOVE.L	#$FFFF007E,(A6)+
	MOVEM.L	L51316(PC),D3/D6-D7/A0
	MOVEP.L	D6,0(A6)
	LEA	$98(A6),A6
	MOVE.L	#$FF87F9F1,(A6)+
	MOVE.L	#$FFFF1E7E,(A6)+
	AND.L	D0,(A6)
	OR.L	#$68009800,(A6)+
	OR.L	D4,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FFD7F9F9,(A6)+
	MOVE.L	#$FFFF1E3E,(A6)+
	AND.L	D0,(A6)
	OR.L	#$30008C00,(A6)+
	OR.L	D4,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$F9F1FFFF,(A6)+
	MOVE.L	#$FFFF1E9E,(A6)+
	AND.L	D0,(A6)
	OR.L	#$18008600,(A6)+
	OR.L	D4,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$F9B1FFFF,(A6)+
	MOVE.L	#$FFFF0ECE,(A6)+
	MOVE.L	#$3FF03FF,D6
	AND.L	D6,(A6)
	OR.L	#$C008000,(A6)+
	OR.L	D7,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FF9FFFFF,(A6)+
	MOVE.L	#$FFFF20E0,(A6)+
	AND	D6,(A6)+
	OR.L	D7,(A6)+
	OR	D7,(A6)+
	LEA	$90(A6),A6
	MOVE.L	A2,(A6)+
	MOVE.L	#$FFFF3C00,(A6)+
	AND	D6,(A6)+
	OR.L	D7,(A6)+
	OR	D7,(A6)+
	LEA	$90(A6),A6
	MOVE.L	A2,(A6)+
	MOVE.L	#$FFFF3C00,(A6)+
	OR.L	#$F800F800,(A6)+
	OR	#$F800,(A6)+
	AND	#$7FF,(A6)
	OR	#$1800,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$E3FFFFFF,(A6)+
	MOVE.L	#$FFFF3CFF,(A6)+
	AND.L	#$7FF07FF,(A6)
	OR.L	D2,(A6)+
	OR	#$F800,(A6)+
	AND	#$7FF,(A6)
	OR	#$B800,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$E3C3FF81,(A6)+
	MOVE.L	#$FFFF3DFF,(A6)+
	AND.L	D6,(A6)
	OR.L	D3,(A6)+
	OR	D7,(A6)+
	AND	D6,(A6)
	OR	#$7C00,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$E7C5FF83,(A6)+
	MOVE.L	#$FFFF39FE,(A6)+
	AND.L	D0,(A6)
	OR.L	D1,(A6)+
	OR.L	D4,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$EFFFFF87,(A6)+
	MOVE.L	#$FFFF31FC,(A6)+
	AND.L	D0,(A6)
	OR.L	#$C000E000,(A6)+
	OR	D4,(A6)+
	AND	D0,(A6)
	OR	#$7E00,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FFFEFFFF,(A6)+
	MOVE.L	#$FFFF0003,(A6)+
	OR	#$1000,(A6)
	AND.L	#$11FF01FF,(A6)+
	OR.L	D4,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FFFEFFFF,(A6)+
	MOVE.L	A0,(A6)+
	AND.L	D6,(A6)+
	OR.L	D7,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FFFEFC1F,(A6)+
	MOVE.L	#$FFFF07E7,(A6)+
	AND.L	#$7FF07FF,(A6)+
	OR.L	#$F800F800,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FFFEFC1F,(A6)+
	MOVE.L	A3,(A6)+
	MOVEM.L	L51326(PC),D0/D4/D6-D7
	AND	D4,(A6)+
	OR.L	D2,(A6)+
	OR	D2,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FE1FFC1F,(A6)+
	MOVE.L	#$FFFF0FE3,(A6)+
	OR.L	D1,(A6)+
	OR.L	D1,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FE1BFC1C,(A6)+
	MOVE.L	A3,(A6)+
	OR	D1,(A6)
	AND.L	D0,(A6)+
	OR.L	D3,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FC1BFFFC,(A6)+
	MOVE.L	A3,(A6)+
	OR	D5,(A6)
	AND.L	D4,(A6)+
	OR.L	D2,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FFF8FFFE,(A6)+
	MOVE.L	A0,(A6)+
	AND.L	D7,(A6)+
	OR.L	D2,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FFFCFE0F,(A6)+
	MOVE.L	#$FFFF01FB,(A6)+
	AND.L	D7,(A6)+
	OR.L	D2,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FE3EFE1F,(A6)+
	MOVE.L	#$FFFF01F3,(A6)+
	AND	D4,(A6)+
	AND	D4,(A6)
	OR.L	#$8000F000,(A6)+
	OR	D2,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FE3FFE39,(A6)+
	MOVE.L	A1,(A6)+
	AND	D4,(A6)+
	AND	D4,(A6)
	OR.L	#$C000F000,(A6)+
	OR	D2,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FF7FFF70,(A6)+
	MOVE.L	#$FFFF11AF,(A6)+
	AND.L	D7,(A6)
	OR.L	D6,(A6)+
	OR.L	D2,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FF6BFFF0,(A6)+
	MOVE.L	#$FFFF30BF,(A6)+
	MOVE.L	#$7FFF7FFF,D2
	MOVE.L	#$3FFF3FFF,D4
	MOVE.L	#$FFFF001F,A1
	AND.L	D4,(A6)
	OR.L	#$80004000,(A6)+
	OR.L	D1,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FFE1FFF0,(A6)+
	MOVE.L	A1,(A6)+
	OR	D1,(A6)+
	AND	D4,(A6)+
	OR.L	D1,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$E7E0FFF0,(A6)+
	MOVE.L	#$FFFF185F,(A6)+
	OR	D3,(A6)+
	AND	D0,(A6)+
	OR.L	D3,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$E760FFF0,(A6)+
	MOVE.L	#$FFFF18DF,(A6)+
	OR	#$6000,(A6)
	AND.L	#$7FFF1FFF,(A6)+
	OR.L	D3,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$E661FFF3,(A6)+
	MOVE.L	#$FFFF19DF,(A6)+
	AND	D0,(A6)
	OR.L	#$C000E000,(A6)+
	OR.L	D3,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FFFFFFFE,(A6)+
	MOVE.L	#$FFFF801F,(A6)+
	OR	D3,(A6)+
	AND	D0,(A6)+
	OR.L	D3,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$7FFFFE3C,(A6)+
	MOVE.L	#$FFFFC1C7,(A6)+
	OR	D3,(A6)+
	AND	D0,(A6)+
	OR.L	D3,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$3FFCFC1C,(A6)+
	MOVE.L	#$FFFFE3E7,(A6)+
	AND.L	#$1FFF1FFF,(A6)+
	OR.L	D3,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$1C7CFC0C,(A6)+
	MOVE.L	#$FFFFE7F7,(A6)+
	AND.L	#$1FFF1FFF,(A6)+
	OR.L	D3,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$3C3CFC0C,(A6)+
	MOVE.L	#$FFFFCFF7,(A6)+
	AND.L	#$1FFF1FFF,(A6)+
	OR.L	D3,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FC0CFC3C,(A6)+
	MOVE.L	#$FFFF0FF7,(A6)+
	AND.L	D4,(A6)+
	OR.L	D1,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FC1CFFFF,(A6)+
	MOVE.L	A3,(A6)+
	AND	D2,(A6)+
	OR.L	D5,(A6)+
	OR	D5,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$F83FFFFF,(A6)+
	MOVE.L	#$FFFF0FCF,(A6)+
	LEA	$98(A6),A6
	AND.L	#$10001,(A6)
	OR.L	#$FFC0FFF0,(A6)+
	OR	#$FFFE,(A6)+
	AND	#1,(A6)
	OR	#$3E,(A6)+
	LEA	$98(A6),A6
	MOVE.L	#$FFC0FFF0,(A6)+
	MOVE.L	#$FFFF003F,(A6)+
	LEA	$98(A6),A6
	MOVE.L	#$FE60FFF8,(A6)+
	MOVE.L	#$FFFF07BF,(A6)+
	AND.L	D2,(A6)+
	OR.L	D5,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FFB0FE7C,(A6)+
	MOVE.L	#$FFFF07DF,(A6)+
	AND.L	D2,(A6)+
	OR.L	D5,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FFF8FE1E,(A6)+
	MOVE.L	#$FFFF07EF,(A6)+
	AND.L	D2,(A6)+
	OR.L	D5,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$1FFEFFFF,(A6)+
	MOVE.L	#$FFFFE7F7,(A6)+
	AND	D2,(A6)+
	OR.L	D5,(A6)+
	OR	D5,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$1FF7FFF8,(A6)+
	MOVE.L	#$FFFFE01F,(A6)+
	OR.L	D5,(A6)+
	OR.L	D5,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$7FF99FF1,(A6)+
	MOVE.L	#$FFFFE01F,(A6)+
	OR	D5,(A6)
	AND.L	#$BFFF3FFF,(A6)+
	OR.L	D1,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$7FFF983E,(A6)+
	MOVE.L	#$FFFFEFC7,(A6)+
	AND.L	D4,(A6)+
	OR.L	D1,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$78FE9830,(A6)+
	MOVE.L	#$FFFFEFDF,(A6)+
	OR	#$4000,(A6)
	AND.L	#$7FFF3FFF,(A6)+
	OR.L	D1,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$F8FC9860,(A6)+
	MOVE.L	#$FFFF6FBF,(A6)+
	OR	D5,(A6)+
	AND	D2,(A6)+
	OR.L	D5,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$F8E1FFE0,(A6)+
	MOVE.L	#$FFFF0F7F,(A6)+
	OR.L	D5,(A6)+
	OR	D5,(A6)+
	AND	D2,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$F9E3FFE1,(A6)+
	MOVE.L	#$FFFF0E7E,(A6)+
	OR.L	D5,(A6)+
	OR.L	D5,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FFE3FFFF,(A6)+
	MOVE.L	#$FFFFC07D,(A6)+
	OR	D5,(A6)+
	AND	D2,(A6)+
	OR.L	D5,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FFC7DFFE,(A6)+
	MOVE.L	#$FFFFE07B,(A6)+
	OR	D5,(A6)
	AND.L	#$BFFF3FFF,(A6)+
	OR.L	D1,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FFFFDC7C,(A6)+
	MOVE.L	#$FFFFEF87,(A6)+
	AND.L	D4,(A6)+
	OR.L	D1,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$DCFEFC38,(A6)+
	MOVE.L	#$FFFF6FC7,(A6)+
	AND.L	D4,(A6)+
	OR.L	D1,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FC78FC18,(A6)+
	MOVE.L	#$FFFF0FEF,(A6)+
	AND.L	D4,(A6)+
	OR.L	D1,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FC3FFC5F,(A6)+
	MOVE.L	#$FFFF0FEF,(A6)+
	OR.L	D1,(A6)+
	OR	D1,(A6)+
	AND	D4,(A6)
	OR	D5,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FE5FFE5F,(A6)+
	MOVE.L	#$FFFF07EF,(A6)+
	MOVE.L	#$1FFF1FFF,D2
	MOVE.L	#$FFFF01DF,A3
	AND.L	D2,(A6)
	OR.L	D5,(A6)+
	OR	D3,(A6)+
	AND	D0,(A6)
	OR	#$6000,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$EF5FFFDF,(A6)+
	MOVE.L	#$FFFF3BE0,(A6)+
	AND.L	D7,(A6)
	OR.L	D5,(A6)+
	OR	#$F000,(A6)+
	AND	D7,(A6)
	OR	#$7000,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$E796FF99,(A6)+
	MOVE.L	#$FFFF3CEF,(A6)+
	AND.L	D7,(A6)
	OR.L	D5,(A6)+
	OR	#$F000,(A6)+
	AND	D7,(A6)
	OR	#$7000,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$E396FF99,(A6)+
	MOVE.L	#$FFFF3DEF,(A6)+
	AND.L	D7,(A6)
	OR.L	#$90008000,(A6)+
	OR	#$F000,(A6)+
	AND	D7,(A6)
	OR	#$7000,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FF90FFFF,(A6)+
	MOVE.L	#$FFFF3DEF,(A6)+
	AND	D0,(A6)
	OR.L	D6,(A6)+
	OR	D3,(A6)+
	AND	D0,(A6)
	OR	#$6000,(A6)+
	LEA	$90(A6),A6
	MOVE.L	A2,(A6)+
	MOVE.L	#$FFFF3C67,(A6)+
	OR.L	D1,(A6)+
	OR	D1,(A6)+
	AND	D4,(A6)
	OR	#$4000,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FFCFFF0C,(A6)+
	MOVE.L	#$FFFF01F3,(A6)+
	OR	D3,(A6)+
	AND	D0,(A6)+
	OR.L	D3,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FF8EFF08,(A6)+
	MOVE.L	#$FFFF01F7,(A6)+
	AND.L	D2,(A6)+
	OR.L	D3,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FF1CE318,(A6)+
	MOVE.L	#$FFFF7FEF,(A6)+
	AND.L	D2,(A6)+
	OR.L	D3,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FFFCE3F8,(A6)+
	MOVE.L	#$FFFF7E1F,(A6)+
	AND.L	D2,(A6)+
	OR.L	D3,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FE38E33F,(A6)+
	MOVE.L	#$FFFF7FDF,(A6)+
	AND	D4,(A6)+
	OR.L	D1,(A6)+
	OR	D1,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FE3FE33F,(A6)+
	MOVE.L	#$FFFF7FDF,(A6)+
	OR.L	D5,(A6)+
	OR.L	D5,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$C2FFFF3F,(A6)+
	MOVE.L	#$FFFF7FC0,(A6)+
	OR.L	D5,(A6)+
	OR	D5,(A6)+
	MOVE.L	#$10001,D2
	MOVE.L	#$7FFF7FFF,D7
	AND	D7,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FFE0FFF0,(A6)+
	MOVE.L	A3,(A6)+
	AND	D4,(A6)+
	AND	D4,(A6)
	OR.L	#$4000C000,(A6)+
	OR	D1,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FFE0F1F8,(A6)+
	MOVE.L	#$FFFF3E3F,(A6)+
	AND.L	D4,(A6)+
	OR.L	D1,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FFF0F99C,(A6)+
	MOVE.L	#$FFFF1E7F,(A6)+
	AND.L	D4,(A6)+
	OR.L	D1,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FFFFFF8F,(A6)+
	MOVE.L	#$FFFF0EFF,(A6)+
	OR.L	D1,(A6)+
	OR.L	D1,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FF9FFF87,(A6)+
	MOVE.L	#$FFFF00FF,(A6)+
	OR.L	D5,(A6)+
	OR.L	D5,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$F18FFF87,(A6)+
	MOVE.L	#$FFFF1EFD,(A6)+
	LEA	$98(A6),A6
	MOVE.L	#$F98FF18E,(A6)+
	MOVE.L	#$FFFF1EFB,(A6)+
	OR	D5,(A6)
	AND.L	#$BFFF3FFF,(A6)+
	OR.L	D1,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$F9FFF1FC,(A6)+
	MOVE.L	#$FFFF1EF7,(A6)+
	AND.L	D4,(A6)+
	OR.L	D1,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FFFCF1FC,(A6)+
	MOVE.L	#$FFFF1EE7,(A6)+
	AND.L	D4,(A6)+
	OR.L	D1,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FFF8F7FF,(A6)+
	MOVE.L	#$FFFF1E07,(A6)+
	AND	D7,(A6)+
	OR.L	D5,(A6)+
	OR	D5,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$F7D8FE1F,(A6)+
	MOVE.L	#$FFFF1BE7,(A6)+
	AND	D7,(A6)+
	OR.L	D5,(A6)+
	OR	D5,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FF9FFE1F,(A6)+
	MOVE.L	#$FFFF03E1,(A6)+
	AND	D7,(A6)+
	OR.L	D5,(A6)+
	OR	D5,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FE16FE1F,(A6)+
	MOVE.L	#$FFFF03E9,(A6)+
	AND.L	D7,(A6)+
	OR.L	D5,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$9E17FFFA,(A6)+
	MOVE.L	#$FFFF63ED,(A6)+
	AND.L	D7,(A6)+
	OR.L	D5,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$DC13FFF9,(A6)+
	MOVE.L	#$FFFF63EE,(A6)+
	OR.L	D5,(A6)+
	OR	D5,(A6)+
	AND	D7,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$DFF1FFF8,(A6)+
	MOVE.L	#$FFFF600F,(A6)+
	OR.L	D5,(A6)+
	OR	D5,(A6)+
	AND	D7,(A6)+
	LEA	$90(A6),A6
	AND	D2,(A6)
	OR.L	#$FFD0FFFE,(A6)+
	OR	#$FFFE,(A6)+
	AND	D2,(A6)
	OR	#$6E,(A6)+
	LEA	$98(A6),A6
	AND.L	D2,(A6)
	OR.L	#$FFEEFFDE,(A6)+
	OR	#$FFFE,(A6)+
	AND	D2,(A6)
	OR	#$76,(A6)+
	LEA	$98(A6),A6
	AND.L	D2,(A6)
	OR.L	#$F1F4FFCC,(A6)+
	OR	#$FFFE,(A6)+
	AND	D2,(A6)
	OR	#$3F7E,(A6)+
	LEA	$98(A6),A6
	MOVE.L	#$FFE8F0D8,(A6)+
	MOVE.L	#$FFFF3F7F,(A6)+
	LEA	$98(A6),A6
	MOVE.L	#$F1D0F0F0,(A6)+
	MOVE.L	#$FFFF3F7F,(A6)+
	LEA	$98(A6),A6
	MOVE.L	#$F1E0F8F0,(A6)+
	MOVE.L	#$FFFF1F7F,(A6)+
	LEA	$98(A6),A6
	MOVE.L	#$F9E0FCF0,(A6)+
	MOVE.L	#$FFFF2F7F,(A6)+
	LEA	$98(A6),A6
	MOVE.L	#$DDE0FEF0,(A6)+
	MOVE.L	#$FFFF377F,(A6)+
	LEA	$98(A6),A6
	AND.L	D2,(A6)
	OR.L	#$CFE0FFF0,(A6)+
	OR	#$FFFE,(A6)+
	AND	D2,(A6)
	OR	#$3B7E,(A6)+
	LEA	$98(A6),A6
	AND.L	#$30003,(A6)
	OR.L	#$DFE0EFF0,(A6)+
	OR	#$FFFC,(A6)+
	AND	#3,(A6)
	OR	#$307C,(A6)+
	LEA	$98(A6),A6
	AND.L	#$70007,(A6)
	OR.L	#$DFE0FFF0,(A6)+
	OR	#$FFF8,(A6)+
	AND	#7,(A6)
	OR	#$2038,(A6)+
	LEA	$98(A6),A6
	MOVE.L	#$F9FFFE7C,(A6)+
	MOVE.L	#$FFFF0797,(A6)+
	LEA	$98(A6),A6
	MOVE.L	#$F3FEFCF8,(A6)+
	MOVE.L	#$FFFF0F0F,(A6)+
	AND.L	D7,(A6)+
	OR.L	D5,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$F7FCF9F0,(A6)+
	MOVE.L	#$FFFF0E1F,(A6)+
	AND.L	D4,(A6)+
	OR.L	D1,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FFF8FFF0,(A6)+
	MOVE.L	A1,(A6)+
	AND.L	D4,(A6)+
	OR.L	D1,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FFF0FFF0,(A6)+
	MOVE.L	A1,(A6)+
	AND.L	D4,(A6)+
	OR.L	D1,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FEF0FF3F,(A6)+
	MOVE.L	A3,(A6)+
	AND	D4,(A6)+
	OR.L	D1,(A6)+
	OR	D1,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FEE0FF3F,(A6)+
	MOVE.L	A3,(A6)+
	AND	D4,(A6)+
	OR.L	D1,(A6)+
	OR	D1,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FE7FFFBF,(A6)+
	MOVE.L	#$FFFF01C0,(A6)+
	OR.L	D3,(A6)+
	OR	D3,(A6)+
	AND	D0,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$F73FFFF8,(A6)+
	MOVE.L	#$FFFF08CF,(A6)+
	AND.L	#$3FF03FF,(A6)
	OR.L	#$E0002000,(A6)+
	OR	#$FC00,(A6)+
	AND	#$3FF,(A6)
	OR	#$DC00,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$F3FCFFFC,(A6)+
	MOVE.L	#$FFFF0C0F,(A6)+
	AND.L	#$1FF01FF,(A6)
	OR.L	#$60002000,(A6)+
	OR	#$FE00,(A6)+
	AND	#$1FF,(A6)
	OR	#$DE00,(A6)+
	LEA	$90(A6),A6
	MOVE.L	#$FFFEFFFE,(A6)+
	MOVE.L	A0,(A6)+
	MOVE.L	#$6123FFDF,D0
	MOVEP.L	D0,0(A6)
	LEA	$98(A6),A6
	MOVE.L	A2,(A6)+
	MOVE.L	#$FFFF0013,(A6)+
	AND.L	#$7F007F,(A6)
	OR.L	#$63002600,(A6)+
	OR	#$FF80,(A6)+
	AND	#$7F,(A6)
	OR	#$DD80,(A6)+
	RTS
L512CA	DC.L	$FFF0FFF,$C0008000,$F000F000,$8000E000
	DC.L	$EFFF0FFF,$80008000,$FFFF007F,$C0C0FFFF
	DC.L	$FFFFEFFB,$FFF3FFFF,$FFFFFFFF,$FFFF0000
L512FA	DC.L	$8FF8FFFF,$C000C000,$7FFF7FFF,$80C0FF7F
	DC.L	$FFFF7DFF,$FFFF01E7,$FFFF0FE7
L51316	DC.L	$E000E000,$50B1FFFF,$FC00FC00,$FFFF0007
L51326	DC.L	$DFFF1FFF,$8FFF0FFF,$8000E000,$FFF0FFF
