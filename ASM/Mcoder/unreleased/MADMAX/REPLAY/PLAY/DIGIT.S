;
;MAD7.MUS=PLAYER DIGIT
;
BASE=$40000
	MOVE	SR,D0
	AND	#$2000,D0
	BNE.S	SUPER
	CLR.L	-(SP)
	MOVE	#$20,-(SP)
	TRAP	#1
	ADDQ	#6,SP
SUPER:
	LEA	$80000,A0
	MOVEQ	#1,D0
	JSR	BASE
	JSR	BASE+8
BCL:
	MOVE	#37,-(SP)
	TRAP	#14
	ADDQ	#2,SP
	MOVE	#5000,D0
WAIT:	DBRA	D0,WAIT
	MOVE	#$700,$FFFF8240.W
	JSR	BASE+4
	CLR	$FFFF8240.W
	MOVE	#$FF,-(SP)
	MOVE	#6,-(SP)
	TRAP	#1
	ADDQ	#4,SP
	TST	D0
	BEQ.S	BCL
	JSR	BASE+12
	MOVE.L	#$08080000,$FFFF8800.W
	MOVE.L	#$09090000,$FFFF8800.W
	MOVE.L	#$0A0A0000,$FFFF8800.W
;	MOVEQ	#0,D0
;	JSR	BASE
	ILLEGAL
