BASE=$40000

	MOVE	SR,D0
	AND	#$2000,D0
	BNE.S	SUPER
	CLR.L	-(SP)
	MOVE	#$20,-(SP)
	TRAP	#1
	ADDQ	#6,SP
SUPER:
	MOVEQ	#1,D0
	JSR	BASE
BCL:
	MOVE	#37,-(SP)
	TRAP	#14
	ADDQ	#2,SP

	JSR	BASE+8

	MOVE	#$FF,-(SP)
	MOVE	#6,-(SP)
	TRAP	#1
	ADDQ	#4,SP

	TST	D0
	BEQ.S	BCL
	ILLEGAL
