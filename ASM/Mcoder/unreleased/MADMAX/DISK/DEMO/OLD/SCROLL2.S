
HELLO GUYS, WELCOME TO THE MEGA-MAD-MIX DEMO CODED BY MCODER. 
THE 240 MUSICS WERE DONE BY MADMAX (224), LAP (10) AND ANCOOL (6). 
THERE IS A TOTAL LENGTH OF 7 HOURS 50 MINUTES AND 27 SECONDS 
BUT THE MUSICS WERE TIMED UNTIL THEY LOOPED, SO THERE IS SOMETHING 
LIKE 7 HOURS OF MUSIC ONLY, BUT DON'T EXPECT TO LISTEN AT ALL THESE 
MUZAXX IN ONE DAY... 

YOU CAN SELECT A MUSIC BY USING THE UP, DOWN AND SPACE KEYS. 
F2 PLAYS THE MUSICS IN SEQUENTIAL ORDER, F3 PLAYS THE MUSICS IN 
RANDOM ORDER, F1 SKIPS A MUSIC, F5 AND F6 ARE THE SAME AS F2 AND F3 
EXCEPT THAT IT PLAYS 20 SECONDS INSTEAD OF THE WHOLE MUSIC. 
HELP OR UNDO ARE USED TO QUIT THIS SCREEN. 

I WOULD LIKE TO THANK EVERYBODY WHO HELPED ME TO COLLECT THESE MUSICS 
(SORRY GUYS, YOU ARE TOO NUMEROUS TO MENTION BUT GOD AND I ARE WITH YOU) 
AND I WOULD LIKE TO GREET THE BIGGEST MUSICIANS ON AMIGA AND C64 : 
CHRIS HUELSBECK, ROB HUBBARD AND MARTIN GALWAY AMONG THE OTHERS... 

ABOUT THE MUZAXX, I ALWAYS TRIED TO MENTION THE ORIGIN BUT THERE 
COULD BE ERRORS (LIKE SPACEBALL (???)) SO DON'T BE ANGRY 
AGAINST ME (FOR THE ANECDOT, THE FUCKING HARDEST RIP WAS IN 'A PREHISTORIC TALE' 
WHERE I SPENT HOURS AND HOURS BECAUSE I DIDN'T FOUND THE GAME OVER MUSIC). 

AND NOW, FOR THE FIRST TIME IN THE DEMO HISTORY, I WILL TELL YOU 
THE STORY OF THIS SCREEN (I TOLD IT TO SOME GUYS AND THEY FOUND IT VERY 
FUNNY INDEED). I STARTED TO CODE THIS SCREEN ONE YEAR AGO JUST AFTER 
THE TRANSBEAUCE 1 AND IT WAS SOMETHING LIKE A VERTICAL ONE PLANE SCROLLER 
(HARDWARE SCROLL) WITH A DISTORTING 3D-VECTOR DEMO (THE SAME AS THE 
TRANSBEAUCE 1 RESET-DEMO, BUT MUCH MORE SLOW) AND AN HORIZONTAL MEGASCROLLER 
AND 6 SPRITES 32-32 IN ONE PLANE ('MCODER'). 
WITH THE TIME, THE DEMO GROWTHS IN LENGTH, NOT BECAUSE I WROTE MORE CODE, 
BUT BECAUSE I FOUND NEW MUSICS EACH WEEK !!! 
I HAD TO REWRITE ALL MY CODE (AAARGH) TO FREE MORE AND MORE MEMORY AND TO ALLOW 
THE DIGI-SOUNDS. 
SOME VERSIONS WERE DESIGNED BEFORE THIS ONE AND INCLUDED SOME NEW IDEAS 
FROM ME (YES, LAMERS, IT'S POSSIBLE) AND PERHAPS IN THE FUTURE I WILL REUSE 
SOME OF THESE IDEAS IN A DEMO-SCREEN. 

ONLY ONE THING IS SURE WITH THIS SCREEN : IT'S THE SCREEN WHICH MADE 
ME WRITE THE BIGGEST NUMBER OF UTILITIES. 
I WROTE : A TFMX TO COSO PACKER, A COSO TO COSO CONVERTER (MADMAX HAD 
SOME PROBLEMS WITH EARLIER VERSIONS), A MADMAX REPLAY (THERE IS ONLY ONE 
REPLAY ROUTINE IN THIS SCREEN !!! BUT I CODED AT LEAST 40 DRIVERS BEFORE 
THIS ONE...), A PATTERN OPTIMISER (THE DEMO REFUSED TO WORK INTO HALF A MEGA), 
AND LOTSA OPTIMISERS (DIGIT...) AND LOTSA CONVERTERS (LAP TO TFMX...). 
FOR INSTANCE, I HAVE A DISK FULL OF THESE UTILITIES (IF MADMAX IS INTERESTED...). 

YOU CAN SEE THAT I HAVE WORKED VERY HARD FOR THIS UGLY SCREEN BUT I HOPE YOU'LL 
APPRECIATE IT THOUGH. HEY MADMAX, I'VE A BETTER REPLAY ROUTINE THAN YOURS. 
MINE TAKES LESS TIME THAN YOUR LATEST AND IS ABLE TO PLAY SYNTH OR DIGI-SOUNDS 
AT ANY FREQUENCY (AH, AH, AH). 

OK, DON'T KILL ME, I'LL TRY TO BE MORE MODEST THE NEXT TIME... 
IT'S TIME TO WRAP, EH EH...           
