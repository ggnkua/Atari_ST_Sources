;
; DESTRUCTION DES DIGITS INUTILISEES (FICHIER ALLDIGS.BIN)
;
LOAD=$40000
LONG=52522
FREQ=$80000
SAVE=$50000

	LEA	LOAD,A5
	LEA	FREQ,A4
	LEA	SAVE,A6
MAIN:
	TST.B	(A4)+
	BNE.S	COPIE
;
; SAUTE LA DIGIT (PAS DE COPIE)
;
SKIPPE:
	CMP.B	#$FF,(A5)+
	BNE.S	SKIPPE
	BRA.S	PAIR
;
; COPIE LA DIGIT
;
COPIE:
	MOVE.B	(A5)+,D0
	MOVE.B	D0,(A6)+
	CMP.B	#$FF,D0
	BNE.S	COPIE

	MOVE	A6,D0
	LSR	#1,D0
	BCC.S	PAIR
	ST	(A6)+
PAIR:
	CMP.B	#$FF,(A5)
	BNE.S	NOTFF
	ADDQ	#1,A5
NOTFF:
	CMP.L	#LOAD+LONG,A5
	BLO.S	MAIN

	LEA	SAVE,A0
	MOVE.L	A6,A1
	MOVEQ	#0,D0
	ILLEGAL
