	CLR.L	-(SP)
	MOVE	#$20,-(SP)
	TRAP	#1
	ADDQ	#6,SP
	BRA.S	SKIP

	CLR	$FFFF8900.W
	LEA	L0000(PC),A0
	MOVE	(A0)+,$FFFF8924.W
	MOVEQ	#7-1,D0
L0001:	MOVE	(A0)+,$FFFF8922.W
1$	TST	$FFFF8922.W
	BNE.S	1$
	DBRA	D0,L0001

L0000:	DC.W	$0FFE,$09D1,$0AA9,$0A29
	DC.W	$090D,$088D,$0803

SKIP:
	MOVEQ	#0,D0
	TST	$FFFF9200.W
	BPL.S	.NOTSTE

;
; STE !!!!
;
	MOVEQ	#1,D0
.NOTSTE
	ILLEGAL
