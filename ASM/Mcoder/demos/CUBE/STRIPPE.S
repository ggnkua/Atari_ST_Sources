SOURCE=$80000
DEST=$100000


	LEA	SOURCE,A5
	LEA	DEST,A6

LOOP:
	MOVE.B	(A5)+,D0
	BEQ.S	FINI
	MOVE.B	D0,(A6)+
	CMP.B	#13,D0
	BNE.S	LOOP

STRIP:
	CMP.B	#' ',-2(A6)
	BNE.S	LOOP

	SUBQ	#1,A6
	MOVE.B	D0,-1(A6)
	BRA	STRIP


FINI:
	LEA	DEST,A0
	MOVE.L	A6,A1
	ILLEGAL
