	NOLIST
NEWMUS	EQU	4*16
;
; PROGRAMME QUI S'AUTOMODIFIE (PLUS DE VARIABLES)
;
; .S AVANT BOTH
;
	OPT	O+,T-
OFF0	EQU	0	;1 BYTE
OFF1	EQU	1	;1 BYTE
OFF2	EQU	2	;1 PTR WORD
OFF6	EQU	4	;1 PTR WORD
OFFA	EQU	6	;1 WORD
OFFE	EQU	8	;1 WORD
OFF10	EQU	10	;1 PTR WORD
OFF14	EQU	12	;1 PTR WORD
OFF18	EQU	14	;1 BYTE
OFF19	EQU	15	;1 BYTE
OFF1A	EQU	16	;1 BYTE
OFF1B	EQU	17	;1 BYTE
OFF1C	EQU	18	;1 BYTE
OFF1D	EQU	19	;1 BYTE
OFF1E	EQU	20	;1 BYTE
OFF1F	EQU	21	;1 BYTE
OFF20	EQU	22	;1 PTR WORD
OFF24	EQU	24	;1 PTR WORD
OFF28	EQU	26	;1 BYTE
OFF29	EQU	27	;1 BYTE
OFF2A	EQU	28	;1 BYTE
OFF2B	EQU	29	;1 BYTE
OFF2C	EQU	30	;1 BYTE
OFF2D	EQU	31	;1 BYTE
OFF2E	EQU	32	;1 BYTE

OFF30	EQU	34	;NB BYTES !!!
;
;CHAN_A	DS.B	OFF30-1
;L760	DS.B	1
;CHAN_B	DS.B	OFF30-1
;	DS.B	1
;CHAN_C	DS.B	OFF30-1
	even
pavol	move.b	newvol(pc,d0.w),VOLUME\W
	bra.s	paf
papad
	sub.b	#$67-2,d0
	cmp.b	#10,d0
	bhs.s	paf
	move.b	keypad(pc,d0.w),VOLUME\W
	bra.s	paf

v1	equ	15-15
v2	equ	15-14
v3	equ	15-13
v4	equ	15-12
v5	equ	15-11
v6	equ	15-9
v7	equ	15-7
v8	equ	15-4
v9	equ	15-1
v0	equ	15-0
newvol	dc.b	v1,v2,v3,v4,v5,v6,v7,v8,v9,v0
keypad	dc.b	v7,v8,v9,v4,v5,v6,v1,v2,v3,v0
	EVEN
playmus
	moveq	#0,d0
	move.b	$fffffc02.w,d0		;lit clavier
	subq.b	#2,d0
	cmp.b	#10,d0
	blo.s	pavol
	cmp.b	#$67-2,d0
	bhs.s	papad

	cmp.b	#$61-2,d0
	blo.s	pahelp
	sub.b	#$61-$3b-10,d0
pahelp
	sub.b	#$3b-2,d0
	cmp	#12,d0
	bhs.s	paf
	ASL	#4,D0
	move	d0,(paf+2)\w
paf	move	#0,d0		;code automodifiable
music	cmp	#1,d0		;code automodifiable
	BEQ	MUSIC50
	move	d0,(music+2)\w
	CLR.B	TRANSPOSE\W
	LEA	STADS\W,A0
	ADD	D0,A0
	MOVE	(A0)+,D0
	MOVE.B	D0,NO_T\W
	LEA	CHAN_A\W,A1
	MOVEQ	#2,D7
	LEA	FIRST\W,A3

INITIAL:MOVE.B	#1,OFF1B(A1)
	CLR.B	(A1)
	CLR.B	OFF2C(A1)
	CLR.B	OFF2D(A1)
	CLR.B	OFF2E(A1)
	MOVE	A3,OFF10(A1)
	MOVE	A3,OFF14(A1)
	MOVE	(A0)+,A2
	MOVE	A2,OFF6(A1)
	MOVE	#2,OFFA(A1)
	MOVE	(A2),OFF2(A1)
	LEA	OFF30(A1),A1
	DBF	D7,INITIAL
	MOVE	(A0)+,PTR1\W
	MOVE	(A0)+,PTR2\W
	MOVE	(A0),PTR3\W

	MOVE.B	#$F8,LATCH7\W
;	ST	LATCH7\W
	ST	L760\W
	CLR.B	REG8\W
	CLR.B	REG9\W
	CLR.B	REG10\W
	ST	REG7\W
	MOVE.L	#$0707FFFF,$FFFF8800.W
	MOVE.L	#$08080000,$FFFF8800.W
	MOVE.L	#$09090000,$FFFF8800.W
	MOVE.L	#$0A0A0000,$FFFF8800.W
RET:	RTS
MUSIC50:
AUTOM7	ADD.B	#0,L760\W
NO_T	EQU	AUTOM7+3
	BCC.S	WALBOL
	LEA	CHAN_A\W,A0
	MOVEQ	#$09,D3
	BSR	MZ_CH
	LEA	CHAN_B\W,A0
	MOVEQ	#$12,D3
	BSR	MZ_CH
	LEA	CHAN_C\W,A0
	MOVEQ	#$24,D3
	BSR	MZ_CH
WALBOL:
AUTOM3	MOVE.B	#$1F,REG6\W
NZ_F	EQU	AUTOM3+3	;=$1F AU DEBUT
	LEA	CHAN_A\W,A0
	MOVEQ	#$09,D3		;MASQUE
	BSR	MZ_50
	MOVE	D0,REG1\W
	MOVE.B	D0,REG0\W
	MOVE.B	D1,REG8\W
	LEA	CHAN_B\W,A0
	MOVEQ	#$12,D3		;MASQUE
	BSR	MZ_50
	MOVE	D0,REG3\W
	MOVE.B	D0,REG2\W
	MOVE.B	D1,REG9\W
	LEA	CHAN_C\W,A0
	MOVEQ	#$24,D3		;MASQUE
	BSR	MZ_50
	MOVE	D0,REG5\W
	MOVE.B	D0,REG4\W
	MOVE.B	D1,REG10\W

	MOVEM.L	REGS\W,D0-D7/A0-A2
	MOVEM.L	D0-D7/A0-A2,$FFFF8800.W

	MOVEQ	#$38,D0
	AND.B	REG7\W,D0
	CMP.B	#$38,D0
	BEQ.S	AUCUN
	MOVE.L	#$0E0E0101,$FFFF8800.W	;SELECTE LES 2 DIVERS
	RTS
AUCUN:	MOVE.L	#$0E0E0707,$FFFF8800.W	;DESELECTE LES 2 DRIVES
	RTS

LAE0:	MOVE.B	(A1)+,OFF6(A0)
	MOVE.B	(A1)+,OFF6+1(A0)
	CLR	OFFA(A0)
	BRA	READ
ENDING:	MOVE	OFFA(A0),D0
	MOVE	OFF6(A0),A2
	ADD	D0,A2
	ADDQ	#2,D0
	TST	(A2)
	BNE.S	SET_MEM
	MOVE	OFF6(A0),A2
	MOVEQ	#2,D0
SET_MEM:MOVE	(A2),A1
	MOVE	D0,OFFA(A0)
	BRA	READ
NOISE:	MOVEQ	#7,D0
	ST	OFF1(A0)
	BRA.S	SETLAT
;	MOVE.B	LATCH7\W,D2
;	AND.B	D3,D0
;	EOR.B	D2,D0
;	AND.B	D3,D0
;	EOR.B	D2,D0
;	MOVE.B	D0,LATCH7\W
;	BRA	READ
SQUARE:	MOVEQ	#$38,D0
	CLR.B	OFF1(A0)
SETLAT	MOVE.B	LATCH7\W,D2
	AND.B	D3,D0
	EOR.B	D2,D0
	AND.B	D3,D0
	EOR.B	D2,D0
	MOVE.B	D0,LATCH7\W
	BRA.S	READ
BOTH:	MOVE.B	D3,D0
	NOT.B	D0
	AND.B	D0,LATCH7\W
	ST	OFF1(A0)
	BRA.S	READ
SLIDE:	CLR	OFFE(A0)
;	BSET	#2,D7
	ADDQ	#4,D7
	MOVE.B	(A1)+,OFF18(A0)
	MOVE.B	(A1)+,OFF19(A0)
	BRA.S	READ
NZ_FREQ:MOVE.B	(A1)+,TRANSPOSE\W
	BRA.S	READ
LB94:	cmp	#NEWMUS,(music+2)\w
	bhs.s	READ
	MOVE.B	(A1)+,OFF2E(A0)
	BRA.S	READ
GL_DN:
;	BSET	#3,D7
	ADDQ	#8,D7
	BRA.S	READ
VIBE_SET:
	MOVE.B	(A1)+,OFF2A(A0)
	MOVE.B	(A1)+,D0
	MOVE.B	D0,OFF29(A0)
	MOVE.B	D0,OFF2B(A0)
	cmp	#NEWMUS,(music+2)\w
	bhs.s	READ
VIBE_1:	MOVE.B	#$40,OFF2C(A0)
	BRA.S	READ
VIBE_0:	CLR.B	OFF2C(A0)
	BRA.S	READ
TOGGLE:
	ADDQ	#2,D7
;	BSET	#1,D7
	BRA.S	READ
PAUSE:	CLR.B	OFF1E(A0)
	BRA.S	VALUED
LBD0:	ST	OFF2D(A0)
	BRA.S	READ

MZ_CH:	SUBQ.B	#1,OFF1B(A0)
	BNE.S	GLISS_IT
	MOVEQ	#0,D7
	MOVE	OFF2(A0),A1
READ:	MOVEQ	#0,D0
	MOVE.B	(A1)+,D0
	BMI.S	EXTEND
	MOVE.B	D0,OFF1D(A0)
	TST.B	OFF1(A0)
	BEQ.S	L24F72
	MOVE.B	D0,NZ_F\W
L24F72:	MOVE	OFF24(A0),A2
	MOVE	A2,OFF20(A0)
	MOVE.B	(A2),D0
	MOVE.B	D0,OFF28(A0)
	MOVE.B	D0,OFF1E(A0)
	MOVE.B	OFF1A(A0),OFF1F(A0)
	TAS	D7			;BIT 7 AU LIEU DE BIT 5
VALUED:	MOVE.B	OFF1C(A0),OFF1B(A0)
	MOVE	A1,OFF2(A0)
	TST.B	OFF2D(A0)
	BEQ.S	L24FCC
	ST	OFF2D(A0)
L24FCC:	MOVE.B	D7,(A0)
	RTS
GLISS_IT:
	BTST	#3,(A0)
	BEQ.S	L24FEA
;	MOVE.B	(A0),D7
;	TST.B	D7
;	BPL.S	GL_DOWN
;	ADDQ.B	#1,OFF1D(A0)
;	RTS
;GL_DOWN:
	SUBQ.B	#1,OFF1D(A0)
L24FEA:	RTS
EXTEND:	CMP.B	#$B8,D0
	BLO.S	TOKENS
	ADD.B	#$20,D0
	BCS.S	LENGTH
	ADD.B	#$10,D0
	BCS.S	ENVS
	ADD.B	#$10,D0
	BCC.S	TEMPS
	ADD	D0,D0
AUTOM4	LEA	0\W,A2
PTR1	EQU	AUTOM4+2

	MOVE	(A2,D0.W),A2
	MOVE	A2,OFF14(A0)
	MOVE	A2,OFF10(A0)
	BRA.S	READ
TEMPS:	ADD.B	#9,D0
	MOVE.L	#$100,D1
	DIVU	D0,D1
	MOVE.B	D1,NO_T\W
	BRA	READ
LENGTH:	ADDQ.B	#1,D0
	MOVE.B	D0,OFF1C(A0)
	BRA	READ
ENVS:	ADD	D0,D0
AUTOM5	LEA	0\W,A2
PTR2	EQU	AUTOM5+2
	MOVE	(A2,D0.W),A2
	MOVE	A2,OFF24(A0)
	MOVE.B	-(A2),OFF1A(A0)
	BRA	READ
TOKENS:	ADD.B	D0,D0			;EFFACE LE BIT 7 !!!
	ADD	D0,D0
	JMP	L24E0E(PC,D0.W)
L24E0E:	BRA.W	PAUSE		;$80
	BRA.W	VIBE_0		;$81
	BRA.W	VIBE_1		;$82
	ILLEGAL			;$83	INUTILISE
	ILLEGAL
	BRA.W	SLIDE		;$84
	BRA.W	GL_DN		;$85
	ILLEGAL			;$86	INUTILISE
	ILLEGAL
	BRA.W	ENDING		;$87
	BRA.W	VIBE_SET	;$88
	BRA.W	NZ_FREQ		;$89
	BRA.W	SQUARE		;$8A
	BRA.W	NOISE		;$8B
	BRA.W	BOTH		;$8C
	BRA.W	TOGGLE		;$8D
;PLAK	BRA.W	PLAK
	ILLEGAL			;$8E	INUTILISE
	ILLEGAL
	BRA.W	VALUED		;$8F
	BRA.W	LBD0		;$90
	ILLEGAL			;$91	INUTILISE
	ILLEGAL
	BRA.W	LB94		;$92
	BRA.W	LAE0		;$93
;	BRA.W	CHFREQ		;$94
CHFREQ:	MOVE.B	(A1)+,NO_T\W	;ICI $94 DIRECTOS !!!
	BRA	READ
;	ILLEGAL			;$95	INUTILISE
;	ILLEGAL

MZ_50:	MOVEQ	#0,D7
	MOVE.B	(A0),D7
	BPL.S	FORM		;BIT 7 AU LIEU DE BIT 5
	SUBQ.B	#1,OFF1F(A0)
	BHS.S	EV_DELAY
	MOVE.B	OFF1A(A0),OFF1F(A0)
	MOVE	OFF20(A0),A2
	MOVE.B	1(A2),D0
	BMI.S	EV_DELAY
	ADDQ	#1,OFF20(A0)
	MOVE.B	D0,OFF28(A0)
EV_DELAY:
	MOVE.B	OFF28(A0),OFF1E(A0)
FORM:
AUTOM2	MOVEQ	#0,D0		;TRANSPOSE=0 AU DEBUT
TRANSPOSE	EQU	AUTOM2+1

	ADD.B	OFF1D(A0),D0
	ADD.B	OFF2E(A0),D0
	MOVE	OFF14(A0),A1
	MOVEQ	#0,D5
	MOVE.B	(A1)+,D5
	BPL.S	CH_CALC
	BCLR	#7,D5
	MOVE	OFF10(A0),A1
CH_CALC:MOVE	A1,OFF14(A0)
	ADD.B	D0,D5
AUTOM6	LEA	0\W,A1
PTR3	EQU	AUTOM6+2
	ADD.B	D5,D5
	MOVE	(A1,D5.W),D0
	MOVE.B	OFF2C(A0),D6
	BTST	#6,D6
	BEQ.S	TWIGGLE
	MOVE.B	OFF29(A0),D2
	ADD.B	D2,D2
	MOVEQ	#0,D1
	MOVE.B	OFF2B(A0),D1
;	BCHG	#7,D6		;BIT 7 AU LIEU DU BIT 5
;	BNE.S	VB_UP
	EOR.B	#$80,D6
	BPL.S	VB_UP

	SUB.B	OFF2A(A0),D1
	BHS.S	VB_REACH
	MOVEQ	#0,D1
	BRA.S	VB_R1
VB_UP:	ADD.B	OFF2A(A0),D1
	CMP.B	D2,D1
	BLO.S	VB_REACH
	MOVE.B	D2,D1
VB_R1:
	MOVE.B	D6,OFF2C(A0)	;BIT 7 AU LIEU DU BIT 5
VB_REACH:
	MOVE.B	D1,OFF2B(A0)
VB_SAME:LSR.B	#1,D2
	SUB.B	D2,D1
	BHS.S	WARBLE
	SUB	#$100,D1
WARBLE:	ADD.B	#$A0,D5
	BCS.S	HI_VB
	MOVEQ	#$18,D2
	ADD	D1,D1
	ADD.B	D2,D5
	BCS.S	HI_VB
	ADD	D1,D1
	ADD.B	D2,D5
	BCS.S	HI_VB
	ADD	D1,D1
	ADD.B	D2,D5
	BCS.S	HI_VB
	ADD	D1,D1
HI_VB:	ADD	D1,D0
TWIGGLE:EOR.B	#1,D7
	MOVE.B	D7,(A0)
	BTST	#2,D7
	BEQ.S	TG_FORM
	MOVE.B	OFF19(A0),D2
	SUBQ.B	#1,D2
	BNE.S	SL_UP
	MOVE.B	OFF18(A0),D6
	EXT	D6
	ADD	OFFE(A0),D6
	MOVE	D6,OFFE(A0)
	ADD	D6,D0
	BRA.S	TG_FORM
SL_UP:	MOVE.B	D2,OFF19(A0)
TG_FORM:NOT.B	D7
;	MOVE.B	LATCH7\W,D2
AUTOM9	MOVEQ	#0,D2
LATCH7	EQU	AUTOM9+1
	AND.B	#3,D7
	BNE.S	SET_7
	MOVE.B	NZ_F\W,D2
	EOR.B	#8,D2
	MOVE.B	D2,REG6\W
	MOVEQ	#7,D2
SET_7:	MOVE.B	REG7\W,D1
	EOR.B	D1,D2
	AND.B	D3,D2
	EOR.B	D1,D2
	TST.B	OFF2D(A0)
	BPL.S	L2519C
	AND.B	#$7F,OFF2D(A0)
	MOVEQ	#$38,D1
	AND.B	D3,D1
	NOT.B	D1
	AND.B	D1,D2
	MOVE.B	#1,REG6\W
L2519C:	MOVE.B	D2,REG7\W
	MOVE.B	OFF1E(A0),D1
AUTOM1	SUB.B	#0,D1		;VOLUME=15 AU DEBUT (=0)
VOLUME	EQU	AUTOM1+3
	BHS.S	L24BA4
	MOVEQ	#0,D1
L24BA4:
	RTS
;
; LES VARIABLES
;
	EVEN
REGS:	DC.W	0
REG0:	DC.B	0	;BYTE REG 0
	DC.B	0
	DC.W	$101
REG1:	DC.B	0	;BYTE REG 1
	DC.B	0
	DC.W	$202
REG2:	DC.B	0	;BYTE REG 2
	DC.B	0
	DC.W	$303
REG3:	DC.B	0	;BYTE REG 3
	DC.B	0
	DC.W	$404
REG4:	DC.B	0	;BYTE REG 4
	DC.B	0
	DC.W	$505
REG5:	DC.B	0	;BYTE REG 5
	DC.B	0
	DC.W	$606
REG6:	DC.B	0	;BYTE REG 6
	DC.B	0
	DC.W	$707
REG7:	DC.B	0	;BYTE REG 7
	DC.B	0
	DC.W	$808
REG8:	DC.B	0	;BYTE REG 8
	DC.B	0
	DC.W	$909
REG9:	DC.B	0	;BYTE REG 9
	DC.B	0
	DC.W	$A0A
REG10:	DC.B	0	;BYTE REG 10
	DC.B	0
;
; LES TABLEAUX
;
	EVEN
NOTE_TAB:
NOTE:
L251C2:	DC.W	$EEE,$E17,$D4D,$C8E,$BD9,$B2F,$A8E,$9F7
	DC.W	$967,$8E0,$861,$7E8,$777,$70B,$6A6,$647
	DC.W	$5EC,$597,$547,$4FB,$4B3,$470,$430,$3F4
	DC.W	$3BB,$385,$353,$323,$2F6,$2CB,$2A3,$27D
	DC.W	$259,$238,$218,$1FA,$1DD,$1C2,$1A9,$191
	DC.W	$17B,$165,$151,$13E,$12C,$11C,$10C,$FD
	DC.W	$EE,$E1,$D4,$C8,$BD,$B2,$A8,$9F
	DC.W	$96,$8E,$86,$7E,$77,$70,$6A,$64
	DC.W	$5E,$59,$54,$4F,$4B,$47,$43,$3F
	DC.W	$3B,$38,$35,$32,$2F,$2C,$2A,$27
	DC.W	$25,$23,$21,$1F,$1D,$1C,$1A,$19
	DC.W	$17,$16,$15,$13,$12,$11,$10,$F

STADS:

; F1=SPEEDBALL
	DC.W	$40,L1048,LFB0,L10D2,L25282,L26106,NOTE
	DC.W	0
; F2=STARRAY
	DC.W	$2C,N95C,N9A2,N9E2,N8E2,N15E4,NOTE
	DC.W	0
; F1=COSMIC PIRATE
	DC.W	$40,V1078,V10A8,V10BA,VFF6,V1AA4,NOTE,0


; F2=ZOMBI
	DC.W	$24,W128C,W123A,W12CE,W10D4,W27EE,NOTE,0

; F3=GENESIS
	DC.W	256/5,MB00,MACA,MB2C,M6CC,M70C,NOTE
	DC.W	0
; F4=LEATHERNECK
	DC.W	256/6,O7D0,O75C,O7DE,O64C,O68C,NOTE
	DC.W	0
; F5=RAMPAGE
	DC.W	256/5,UB14,UABA,UB36,U6CC,U70C,NOTE,0	;RAMPAGE
; F6=ENDURO 1
	DC.W	256*9/70,RB4E,RB6C,RB72,R1FF86,R1FFCC,NOTE-24	;ENDURO 1
	DC.W	0
; F8=ICE PALACE
	DC.W	256/8,TBF2,TB72,TC92,T2CAE0,T2CB22,NOTE		;ICE PALACE
	DC.W	0
; HELP=GOLDRUNNER 2
	DC.W	256/5,Q840,Q906,Q91C,Q726,Q766,NOTE		;GOLDRUNNER 2
	DC.W	0
; F9=XENON 1
	DC.W	256/5,PAB0,PAA6,PAC8,P6D8,P718,NOTE		;XENON
	DC.W	0
; F10=XENON 2
	DC.W	256/5,PCF4,PCDA,PD02,P6D8,P718,NOTE		;XENON
	DC.W	0
;
; LISTE DES MORCEAUX
;
LFB0:	DC.W	L1745,L1102,L110E
	DC.W	L1133,L11AA,L11CD,L115C
	DC.W	L1181,L110E,L1133,L11AA
	DC.W	L11CD,L115C,L1181,L110E
	DC.W	L110E,L1181,L1181,L1102
	DC.W	L11F6,L11F6,L1212,L1212
	DC.W	L11F6,L11F6,L1212,L1212
	DC.W	L11F6,L11F6,L1212,L1212
	DC.W	L1102,L1748,L1102,L110E
	DC.W	L1133,L11AA,L11CD,L115C
	DC.W	L1181,L110E,L1133,L11AA
	DC.W	L11CD,L115C,L1181,L110E
	DC.W	L110E,L1181,L1181,L1745
	DC.W	L1102,L115C,L115C,L122C
	DC.W	L11AA,L115C,L115C,L122C
	DC.W	L11AA,L1748,L115C,L115C
	DC.W	L122C,L11AA,L115C,L115C
	DC.W	L122C,L11AA,L174B,L1102
	DC.W	L174E,L1102,L1751,L1102
	DC.W	0
L1048:	DC.W	L124F,L125B,L125B
	DC.W	L1281,L1281,L126E,L126E
	DC.W	L125B,L125B,L1281,L1281
	DC.W	L126E,L126E,L125B,L125B
	DC.W	L126E,L126E,L124F,L1292
	DC.W	L1292,L12A1,L12A1,L1292
	DC.W	L1292,L12A1,L12A1,L1292
	DC.W	L1292,L12A1,L12A1,L124F
	DC.W	L124F,L125B,L125B,L1281
	DC.W	L1281,L126E,L126E,L125B
	DC.W	L125B,L1281,L1281,L126E
	DC.W	L126E,L125B,L125B,L126E
	DC.W	L126E,L124F,L126E,L126E
	DC.W	L1281,L1281,L126E,L126E
	DC.W	L1281,L1281,L126E,L126E
	DC.W	L1281,L1281,L126E,L126E
	DC.W	L1281,L1281,L124F,L124F
	DC.W	L124F,0
L10D2:	DC.W	L12BF,L1317
	DC.W	L135F,L131C,L135F,L12CB
	DC.W	L12BF,L13E1,L13AC,L13E1
	DC.W	L12BF,L12BF,L1317,L135F
	DC.W	L131C,L135F,L12CB,L12BF
	DC.W	L1414,L1414,L12BF,L12BF
	DC.W	L12BF,0

MACA:	DC.W	MB94,MB94
	DC.W	MBB1,MBB1,MBD4,MBD4
	DC.W	MBB1,MBB1,MBD4,MBD4
	DC.W	MBB1,MBB1,MBF5,MBF5
	DC.W	MBF5,MBF5,MBB1,MBB1
	DC.W	MBB1,MBB1,MBB1,MBB1
	DC.W	MBB1,MBB1,MB94,MB94
	DC.W	0
MB00:	DC.W	MC16,MC24,MC24
	DC.W	MC3E,MC3E,MC24,MC24
	DC.W	MC3E,MC3E,MC24,MC24
	DC.W	MC66,MC66,MC66,MC66
	DC.W	MC8E,MC8E,MC8E,MC8E
	DC.W	MB94,MB94,0
MB2C:	DC.W	MDE3
	DC.W	MCB6,MCC1,MCC1,MCDB
	DC.W	MCC1,MCC1,MCDB,MCC1
	DC.W	MCC1,MD0A,MD0A,MD2D
	DC.W	MD2D,MD2D,MD2D,MD2D
	DC.W	MCB6,MDE0,MCC1,MCC1
	DC.W	MCDB,MCC1,MCC1,MCDB
	DC.W	MCC1,MCC1,MD0A,MD0A
	DC.W	MD2D,MD2D,MD2D,MD2D
	DC.W	MD2D,MCB6,MDE9,MCC1
	DC.W	MCC1,MCDB,MCC1,MCC1
	DC.W	MCDB,MCC1,MCC1,MD0A
	DC.W	MD0A,MD2D,MD2D,MD2D
	DC.W	MD2D,MD2D,0

N95C:	DC.W	NA2E,NA22
N960:	DC.W	NA61,NA68,NA68
	DC.W	NA68,NA68,NAAA,NAAA
	DC.W	NA68,NA68,NA68,NA68
	DC.W	NAAA,NAAA,NB33,NB33
	DC.W	NB33,NB33,NB6D,NA61
	DC.W	NFB1,NB6D,NB33,NB33
	DC.W	NB33,NB33,NA61,NFB4
	DC.W	NB33,NB33,NB33,NB33
	DC.W	NFAE,0
N9A2:	DC.W	NC60,NA26
N9A6:	DC.W	NC7B,NC82,NC82,NC82
	DC.W	NC82,NC98,NC98,NC82
	DC.W	NC82,NC82,NC82,NC98
	DC.W	NC98,NC9F,NC9F,NC9F
	DC.W	NC9F,NCB0,NC7B,NCB0
	DC.W	NC9F,NC9F,NC9F,NC9F
	DC.W	NC7B,NC9F,NC9F,NC9F
	DC.W	NC9F,0
N9E2:	DC.W	ND12,NA2A
N9E6:	DC.W	ND2D,ND34,ND34,ND34
	DC.W	ND34,ND46,ND46,ND34
	DC.W	ND34,ND34,ND34,ND46
	DC.W	ND46,ND4D,ND4D,ND4D
	DC.W	ND4D,ND57,ND2D,ND57
	DC.W	ND4D,ND4D,ND4D,ND4D
	DC.W	ND2D,ND4D,ND4D,ND4D
	DC.W	ND4D,0

O75C:	DC.W	O83D
	DC.W	O83D,O83D,O83D,O7F8
	DC.W	O80F,O826,O7F8,O7F8
	DC.W	O80F,O826,O83D,O83D
	DC.W	O7F8,O80F,O826,O7F8
	DC.W	O7F8,O80F,O826,O83D
	DC.W	O83D,O826,O826,O7F8
	DC.W	O7F8,O826,O826,O83D
	DC.W	O83D,O7F8,O80F,O826
	DC.W	O7F8,O7F8,O80F,O826
	DC.W	O83D,O83D,O7F8,O80F
	DC.W	O826,O7F8,O7F8,O80F
	DC.W	O826,O83D,O83D,O7F8
	DC.W	O80F,O826,O7F8,O7F8
	DC.W	O80F,O826,O83D,O83D
	DC.W	0
O7D0:	DC.W	O85A,O874,O8D2
	DC.W	OB71,O885,O885,0
O7DE:	DC.W	OB7C,O917,O917,O937
	DC.W	O937,O987,OB7F,O9B0
	DC.W	OB82,OB71,OB85,O9B0
	DC.W	0

PAA6:	DC.W	PAF8,PAF8
	DC.W	PAF8,PAF8,0
PAB0:	DC.W	PB12
	DC.W	PB53,PB53,PB6B,PB6B
	DC.W	PB92,PB92,PB6B,PB6B
	DC.W	PB6B,PB6B,0
PAC8:	DC.W	PEAF
	DC.W	PBB3,PBB3,PBCE,PBCE
	DC.W	PBEA,PC13,PEB5,PBB3
	DC.W	PBB3,PBCE,PBCE,PBEA
	DC.W	PC13,PEA9,PBB3,PBB3
	DC.W	PBCE,PBCE,PBEA,PC13
	DC.W	PC38,PC38,0
PCDA:	DC.W	PD2E,PD2E,PD2E,PD2E
	DC.W	PD41,PD41,PD2E,PD2E
	DC.W	PD41,PD41,PD2E,PD2E
	DC.W	0
PCF4:	DC.W	PD4E,PD60,PD6B
	DC.W	PD4E,PD77,PD4E,0
PD02:	DC.W	PEA6,PD86,PDAF,PDAF
	DC.W	PDAF,PDAF,PDD6,PDAF
	DC.W	PDAF,PDAF,PDAF,PEAC
	DC.W	PE19,PE19,PEAF,PE5D
	DC.W	PE5D,PE84,PE5D,PE84
	DC.W	PE5D,0

Q840:	DC.W	Q92E,Q92E,Q948,Q948
	DC.W	Q95A,Q95A,Q96C,Q97E
	DC.W	Q948,Q97E,Q92E,Q92E
	DC.W	Q948,Q948,Q95A,Q95A
	DC.W	Q96C,Q97E,Q948,Q97E
	DC.W	Q97E,Q92E,Q92E,Q948
	DC.W	Q948,Q95A,Q95A,Q96C
	DC.W	Q97E,Q948,Q97E,Q92E
	DC.W	Q92E,Q948,Q948,Q95A
	DC.W	Q95A,Q96C,Q97E,Q948
	DC.W	Q97E,Q97E,Q990,Q990
	DC.W	Q948,Q948,Q990,Q990
	DC.W	Q96C,Q97E,Q948,Q97E
	DC.W	Q97E,Q92E,Q92E,Q948
	DC.W	Q948,Q95A,Q95A,Q96C
	DC.W	Q97E,Q948,Q97E,Q92E
	DC.W	Q92E,Q948,Q948,Q95A
	DC.W	Q95A,Q96C,Q97E,Q948
	DC.W	Q97E,Q97E,Q92E,Q92E
	DC.W	Q92E,Q92E,Q9A2,Q9A2
	DC.W	Q9A2,Q9A2,Q92E,Q92E
	DC.W	Q92E,Q92E,Q9A2,Q9A2
	DC.W	Q9A2,Q9A2,Q92E,Q92E
	DC.W	Q92E,Q92E,Q9A2,Q9A2
	DC.W	Q9A2,Q9A2,0
Q906:	DC.W	Q9B4
	DC.W	QA2B,QAA2,Q9B4,QD78
	DC.W	QAD8,QD7B,QAD8,QD75
	DC.W	QAD8,0
Q91C:	DC.W	QD78,QAF7
	DC.W	QB6E,QC59,QBE5,QC8F
	DC.W	QC8F,QC8F,0

RB4E:	DC.W	RB7E
	DC.W	RB7E,RB7E,RB7E,RB95
	DC.W	RB95,RB95,RB95,RB7E
	DC.W	RB7E,RB95,RB95,RB95
	DC.W	RB95,0
RB6C:	DC.W	RBB0,RBBD,0
RB72:	DC.W	RBC2,RBC2,RBE5
	DC.W	RC01,RC19,0

TB72:	DC.W	TFEE
	DC.W	TCE0,TCF2,TD16,TCF2
	DC.W	TD16,TF40,TD33,TD33
	DC.W	TD61,TD33,TD33,TD61
	DC.W	TFF1,TD33,TD33,TD61
	DC.W	TFEB,TD33,TD33,TD61
	DC.W	TFF4,TD33,TD33,TD61
	DC.W	TFF7,TD33,TD33,TD61
	DC.W	TF40,TF40,TF40,TD33
	DC.W	TD33,TD61,TD33,TD33
	DC.W	TD61,TF40,TF40,TF40
	DC.W	TFF1,TD33,TD33,TD61
	DC.W	TF40,TF40,TF40,TFEB
	DC.W	TD33,TD33,TD61,TFF4
	DC.W	TD33,TD33,TD61,TFF7
	DC.W	TD33,TD33,TD61,TF40
	DC.W	TF40,TF40,0
TBF2:	DC.W	TDAB
	DC.W	TCF0,TCF6,TD16,TCF6
	DC.W	TDB6,TF40,TDCE,TDCE
	DC.W	TDCE,TDCE,TDE3,TDCE
	DC.W	TDCE,TDCE,TDCE,TDE3
	DC.W	TDCE,TDCE,TDCE,TDCE
	DC.W	TDE3,TDCE,TDCE,TDCE
	DC.W	TDCE,TDE3,TDCE,TDCE
	DC.W	TDCE,TDCE,TDE3,TDCE
	DC.W	TDCE,TDCE,TDCE,TDE3
	DC.W	TF40,TF40,TF40,TDCE
	DC.W	TDCE,TDCE,TDCE,TDE3
	DC.W	TDCE,TDCE,TDCE,TDCE
	DC.W	TDE3,TF40,TF40,TF40
	DC.W	TDCE,TDCE,TDCE,TDCE
	DC.W	TDE3,TF40,TF40,TF40
	DC.W	TDCE,TDCE,TDCE,TDCE
	DC.W	TDE3,TDCE,TDCE,TDCE
	DC.W	TDCE,TDE3,TDCE,TDCE
	DC.W	TDCE,TDCE,TDE3,TF40
	DC.W	TF40,TF40,0
TC92:	DC.W	TE26
	DC.W	TE37,TE5E,TE37,TE72
	DC.W	TF40,TE8A,TEC3,TE8A
	DC.W	TEC3,TE8A,TEC3,TF0C
	DC.W	TE8A,TEC3,TF0C,TF40
	DC.W	TF40,TF40,TE8A,TEC3
	DC.W	TF40,TF40,TF40,TE8A
	DC.W	TEC3,TF40,TF40,TF40
	DC.W	TE8A,TEC3,TF0C,TE8A
	DC.W	TEC3,TF0C,TF40,TF40
	DC.W	TF40,0

UABA:	DC.W	UB52,UB52
	DC.W	UB67,UB77,UB77,UB8A
	DC.W	UB9D,UB8A,UB9D,UB8A
	DC.W	UB9D,UB77,UB77,UB8A
	DC.W	UB9D,UB8A,UB9D,UB8A
	DC.W	UB9D,UB52,UBB0,UBB0
	DC.W	UBB0,UBB0,UBB0,UBB0
	DC.W	UBB0,UBB0,UB77,UB77
	DC.W	UB8A,UB9D,UB8A,UB9D
	DC.W	UB8A,UB9D,UB77,UB77
	DC.W	UB8A,UB9D,UB8A,UB9D
	DC.W	UB8A,UB9D,0
UB14:	DC.W	UBC6
	DC.W	UBC6,UBC6,UBDA,UBDA
	DC.W	UBC6,UBED,UBED,UBED
	DC.W	UBED,UBED,UBED,UBED
	DC.W	UBED,UBDA,UBDA,0
UB36:	DC.W	UBFE,UBFE,UBFE,UC12
	DC.W	UC72,UBFE,UCCF,UD96
	DC.W	UCCF,UD9C,UC12,UC72
	DC.W	UD99,0
V1078	DC.W	V10EB
	DC.W	V1102,V1113
V107E	DC.W	V1117,V1117
	DC.W	V1117,V1117,V1135,V114D
	DC.W	V1135,V114D,V1135,V114D
	DC.W	V1135,V114D,V1135,V114D
	DC.W	V1135,V114D,V1135,V114D
	DC.W	V1135,V114D,0
V10A8	DC.W	V1165
	DC.W	V116C,V1187,V118F
V10B0	DC.W	V1193
	DC.W	V11AA,V1193,V1211,0
V10BA	DC.W	V12C8,V12D0,V12EE,V130D
V10C2	DC.W	V1423,V1311,V1328,V1420
	DC.W	V1311,V1328,V1426,V1311
	DC.W	V1328,V1423,V1311,V1328
	DC.W	V1420,V1311,V1328,V1426
	DC.W	V1311,V1328,0
W123A
	DC.W	W177A
	DC.W	W12E8,W12F6,W1324,W1324
	DC.W	W134B,W134B,W134B,W134B
	DC.W	W1379,W13A4,W134B,W134B
	DC.W	W13CF,W134B,W13CF,W134B
	DC.W	W134B,W13FD,W177D,W1324
	DC.W	W1324,W134B,W134B,W134B
	DC.W	W134B,W1379,W13A4,W134B
	DC.W	W134B,W13CF,W134B,W13CF
	DC.W	W134B,W134B,W13FD,W1408
	DC.W	W1408,W1408,W144B,0
W128C
	DC.W	W144F,W1462,W14C4,W14D2
	DC.W	W14D2,W14D2,W14D2,W14EF
	DC.W	W14D2,W14D2,W1520,W14D2
	DC.W	W1520,W14D2,W14D2,W153C
	DC.W	W14C4,W14D2,W14D2,W14D2
	DC.W	W14D2,W14EF,W14D2,W14D2
	DC.W	W1520,W14D2,W1520,W14D2
	DC.W	W14D2,W153C,W1549,W15C9
	DC.W	0
W12CE
	DC.W	W15CD,W15DE,W163E
	DC.W	W164A,W1670,W16AE,W163E
	DC.W	W164A,W1670,W16AE,W16BB
	DC.W	W1739,0
;
;CH_TAB DE TOUTES LES MUSIQUES
;
L25282:	DC.W	FIRST,INST1,INST2,INST3
	DC.W	INST4,INST5,INST6,INST7
	DC.W	INST8,INST9,INST10,INST11
	DC.W	INST12,INST13,LF55

M6CC:
P6D8:
	DC.W	FIRST,INST5,INST7,INST1
	DC.W	INST4,INST9,INST14,INST3
	DC.W	INST15,INST10,INST11,INST12
	DC.W	INST13,INST16

N8E2:	DC.W	FIRST,INST1,INST2,INST16
	DC.W	INST4,INST5,INST6,INST7
	DC.W	INST8,INST9,INST10,INST11
	DC.W	INST12,INST13,N923
O64C:
Q726:
	DC.W	FIRST,INST6,INST7,INST1
	DC.W	INST2,INST9,INST14,INST3
	DC.W	INST15,INST10,INST11,INST12
	DC.W	INST13,INST16

R1FF86:	DC.W	FIRST,INST5,INST7,INST1
	DC.W	INST2,INST9,INST17,INST8
	DC.W	INST6,R763,INST11,R769
	DC.W	INST13,INST4

T2CAE0:	DC.W	FIRST,INST5,INST7,INST1
	DC.W	INST2,INST9,INST17,INST3
	DC.W	INST6,INST10,INST11,INST12
	DC.W	INST13,INST8

U6CC:	DC.W	FIRST,INST5,INST7,INST1
	DC.W	INST4,INST9,INST14,INST8
	DC.W	INST6,INST10,INST11,INST12
	DC.W	INST13,INST16

VFF6	DC.W	FIRST,INST1
	DC.W	INST2,INST3,INST4,INST5
	DC.W	INST6,INST7,INST8,INST9
	DC.W	V1033,INST12,INST13,INST10
	DC.W	V103B,V1043

W10D4	DC.W	FIRST,INST1,INST2,INST3
	DC.W	INST4,INST5,INST6,INST7
	DC.W	INST8,INST9,W1111,INST12
	DC.W	INST13,INST10,W1119,INST15
;
;EV_TAB DE TOUTES LES MUSIQUES
;
L26106:	DC.W	L1DB7,L1DBF,L1DC5,L1DD7
	DC.W	L1E01,L1E0C,L1E36,L1E5B
	DC.W	L1E8B,L1E9B,L1EA6,L1EB2
	DC.W	L1EBA,L1EC1,L1EC4,L1EC7

M70C:	DC.W	M729,M72C,M737,M749
	DC.W	M75F,M767,M76F,M772
	DC.W	M779,M77C,M77F,M790
	DC.W	M799,M7AB

N15E4:	DC.W	N15FD,N1606,N1619,N162B
	DC.W	N1655,N165E,N1688,N168E
	DC.W	N16BE,N16CF,N16E7,N16F5

O68C:	DC.W	O6A9,O6AC,O6B7,O6C9
	DC.W	O6DF,O6E7,O6EE,O6F1
	DC.W	O6F8,O6FB,O6FE,O70F
	DC.W	O716,O728

P718:	DC.W	P72F,P732,P73D,P74F
	DC.W	P765,P76D,P775,P778
	DC.W	P77F,P787,P79C

Q766:	DC.W	Q783,Q786,Q791,Q7A3
	DC.W	Q7CD,Q7D5,Q7DC,Q7DF
	DC.W	Q7E6,Q7E9,Q7EC,Q7FD
	DC.W	Q803,Q809

R1FFCC:	DC.W	R78F,R792,R79D,R7C3
	DC.W	R7D9,R7DE,R7E3,R7EB
	DC.W	R7F3,R7F9,R7FE,R806
	DC.W	R818

T2CB22:	DC.W	T773,T776,T77D,T78F
	DC.W	T7BE,T7CD,T7FC,T80A
	DC.W	T815,T81D,T820,T831
	DC.W	T843,T850,T861,T868

U70C:	DC.W	U729,U72C,U737,U75D
	DC.W	U773,U77B,U783,U786
	DC.W	U78D,U790,U793,U7A4
	DC.W	U7AA,U7BC

V1AA4	DC.W	V1AC5,V1AD1,V1AD6,V1AE8
	DC.W	V1B12,V1B19,V1B43,V1B49
	DC.W	V1B76,V1B7A,V1B81,V1BAF
	DC.W	V1BDB,V1C02,V1C05,V1C0A

W27EE	DC.W	W280F,W2818,W281D,W282F
	DC.W	W2859,W285E,W2888,W288D
	DC.W	W28BD,W28CE,W28DE,W28ED
	DC.W	W28F5,W28FC,W28FF,W2902
;
; LISTE DES INSTRUMENTS
;
FIRST	DC.B	$80
INST1:	DC.B	0,3,$87
INST2:	DC.B	0,4,$87
INST3:	DC.B	0,3,7,$8C
INST4:	DC.B	0,4,7,$8C
INST5:	DC.B	7,$C,$8F
INST6:	DC.B	7,$C,$90
INST7:	DC.B	3,7,$8C
INST8:	DC.B	4,7,$8C
INST9:	DC.B	0,$8C
INST10:	DC.B	0,$83
INST11:	DC.B	0,$84
INST12:	DC.B	0,$85
INST13:	DC.B	0,$87
INST14:	DC.B	0,0,0,$8C
INST15:	DC.B	0,$81
INST16:	DC.B	0,$82
INST17:	DC.B	$C,0,0,$80

R763:	DC.B	0,0,$C,$8C
R769:	DC.B	0,0,0,0,$8C
N923:	DC.B	$C,0,0,0,0,0,0,0,$80
LF55:	DC.B	$C,0,0,0,0,0,0,$80

V1033
W1111
	DC.B	0,$90
V103B
W1119
	DC.B	$C,0,0,0,0,0,0,$80
V1043	DC.B	0,1,$82
;
; LISTE DES SEQUENCES
;
	DC.B	1
M75F:
O6DF:
P765:
Q7CD:
U773:
	DC.B	$F,$E,$D,$C,$B,$A,$87

	DC.B	1
M72C:
O6AC:
P732:
Q786:
U72C:
	DC.B	$F,$E,$D,$B,$A,9,8,7,6,$87

	DC.B	1
L1DC5:
M737:
O6B7:
P73D:
Q791:
T77D:
	DC.B	$F,$E,$C,$B,$D,$C,$A,9,$B,$A,8,7,9,8,6,5,$87

	DC.B	$FF
U78D:
U790:
Q7E6:
O6F8:
M779:
	DC.B	$D,$87

	DC.B	0
U729:
R78F:
P72F:
M729:
	DC.B	0,$87


	DC.B	1
L1E01:	DC.B	$F,$F,$E,$D,$C,$B,$A,9,8,$87
	DC.B	1
L1DB7:	DC.B	$E,$D,$B,9,8,7,$87
	DC.B	2
L1DBF:	DC.B	$F,$E,$D,$B,$87

	DC.B	1
L1E9B:	DC.B	$D,$C,$A,8,7,5,3,1,0,$87
	DC.B	2
L1EB2:	DC.B	8,9,$A,$B,$C,$D,$87
	DC.B	1
L1EBA:	DC.B	$F,$F,$F,$E,1,$87
	DC.B	1
L1EC1:	DC.B	$D,$87
	DC.B	1
L1EC4:	DC.B	$F,$87
	DC.B	1
L1EA6:	DC.B	$E,$D,$C,$B,$A,9,$B,$A,9,8,$87
	DC.B	$FF
L1EC7:	DC.B	0,$87
	DC.B	2
L1E0C:
N165E:
	DC.B	$F,$E,$D,$C,$B,$D,$C,$B,$A,9,$B,$A,9,8
	DC.B	7,9,8,7,6,5,7,6,5,4,3,5,4,3,2,1
	DC.B	4,3,2,1,3,2,1,2,1,0,$87

	DC.B	2
T7CD:	DC.B	$F,$E,$D,$C,$B,$D,$C,$B,$A,9,$B,$A,9,8
	DC.B	7,9,8,7,6,5,7,6,5,4,3,6,5,4,3,2,5
	DC.B	4,3,2,1,4,3,2,1,3,2,1,2,1,0,$87
	DC.B	2
R7C3:	DC.B	$F,$E,$D,$C,$B,$D,$C,$B,$A,9,$B,$A,9,8,7
	DC.B	9,8,7,6,5,$87
	DC.B	3
T7BE:	DC.B	$F,$E,$D,$C,$B,$D,$C,$B,$A,9,$B,$A,9,$87
	DC.B	1
M749:
O6C9:
P74F:
U75D:
	DC.B	$F,$E,$D,$C,$B,$D,$C,$B,$A,9,$B,$A,9
	DC.B	8,7,9,8,7,6,5,$87

	DC.B	1
L1DD7:	DC.B	$F,$E,$D,$C,$B,$D,$C,$B,$A,9,$B,$A,9,8,7,9
	DC.B	8,7,6,5,7,6,5,4,3,5,4,3,2,1,4,3
	DC.B	2,1,3,2,1,2,1,0,$87
	DC.B	1
Q7A3:	DC.B	$F,$E,$D,$C,$B,$D,$C,$B,$A,9,$B,$A,9,8,7,9
	DC.B	8,7,6,5,8,7,6,5,4,7,6,5,4,3,6,5
	DC.B	4,3,2,5,4,3,2,1,$87
	DC.B	1
T78F:	DC.B	$F,$E,$D,$C,$B,$D,$C,$B,$A,9,$B,$A,9,8,7,9
	DC.B	8,7,6,5,7,6,5,4,3,6,5,4,3,2,5,4
	DC.B	3,2,1,4,3,2,1,3,2,1,2,1,0,$87
	DC.B	2
N168E:
L1E5B:
	DC.B	$A,$B,$C,$D,$E,$F,$F,$E,$E,$E,$E,$D,$D,$C
	DC.B	$C,$C,$C,$B,$B,$B,$B,$A,$A,$A,$A,9,9,9,9,8
	DC.B	8,8,8,7,7,7,7,6,6,6,6,5,4,3,2,1,$87
	DC.B	2
N16CF:	DC.B	$A,$B,$C,$D,$E,$F,$F,$E,$E,$E,$E,$D,$D
	DC.B	$C,$C,$C,$C,$B,$B,$B,$B,$A,$87

	DC.B	6
M799:
O716:
U7AA:
	DC.B	$F,$E,$C,$B,$D,$C,$A,9,$B,$A,8,7,9,8,6,5,$87
	DC.B	6
R818:	DC.B	$D,$C,$A,9,$B,$A,8,7,9,8,6,5,7,6,5,3,$87

	DC.B	2
L1E36:	DC.B	$D,$C,$B,$A,9,$B,$A,9,8,7,9,8,7,6,5,7
	DC.B	6,5,4,3,5,4,3,2,1,4,3,2,1,3,2,1
	DC.B	2,1,0,$87

	DC.B	1
N1606:	DC.B	$F,$F,$E,$E,$C,$D,$C,$A,9,$B,$A,8,7,9,8,6,5,$87
	DC.B	1
N1619:	DC.B	$F,$F,$E,$C,$D,$C,$A,9,$B,$A,8,7,9,8,6,5,$87

	DC.B	1
R79D:
U737:
	DC.B	$F,$E,$C,$B,$D,$C,$A,9,$B,$A,8,7,9,8,6,5,7
	DC.B	6,5,4,6,5,4,3,5,4,3,2,4,3,2,1,3,2,1,0,$87

	DC.B	1
T831:	DC.B	$F,$E,$C,$B,$D,$C,$A,9,$B,$A,8,7,$A,8,6,5,$87

	DC.B	3
Q809:	DC.B	$A,$B,$C,$D,$E,$F,$E,$C,$B,$D,$C,$A,9,$B,$A
	DC.B	8,7,9,8,6,5,$87
	DC.B	3
R806:	DC.B	$D,$C,$A,9,$B,$A,8,7,9,8,6,5
	DC.B	7,6,4,3,$87
	DC.B	3
T850:	DC.B	$A,$B,$C,$D,$E,$F,$E,$C,$B,$D,$C,$A,9,$B,$A,$87
	DC.B	4
L1E8B:	DC.B	$E,$D,$C,$B,$A,9,8,7,6,5,4,3,2,1,$87
	DC.B	6
N16BE:	DC.B	$F,$F,$E,$D,$C,$B,9,8,7,6,5,4,3,2,1,$87
	DC.B	1
N16E7:	DC.B	$E,$D,$C,$B,9,8,7,6,5,4,2,1,$87
	DC.B	1
R7FE:	DC.B	$D,$A,8,6,3,1,$87
	DC.B	$A
T7FC:	DC.B	$C,$B,$A,9,8,7,6,5,4,3,2,1,$87
	DC.B	$A
T80A:	DC.B	9,8,7,6,5,4,3,2,1,$87
	DC.B	$A
T815:	DC.B	6,5,4,3,2,1,$87

	DC.B	$FF
O6EE:
Q7DC:
	DC.B	9,$87

	DC.B	3
M767:
P76D:
	DC.B	$E,$D,$C,$B,$A,9,$87
	DC.B	2
N16F5:	DC.B	9,$A,$B,$C,$D,$D,$D,$C,$C,$C,$B,$B,$B,$A,$A,$A,9,$87
	DC.B	1
P77F:
U77B:
	DC.B	$E,$D,$C,$B,$A,9,$87
	DC.B	$A
T861:	DC.B	$D,$C,$B,$A,9,$87

	DC.B	1
M76F:
P775:
U783:
	DC.B	$A,$87
	DC.B	1
T843:	DC.B	$C,$D,$E,$C,$B,$B,$A,9,8,$B,$A,$87
	DC.B	1
N1655:	DC.B	$F,$F,$E,$D,$C,$B,$A,$87
	DC.B	6
Q7FD:	DC.B	$D,$C,$B,$A,$87
	DC.B	7
T776:	DC.B	$E,$D,$C,$B,$A,$87

	DC.B	3
O6E7:
Q7D5:
	DC.B	$E,$D,$C,$B,$A,$87
	DC.B	3
O70F:	DC.B	$F,$E,$C,$B,$A,$87
	DC.B	3
R7E3:	DC.B	$F,$E,$D,$C,$B,$A,$87
	DC.B	2
R7F3:	DC.B	$D,$C,$B,$A,$87
	DC.B	2
R7F9:	DC.B	$F,$D,$A,$87
	DC.B	2
U7A4:	DC.B	$E,$C,$B,$A,$87

	DC.B	0
O6A9:
Q783:
	DC.B	8,$87

	DC.B	1
M772:
O6F1:
P778:
Q7DF:
U786:
	DC.B	$D,$B,$A,9,8,$87
	DC.B	1
R7EB:	DC.B	$D,$C,$B,$A,9,8,$87
	DC.B	$FF
M77C:
O6FB:
Q7E9:
T81D:
	DC.B	$E,$87
	DC.B	3
M790:	DC.B	$F,$E,$C,$B,$A,$D,$C,$87
	DC.B	1
N1688:	DC.B	$C,$D,$D,$C,$87
	DC.B	2
R7D9:	DC.B	$E,$D,$C,$87
	DC.B	1
N15FD:	DC.B	$E,$D,$C,$B,$A,8,6,$87
	DC.B	1
P79C:	DC.B	$C,$B,$A,9,8,7,6,$87
	DC.B	3
R792:	DC.B	$F,$E,$D,$B,$A,9,8,7,6,$87
	DC.B	1
N162B:	DC.B	$F,$F,$C,$B,$A,$D,$C,$B,$A
	DC.B	9,$B,$A,9,8,7,9,8,7,6,5,7,6,5,4,3
	DC.B	5,4,3,2,1,4,3,2,1,3,2,1,2,1,0,$87
	DC.B	7
Q803:	DC.B	$E,$D,$C,$B,$87
	DC.B	$F
R7DE:	DC.B	$F,$E,$D,$87
	DC.B	3
U7BC:	DC.B	$F,$E,$D,$87
	DC.B	0
T773:	DC.B	$D,$87
	DC.B	1
Q7EC:
T820:
M77F:
O6FE:
U793:
	DC.B	$E,$C,$B,$A,$C,$A,9,8,$A,8,7,6,8,6,5,$87
	DC.B	1
P787:	DC.B	$E,$D,$C,$B,$A,$C,$B,$A,9,8,$A,9,8,7,6,8,7,6,5,$87
	DC.B	1
T868:	DC.B	$D,$C,$B,$A,9,8,7,6,5,$87

	DC.B	3
M7AB:
O728:
	DC.B	$A,$B,$C,$D,$E,$F,$E,$C,$B,$D,$C,$A,9,$B
	DC.B	$A,8,7,9,8,6,5,$87
;
; MUSIQUE DE SPEEDBALL
;
L1102:	DC.B	$8A,$88,1,1
	DC.B	$90,$D7,$E5,$84,$28,1,$24,$87
NA61:	DC.B	$D7,$E5,$84,$28,1
	DC.B	$24,$87
L110E:	DC.B	$D4,$E1,$13,$13,$D2,$8B,$1F,$D4
	DC.B	$8A,$13,$13,$13,$8C,$84,$28,1
	DC.B	$2B,$8A,$13,$13,$13,$D2,$8B,$1F
	DC.B	$D4,$8A,$13,$13,$13,$8C,$84,$32
	DC.B	1,$30,$8A,$13,$87
TD33:	DC.B	$BB
	DC.B	$8A,$88,1,2,$D2,$C0,$E1,$C
	DC.B	$C,$13,$13,$8D,7,7,$13,$13
	DC.B	$C,$C,$F,$F,$8D,7,7,$F
	DC.B	$F,$E1,$C,$C,$13,$13,$8D,7
	DC.B	7,$13,$13,7,7,$13,$13,$8D
	DC.B	7,7,$13,$13,$87
UB9D:	DC.B	$C
	DC.B	$18,$8D,$C,$18,$C,$18,$C,$1F
	DC.B	$C,$18,$8D,$C,$18,$C,$18,$C
	DC.B	$13,$87
UBB0:	DC.B	$E1,$D5,$81,$11,$11,$8D
	DC.B	$C,$C,$F,$1B,$D,$D,$11,$1D
	DC.B	$8D,$C,$C,$F,$F,$C,$13,$87

L1133:	DC.B	$13,$13,$D2
	DC.B	$8B,$1F,$D4,$8A,$13,$13,$13,$8C
	DC.B	$84,$28,1,$2B,$8A,$13,$13,$13
	DC.B	$D2,$8B,$1F,$D4,$8A,$13,$13,$8C
	DC.B	$84,$32,1,$30,$84,$32,1,$30
	DC.B	$84,$32,1,$30,$8A,$87
L1181:	DC.B	$C,$C,$D2,$8B,$1F
	DC.B	$D4,$8A,$C,$C,$C,$8C,$84,$28
	DC.B	1,$2B,$8A,$C,$C,$C,$D2,$8B
	DC.B	$1F,$D4,$8A,$C,$C,$8C,$84,$32
	DC.B	1,$30,$84,$32,1,$30,$84,$32
	DC.B	1,$30,$8A,$87
L11CD:	DC.B	$F
	DC.B	$F,$D2,$8B,$1F,$D4,$8A,$F,$F
	DC.B	$F,$8C,$84,$28,1,$2B,$8A,$F
	DC.B	$F,$F,$D2,$8B,$1F,$D4,$8A,$F
	DC.B	$F,$8C,$84,$32,1,$30,$84,$32
	DC.B	1,$30,$84,$32,1,$30,$8A,$87

L115C:	DC.B	$D4,$E1
	DC.B	$C,$C,$D2,$8B,$1F,$D4,$8A,$C
	DC.B	$C,$C,$8C,$84,$28,1,$2B,$8A
	DC.B	$C,$C,$C,$D2,$8B,$1F,$D4,$8A
	DC.B	$C,$C,$C,$8C,$84,$32,1,$30
	DC.B	$8A,$C,$87
MC16:	DC.B	$8A,$C0,$D9,$88,3,6,$82,$FF
	DC.B	$C,$84,$F8,8,$C,$87
MCB6:	DC.B	$8A,$C0,$D8,$81,$FF,$C,$84,$F8
	DC.B	8,$C,$87
O826:	DC.B	$8A,$E0,$11,$11,$E1,$11,$81,$8C
	DC.B	$52,$82,$8A,$11,$F,$E0,$F,$11
	DC.B	$E1,$8B,$8D,$1F,$8A,$C,$87


L11AA:	DC.B	$F,$F,$D2,$8B
	DC.B	$1F,$D4,$8A,$F,$F,$F,$8C,$84
	DC.B	$28,1,$2B,$8A,$F,$F,$F,$D2
	DC.B	$8B,$1F,$D4,$8A,$F,$F,$F,$8C
	DC.B	$84,$32,1,$30,$8A,$F,$87
L11F6:	DC.B	$D4,$E1,$F,$F,$D2,$8B,$1F,$D4
	DC.B	$8A,$F,$F,$F,$8C,$84,$28,1
	DC.B	$2B,$8A,$F,$F,$F,$D2,$8B,$1F
	DC.B	$D4,$8A,$F,$87
MBD4:	DC.B	$C0,$E1
	DC.B	$D2,$8A,$11,$1D,$8B,$8D,$1F,$8A
	DC.B	$1D,$11,$1D,$8C,$8D,$14,$8A,$1D
	DC.B	$11,$1D,$8B,$8D,$1F,$8A,$1D,$11
	DC.B	$1D,$8C,$8D,$14,$8A,$F,$87
NA2E:	DC.B	$8A,$88,1,2,$90,$D2,$E0,$22
	DC.B	$22,$22,$22,$E1,$22,$E5,$F,$E1
	DC.B	$D,$E5,$F,$E1,$D,$E5,$F,$E0
	DC.B	$D,$D,$E1,$F,$E0,$22,$22,$22
	DC.B	$22,$E1,$22,$E5,$F,$E1,$D,$E5
	DC.B	$F,$E1,$D,$E5,$F,$E0,$D,$D
	DC.B	$E1,$F,$87
NB33:	DC.B	$D1,$8A,$E1
	DC.B	$14,$D0,$8B,1,$D2,$8C,$84,$50
	DC.B	1,$8D,$1F,$D1,$8A,$E1,$14,$14
	DC.B	8,$D2,$8C,$84,$50,1,$8D,$1F
	DC.B	$D0,$8B,1,$D1,$8A,$E1,$17,$D0
	DC.B	$8B,1,$D2,$8C,$84,$50,1,$8D
	DC.B	$1F,$D1,$8A,$E1,$16,$8D,$16,$F
	DC.B	$E0,$8D,$12,$12,$E1,$F,$87
O80F:	DC.B	$8A,$E0,$14,$14,$E1,$14,$81
	DC.B	$8C,$52,$82,$8A,$14,$13,$E0,$13
	DC.B	$14,$E1,$8B,$8D,$1F,$8A,$F,$87

L1212:	DC.B	$D,$D,$D2,$8B
	DC.B	$1F,$D4,$8A,$D,$D,$D,$8C,$84
	DC.B	$28,1,$2B,$8A,$D,$D,$D,$D2
	DC.B	$8B,$1F,$D4,$8A,$D,$87
NB6D:	DC.B	$D1
	DC.B	$8A,$E1,$F,$D0,$8B,1,$D2,$8C
	DC.B	$84,$50,1,$8D,$1F,$D0,$8B,1
	DC.B	$D1,$8A,$F,$F,$D2,$8C,$84,$50
	DC.B	1,$8D,$1A,$D0,$8B,1,$D1,$8A
	DC.B	$F,$D0,$8B,1,$D2,$8C,$84,$50
	DC.B	1,$8D,$1F,$D0,$8B,1,$D1,$8A
	DC.B	$F,$F,$D2,$8C,$84,$50,1,$8D
	DC.B	$1A,$D0,$8B,1,$D1,$8A,$12,$D0
	DC.B	$8B,1,$D2,$8C,$84,$50,1,$8D
	DC.B	$1F,$D0,$8B,1,$D1,$8A,$12,$12
	DC.B	$D2,$8C,$84,$50,1,$8D,$1A,$D0
	DC.B	$8B,1,$D1,$8A,$D,$D0,$8B,1
	DC.B	$D2,$8C,$84,$50,1,$8D,$1F,$D0
	DC.B	$8B,1,$D1,$8A,$D,$D,$D2,$8C
	DC.B	$84,$50,1,$8D,$1A,$D0,$8B,1
	DC.B	$D1,$8A,$E1,$F,$D0,$8B,1,$D2
	DC.B	$8C,$84,$50,1,$8D,$1F,$D0,$8B
	DC.B	1,$D1,$8A,$F,$F,$D2,$8C,$84
	DC.B	$50,1,$8D,$1A,$D1,$8A,$F,$D1
	DC.B	$8A,$F,$D0,$8B,1,$D2,$8C,$84
	DC.B	$50,1,$8D,$1F,$D0,$8B,1,$D1
	DC.B	$8A,$F,$F,$D2,$8C,$84,$50,1
	DC.B	$8D,$1A,$D1,$8A,$F,$D1,$8A,$14
	DC.B	$D0,$8B,1,$D2,$8C,$84,$50,1
	DC.B	$8D,$1F,$D0,$8B,1,$D1,$8A,$14
	DC.B	$14,$D2,$8C,$84,$50,1,$8D,$1A
	DC.B	$D1,$8A,$14,$D1,$8A,$D,$D0,$8B
	DC.B	1,$D2,$8C,$84,$50,1,$8D,$1F
	DC.B	$D0,$8B,1,$D1,$8A,$D,$D,$D2
	DC.B	$8C,$84,$50,1,$8D,$1A,$D1,$8A
	DC.B	$D,$87

L122C:	DC.B	$14,$14
	DC.B	$D2,$8B,$1F,$D4,$8A,$14,$14,$14
	DC.B	$8C,$84,$28,1,$2B,$8A,$14,$14
	DC.B	$14,$D2,$8B,$1F,$D4,$8A,$14,$14
	DC.B	$14,$8C,$84,$32,1,$30,$8A,$14,$87

L124F:	DC.B	$8A,$88,1,2,$D7,$E5,$84
	DC.B	$28,1,$28,$90,$87
TCE0:	DC.B	$BF,$8A,$88,2
	DC.B	4,$82,$D5,$C0,$E7,7,7,7
	DC.B	$A,$BE,$90,$87

L125B:	DC.B	$DA,$E1,$1F
	DC.B	$1F,$1F,$1F,$1F,$1F,$1F,$1F,$1F
	DC.B	$1F,$1F,$1F,$1F,$1F,$1F,$1F,$87

L126E:	DC.B	$DA,$E1,$18,$18,$18,$18,$18,$18
	DC.B	$18,$18,$18,$18,$18,$18,$18,$18
	DC.B	$18,$18,$87
L1281:	DC.B	$1B,$1B,$1B,$1B,$1B
	DC.B	$1B,$1B,$1B,$1B,$1B,$1B,$1B,$1B
	DC.B	$1B,$1B,$1B,$87
L1292:	DC.B	$DA,$E1,$1B,$1B
	DC.B	$1B,$1B,$1B,$1B,$1B,$1B,$1B,$1B
	DC.B	$1B,$1B,$87
L12A1:	DC.B	$19,$19,$19,$19,$19
	DC.B	$19,$19,$19,$19,$19,$19,$19,$87
L12AE:	DC.B	$20,$20,$20,$20,$20,$20,$20,$20
	DC.B	$20,$20,$20,$20,$20,$20,$20,$20,$87
L12BF:	DC.B	$8A,$C0,$88,1,2,$D7,$E5
	DC.B	$84,$28,1,$2B,$87
L12CB:	DC.B	$92,0,$8A
	DC.B	$DA,$88,1,2,$C0,$E1,$26,$2B
	DC.B	$32,$26,$2B,$32,$26,$2B,$32,$26
	DC.B	$2B,$32,$26,$2B,$32,$26,$2B,$32
	DC.B	$26,$2B,$32,$26,$2B,$32,$26,$2B
	DC.B	$32,$26,$2B,$32,$26,$2B,$32,$28
	DC.B	$2B,$32,$28,$2B,$32,$28,$2B,$32
	DC.B	$28,$2B,$32,$28,$2B,$32,$28,$2B
	DC.B	$32,$28,$2B,$32,$28,$2B,$32,$28
	DC.B	$2B,$32,$28,$2B,$32,$28,$92,0,$87

L1317:	DC.B	$88,2,2,$D3,$CE
L131C:	DC.B	$E1,$2C
	DC.B	$E3,$2B,$26,$E5,$26,$E1,$2C,$2C
	DC.B	$2B,$E3,$26,$E5,$26,$E1,$33,$33
	DC.B	$32,$E3,$2B,$E5,$2B,$E1,$27,$27
	DC.B	$26,$E3,$2B,$E5,$2B,$CE,$E1,$27
	DC.B	$27,$27,$E3,$24,$E5,$24,$E1,$21
	DC.B	$21,$21,$E3,$1F,$E5,$1F,$E1,$27
	DC.B	$27,$27,$E3,$26,$E5,$26,$E1,$20
	DC.B	$20,$20,$E3,$1F,$E5,$1F,$92,0,$87

L135F:	DC.B	$E0,$DA,$C0,$88,1,1,$1F
	DC.B	$24,$2B,$24,$1F,$24,$30,$24,$1F
	DC.B	$24,$2B,$24,$1F,$24,$30,$24,$1F
	DC.B	$24,$2B,$24,$1F,$24,$30,$24,$1F
	DC.B	$24,$2B,$24,$1F,$24,$30,$24,$24
	DC.B	$2B,$30,$2B,$24,$2B,$37,$2B,$24
	DC.B	$2B,$30,$2B,$24,$2B,$37,$2B,$24
	DC.B	$2B,$30,$2B,$24,$2B,$37,$2B,$24
	DC.B	$2B,$30,$2B,$24,$2B,$37,$2B,$DC
	DC.B	$92,$F4,$88,4,4,$87
L13AC:	DC.B	$E1,$27
	DC.B	$27,$2C,$E3,$2E,$E1,$27,$27,$E3
	DC.B	$2C,$E5,$2E,$E1,$33,$33,$38,$E3
	DC.B	$3A,$E1,$31,$31,$E3,$38,$E5,$3A
	DC.B	$E1,$27,$27,$2C,$E3,$2E,$E1,$27
	DC.B	$27,$E3,$2C,$E5,$2E,$E1,$33,$33
	DC.B	$38,$E3,$3A,$E1,$31,$31,$E3,$38
	DC.B	$E5,$3A,$87
L13E1:	DC.B	$E1,$DA,$27,$2A,$27
	DC.B	$2C,$27,$2E,$27,$33,$27,$2A,$27
	DC.B	$2C,$27,$2E,$27,$33,$27,$2A,$27
	DC.B	$2C,$27,$2E,$27,$33,$25,$2A,$25
	DC.B	$2C,$25,$2E,$25,$31,$25,$2A,$25
	DC.B	$2C,$25,$2E,$25,$31,$25,$2A,$25
	DC.B	$2C,$25,$2E,$25,$31,$87
L1414:	DC.B	$D7,$88
	DC.B	4,4,$CE,$FF,$24,$1F,$20,$1F
	DC.B	$30,$2B,$2C,$2B,$87
;
; MUSIQUE DE GENESIS
;
MB94:	DC.B	$88,1
	DC.B	2,$82,$C0,$90,$D2,$8B,$E1,$1B
	DC.B	$E3,$19,$E1,$17,$E3,$15,$E1,$13
	DC.B	$E3,$11,$E1,$F,$E3,$D,$E3,$B
	DC.B	$E3,9,$87
MBB1:	DC.B	$C0,$88,1,2,$82
	DC.B	$E1,$D2,$8A,$C,$18,$8C,$1F,$8A
	DC.B	$18,$C,$18,$8C,$8D,$13,$8A,$18
	DC.B	$C,$18,$8C,$1F,$8A,$18,$C,$18
	DC.B	$8C,$8D,$13,$8A,$16,$87
MBF5:	DC.B	$C0
	DC.B	$E1,$D2,$8A,$10,$1C,$8B,$8D,$1F
	DC.B	$8A,$1C,$10,$1C,$8C,$8D,$14,$8A
	DC.B	$1C,$10,$1C,$8B,$8D,$1F,$8A,$1C
	DC.B	$10,$1C,$8C,$8D,$14,$8A,$10,$87
MC24:	DC.B	$8A,$DA
	DC.B	$88,1,2,$E1,$C9,$30,$E7,$30
	DC.B	$E1,$CD,$30,$E3,$30,$E1,$C8,$30
	DC.B	$E7,$30,$E1,$CB,$2B,$E3,$2B,$87
MC3E:	DC.B	$8A,$D7,$88,1,2,$C0,$E0,$29
	DC.B	$24,$20,$1D,$2C,$29,$24,$20,$30
	DC.B	$2C,$29,$24,$35,$30,$2C,$1D,$38
	DC.B	$35,$30,$2C,$3C,$38,$35,$30,$41
	DC.B	$3C,$38,$35,$44,$41,$3C,$38,$87
MC66:	DC.B	$8A,$D7,$88,1,2,$C0,$E0,$40
	DC.B	$44,$47,$4A,$3E,$40,$44,$47,$3B
	DC.B	$3E,$40,$44,$38,$3B,$3E,$40,$34
	DC.B	$38,$3B,$3E,$32,$34,$38,$3B,$2F
	DC.B	$32,$34,$38,$2C,$2F,$32,$34,$87
MC8E:	DC.B	$8A,$DA,$88,2,4,$E1,$C5,$25
	DC.B	$24,$25,$24,$25,$24,$25,$24,$31
	DC.B	$30,$31,$30,$31,$30,$31,$30,$25
	DC.B	$24,$25,$24,$25,$24,$25,$24,$2C
	DC.B	$2B,$2C,$2B,$2E,$2B,$2E,$2B,$87
MCC1:	DC.B	$8A,$DA,$88,1,2
	DC.B	$E1,$C9,$37,$E7,$37,$E1,$CD,$37
	DC.B	$E3,$37,$E1,$C8,$37,$E7,$37,$E1
	DC.B	$CB,$32,$E3,$32,$87
MCDB:	DC.B	$D3,$E1,$C5
	DC.B	$1D,$1D,$E1,$C9,$33,$E3,$32,$E5
	DC.B	$84,$FE,5,$30,$E1,$3A,$E3,$39
	DC.B	$38,$E5,$84,$FE,5,$39,$E1,$8F
	DC.B	$E3,$33,$E3,$32,$E5,$84,$FE,5
	DC.B	$30,$E1,$33,$E3,$32,$31,$E5,$84
	DC.B	$FE,5,$32,$87
MD0A:	DC.B	$DB,$E1,$CA,$28
	DC.B	$E3,$28,$CC,$E9,$84,4,$1E,$28
	DC.B	$E1,$CA,$34,$E3,$34,$CC,$E9,$84
	DC.B	2,$1E,$34,$E1,$CA,$28,$E3,$28
	DC.B	$CC,$F9,$84,$FC,$1E,$28,$87
MD2D:	DC.B	$8A
	DC.B	$DA,$E1,$C5,$81,$25,$24,$25,$24
	DC.B	$25,$24,$25,$24,$31,$30,$31,$30
	DC.B	$31,$30,$31,$30,$25,$24,$25,$24
	DC.B	$25,$24,$25,$24,$2C,$2B,$2C,$2B
	DC.B	$2E,$2B,$2E,$2B,$87
MDBB:	DC.B	$8A,$88,1
	DC.B	2,$82,$C9,$DD,$EF,$84,1,$18
	DC.B	$30,$87
MDC8:	DC.B	$8A,$82,$88,4,8,$D6
	DC.B	$C0,$FF,$46,$52,$87
;
; MUSIQUE DE STARRAY
;
; 0 et 2
;
NA22:	DC.B	$93
	DC.B	N960/256
	DC.B	N960&255
	DC.B	$87
NA26:	DC.B	$93
	DC.B	N9A6/256
	DC.B	N9A6&255
	DC.B	$87
NA2A:	DC.B	$93
	DC.B	N9E6/256
	DC.B	N9E6&255
	DC.B	$87
NA68:	DC.B	$D1,$8A,$E3,$F,$D2,$8C
	DC.B	$E1,$84,$50,1,$8D,$1F,$D1,$8A
	DC.B	$E0,$12,$E1,$14,$E2,$14,$D2,$E1
	DC.B	$8C,$E1,$84,$50,1,$8D,$1F,$8B
	DC.B	$D0,$E0,1,1,$D1,$8A,$E3,$D
	DC.B	$D2,$8C,$E1,$84,$50,1,$8D,$1F
	DC.B	$D1,$8A,$E0,$12,$E1,$12,$14,$E0
	DC.B	$12,$E1,$8D,$14,$D2,$8C,$84,$50
	DC.B	1,$8D,$1F,$87
NAAA:	DC.B	$D1,$8A,$E1,$D
	DC.B	$D0,$8B,1,$D2,$8C,$84,$50,1
	DC.B	$8D,$1F,$D1,$8A,$E0,$D,$E1,$D
	DC.B	$E2,$D,$D2,$E1,$8C,$E1,$84,$50
	DC.B	1,$8D,$1F,$8B,$D0,$E1,1,$D1
	DC.B	$8A,$E1,$D,$D0,$8B,1,$D2,$8C
	DC.B	$84,$50,1,$8D,$1F,$D1,$8A,$E0
	DC.B	$12,$E1,$12,$14,$E0,$12,$E1,$8D
	DC.B	$14,$D2,$8C,$84,$50,1,$8D,$1F
	DC.B	$D1,$8A,$E1,$F,$D0,$8B,1,$D2
	DC.B	$8C,$84,$50,1,$8D,$1F,$D1,$8A
	DC.B	$E0,$14,$E1,$14,$E2,$F,$D2,$E1
	DC.B	$8C,$E1,$84,$50,1,$8D,$1F,$8B
	DC.B	$D0,$E1,1,$D1,$8A,$E1,$12,$D0
	DC.B	$8B,1,$D2,$8C,$84,$50,1,$8D
	DC.B	$1F,$D1,$8A,$E0,$D,$E1,$D,$F
	DC.B	$E0,$D,$E1,$8D,$F,$D2,$8C,$84
	DC.B	$50,1,$8D,$1F,$87
NC60:	DC.B	$8A,$88,1,2,$D2,$E0
	DC.B	$27,$27,$27,$27,$E1,$27,$DB,$F9
	DC.B	$22,$D2,$E0,$27,$27,$27,$27,$E1
	DC.B	$27,$DB,$F9,$22,$87
NC7B:	DC.B	$D7,$E5,$84
	DC.B	$28,1,$28,$87
NC82:	DC.B	$81,$D1,$8A,$E3
	DC.B	$F,$82,$D3,$E1,$33,$E0,$2E,$E1
	DC.B	$31,$E6,$33,$81,$D1,$8A,$EF,$D
	DC.B	$82,$87
NC98:	DC.B	$D6,$EF,$20,$27,$22,$25,$87
NC9F:	DC.B	$D6,$E3,$20,$E1,$2C,$E9,$20
	DC.B	$E3,$23,$E1,$2C,$22,$E5,$1E,$E1
	DC.B	$1B,$87
NCB0:	DC.B	$D1,$81,$E3,$F,$82,$27
	DC.B	$81,$E1,$F,$F,$82,$E3,$27,$81
	DC.B	$E3,$F,$82,$27,$81,$E1,$F,$F
	DC.B	$82,$E3,$27,$81,$E3,$12,$82,$27
	DC.B	$81,$E1,$12,$12,$82,$E3,$27,$81
	DC.B	$E3,$D,$82,$27,$81,$E1,$D,$D
	DC.B	$82,$E3,$27,$81,$E3,$F,$82,$27
	DC.B	$81,$E1,$F,$F,$82,$E3,$27,$81
	DC.B	$E3,$F,$82,$27,$81,$E1,$F,$F
	DC.B	$82,$E3,$27,$81,$E3,$14,$82,$27
	DC.B	$81,$E1,$14,$14,$82,$E3,$27,$81
	DC.B	$E3,$D,$82,$27,$81,$E1,$D,$D
	DC.B	$82,$E3,$27,$87
ND12:	DC.B	$8A,$88,1,2
	DC.B	$D2,$E0,$2E,$2E,$2E,$2E,$E1,$2E
	DC.B	$DB,$F9,$27,$D2,$E0,$2E,$2E,$2E
	DC.B	$2E,$E1,$2E,$DB,$F9,$27,$87
ND2D:	DC.B	$D7
	DC.B	$E5,$84,$28,1,$2B,$87
ND34:	DC.B	$D1,$8A
	DC.B	$E3,3,$D3,$E1,$38,$E0,$33,$E1
	DC.B	$36,$E6,$38,$D1,$8A,$EF,1,$87
ND46:	DC.B	$D6,$EF,$25,$2C,$27,$2A,$87
ND4D:	DC.B	$D5
	DC.B	$C9,$EF,$2C,$E5,$2C,$E9,$2C,$C0,$87
ND57:	DC.B	$D2,$E3,$C0,3,$C3,$25,$E1
	DC.B	$C0,3,3,$E3,$C3,$25,$E3,$C0
	DC.B	3,$C3,$25,$E1,$C0,3,3,$E3
	DC.B	$C3,$25,$E3,$C0,6,$C3,$25,$E1
	DC.B	$C0,6,6,$E3,$C3,$25,$E3,$C0
	DC.B	1,$C3,$25,$E1,$C0,1,1,$E3
	DC.B	$C3,$25,$E3,$C0,3,$C3,$31,$E1
	DC.B	$C0,3,3,$E3,$C3,$31,$E3,$C0
	DC.B	3,$C3,$31,$E1,$C0,3,3,$E3
	DC.B	$C3,$31,$E3,$C0,8,$C3,$31,$E1
	DC.B	$C0,8,8,$E3,$C3,$31,$E3,$C0
	DC.B	1,$C3,$31,$E1,$C0,1,1,$E3
	DC.B	$C3,$31,$C0,$87
;
; MUSIQUE DE LEATHERNECK
;
O7F8:	DC.B	$8A,$E0,$C,$C,$E1,$C
	DC.B	$81,$8C,$52,$82,$8A,$C,$A,$E0
	DC.B	$A,$C,$E1,$8B,$8D,$1F,$8A,7,$87
O83D:	DC.B	$90
	DC.B	$88,1,2,$82,$D2,$8A,$E0,$13
	DC.B	$13,$E1,$13,$81,$8C,$52,$82,$8A
	DC.B	$13,$11,$E0,$11,$13,$E1,$8B,$8D
	DC.B	$1F,$8A,$E,$87
O85A:	DC.B	$8A,$C0,$D5,$88
	DC.B	1,2,$82,$C0,$EF,$1F,$88,2
	DC.B	4,$1F,$88,3,6,$1F,$84,$FE
	DC.B	8,$88,4,8,$1F,$87
O874:	DC.B	$C0,$D6
	DC.B	$88,2,2,$82,$C0,$EF,$24,$27
	DC.B	$29,$2B,$24,$27,$29,$26,$32
O885:	DC.B	$D7
	DC.B	$C5,$81,$E2,$3C,$3C,$3C,$3C,$3C
	DC.B	$E0,$3C,$E2,$3F,$3F,$3F,$3F,$3F
	DC.B	$E0,$3F,$E2,$41,$41,$41,$41,$41
	DC.B	$E0,$41,$E2,$43,$44,$43,$44,$43
	DC.B	$E0,$43,$E2,$3C,$3C,$3C,$3C,$3C
	DC.B	$E0,$3C,$E2,$3F,$3F,$3F,$3F,$3F
	DC.B	$E0,$3F,$E2,$41,$41,$41,$41,$41
	DC.B	$E0,$41,$E2,$3E,$3E,$3E,$3E,$3E
	DC.B	$E0,$3E,$DA,$E2,$3E,$3E,$3E,$3F
	DC.B	$3E,$E0,$3E,$87
O8D2:	DC.B	$D7,$C5,$81,$E2
	DC.B	$41,$41,$41,$41,$41,$E0,$41,$E2
	DC.B	$41,$41,$41,$41,$41,$E0,$41,$E2
	DC.B	$3C,$3C,$3C,$3C,$3C,$E0,$3C,$E2
	DC.B	$3C,$3C,$3C,$3C,$3C,$E0,$3C,$E2
	DC.B	$41,$41,$41,$41,$41,$E0,$41,$E2
	DC.B	$41,$41,$41,$41,$41,$E0,$41,$E2
	DC.B	$3E,$3E,$3E,$3E,$3E,$E0,$3E,$DA
	DC.B	$E2,$3E,$3E,$3E,$3E,$3E,$E0,$3E,$87
O917:	DC.B	$8A,$DA,$C5,$88,1,2,$82
	DC.B	$E0,$2B,$2B,$E3,$2B,$E1,$29,$2B
	DC.B	$E0,$29,$E4,$2B,$E0,$2B,$2B,$E3
	DC.B	$2B,$E1,$2B,$29,$E0,$29,$E4,$2B,$87
O937:	DC.B	$DA,$C5,$E0,$24,$24,$E3,$24
	DC.B	$E1,$22,$24,$E0,$22,$E2,$24,$E1
	DC.B	$26,$EF,$27,$E0,$2C,$2C,$E3,$2C
	DC.B	$E1,$2C,$30,$E0,$30,$E2,$2E,$E1
	DC.B	$2C,$EF,$2B,$E0,$30,$30,$E3,$30
	DC.B	$E1,$2E,$30,$E0,$30,$E2,$2E,$E1
	DC.B	$2B,$EF,$27,$E0,$2C,$2C,$E3,$2C
	DC.B	$E1,$2C,$30,$E0,$30,$E2,$2E,$E1
	DC.B	$2C,$EF,$2B,$E1,$2C,$E0,$2C,$E2
	DC.B	$2B,$E1,$29,$E7,$84,2,$18,$2B,$87
O987:	DC.B	$D4,$C6,$88,1,2,$F7,$30
	DC.B	$E1,$33,$E0,$33,$E2,$32,$E1,$30
	DC.B	$F7,$2B,$E1,$33,$E0,$33,$E2,$32
	DC.B	$E1,$30,$F7,$2C,$E1,$33,$E0,$33
	DC.B	$E2,$32,$E1,$30,$FF,$84,$FE,$60
	DC.B	$2F,$87
O9B0:	DC.B	$D7,$81,$CC,$E2,$30,$30
	DC.B	$30,$30,$30,$E0,$30,$E2,$38,$38
	DC.B	$38,$38,$38,$E0,$38,$E2,$35,$35
	DC.B	$35,$35,$35,$E0,$35,$CB,$E2,$37
	DC.B	$37,$37,$37,$37,$E0,$37,$CC,$E2
	DC.B	$30,$30,$30,$30,$30,$E0,$30,$E2
	DC.B	$38,$38,$38,$38,$38,$E0,$38,$E2
	DC.B	$35,$35,$35,$35,$35,$E0,$35,$E2
	DC.B	$37,$37,$37,$37,$37,$E0,$37,$CB
	DC.B	$E2,$3E,$3E,$3E,$3E,$3E,$E0,$3E,$87
OB71:	DC.B	$EF,$80,$80,$80,$80
	DC.B	$80,$80,$80,$80,$80,$87
;
; MUSIQUE DE XENON
;
PAF8:	DC.B	$88,1
	DC.B	2,$82,$90,$E1,$D2,$8A,$C,$18
	DC.B	$D1,$8C,$C,$D2,$8A,$13,$C,$18
	DC.B	$D1,$8B,$8D,$C,$D2,$8A,$1A,$87
PB12:
	DC.B	$8A,$D6,$82,$E7,$88,2,4,$30
	DC.B	$88,3,6,$8F,$88,4,8,$8F
	DC.B	$88,5,$A,$8F,$88,6,$C,$8F
	DC.B	$88,7,$E,$8F,$88,8,$10,$8F
	DC.B	$88,9,$12,$8F,$88,$A,$14,$8F
	DC.B	$88,$B,$16,$8F,$88,$C,$18,$8F
	DC.B	$88,$D,$1A,$8F,$88,$E,$1C,$8F
	DC.B	$88,$F,$1E,$F7,$84,$FF,1,$8F,$87
PB53:	DC.B	$8A,$88,2,4,$82,$E3,$D5
	DC.B	$30,$30,$30,$30,$30,$30,$30,$30
	DC.B	$2B,$2B,$2B,$2B,$2B,$2B,$2B,$2B,$87
PB6B:	DC.B	$8A,$88,1,2,$E0,$D7,$24
	DC.B	$27,$2B,$27,$2B,$2E,$2B,$2E,$30
	DC.B	$2E,$30,$33,$30,$33,$37,$33,$37
	DC.B	$3A,$37,$3A,$3C,$3A,$3C,$3F,$3C
	DC.B	$3F,$43,$3F,$43,$46,$43,$46,$87
PB92:	DC.B	$2B,$2E,$32,$2E,$32,$35,$32,$35
	DC.B	$37,$35,$37,$3A,$37,$3A,$3E,$3A
	DC.B	$3E,$41,$3E,$41,$43,$41,$43,$46
	DC.B	$43,$46,$4A,$46,$4A,$4D,$4A,$4D,$87
PBB3:	DC.B	$8A,$88,1,2,$82,$D4,$E3
	DC.B	$C5,$3C,$3C,$3C,$3C,$3C,$3C,$3C
	DC.B	$3C,$E4,$C8,$47,$47,$47,$47,$47
	DC.B	$47,$E1,$47,$87
PBCE:	DC.B	$C0,$8A,$88,2
	DC.B	4,$82,$E1,$D5,$8F,$E3,$32,$33
	DC.B	$35,$37,$32,$33,$35,$37,$30,$33
	DC.B	$37,$3E,$30,$33,$37,$E1,$3E,$87
PBEA:	DC.B	$88,2,4,$D3,$C0,$E3,$30,$33
	DC.B	$37,$E1,$30,$E3,$33,$37,$E1,$30
	DC.B	$E3,$33,$37,$C9,$E3,$30,$CA,$33
	DC.B	$C9,$37,$E1,$30,$E3,$CA,$33,$C9
	DC.B	$37,$E1,$30,$E3,$CA,$33,$C9,$37,$87
PC13:	DC.B	$C0,$E3,$37,$3A,$3E,$E1,$37
	DC.B	$E3,$3A,$3E,$E1,$37,$E3,$3A,$3E
	DC.B	$C9,$E3,$37,$CA,$3A,$C9,$3E,$E1
	DC.B	$37,$E3,$CA,$3A,$C9,$3E,$E1,$37
	DC.B	$E3,$CA,$3A,$C9,$3E,$87
PC38:	DC.B	$CD,$E3
	DC.B	$3A,$3A,$3A,$3A,$3A,$3A,$3A,$3A
	DC.B	$E4,$3A,$3A,$3A,$3A,$3A,$E6,$3A,$87
PD2E:	DC.B	$88,1,2,$82
	DC.B	$90,$D3,$8A,$E0,$C,$C,$E1,$18
	DC.B	$C,$18,$C,$18,$C,$18,$87
PD41:	DC.B	$8A
	DC.B	$E0,$A,$A,$E1,$16,$A,$16,$A
	DC.B	$16,$A,$16,$87
PD4E:	DC.B	$8A,$88,1,2
	DC.B	$82,$D9,$C9,$E5,$28,$28,$E3,$28
	DC.B	$E5,$28,$28,$E3,$28,$87
PD60:	DC.B	$E5,$34
	DC.B	$34,$E3,$34,$E5,$34,$34,$E3,$34,$87
PD6B:	DC.B	$C9,$E5,$2B,$2B,$E3,$2B,$E5
	DC.B	$2B,$2B,$E3,$2B,$87
PD77:	DC.B	$C9,$E5,$2B
	DC.B	$2B,$CD,$E3,$2E,$CA,$E5,$2E,$2E
	DC.B	$CD,$E3,$2E,$87
PD86:	DC.B	$8A,$DA,$88,1
	DC.B	1,$82,$C6,$E1,$80,$34,$35,$34
	DC.B	$80,$34,$35,$34,$80,$34,$35,$34
	DC.B	$80,$34,$35,$34,$80,$40,$41,$40
	DC.B	$80,$40,$41,$40,$80,$40,$41,$40
	DC.B	$80,$40,$41,$40,$87
PDAF:	DC.B	$D7,$C5,$88
	DC.B	1,1,$E0,$37,$37,$E1,$3A,$3C
	DC.B	$E0,$3A,$3A,$E1,$3C,$37,$E0,$3C
	DC.B	$3C,$E1,$37,$3A,$E0,$37,$37,$E1
	DC.B	$3A,$3C,$E0,$3A,$3A,$E1,$3C,$37
	DC.B	$E0,$3C,$3C,$87
PDD6:	DC.B	$D9,$88,1,2
	DC.B	$E1,$C5,$8C,$24,$8A,$30,$35,$34
	DC.B	$8C,$24,$8A,$30,$35,$34,$8C,$24
	DC.B	$8A,$30,$35,$34,$8C,$24,$8A,$30
	DC.B	$35,$34,$C5,$8C,$24,$8A,$CA,$30
	DC.B	$35,$C9,$34,$C5,$8C,$24,$8A,$CA
	DC.B	$30,$35,$C9,$34,$C5,$8C,$24,$8A
	DC.B	$CA,$30,$35,$C9,$34,$C5,$8C,$24
	DC.B	$8A,$CA,$30,$35,$C9,$34,$87
PE19:	DC.B	$D8
	DC.B	$88,1,2,$C5,$E1,$28,$29,$2B
	DC.B	$E3,$2C,$2B,$F1,$28,$E1,$28,$2B
	DC.B	$2D,$E3,$2E,$2D,$F1,$28,$E1,$35
	DC.B	$37,$39,$E3,$3A,$39,$F1,$32,$E1
	DC.B	$CA,$35,$C9,$37,$39,$E3,$CA,$3A
	DC.B	$C9,$39,$F1,$34,$E1,$35,$37,$39
	DC.B	$E3,$3A,$39,$F1,$32,$E1,$CA,$35
	DC.B	$C9,$37,$39,$E3,$CA,$3A,$C9,$39
	DC.B	$F1,$34,$87
PE5D:	DC.B	$D7,$88,1,1,$C0
	DC.B	$E0,$18,$1C,$1F,$24,$1C,$1F,$24
	DC.B	$34,$1F,$24,$34,$37,$24,$34,$37
	DC.B	$3C,$34,$37,$3C,$40,$37,$3C,$40
	DC.B	$43,$3C,$40,$43,$48,$40,$43,$48
	DC.B	$4C,$87
PE84:	DC.B	$16,$1A,$1D,$22,$1A,$1D
	DC.B	$22,$26,$1D,$22,$26,$29,$22,$26
	DC.B	$29,$2E,$26,$29,$2E,$32,$29,$2E
	DC.B	$32,$35,$2E,$32,$35,$3A,$32,$35
	DC.B	$3A,$3E,$87
;
; MUSIQUE DE GOLDRUNNER 2
;
;
Q92E:	DC.B	$90,$8A
	DC.B	$D3,$C0,$88,1,2,$82,$E1,$C
	DC.B	$18,$8B,$8D,$1F,$8A,$18,$C,$18
	DC.B	$8B,$8D,$11,$8A,$E0,$C,$18,$87
Q948:	DC.B	$E1,$11,$1D,$8B,$8D,$1F,$8A,$1D
	DC.B	$11,$1D,$8B,$8D,$11,$8A,$E0,$11
	DC.B	$1D,$87
Q95A:	DC.B	$E1,$E,$1A,$8B,$8D,$1F
	DC.B	$8A,$1A,$E,$1A,$8B,$8D,$11,$8A
	DC.B	$E0,$E,$1A,$87
Q96C:	DC.B	$E1,$15,$21,$8B
	DC.B	$8D,$1F,$8A,$21,$15,$21,$8B,$8D
	DC.B	$11,$8A,$E0,$15,$21,$87
Q97E:	DC.B	$E1,$13
	DC.B	$1F,$8B,$8D,$1F,$8A,$1F,$13,$1F
	DC.B	$8B,$8D,$11,$8A,$E0,$13,$1F,$87
Q990:	DC.B	$E1,$10,$1C,$8B,$8D,$1F,$8A,$1C
	DC.B	$10,$1C,$8B,$8D,$11,$8A,$E0,$10
	DC.B	$1C,$87
Q9A2:	DC.B	$E1,$F,$1B,$8B,$8D,$1F
	DC.B	$8A,$1B,$F,$1B,$8B,$8D,$11,$8A
	DC.B	$E0,$F,$1B,$87
Q9B4:	DC.B	$8A,$DC,$88,1
	DC.B	2,$82,$C0,$EF,$84,$FF,$3C,$28
	DC.B	$E3,$29,$28,$E1,$26,$E3,$28,$F1
	DC.B	$84,$FF,$3C,$24,$E3,$29,$28,$E1
	DC.B	$26,$E3,$28,$F1,$84,$FF,$3C,$21
	DC.B	$E3,$29,$28,$E1,$26,$E3,$28,$ED
	DC.B	$24,$E1,$24,$ED,$23,$E1,$23,$ED
	DC.B	$21,$E1,$21,$F1,$84,$FE,$3C,$1F
	DC.B	$EF,$84,$FE,$3C,$28,$E3,$30,$2F
	DC.B	$E1,$2D,$E3,$2F,$F1,$84,$FE,$3C
	DC.B	$24,$E3,$30,$2F,$E1,$2D,$E3,$2F
	DC.B	$F1,$84,$FE,$3C,$26,$E3,$30,$2F
	DC.B	$E1,$2D,$E3,$2F,$ED,$C9,$2D,$E1
	DC.B	$2D,$ED,$CA,$2B,$E1,$2B,$ED,$29
	DC.B	$E1,$29,$F1,$CB,$26,$E3,$32,$32
	DC.B	$32,$32,$87
QA2B:	DC.B	$8A,$DC,$88,1,2
	DC.B	$82,$C0,$EF,$84,$FF,$3C,$34,$E3
	DC.B	$35,$34,$E1,$32,$E3,$34,$F1,$84
	DC.B	$FF,$3C,$30,$E3,$35,$34,$E1,$32
	DC.B	$E3,$34,$F1,$84,$FF,$3C,$2D,$E3
	DC.B	$35,$34,$E1,$32,$E3,$34,$ED,$30
	DC.B	$E1,$30,$ED,$2F,$E1,$2F,$ED,$2D
	DC.B	$E1,$2D,$F1,$84,$FE,$3C,$2B,$EF
	DC.B	$84,$FE,$3C,$34,$E3,$3C,$3B,$E1
	DC.B	$39,$E3,$3B,$F1,$84,$FE,$3C,$30
	DC.B	$E3,$3C,$3B,$E1,$39,$E3,$3B,$F1
	DC.B	$84,$FE,$3C,$32,$E3,$3C,$3B,$E1
	DC.B	$39,$E3,$3B,$ED,$C9,$39,$E1,$39
	DC.B	$ED,$CA,$37,$E1,$37,$ED,$35,$E1
	DC.B	$35,$F1,$CB,$32,$E3,$3E,$3E,$3E
	DC.B	$3E,$87
QAA2:	DC.B	$8A,$DC,$88,1,2,$82
	DC.B	$C0,$EF,$2B,$E3,$2B,$28,$E1,$29
	DC.B	$E3,$2B,$F1,$2D,$E3,$2D,$29,$E1
	DC.B	$2B,$E3,$2D,$F1,$2F,$E3,$2F,$2B
	DC.B	$E1,$2D,$E3,$2F,$ED,$30,$E1,$30
	DC.B	$ED,$2F,$E1,$2F,$ED,$2D,$E1,$2D
	DC.B	$F1,$2B,$E3,$37,$37,$37,$37,$87
QAD8:	DC.B	$8A,$D3,$88,1,1,$82,$ED,$CA
	DC.B	$30,$F5,$C9,$30,$E9,$CA,$30,$F1
	DC.B	$C9,$30,$ED,$CA,$30,$F5,$C9,$30
	DC.B	$E9,$CA,$30,$F1,$C9,$30,$87
QAF7:	DC.B	$8A
	DC.B	$DB,$81,$C0,$E0,$80,$EF,$84,$FF
	DC.B	$3C,$28,$E3,$29,$28,$E1,$26,$E3
	DC.B	$28,$F1,$84,$FF,$3C,$24,$E3,$29
	DC.B	$28,$E1,$26,$E3,$28,$F1,$84,$FF
	DC.B	$3C,$21,$E3,$29,$28,$E1,$26,$E3
	DC.B	$28,$ED,$24,$E1,$24,$ED,$23,$E1
	DC.B	$23,$ED,$21,$E1,$21,$F1,$84,$FE
	DC.B	$3C,$1F,$EF,$84,$FE,$3C,$28,$E3
	DC.B	$30,$2F,$E1,$2D,$E3,$2F,$F1,$84
	DC.B	$FE,$3C,$24,$E3,$30,$2F,$E1,$2D
	DC.B	$E3,$2F,$F1,$84,$FE,$3C,$26,$E3
	DC.B	$30,$2F,$E1,$2D,$E3,$2F,$ED,$C9
	DC.B	$2D,$E1,$2D,$ED,$CA,$2B,$E1,$2B
	DC.B	$ED,$29,$E1,$29,$F1,$CB,$26,$E3
	DC.B	$32,$32,$32,$E2,$32,$87
QB6E:	DC.B	$8A,$DB
	DC.B	$81,$C0,$E0,$80,$EF,$84,$FF,$3C
	DC.B	$34,$E3,$35,$34,$E1,$32,$E3,$34
	DC.B	$F1,$84,$FF,$3C,$30,$E3,$35,$34
	DC.B	$E1,$32,$E3,$34,$F1,$84,$FF,$3C
	DC.B	$2D,$E3,$35,$34,$E1,$32,$E3,$34
	DC.B	$ED,$30,$E1,$30,$ED,$2F,$E1,$2F
	DC.B	$ED,$2D,$E1,$2D,$F1,$84,$FE,$3C
	DC.B	$2B,$EF,$84,$FE,$3C,$34,$E3,$3C
	DC.B	$3B,$E1,$39,$E3,$3B,$F1,$84,$FE
	DC.B	$3C,$30,$E3,$3C,$3B,$E1,$39,$E3
	DC.B	$3B,$F1,$84,$FE,$3C,$32,$E3,$3C
	DC.B	$3B,$E1,$39,$E3,$3B,$ED,$C9,$39
	DC.B	$E1,$39,$ED,$CA,$37,$E1,$37,$ED
	DC.B	$35,$E1,$35,$F1,$CB,$32,$E3,$3E
	DC.B	$3E,$3E,$E2,$3E,$87
QBE5:	DC.B	$8A,$DC,$88
	DC.B	1,2,$82,$C0,$EF,$84,$FF,$3C
	DC.B	$24,$E3,$26,$24,$E1,$23,$E3,$24
	DC.B	$F1,$84,$FF,$3C,$21,$E3,$26,$24
	DC.B	$E1,$23,$E3,$24,$F1,$84,$FF,$3C
	DC.B	$1D,$E3,$26,$24,$E1,$23,$E3,$24
	DC.B	$ED,$21,$E1,$21,$ED,$1F,$E1,$1F
	DC.B	$ED,$1D,$E1,$1D,$F1,$84,$FE,$3C
	DC.B	$1A,$EF,$84,$FE,$3C,$24,$E3,$2D
	DC.B	$2B,$E1,$29,$E3,$2B,$F1,$84,$FE
	DC.B	$3C,$21,$E3,$2D,$2B,$E1,$29,$E3
	DC.B	$2B,$F1,$84,$FE,$3C,$29,$E3,$2D
	DC.B	$2B,$E1,$29,$E3,$2B,$ED,$2D,$E1
	DC.B	$2D,$ED,$2B,$E1,$2B,$ED,$29,$E1
	DC.B	$29,$F1,$26,$E3,$32,$32,$32,$32,$87
QC59:	DC.B	$8A,$DC,$88,1,2,$82,$C0
	DC.B	$EF,$28,$E3,$28,$24,$E1,$26,$E3
	DC.B	$28,$F1,$29,$E3,$29,$26,$E1,$28
	DC.B	$E3,$29,$F1,$2B,$E3,$2B,$28,$E1
	DC.B	$29,$E3,$2B,$ED,$2D,$E1,$2D,$ED
	DC.B	$2B,$E1,$2B,$ED,$29,$E1,$29,$F1
	DC.B	$26,$E3,$32,$32,$32,$32,$87
QC8F:	DC.B	$8A
	DC.B	$D3,$81,$C0,$E5,$48,$43,$44,$41
	DC.B	$E7,$43,$E5,$48,$43,$44,$3F,$E7
	DC.B	$43,$E5,$54,$4F,$50,$4D,$E7,$4F
	DC.B	$E5,$54,$4F,$50,$4B,$E7,$4F,$87
;
; MUSIQUE DE ENDURO RACER
;
RB7E:	DC.B	$88,2
	DC.B	4,$82,$90,$D2,$8A,$E1,$18,$8B
	DC.B	$E0,$8D,$1F,$8A,$18,$18,$18,$8B
	DC.B	$8D,$1F,$8A,$18,$87
RB95:	DC.B	$8A,$E1,$16
	DC.B	$8B,$E0,$8D,$1F,$8A,$16,$16,$16
	DC.B	$8B,$8D,$1F,$8A,$16,$87
RBB0:	DC.B	$8A,$88,2,4,$82,$D5,$EF,$18
	DC.B	$18,$16,$EB,$16,$87
RBBD:	DC.B	$EF,$18,$16
	DC.B	$16,$87
RBC2:	DC.B	$8A,$C0,$88,1,2,$82
	DC.B	$D3,$E1,$24,$E0,$C9,$30,$C0,$24
	DC.B	$24,$C9,$33,$C0,$24,$24,$C9,$35
	DC.B	$C0,$24,$24,$C9,$33,$C0,$24,$24
	DC.B	$E1,$C9,$30,$C0,$87
RBE5:	DC.B	$E1,$22,$E0
	DC.B	$C9,$2E,$C0,$22,$22,$C9,$32,$C0
	DC.B	$22,$22,$C9,$33,$C0,$22,$22,$C9
	DC.B	$32,$C0,$22,$22,$E1,$C9,$2E,$C0,$87
RC01:	DC.B	$E0,$22,$22,$C9,$2E,$C0,$22
	DC.B	$C9,$32,$C0,$22,$C9,$33,$C0,$22
	DC.B	$C9,$32,$C0,$22,$C9,$2E,$C0,$22,$87
RC19:	DC.B	$C5,$E1,$30,$E0,$33,$35,$33
	DC.B	$30,$E1,$33,$E0,$35,$33,$E1,$30
	DC.B	$E0,$35,$33,$35,$E2,$2E,$32,$33
	DC.B	$E1,$32,$2E,$E0,$33,$32,$32,$33
	DC.B	$E1,$2E,$E2,$3E,$3F,$E1,$3E,$3A
	DC.B	$E0,$3F,$3E,$3E,$3F,$87
;
; MUSIQUE DE ICE PALACE
;
TCF0:	DC.B	$81,$87
TCF2:	DC.B	$88,2
	DC.B	4,$82
TCF6:	DC.B	$8A,$D5,$C0,$E3,$C,$C
	DC.B	$C,$E1,$C,$16,$E3,$C,$C,$C
	DC.B	$E1,$C,$16,$E3,$C,$C,$C,$E1
	DC.B	$C,$16,$E3,$C,$C,$C,$E1,$C
	DC.B	$16,$87
TD16:	DC.B	$E3,7,7,7,$E1,7
	DC.B	6,$E3,7,7,7,$E1,7,6
	DC.B	$E3,7,7,7,$E1,7,6,$E3
	DC.B	7,7,7,$E1,7,6,$87
TD61:	DC.B	8,8,$14
	DC.B	$14,$8D,8,8,$14,$14,5,5
	DC.B	$11,$11,$8D,5,5,$11,$11,7
	DC.B	7,$13,$13,$8D,7,7,$13,$13
	DC.B	$13,$13,$1F,$1F,$8D,$13,$13,$1F
	DC.B	$1F,8,8,$14,$14,$8D,8,8
	DC.B	$14,$14,5,5,$11,$11,$8D,5
	DC.B	5,$11,$11,3,3,$F,$F,$8D
	DC.B	3,3,$F,$F,7,7,$13,$13
	DC.B	$8D,$13,$13,$8D,$1F,$1F,$87
TDAB:	DC.B	$D5
	DC.B	$8B,$E9,$8D,$E,$8D,8,$EB,$8D
	DC.B	5,$87
TDB6:	DC.B	$D1,$8A,$88,2,4,$82
	DC.B	$C0,$ED,$37,$E1,$3E,$ED,$3E,$E1
	DC.B	$42,$ED,$43,$E1,$4A,$ED,$4A,$E1
	DC.B	$4A,$87
TDCE:	DC.B	$8A,$DF,$81,$E3,$C3,$3C
	DC.B	$43,$48,$43,$E1,$C3,$3C,$3C,$43
	DC.B	$43,$48,$48,$C1,$43,$43,$87
TDE3:	DC.B	$E1
	DC.B	$C5,$44,$44,$44,$44,$44,$44,$44
	DC.B	$44,$41,$41,$41,$41,$41,$41,$41
	DC.B	$41,$43,$43,$43,$43,$43,$43,$43
	DC.B	$43,$4F,$4F,$4F,$4F,$4F,$4F,$4F
	DC.B	$4F,$44,$44,$44,$44,$44,$44,$44
	DC.B	$44,$41,$41,$41,$41,$41,$41,$41
	DC.B	$41,$3F,$3F,$3F,$3F,$4B,$4B,$4B
	DC.B	$4B,$43,$43,$43,$43,$4F,$4F,$4F
	DC.B	$4F,$87
TE26:	DC.B	$8A,$88,1,2,$82,$DD
	DC.B	$C0,$F7,$52,$E5,$85,$8F,$E1,$D5
	DC.B	$CB,$38,$87
TE37:	DC.B	$8A,$88,1,2,$82
	DC.B	$D4,$ED,$84,1,$46,$37,$E1,$CC
	DC.B	$3D,$ED,$84,1,$46,$3C,$E1,$CB
	DC.B	$44,$ED,$84,1,$46,$43,$E1,$CC
	DC.B	$49,$ED,$84,1,$46,$48,$E1,$CB
	DC.B	$50,$87
TE5E:	DC.B	$D4,$8A,$C5,$ED,$3E,$E1
	DC.B	$42,$ED,$43,$E1,$49,$ED,$4A,$E1
	DC.B	$4E,$ED,$4F,$E1,$4F,$87
TE72:	DC.B	$D1,$8A
	DC.B	$88,1,2,$82,$C0,$ED,$3E,$E1
	DC.B	$42,$ED,$43,$E1,$49,$ED,$4A,$E1
	DC.B	$4E,$ED,$4F,$E1,$4F,$87
TE8A:	DC.B	$D3,$8A
	DC.B	$88,4,4,$82,$C6,$E9,$30,$E1
	DC.B	$32,$E3,$33,$E9,$37,$E1,$37,$E3
	DC.B	$38,$E9,$35,$E1,$32,$E3,$33,$E9
	DC.B	$32,$E1,$33,$E3,$32,$C5,$E9,$30
	DC.B	$E1,$32,$E3,$33,$E9,$37,$E1,$37
	DC.B	$E3,$38,$E9,$35,$E1,$32,$E3,$33
	DC.B	$E9,$32,$E1,$33,$E3,$32,$87
TEC3:	DC.B	$DA
	DC.B	$8A,$81,$C0,$E1,$3B,$3C,$3C,$3C
	DC.B	$3E,$3C,$3C,$3C,$3B,$3C,$3C,$3C
	DC.B	$3F,$3C,$3C,$3C,$3C,$3E,$3E,$3E
	DC.B	$3F,$3E,$3E,$3E,$48,$4A,$4A,$4A
	DC.B	$4B,$4A,$4A,$4A,$C5,$3B,$3C,$3C
	DC.B	$3C,$3E,$3C,$3C,$3C,$3B,$3C,$3C
	DC.B	$3C,$3F,$3C,$3C,$3C,$CB,$39,$3A
	DC.B	$3A,$3A,$45,$46,$46,$46,$CC,$38
	DC.B	$37,$37,$37,$44,$43,$43,$43,$87
TF0C:	DC.B	$DB,$8A,$81,$E5,$C0,$48,$43,$44
	DC.B	$41,$43,$3E,$3F,$3B,$3C,$37,$38
	DC.B	$35,$37,$32,$33,$2F,$C6,$48,$43
	DC.B	$44,$41,$43,$3E,$3F,$3B,$3C,$37
	DC.B	$38,$35,$37,$32,$33,$2F,$C5,$48
	DC.B	$43,$44,$41,$43,$3E,$3F,$3B,$3C
	DC.B	$37,$E3,$8F,$87
TF40:	DC.B	$E5,$85,$8F,$87
TFE8:	DC.B	$FF,$80,$87
;
; MUSIQUE DE RAMPAGE
;
UB52:	DC.B	$8A,$88,1,1
	DC.B	$82,$C0,$90,$D2,$E1,$11,$E3,$11
	DC.B	$E1,$11,$E3,$11,$E1,$11,$F1,$11,$87
UB67:	DC.B	$D9,$FF,$88,4,8,$82,$84
	DC.B	$FA,8,$11,$D2,$E1,$88,1,1,$87
UB77:	DC.B	$11,$1D,$8D,$11,$1D,$11,$1D
	DC.B	$11,$24,$11,$1D,$8D,$11,$1D,$11
	DC.B	$1D,$11,$18,$87
UB8A:	DC.B	$F,$1B,$8D,$F
	DC.B	$1B,$F,$1B,$F,$22,$F,$1B,$8D
	DC.B	$F,$1B,$F,$1B,$F,$16,$87
UBC6:	DC.B	$8A,$88,1,1,$82,$C0,$D2,$E1
	DC.B	$18,$E3,$18,$E1,$18,$E3,$18,$E1
	DC.B	$18,$F1,$18,$87
UBDA:	DC.B	$8A,$DB,$FF,$C2
	DC.B	$35,$35,$C7,$33,$C1,$30,$C7,$33
	DC.B	$C1,$30,$C7,$33,$C8,$30,$87
UBED:	DC.B	$8A
	DC.B	$DB,$C2,$E5,$35,$35,$E3,$C3,$35
	DC.B	$C2,$E5,$35,$35,$E3,$C1,$29,$87
UBFE:	DC.B	$8A,$88,1,1,$82,$C0,$D2,$E1
	DC.B	$1D,$E3,$1D,$E1,$1D,$E3,$1D,$E1
	DC.B	$1D,$F1,$1D,$87
UC12:	DC.B	$8A,$88,4,4
	DC.B	$C0,$DD,$EB,$30,$E1,$2C,$D3,$F1
	DC.B	$29,$DD,$EB,$30,$E1,$2C,$D3,$ED
	DC.B	$29,$E3,$28,$EF,$27,$E3,$8C,$46
	DC.B	$41,$3A,$8A,$E1,$29,$F1,$24,$E3
	DC.B	$8C,$46,$41,$3A,$35,$8A,$8A,$EF
	DC.B	$C5,$27,$E3,$8C,$46,$41,$3A,$8A
	DC.B	$E1,$25,$F1,$24,$E3,$8C,$46,$41
	DC.B	$3A,$35,$8A,$EF,$CA,$27,$E3,$8C
	DC.B	$46,$41,$3A,$8A,$E1,$25,$F1,$24
	DC.B	$8C,$D5,$E0,$30,$34,$37,$3C,$34
	DC.B	$37,$3C,$40,$37,$3C,$40,$43,$3C
	DC.B	$40,$43,$48,$87
UC72:	DC.B	$8A,$88,4,4
	DC.B	$C0,$D3,$EB,$30,$E1,$2C,$F1,$29
	DC.B	$EB,$30,$E1,$2C,$ED,$29,$E3,$28
	DC.B	$EF,$27,$E3,$8C,$46,$41,$3A,$8A
	DC.B	$E1,$29,$F1,$24,$E3,$8C,$46,$41
	DC.B	$3A,$35,$8A,$8A,$EF,$C5,$27,$E3
	DC.B	$8C,$46,$41,$3A,$8A,$E1,$25,$F1
	DC.B	$24,$E3,$8C,$46,$41,$3A,$35,$8A
	DC.B	$EF,$CA,$27,$E3,$8C,$46,$41,$3A
	DC.B	$8A,$E1,$25,$F1,$24,$8C,$D5,$E0
	DC.B	$30,$34,$37,$3C,$34,$37,$3C,$40
	DC.B	$37,$3C,$40,$43,$3C,$40,$43,$48,$87
UCCF:	DC.B	$8A,$88,1,2,$C5,$D3,$E1
	DC.B	$24,$E3,$24,$E1,$24,$25,$E3,$24
	DC.B	$E1,$24,$27,$E3,$24,$E1,$24,$2C
	DC.B	$E3,$29,$E1,$29,$25,$E3,$24,$E1
	DC.B	$24,$22,$E3,$1F,$E1,$20,$1F,$ED
	DC.B	$1D,$D5,$E1,$30,$E3,$30,$E1,$30
	DC.B	$31,$E3,$30,$E1,$30,$33,$E3,$30
	DC.B	$E1,$30,$38,$E3,$35,$E1,$35,$31
	DC.B	$E3,$30,$E1,$30,$2E,$E3,$2B,$E1
	DC.B	$2C,$2B,$ED,$29,$87

;
; musique de COSMIC PIRATE
;
;	DC.B	$FF,$80
;	DC.B	$87
V10EB
	DC.B	$D4,$88,1,2,$8A,$E3,$80
	DC.B	$C,$18,$C,$18,$C,$18,$C,$18
	DC.B	$13,$1F,$13,$1F,$13,$1F,$13,$1F
V1102	DC.B	$C,$18,$C,$18,$C,$18,$C,$18
	DC.B	$13,$1F,$13,$1F,$13,$1F,$13,$1F
	DC.B	$87
V1113
	DC.B	$93
	DC.B	V107E/256
	DC.B	V107E&255,$87
V1117
	DC.B	$8A,$D4,$88
	DC.B	1,2,$90,$E3,$C,$E1,$8D,$18
	DC.B	$18,$13,$13,$8D,$1A,$E3,$18,$E1
	DC.B	$18,$8D,$1F,$1F,$13,$8D,$13,$8D
	DC.B	$1F,$1F,$87
V1135
	DC.B	$E3,$C,$E1,$8D,$18
	DC.B	$18,$13,$13,$8D,$1F,$E3,$C,$E1
	DC.B	$C,$8D,$18,$18,$13,$8D,$13,$8D
	DC.B	$18,$18,$87
V114D
	DC.B	$E3,$A,$E1,$8D,$16
	DC.B	$16,$11,$11,$8D,$16,$E3,$A,$E1
	DC.B	$A,$8D,$16,$16,$11,$8D,$11,$8D
	DC.B	$16,$16,$87
V1165
	DC.B	$D6,$8A,$88,2,2
	DC.B	$E3,$80
V116C
	DC.B	$1F,$1D,$1C,$1A,$E1,$18
	DC.B	$1C,$1D,$1C,$E3,$18,$E1,$1F,$21
	DC.B	$E3,$23,$1A,$1A,$E1,$1F,$21,$E3
	DC.B	$23,$1A,$1A,$8F,$87
V1187
	DC.B	$DD,$88,1
	DC.B	2,$FF,$1C,$1F,$87
V118F
	DC.B	$93
	DC.B	V10B0/256,V10B0&255
	DC.B	$87
V1193
	DC.B	$8A,$DD,$88,1,2,$FF,$1C
	DC.B	$1F,$1B,$FB,$84,$FC,$30,$18,$81
	DC.B	$D1,$92,$F4,$D1,$E1,$2B,$29,$87
V11AA
	DC.B	$FB,$2B,$E1,$29,$2B,$EF,$27,$EB
	DC.B	$26,$88,1,2,$E1,$27,$26,$FB
	DC.B	$27,$E1,$26,$27,$FB,$22,$81,$E1
	DC.B	$27,$26,$FB,$27,$E1,$26,$27,$EF
	DC.B	$24,$EB,$22,$88,1,2,$E1,$24
	DC.B	$22,$FB,$24,$E1,$22,$24,$FB,$1D
	DC.B	$81,$92,0,$E1,$2B,$29,$FB,$2B
	DC.B	$E1,$29,$2B,$EF,$27,$EB,$26,$88
	DC.B	1,2,$E1,$27,$26,$FB,$27,$E1
	DC.B	$26,$27,$FB,$22,$81,$E1,$27,$26
	DC.B	$FB,$27,$E1,$26,$27,$EF,$24,$EB
	DC.B	$22,$88,1,2,$E1,$24,$22,$FB
	DC.B	$24,$E1,$22,$24,$FF,$1D,$87
V1211
	DC.B	$92
	DC.B	$C,$D9,$88,1,1,$CE,$E1,$2B
	DC.B	$24,$2B,$24,$2B,$24,$2B,$24,$2B
	DC.B	$24,$2B,$24,$2B,$24,$2B,$24,$2B
	DC.B	$24,$2B,$24,$2B,$24,$2B,$24,$29
	DC.B	$22,$29,$22,$29,$22,$29,$22,$2B
	DC.B	$24,$2B,$24,$2B,$24,$2B,$24,$2B
	DC.B	$24,$2B,$24,$2B,$24,$2B,$24,$26
	DC.B	$22,$26,$22,$26,$22,$26,$22,$26
	DC.B	$22,$26,$22,$26,$22,$26,$22,$FB
	DC.B	$27,$E1,$26,$27,$EF,$24,$EB,$22
	DC.B	$E1,$24,$22,$FB,$24,$E1,$22,$24
	DC.B	$FF,$1D,$E1,$92,0,$2B,$24,$2B
	DC.B	$24,$2B,$24,$2B,$24,$2B,$24,$2B
	DC.B	$24,$2B,$24,$2B,$24,$2B,$24,$2B
	DC.B	$24,$2B,$24,$2B,$24,$29,$22,$29
	DC.B	$22,$29,$22,$29,$22,$2B,$24,$2B
	DC.B	$24,$2B,$24,$2B,$24,$2B,$24,$2B
	DC.B	$24,$2B,$24,$2B,$24,$26,$22,$26
	DC.B	$22,$26,$22,$26,$22,$26,$22,$26
	DC.B	$22,$26,$22,$26,$22,$88,1,2
	DC.B	$D1,$C0,$FB,$27,$E1,$26,$27,$EF
	DC.B	$24,$EB,$22,$E1,$24,$22,$FB,$24
	DC.B	$E1,$22,$24,$FF,$1D,$87
V12C8
	DC.B	$88,2
	DC.B	2,$D6,$8A,$E1,$24,$23
V12D0	DC.B	$E3,$24
	DC.B	$21,$1F,$1D,$E1,$1C,$1F,$21,$1F
	DC.B	$E3,$1C,$E1,$23,$24,$E3,$26,$1F
	DC.B	$1F,$E1,$23,$24,$E3,$26,$1F,$1F
	DC.B	$E1,$24,$23,$87
V12EE
	DC.B	$E3,$24,$21,$1F
	DC.B	$1D,$E1,$1C,$1F,$21,$1F,$E3,$1C
	DC.B	$E1,$23,$24,$E3,$26,$1F,$1F,$E1
	DC.B	$23,$24,$E3,$26,$1F,$E7,$84,5
	DC.B	$10,$1F,$87
V130D
	DC.B	$93
	DC.B	V10C2/256,V10C2&255
	DC.B	$87
V1311
	DC.B	$8A
	DC.B	$D5,$88,1,2,$FF,$C9,$2B,$30
	DC.B	$2B,$FB,$30,$C0,$D1,$88,2,4
	DC.B	$92,$F4,$E1,$2B,$29,$87
V1328
	DC.B	$FB,$2B
	DC.B	$E1,$29,$2B,$EF,$27,$EB,$26,$E1
	DC.B	$2B,$29,$FB,$2B,$E1,$29,$2B,$FB
	DC.B	$26,$E1,$27,$26,$FB,$27,$E1,$26
	DC.B	$27,$EF,$24,$EB,$22,$E1,$27,$26
	DC.B	$FB,$27,$E1,$26,$27,$FB,$22,$88
	DC.B	1,2,$92,0,$E1,$2B,$29,$FB
	DC.B	$2B,$E1,$29,$2B,$EF,$27,$EB,$26
	DC.B	$E1,$2B,$29,$FB,$2B,$E1,$29,$2B
	DC.B	$FB,$26,$E1,$27,$26,$FB,$27,$E1
	DC.B	$26,$27,$EF,$24,$EB,$22,$E1,$27
	DC.B	$26,$FB,$27,$E1,$26,$27,$FF,$22
	DC.B	$87

;
; EVTAB
;
	DC.B	1
V1AC5	DC.B	$B,$D,$C,$B,$A,9,8
	DC.B	7,6,5,$87
	DC.B	6
V1AD1	DC.B	$F,$E,$D
	DC.B	$87
	DC.B	1
V1AD6	DC.B	$F,$F,$E,$B,$D,$C
	DC.B	$A,9,$B,$A,8,7,9,8
	DC.B	6,5,$87
	DC.B	1
V1AE8	DC.B	$F,$E,$D,$C
	DC.B	$B,$D,$C,$B,$A,9,$B,$A
	DC.B	9,8,7,9,8,7,6,5
	DC.B	7,6,5,4,3,5,4,3
	DC.B	2,1,4,3,2,1,3,2
	DC.B	1,2,1,0,$87
	DC.B	1
V1B12	DC.B	$F,$F
	DC.B	$E,$D,$C,$87
	DC.B	2
V1B19	DC.B	$F,$E,$D
	DC.B	$C,$B,$D,$C,$B,$A,9,$B
	DC.B	$A,9,8,7,9,8,7,6
	DC.B	5,7,6,5,4,3,5,4
	DC.B	3,2,1,4,3,2,1,3
	DC.B	2,1,2,1,0,$87
	DC.B	1
V1B43	DC.B	$D
	DC.B	$F,$D,$C,$87
	DC.B	5
V1B49	DC.B	$A,$B,$C
	DC.B	$D,$E,$E,$E,$E,$D,$D,$C
	DC.B	$C,$C,$C,$B,$B,$B,$B,$A
	DC.B	$A,$A,$A,9,9,9,9,8
	DC.B	8,8,8,7,7,7,7,6
	DC.B	6,6,6,5,4,3,2,1
	DC.B	$87
	DC.B	2
V1B76	DC.B	$E,$E,$87
	DC.B	1
V1B7A	DC.B	$E,$D
	DC.B	$C,$B,$A,$87
	DC.B	1
V1B81	DC.B	$F,$E,$D
	DC.B	$D,$D,$C,$C,$C,$B,$B,$B
	DC.B	$A,$A,$A,9,9,9,8,8
	DC.B	8,8,7,7,7,7,6,6
	DC.B	6,6,5,5,5,5,4,4
	DC.B	4,4,3,3,3,3,2,2
	DC.B	1,$87
	DC.B	1
V1BAF	DC.B	$E,$D,$D,$C,$C
	DC.B	$C,$B,$B,$B,$A,$A,$A,9
	DC.B	9,9,8,8,8,8,7,7
	DC.B	7,7,6,6,6,6,5,5
	DC.B	5,5,4,4,4,4,3,3
	DC.B	3,3,2,2,1,$87
	DC.B	1
V1BDB	DC.B	$C
	DC.B	$B,$B,$B,$A,$A,$A,9,9
	DC.B	9,8,8,8,8,7,7,7
	DC.B	7,6,6,6,6,5,5,5
	DC.B	5,4,4,4,4,3,3,3
	DC.B	3,2,2,1,$87
	DC.B	1
V1C02	DC.B	$D,$87
	DC.B	4
V1C05	DC.B	$F,$E,$D,$87
	DC.B	$FF
V1C0A	DC.B	0,$87
;
; MUSIQUE DE ZOMBI
;

W12E8
	DC.B	$8A,$D8,$88,1
	DC.B	2,$C0,$EF,$10,$10,$1C,$81,$CE
	DC.B	$40,$87
W12F6
	DC.B	$C0,$88,1,1,$E2,$10
	DC.B	$10,$10,$10,$10,$10,$10,$10,$10
	DC.B	$10,$10,$10,$10,$10,$10,$10,$10
	DC.B	$10,$10,$10,$E,$E,$E,$E,$13
	DC.B	$13,$13,$13,$15,$15,$15,$15,$10
	DC.B	$10,$10,$10,$10,$10,$10,$10,$87
W1324
	DC.B	$88,1,2,$8A,$D2,$90,$E1,$10
	DC.B	$E0,$10,$E1,$10,$E0,$10,$E1,$10
	DC.B	$E0,$10,$E1,$10,$E0,$10,$E1,$10
	DC.B	$E0,$10,$E1,$10,$E0,$10,$E1,$10
	DC.B	$E0,$10,$E1,$10,$E0,$10,$87
W134B
	DC.B	$88
	DC.B	1,1,$E1,$10,$E0,$10,$E1,$8C
	DC.B	$84,$28,1,$2B,$8A,$E0,$10,$E1
	DC.B	$10,$E0,$10,$E1,$10,$E0,$10,$E1
	DC.B	$10,$E0,$10,$E1,$8C,$84,$32,1
	DC.B	$30,$8A,$E0,$10,$E1,$10,$E0,$10
	DC.B	$E1,$10,$E0,$10,$87
W1379
	DC.B	$E1,$13,$E0
	DC.B	$13,$E1,$8C,$84,$28,1,$2B,$8A
	DC.B	$E0,$13,$E1,$13,$E0,$13,$E1,$13
	DC.B	$E0,$13,$E1,$13,$E0,$13,$E1,$8C
	DC.B	$84,$32,1,$30,$8A,$E0,$13,$E1
	DC.B	$13,$E0,$13,$E1,$13,$E0,$13,$87
W13A4
	DC.B	$E1,$11,$E0,$11,$E1,$8C,$84,$28
	DC.B	1,$2B,$8A,$E0,$11,$E1,$11,$E0
	DC.B	$11,$E1,$11,$E0,$11,$E1,$11,$E0
	DC.B	$11,$E1,$8C,$84,$32,1,$30,$8A
	DC.B	$E0,$11,$E1,$11,$E0,$11,$E1,$11
	DC.B	$E0,$11,$87
W13CF
	DC.B	$E0,$C,$C,$C,$8C
	DC.B	$84,$28,1,$2B,$8A,$C,$18,$C
	DC.B	$C,$C,$8C,$84,$32,1,$30,$8A
	DC.B	$C,$C,$C,$C,$C,$8C,$84,$28
	DC.B	1,$2B,$8A,$C,$18,$C,$C,$C
	DC.B	$8C,$84,$32,1,$30,$8A,$C,$C
	DC.B	$87
W13FD
	DC.B	$D8,$EB,$10,$10,$18,$15,$10
	DC.B	$10,$10,$10,$87
W1408
	DC.B	$D2,$E0,$C,$C
	DC.B	$C,$C,$C,$C,$C,$C,$C,$C
	DC.B	$C,$C,$C,$C,$C,$C,$11,$11
	DC.B	$11,$11,$11,$11,$11,$11,$11,$11
	DC.B	$11,$11,$11,$11,$11,$11,$C,$C
	DC.B	$C,$C,$C,$C,$C,$C,$C,$C
	DC.B	$C,$C,$C,$C,$C,$C,$E,$E
	DC.B	$E,$E,$E,$E,$E,$E,$13,$13
	DC.B	$13,$13,$13,$13,$13,$13,$87
W144B
	DC.B	$D8
	DC.B	$F7,$1C,$87
W144F
	DC.B	$94,$26,$8A,$D9,$88
	DC.B	1,2,$E1,$80,$C0,$EF,$17,$17
	DC.B	$23,$81,$ED,$CE,$47,$87
W1462
	DC.B	$94,$1C
	DC.B	$D2,$C0,$88,1,2,$E3,$23,$E0
	DC.B	$23,$23,$E1,$23,$23,$23,$E3,$23
	DC.B	$E0,$23,$23,$E1,$23,$23,$23,$E3
	DC.B	$23,$E0,$23,$23,$E1,$23,$23,$23
	DC.B	$E3,$23,$E0,$23,$23,$E1,$23,$23
	DC.B	$23,$E3,$23,$E0,$23,$23,$E1,$23
	DC.B	$23,$23,$E3,$23,$E0,$23,$23,$E1
	DC.B	$23,$23,$23,$E3,$26,$E0,$26,$26
	DC.B	$E1,$26,$26,$26,$E3,$28,$E0,$28
	DC.B	$28,$E1,$28,$28,$28,$E3,$28,$E0
	DC.B	$28,$28,$E1,$28,$28,$28,$E3,$28
	DC.B	$E0,$28,$28,$E1,$28,$28,$28,$87
W14C4
	DC.B	$94,$1E,$D8,$C0,$EA,$17,$EC,$17
	DC.B	$CE,$EA,$17,$EC,$17,$87
W14D2
	DC.B	$CE,$81
	DC.B	$D0,$E0,$3B,$40,$43,$3C,$40,$43
	DC.B	$3E,$40,$43,$39,$40,$43,$3B,$40
	DC.B	$43,$3C,$40,$43,$37,$40,$43,$3E
	DC.B	$40,$43,$87
W14EF
	DC.B	$3B,$3E,$43,$3C,$3E
	DC.B	$43,$3B,$3E,$43,$39,$3E,$43,$3B
	DC.B	$3E,$43,$3C,$3E,$43,$37,$3E,$43
	DC.B	$3E,$3E,$43,$39,$3C,$41,$3B,$3C
	DC.B	$41,$39,$3C,$41,$3B,$3C,$41,$45
	DC.B	$48,$4D,$47,$48,$4D,$45,$48,$4D
	DC.B	$47,$48,$4D,$87
W1520
	DC.B	$D8,$88,2,2
	DC.B	$C0,$92,0,$E3,$24,$E0,$1F,$24
	DC.B	$E3,$28,$E0,$24,$28,$E3,$2B,$E0
	DC.B	$28,$2B,$E3,$30,$E0,$2B,$30,$87
W153C
	DC.B	$CE,$81,$D5,$EB,$3B,$37,$37,$34
	DC.B	$34,$34,$40,$40,$87
W1549
	DC.B	$D8,$C0,$88
	DC.B	1,2,$94,$18,$E2,$18,$18,$E1
	DC.B	$18,$E2,$18,$18,$E1,$18,$E2,$18
	DC.B	$18,$E1,$18,$E2,$18,$18,$E1,$18
	DC.B	$E2,$18,$18,$E1,$18,$E2,$18,$18
	DC.B	$E1,$18,$E2,$1A,$1A,$E1,$1A,$E2
	DC.B	$1A,$1A,$E1,$1A,$E2,$24,$24,$E1
	DC.B	$24,$E2,$24,$24,$E1,$24,$E2,$24
	DC.B	$24,$E1,$24,$E2,$24,$24,$E1,$24
	DC.B	$E2,$24,$24,$E1,$24,$E2,$24,$24
	DC.B	$E1,$24,$E2,$26,$26,$E1,$26,$E2
	DC.B	$26,$26,$E1,$26,$E2,$27,$27,$E1
	DC.B	$27,$E2,$24,$24,$E1,$24,$E2,$24
	DC.B	$24,$E1,$24,$E2,$29,$29,$E1,$29
	DC.B	$E2,$27,$27,$E1,$27,$E2,$24,$24
	DC.B	$E1,$24,$E2,$26,$26,$E1,$26,$E2
	DC.B	$26,$26,$E1,$26,$87
W15C9
	DC.B	$D8,$F7,$21
	DC.B	$87
W15CD
	DC.B	$8A,$D8,$88,1,2,$E3,$80
	DC.B	$C0,$EF,$1C,$1C,$28,$81,$EB,$CE
	DC.B	$4C,$87
W15DE
	DC.B	$D2,$C0,$88,1,2,$E3
	DC.B	$28,$E0,$28,$28,$E1,$28,$28,$28
	DC.B	$E3,$2A,$E0,$2A,$2A,$E1,$2A,$2A
	DC.B	$2A,$E3,$2B,$E0,$2B,$2B,$E1,$2B
	DC.B	$2B,$2B,$E3,$2D,$E0,$2D,$2D,$E1
	DC.B	$2D,$2D,$2D,$E3,$28,$E0,$28,$28
	DC.B	$E1,$28,$28,$28,$E3,$2A,$E0,$2A
	DC.B	$2A,$E1,$2A,$2A,$2A,$E3,$2B,$E0
	DC.B	$2B,$2B,$E1,$2B,$2B,$2B,$E3,$2D
	DC.B	$E0,$2D,$2D,$E1,$2D,$2D,$2D,$E3
	DC.B	$2F,$E0,$2F,$2F,$E1,$2F,$2F,$2F
	DC.B	$E3,$2F,$E0,$2F,$2F,$E1,$2F,$2F
	DC.B	$2F,$87
W163E
	DC.B	$D8,$C0,$EA,$1C,$EC,$1C
	DC.B	$CE,$EA,$1C,$EC,$1C,$87
W164A
	DC.B	$D7,$88
	DC.B	2,2,$C0,$92,0,$EA,$41,$EC
	DC.B	$40,$EA,$39,$EC,$3B,$EA,$42,$EC
	DC.B	$40,$EA,$39,$EC,$37,$EA,$32,$EC
	DC.B	$37,$EA,$35,$EC,$34,$EA,$2F,$EC
	DC.B	$3B,$F7,$47,$87
W1670
	DC.B	$88,2,2,$C0
	DC.B	$D8,$E3,$28,$E0,$24,$28,$E3,$2B
	DC.B	$E0,$28,$2B,$E3,$30,$E0,$2B,$30
	DC.B	$E3,$34,$E0,$30,$34,$D7,$F7,$34
	DC.B	$D8,$E3,$34,$E0,$30,$34,$E3,$37
	DC.B	$E0,$34,$37,$E3,$3C,$E0,$37,$3C
	DC.B	$E3,$40,$E0,$3C,$40,$D7,$F7,$CE
	DC.B	$84,1,$30,$40,$81,$D5,$EB,$4C
	DC.B	$4C,$87
W16AE
	DC.B	$CE,$81,$D5,$EB,$40,$3B
	DC.B	$3C,$39,$3B,$3B,$47,$47,$87
W16BB
	DC.B	$D8
	DC.B	$C0,$88,1,2,$E2,$1F,$1F,$E1
	DC.B	$1F,$E2,$1F,$1F,$E1,$1F,$E2,$1D
	DC.B	$1D,$E1,$1D,$E2,$1D,$1D,$E1,$1D
	DC.B	$E2,$1F,$1F,$E1,$1F,$E2,$1F,$1F
	DC.B	$E1,$1F,$E2,$1F,$1F,$E1,$1F,$E2
	DC.B	$1F,$1F,$E1,$1F,$E2,$2B,$2B,$E1
	DC.B	$2B,$E2,$2B,$2B,$E1,$2B,$E2,$29
	DC.B	$29,$E1,$29,$E2,$29,$29,$E1,$29
	DC.B	$E2,$2B,$2B,$E1,$2B,$E2,$2B,$2B
	DC.B	$E1,$2B,$E2,$2B,$2B,$E1,$2B,$E2
	DC.B	$2B,$2B,$E1,$2B,$E2,$2B,$2B,$E1
	DC.B	$2B,$E2,$27,$27,$E1,$27,$E2,$29
	DC.B	$29,$E1,$29,$E2,$2C,$2C,$E1,$2C
	DC.B	$E2,$2B,$2B,$E1,$2B,$E2,$27,$27
	DC.B	$E1,$27,$E2,$2B,$2B,$E1,$2B,$E2
	DC.B	$1F,$1F,$E1,$1F,$87
W1739
	DC.B	$D8,$F7,$28
	DC.B	$87
;
	DC.B	1
W280F	DC.B	$E,$C,$B,$A,9,8,7
	DC.B	$87
	DC.B	2
W2818	DC.B	$F,$E,$D,$87
	DC.B	1
W281D	DC.B	$F
	DC.B	$F,$E,$C,$D,$C,$A,9,$B
	DC.B	$A,8,7,9,8,6,5,$87
	DC.B	1
W282F	DC.B	$F,$E,$D,$C,$B,$D,$C
	DC.B	$B,$A,9,$B,$A,9,8,7
	DC.B	9,8,7,6,5,7,6,5
	DC.B	4,3,5,4,3,2,1,4
	DC.B	3,2,1,3,2,1,2,1
	DC.B	0,$87
	DC.B	2
W2859	DC.B	$F,$E,$D,$87
	DC.B	2
W285E	DC.B	$F,$E,$D,$C,$B,$D,$C,$B
	DC.B	$A,9,$B,$A,9,8,7,9
	DC.B	8,7,6,5,7,6,5,4
	DC.B	3,5,4,3,2,1,4,3
	DC.B	2,1,3,2,1,2,1,0
	DC.B	$87
	DC.B	8
W2888	DC.B	$F,$E,$D,$87
	DC.B	2
W288D	DC.B	$A
	DC.B	$B,$C,$D,$E,$F,$F,$E,$E
	DC.B	$E,$E,$D,$D,$C,$C,$C,$C
	DC.B	$B,$B,$B,$B,$A,$A,$A,$A
	DC.B	9,9,9,9,8,8,8,8
	DC.B	7,7,7,7,6,6,6,6
	DC.B	5,4,3,2,1,$87
	DC.B	8
W28BD	DC.B	$F
	DC.B	$E,$D,$C,$B,$A,9,8,7
	DC.B	6,5,4,3,2,1,$87
	DC.B	6
W28CE	DC.B	$E,$D,$C,$B,$A,9,8,7
	DC.B	6,5,4,3,2,1,$87
	DC.B	6
W28DE	DC.B	$D,$C,$B,$A,9,8,7,6
	DC.B	5,4,3,2,1,$87
	DC.B	2
W28ED	DC.B	8
	DC.B	9,$A,$B,$C,$D,$87
	DC.B	1
W28F5	DC.B	$F
	DC.B	$F,$F,$E,1,$87
	DC.B	1
W28FC	DC.B	$D,$87
	DC.B	1
W28FF	DC.B	$B,$87
	DC.B	$FF
W2902	DC.B	0,$87


UD99:
TFEE:
QD78:
PEA9:
OB7C:
NFAE:
MDE3:
L1745:
V1423:
W177A:
	DC.B	$89,0,$87

UD96:
OB7F:
NFB1:
TFF1:
QD7B:
PEAC:
L1748:
V1426:
W177D:
	DC.B	$89,1,$87
PEAF:
NFB4:
TFF4:
OB82:
W1780:
	DC.B	$89,2,$87

TFF7:
OB85:
	DC.B	$89,3,$87

PEB5:
MDE9:
	DC.B	$89,4,$87

L174B:	DC.B	$89,$C,$87
L174E:	DC.B	$89,$18,$87
L1751:	DC.B	$89,$24,$87

MDE0:
	DC.B	$89,$FE,$87

QD75:
PEA6:
UD9C:
TFEB:
V1420:
	DC.B	$89,$FF,$87
