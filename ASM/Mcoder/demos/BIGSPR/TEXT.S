;
; MOULINETTE DE SCROLLER-TEXTE
;
LOAD=$40000
SAVE=$50000
SAVE2=$60000

	LEA	LOAD,A5
	LEA	SAVE,A6
BCL:
	MOVE.B	(A5)+,D0
	BEQ.S	FINI
	CMP.B	#13,D0
	BEQ.S	BCL
	CMP.B	#10,D0
	BEQ.S	BCL
	MOVE.B	D0,(A6)+
	BRA.S	BCL

FINI:
	ST	(A6)
;
; INITIALISE LE SCROLLER
;
	LEA	SAVE,A0
	LEA	SAVE2,A1
	MOVEQ	#0,D0
CONV:	MOVE.B	(A0)+,D0
	BMI.S	FINCONV
	MOVE.B	L5D94(PC,D0.W),(A1)+
	BRA.S	CONV
FINCONV:
	LEA	SAVE2,A0
	ST	(A1)+
	ILLEGAL
L5D94:
	DC.B	$2E,$24,$24,$24,$24,$24,$24,$24
	DC.B	$24,$24,$24,$24,$24,$24,$24,$24
	DC.B	$24,$24,$24,$24,$24,$24,$24,$24	;10
	DC.B	$24,$24,$24,$24,$24,$24,$24,$24
	DC.B	$24,$29,$2D,$24,$24,$24,$24,$2D	;20
	DC.B	$25,$26,$24,$24,$2B,$30,$27,$24
	DC.B	$23,$1A,$1B,$1C,$1D,$1E,$1F,$20	;30
	DC.B	$21,$22,$28,$2C,$24,$24,$24,$2A
	DC.B	$24,0,1,2,3,4,5,6		;40
	DC.B	7,8,9,$A,$B,$C,$D,$E
	DC.B	$F,$10,$11,$12,$13,$14,$15,$16	;50
	DC.B	$17,$18,$19,$24,$24,$24,$24,$24
	DC.B	$24,$24,$24,$24,$24,$24,$24,$24	;60
	DC.B	$24,$24,$24,$24,$24,$24,$24,$24
	DC.B	$24,$24,$24,$24,$24,$24,$24,$24	;70
	DC.B	$24,$24,$24,$24,$24,$24,$24,$24
