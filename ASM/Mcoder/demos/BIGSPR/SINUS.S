TABLEX:
	REPT	3
	DC.W	144,145,147,149,151,152,154,156,158,159,161,163,165,166,168,170
	DC.W	172,173,175,177,178,180,182,184,185,187,189,190,192,194,195,197
	DC.W	199,200,202,203,205,207,208,210,211,213,214,216,218,219,221,222
	DC.W	224,225,226,228,229,231,232,233,235,236,238,239,240,242,243,244
	DC.W	245,247,248,249,250,251,253,254,255,256,257,258,259,260,261,262
	DC.W	263,264,265,266,267,268,269,270,270,271,272,273,274,274,275,276
	DC.W	277,277,278,278,279,280,280,281,281,282,282,283,283,284,284,284
	DC.W	285,285,285,286,286,286,286,287,287,287,287,287,287,287,287,287
	DC.W	288,287,287,287,287,287,287,287,287,287,286,286,286,286,285,285
	DC.W	285,284,284,284,283,283,282,282,281,281,280,280,279,278,278,277
	DC.W	277,276,275,274,274,273,272,271,270,270,269,268,267,266,265,264
	DC.W	263,262,261,260,259,258,257,256,255,254,253,251,250,249,248,247
	DC.W	245,244,243,242,240,239,238,236,235,233,232,231,229,228,226,225
	DC.W	224,222,221,219,218,216,214,213,211,210,208,207,205,203,202,200
	DC.W	199,197,195,194,192,190,189,187,185,184,182,180,178,177,175,173
	DC.W	172,170,168,166,165,163,161,159,158,156,154,152,151,149,147,145
	DC.W	144,142,140,138,136,135,133,131,129,128,126,124,122,121,119,117
	DC.W	115,114,112,110,109,107,105,103,102,100,98,97,95,93,92,90
	DC.W	88,87,85,84,82,80,79,77,76,74,73,71,69,68,66,65
	DC.W	63,62,61,59,58,56,55,54,52,51,49,48,47,45,44,43
	DC.W	42,40,39,38,37,36,34,33,32,31,30,29,28,27,26,25
	DC.W	24,23,22,21,20,19,18,17,17,16,15,14,13,13,12,11
	DC.W	10,10,9,9,8,7,7,6,6,5,5,4,4,3,3,3
	DC.W	2,2,2,1,1,1,1,0,0,0,0,0,0,0,0,0
	DC.W	0,0,0,0,0,0,0,0,0,0,1,1,1,1,2,2
	DC.W	2,3,3,3,4,4,5,5,6,6,7,7,8,9,9,10
	DC.W	10,11,12,13,13,14,15,16,17,17,18,19,20,21,22,23
	DC.W	24,25,26,27,28,29,30,31,32,33,34,36,37,38,39,40
	DC.W	42,43,44,45,47,48,49,51,52,54,55,56,58,59,61,62
	DC.W	63,65,66,68,69,71,73,74,76,77,79,80,82,84,85,87
	DC.W	88,90,92,93,95,97,98,100,102,103,105,107,109,110,112,114
	DC.W	115,117,119,121,122,124,126,128,129,131,133,135,136,138,140,142
	ENDR
	DCB.W	MAX,$8000
TABLEY:
	REPT	3
	DC.W	27040,26880,26880,26880,26880,26880,26880,26880,26880,26880
	DC.W	26880,26880,26880,26720,26720,26720,26720,26720,26560,26560
	DC.W	26560,26560,26400,26400,26400,26400,26240,26240,26240,26080
	DC.W	26080,25920,25920,25920,25760,25760,25600,25600,25440,25440
	DC.W	25440,25280,25280,25120,24960,24960,24800,24800,24640,24640
	DC.W	24480,24320,24320,24160,24160,24000,23840,23840,23680,23520
	DC.W	23520,23360,23200,23040,23040,22880,22720,22720,22560,22400
	DC.W	22240,22080,22080,21920,21760,21600,21440,21280,21280,21120
	DC.W	20960,20800,20640,20480,20320,20320,20160,20000,19840,19680
	DC.W	19520,19360,19200,19040,18880,18720,18560,18400,18240,18080
	DC.W	17920,17760,17760,17600,17440,17280,17120,16960,16800,16640
	DC.W	16480,16320,16000,15840,15680,15520,15360,15200,15040,14880
	DC.W	14720,14560,14400,14240,14080,13920,13760,13600,13440,13280
	DC.W	13120,12960,12800,12640,12480,12320,12160,12000,11840,11680
	DC.W	11520,11360,11200,11040,10880,10560,10400,10240,10080,9920
	DC.W	9760,9600,9440,9280,9120,9120,8960,8800,8640,8480
	DC.W	8320,8160,8000,7840,7680,7520,7360,7200,7040,6880
	DC.W	6720,6560,6560,6400,6240,6080,5920,5760,5600,5600
	DC.W	5440,5280,5120,4960,4800,4800,4640,4480,4320,4160
	DC.W	4160,4000,3840,3840,3680,3520,3360,3360,3200,3040
	DC.W	3040,2880,2720,2720,2560,2560,2400,2240,2240,2080
	DC.W	2080,1920,1920,1760,1600,1600,1440,1440,1440,1280
	DC.W	1280,1120,1120,960,960,960,800,800,640,640
	DC.W	640,480,480,480,480,320,320,320,320,160
	DC.W	160,160,160,160,0,0,0,0,0,0
	DC.W	0,0,0,0,0,0,0,0,0,0
	DC.W	0,0,0,0,0,0,0,0,0,160
	DC.W	160,160,160,160,320,320,320,320,480,480
	DC.W	480,480,640,640,640,800,800,960,960,960
	DC.W	1120,1120,1280,1280,1440,1440,1440,1600,1600,1760
	DC.W	1920,1920,2080,2080,2240,2240,2400,2560,2560,2720
	DC.W	2720,2880,3040,3040,3200,3360,3360,3520,3680,3840
	DC.W	3840,4000,4160,4160,4320,4480,4640,4800,4800,4960
	DC.W	5120,5280,5440,5600,5600,5760,5920,6080,6240,6400
	DC.W	6560,6560,6720,6880,7040,7200,7360,7520,7680,7840
	DC.W	8000,8160,8320,8480,8640,8800,8960,9120,9120,9280
	DC.W	9440,9600,9760,9920,10080,10240,10400,10560,10880,11040
	DC.W	11200,11360,11520,11680,11840,12000,12160,12320,12480,12640
	DC.W	12800,12960,13120,13280,13440,13600,13760,13920,14080,14240
	DC.W	14400,14560,14720,14880,15040,15200,15360,15520,15680,15840
	DC.W	16000,16320,16480,16640,16800,16960,17120,17280,17440,17600
	DC.W	17760,17760,17920,18080,18240,18400,18560,18720,18880,19040
	DC.W	19200,19360,19520,19680,19840,20000,20160,20320,20320,20480
	DC.W	20640,20800,20960,21120,21280,21280,21440,21600,21760,21920
	DC.W	22080,22080,22240,22400,22560,22720,22720,22880,23040,23040
	DC.W	23200,23360,23520,23520,23680,23840,23840,24000,24160,24160
	DC.W	24320,24320,24480,24640,24640,24800,24800,24960,24960,25120
	DC.W	25280,25280,25440,25440,25440,25600,25600,25760,25760,25920
	DC.W	25920,25920,26080,26080,26240,26240,26240,26400,26400,26400
	DC.W	26400,26560,26560,26560,26560,26720,26720,26720,26720,26720
	DC.W	26880,26880,26880,26880,26880,26880,26880,26880,26880,26880
	DC.W	26880,26880
	ENDR
	DCB.W	MAX,$8000
