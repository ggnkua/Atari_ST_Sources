
	MOVE.L	A1,-(A7)
	MOVE.W	#2,-(A7)
	MOVE.L	A0,-(A7)
	MOVE.W	#$3D,-(A7)
L6A712	TRAP	#1
	ADDQ.L	#8,A7
	TST.W	D0
	BPL.S	L6A71E
	SUBQ.L	#8,A7
	BRA.S	L6A712
L6A71E	MOVE.W	D0,-(A7)
	PEA	$18000
	PEA	$FFFFFF
	MOVE.W	D0,-(A7)
	MOVE.W	#$3F,-(A7)
	TRAP	#1
	ADDA.W	#$C,A7
	MOVE.W	#$3E,-(A7)
	TRAP	#1
	ADDQ.L	#4,A7
	MOVEA.L	(A7)+,A1
	LEA	$18000,A0
	MOVE.L	(A0)+,D0
	MOVE.L	(A0)+,D1
	MOVE.L	(A0)+,D5
	MOVEA.L	A1,A2
	ADDA.L	D0,A0
	ADDA.L	D1,A2
	MOVE.L	-(A0),D0
	EOR.L	D0,D5
L6A758	LSR.L	#1,D0
	BNE.S	L6A75E
	BSR.S	L6A7D4
L6A75E	BCS.S	L6A792
	MOVEQ	#8,D1
	MOVEQ	#1,D3
	LSR.L	#1,D0
	BNE.S	L6A76A
	BSR.S	L6A7D4
L6A76A	BCS.S	L6A7BA
	MOVEQ	#3,D1
	CLR.W	D4
L6A770	BSR.S	L6A7E0
	MOVE.W	D2,D3
	ADD.W	D4,D3
L6A776	MOVEQ	#7,D1
L6A778	LSR.L	#1,D0
	BNE.S	L6A77E
	BSR.S	L6A7D4
L6A77E	ROXL.L	#1,D2
	DBF	D1,L6A778
	MOVE.B	D2,-(A2)
	DBF	D3,L6A776
	BRA.S	L6A7C6
L6A78C	MOVEQ	#8,D1
	MOVEQ	#8,D4
	BRA.S	L6A770
L6A792	MOVEQ	#2,D1
	BSR.S	L6A7E0
	CMPI.B	#2,D2
	BLT.S	L6A7B0
	CMPI.B	#3,D2
	BEQ.S	L6A78C
	MOVEQ	#8,D1
	BSR.S	L6A7E0
	MOVE.W	D2,D3
	MOVE.W	#$C,D1
	BRA	L6A7BA
L6A7B0	MOVE.W	#9,D1
	ADD.W	D2,D1
	ADDQ.W	#2,D2
	MOVE.W	D2,D3
L6A7BA	BSR.S	L6A7E0
L6A7BC	SUBQ.W	#1,A2
	MOVE.B	0(A2,D2.L),(A2)
	DBF	D3,L6A7BC
L6A7C6	CMPA.L	A2,A1
	BLT.S	L6A758
	TST.L	D5
	BNE.S	L6A7D0
	RTS
L6A7D0	MOVEQ	#-1,D0
	RTS
L6A7D4	MOVE.L	-(A0),D0
	EOR.L	D0,D5
	MOVE.B	#$10,CCR
	ROXR.L	#1,D0
	RTS
L6A7E0	SUBQ.W	#1,D1
	CLR.W	D2
L6A7E4	LSR.L	#1,D0
	BNE.S	L6A7F2
	MOVE.L	-(A0),D0
	EOR.L	D0,D5
	MOVE.B	#$10,CCR
	ROXR.L	#1,D0
L6A7F2	ROXL.L	#1,D2
	DBF	D1,L6A7E4
	RTS
