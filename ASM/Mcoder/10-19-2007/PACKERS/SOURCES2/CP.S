
	MOVEA.L	$2AA7E,A2
	LEA	$3FC3E,A1
	MOVE.W	#3,D7
L2039E	LEA	(A2),A0
	MOVE.W	$2AA86,D6
	MULU	#$28,D6
	SUBQ.W	#1,D6
	MOVE.W	#1,D1
	MOVE.W	#7,D2
L203B4	MOVE.B	(A0),D3
	MOVE.B	D3,D4
	ADDQ.B	#1,D4
	LEA	(A1),A3
	ADDQ.L	#1,A1
	MOVE.B	#$FF,D5
L203C2	MOVE.B	(A0),D0
	ADDA.W	D1,A0
	EXG	D1,D2
	MOVE.B	D0,(A1)+
	CMP.B	D0,D4
	BNE.S	L203D2
	CMP.B	D0,D3
	BEQ.S	L203F8
L203D2	MOVE.B	D4,D3
	MOVE.B	D0,D4
	ADDQ.B	#1,D5
	CMP.B	#$7F,D5
	BCC.S	L203EC
	DBF	D6,L203C2
L203E2	MOVE.B	D5,(A3)
L203E4	ADDQ.L	#2,A2
	DBF	D7,L2039E
	BRA.S	L20426
L203EC	MOVE.B	D5,(A3)
	DBF	D6,L203B4
	BRA.S	L203E4
L203F4	SUBQ.L	#2,A1
	BRA.S	L20408
L203F8	SUBQ.B	#2,D5
	BMI.S	L203F4
	SUBQ.L	#1,A1
	MOVE.B	D5,(A3)
	LEA	-2(A1),A3
	MOVE.B	#$FF,D5
L20408	DBF	D6,L2040E
	BRA.S	L203E2
L2040E	CMP.B	(A0),D0
	BNE.S	L20420
	ADDA.W	D1,A0
	EXG	D1,D2
	SUBQ.B	#1,D5
	CMP.B	#$80,D5
	BHI.S	L20408
	BRA.S	L203EC
L20420	MOVE.B	D5,(A3)
	BRA	L203B4
L20426	MOVE.L	A1,D0
	SUBI.L	#$3FC3E,D0
	ADDQ.L	#1,D0
	BCLR	#0,D0
	MOVE.L	D0,$2AA76
	MOVEA.L	$2AA82,A0
	ADDQ.L	#2,A0
	LEA	$2CEFE,A1
	MOVE.W	$2AA86,D7
	MULU	#3,D7
	SUBQ.W	#1,D7
L20454	MOVE.W	#$D,D6
	CLR.W	D0
	MOVE.W	#1,D1
	LEA	(A1),A2
	ADDQ.L	#2,A1
L20462	MOVE.W	(A0)+,D2
	BLE.S	L2046A
	BSET	D1,D0
	MOVE.W	D2,(A1)+
L2046A	ADDQ.W	#1,D1
	DBF	D6,L20462
	ADDQ.L	#4,A0
	MOVE.W	D0,(A2)
	DBF	D7,L20454
	SUBA.L	#$2CEFE,A1
	MOVE.L	A1,$2AA7A
	RTS
