
	MOVE.L	A0,-(A7)
	MOVE.L	(A0)+,D7
	MOVE.L	(A0)+,D6
	MOVE.W	D7,D5
	SUBQ.W	#1,D5
L233B6	MOVE.B	(A0)+,(A1)+
	DBF	D5,L233B6
	MOVEA.L	A1,A2
	MOVEA.L	(A7),A1
	MOVE.L	D6,D5
L233C2	MOVE.B	(A0)+,(A1)+
	SUBQ.L	#1,D5
	BNE	L233C2
	MOVEA.L	(A7)+,A0
	CLR.L	D5
	MOVE.W	D7,D5
	LSL.L	#3,D5
	ADDA.L	D5,A0
	SUBQ.W	#1,D7
	CLR.B	D6
L233D8	MOVE.B	-(A2),D0
	BTST	#7,D0
	BEQ	L23430
	MOVE.B	-(A1),-(A0)
	BTST	#6,D0
	BEQ	L2343A
L233EC	MOVE.B	-(A1),-(A0)
	BTST	#5,D0
	BEQ	L23444
L233F6	MOVE.B	-(A1),-(A0)
	BTST	#4,D0
	BEQ	L2344E
L23400	MOVE.B	-(A1),-(A0)
	BTST	#3,D0
	BEQ	L23458
L2340A	MOVE.B	-(A1),-(A0)
	BTST	#2,D0
	BEQ	L23462
L23414	MOVE.B	-(A1),-(A0)
	BTST	#1,D0
	BEQ	L2346C
L2341E	MOVE.B	-(A1),-(A0)
	BTST	#0,D0
	BEQ	L23476
L23428	MOVE.B	-(A1),-(A0)
	DBF	D7,L233D8
	RTS
L23430	MOVE.B	D6,-(A0)
	BTST	#6,D0
	BNE	L233EC
L2343A	MOVE.B	D6,-(A0)
	BTST	#5,D0
	BNE	L233F6
L23444	MOVE.B	D6,-(A0)
	BTST	#4,D0
	BNE	L23400
L2344E	MOVE.B	D6,-(A0)
	BTST	#3,D0
	BNE	L2340A
L23458	MOVE.B	D6,-(A0)
	BTST	#2,D0
	BNE	L23414
L23462	MOVE.B	D6,-(A0)
	BTST	#1,D0
	BNE	L2341E
L2346C	MOVE.B	D6,-(A0)
	BTST	#0,D0
	BNE	L23428
L23476	MOVE.B	D6,-(A0)
	DBF	D7,L233D8
	RTS
	NEG.W	D1
