
	BRA	L0000
	DC.B	"Pack-Ice: The best packer on the ST. It is Public Domain. "
	DC.B	"You may use it for packing anything you like. I don't "
	DC.B	"want any donations. Greetings go to all people who use this packer. "
	DC.B	0,0
L0000:	MOVE.L	A7,A5
	MOVE.L	4(A5),A5
	MOVE.L	12(A5),D0
	ADD.L	20(A5),D0
	ADD.L	28(A5),D0
	ADD.L	#$200,D0
	MOVE.L	D0,-(A7)
	MOVE.L	A5,-(A7)
	CLR.W	-(A7)
	MOVE.W	#$4A,-(A7)
	TRAP	#1
	ADD.W	#$C,A7
	MOVE.W	L009F(PC),L010D
	MOVE.W	L00A6(PC),L010E
	BSR	L0001
	BSR	L005D
	BSR	L0007
	BSR	L0009
	BSR	L005C
	BSR	L0002
	BRA.S	L0003
L0001:	MOVE.L	#$A000100,D0
	BSR	L0004
	MOVE.W	D0,L0104
	MOVEQ	#-1,D7
	ADDQ.W	#1,D0
	BEQ	L0003
	RTS
L0002:	MOVE.L	#$13000100,D0
	BSR	L0004
	RTS
L0003:	MOVE.W	D0,D7
	MOVE.W	D7,-(A7)
	MOVE.W	#$4C,-(A7)
	TRAP	#1
L0004:	MOVEM.L	A0-A6/D1-D7,-(A7)
	LEA	L00FE(PC),A0
	CLR.L	(A0)+
	CLR.L	(A0)+
	CLR.W	(A0)
	MOVEP.L	D0,-7(A0)
	CMP.B	#$70,-7(A0)
	BNE.S	L0005
	MOVE.B	#1,1(A0)
L0005:	LEA	L0006(PC),A0
	MOVE.L	A0,D1
	MOVE.W	#$C8,D0
	TRAP	#2
	MOVEQ	#0,D0
	MOVE.W	L0103(PC),D0
	MOVEM.L	(A7)+,A0-A6/D1-D7
	RTS
L0006:	DC.L	L00FE
	DC.L	L00FF
	DC.L	L0102
	DC.L	L0103
	DC.L	L0100
	DC.L	L0101
L0007:	MOVEQ	#0,D4
	BSR	L003E
	BNE.S	L0008
	MOVEQ	#1,D4
L0008:	MOVE.W	D4,L0106
	RTS
L0009:	LEA	L00F8(PC),A0
	BSR	L003F
L000A:	TST.W	L0106
	BEQ.S	L000B
	LEA	L00FA(PC),A0
	BSR	L005B
	ADD.W	#$30,D0
	BRA.S	L000D
L000B:	LEA	L00E9(PC),A0
	BSR	L003F
L000C:	BSR	L003C
	CMP.B	#$33,D0
	BNE.S	L000E
	LEA	L00DF(PC),A0
	BSR	L003F
	BSR	L0046
	LEA	L00DF(PC),A0
	BSR	L003F
	BRA.S	L000A
L000D:	CMP.B	#$33,D0
	BNE.S	L000E
	BSR	L0046
	BRA.S	L000A
L000E:	MOVE.B	#1,L0115
	CMP.B	#$31,D0
	BEQ.S	L0012
	CMP.B	#$D,D0
	BEQ.S	L0012
	CMP.B	#$32,D0
	BNE.S	L000C
	CLR.B	L0115
L000F:	TST.W	L0106
	BEQ.S	L0010
	LEA	L00FB(PC),A0
	BSR	L005B
	ADD.W	#$6C,D0
	CMP.W	#$6E,D0
	BEQ.S	L0011
	MOVEQ	#$79,D0
	BRA.S	L0011
L0010:	LEA	L00E5(PC),A0
	BSR	L003F
	BSR	L003C
L0011:	MOVE.W	L010D(PC),L009F
	MOVE.W	L010E(PC),L00A6
	CMP.B	#$D,D0
	BEQ.S	L0015
	OR.B	#$20,D0
	CMP.B	#$79,D0
	BEQ.S	L0015
	CMP.B	#$6E,D0
	BNE.S	L000F
	MOVE.W	#$602C,L009F
	MOVE.W	#$6012,L00A6
	BRA.S	L0015
L0012:	CLR.W	L0107
	TST.W	L0106
	BEQ.S	L0013
	LEA	L00FD(PC),A0
	BSR	L005B
	CMP.W	#1,D0
	BEQ.S	L0015
	BRA.S	L0014
L0013:	LEA	L00E6(PC),A0
	BSR	L003F
	BSR	L003C
	CMP.B	#$79,D0
	BNE.S	L0015
L0014:	MOVE.W	#1,L0107
L0015:	MOVEQ	#-1,D3
	MOVE.W	D3,L0110
	TST.W	L0106
	BEQ	L001B
	MOVE.W	#$19,-(A7)
	TRAP	#1
	ADDQ.L	#2,A7
	LEA	L0120(PC),A4
	MOVE.B	#$41,(A4)
	ADD.B	D0,(A4)+
	MOVE.B	#$3A,(A4)+
	CLR.W	-(A7)
	PEA	(A4)
	MOVE.W	#$47,-(A7)
	TRAP	#1
	ADDQ.L	#8,A7
L0016:	TST.B	(A4)+
	BNE.S	L0016
	MOVE.B	#$5C,-1(A4)
	MOVE.B	#$2A,(A4)+
	MOVE.B	#$2E,(A4)+
	MOVE.B	#$2A,(A4)+
	CLR.B	(A4)+
	BSR	L005C
	LEA	L0100(PC),A4
	MOVE.L	#$5A000202,D0
	MOVE.L	#L0120,(A4)+
	MOVE.L	#L0122,(A4)+
	BSR	L0004
	TST.W	D0
	BEQ	L0033
	MOVE.L	L0103(PC),D4
	BSR	L005D
	LEA	L00F8(PC),A0
	BSR	L003F
	TST.W	D4
	BEQ	L0033
	LEA	L0120(PC),A2
L0017:	TST.B	(A2)+
	BNE.S	L0017
L0018:	CMP.B	#$5C,-(A2)
	BEQ.S	L0019
	CMP.B	#$3A,(A2)
	BNE.S	L0018
	ADDQ.L	#1,A2
	MOVE.B	#$5C,(A2)
L0019:	CLR.B	1(A2)
	LEA	L0120(PC),A4
	CMP.B	#$3A,1(A4)
	BNE.S	L001A
	MOVEQ	#$E,D0
	SWAP	D0
	MOVE.B	(A4),D0
	OR.B	#$20,D0
	SUB.B	#$61,D0
	MOVE.L	D0,-(A7)
	TRAP	#1
	ADDQ.L	#4,A7
	ADDQ.L	#2,A4
L001A:	PEA	(A4)
	MOVE.W	#$3B,-(A7)
	TRAP	#1
	ADDQ.L	#6,A7
	TST.L	D0
	BMI	L0033
	LEA	L0122(PC),A2
	TST.B	(A2)
	BNE.S	L001C
	MOVE.L	#$2A2E2A00,(A2)
	BRA.S	L001C
L001B:	LEA	L00E0(PC),A0
	BSR	L003F
	PEA	L0121(PC)
	MOVE.W	#$A,-(A7)
	TRAP	#1
	ADDQ.L	#6,A7
	LEA	L0122(PC),A1
	ADD.W	D0,A1
	CLR.B	(A1)
	LEA	L00DF(PC),A0
	BSR	L003F
L001C:	PEA	L00DC(PC)
	MOVE.W	#$1A,-(A7)
	TRAP	#1
	ADDQ.L	#6,A7
	MOVE.W	#0,-(A7)
	PEA	L0122(PC)
	MOVE.W	#$4E,-(A7)
	TRAP	#1
	ADDQ.L	#8,A7
	TST.L	D0
	BMI	L0033
L001D:	BSR	L0065
	BMI.S	L001E
	MOVE.L	L00DD(PC),D3
	ADD.L	#$8988,D3
	AND.W	#-2,D3
	MOVE.L	D3,-(A7)
	MOVE.W	#$48,-(A7)
	TRAP	#1
	ADDQ.L	#6,A7
	TST.L	D0
	BPL.S	L001F
	BSR	L0067
L001E:	MOVE.L	L00DD(PC),D3
	ADD.L	#$988,D3
	AND.W	#-2,D3
	MOVE.L	D3,-(A7)
	MOVE.W	#$48,-(A7)
	TRAP	#1
	ADDQ.L	#6,A7
	TST.L	D0
	BMI	L0035
L001F:	ADDQ.L	#1,D0
	AND.W	#-2,D0
	MOVE.L	D0,L0119
	MOVE.L	D0,A0
	ADD.L	#$974,D0
	MOVE.L	D0,L0117
	MOVE.L	#-$50015002,D0
	LSR.L	#3,D3
L0020:	MOVE.L	D0,(A0)+
	MOVE.L	D0,(A0)+
	SUBQ.L	#1,D3
	BNE.S	L0020
	MOVE.W	#$960,L011D
	BSR	L0037
	BMI	L0036
	MOVE.L	L0117(PC),A0
	MOVE.L	L00DD(PC),D0
	BSR	L0038
	BMI	L0036
	BSR	L003B
	MOVE.L	L00DD(PC),D1
	ADD.L	L0117(PC),D1
	MOVE.L	D1,L0118
	LEA	L00E2(PC),A0
	BSR	L003F
	TST.W	L010A
	BPL.S	L0021
	LEA	L00F2(PC),A0
	BSR	L003F
L0021:	TST.W	L0107
	BEQ.S	L0022
	LEA	L00E3(PC),A0
	BSR	L003F
L0022:	LEA	L00DE(PC),A0
	BSR	L003F
	CLR.W	L011E
	BSR	L0040
	BSR	L005E
	BSR	L0068
	MOVE.L	D0,A3
	TST.L	D0
	BMI	L0036
	BSR	L0042
	TST.W	L011E
	BNE	L0030
	TST.W	L011F
	BEQ.S	L0023
	LEA	L00EE(PC),A0
	BSR	L003F
	BRA	L0032
L0023:	LEA	(A3),A1
	TST.B	L0115
	BNE.S	L0024
	ADD.W	#$1C0,A1
L0024:	MOVE.L	A1,L0113
	MOVE.L	L00DD(PC),A2
	CMP.L	A2,A1
	BGE	L0031
	TST.W	L0110
	BEQ	L002E
	LEA	L00EB(PC),A0
	BSR	L003F
	MOVE.L	L00DD(PC),D1
	ADD.L	#$271A,D1
	MOVE.L	D1,-(A7)
	MOVE.W	#$48,-(A7)
	TRAP	#1
	ADDQ.L	#6,A7
	TST.L	D0
	BPL.S	L0025
	LEA	L00EA(PC),A0
	BSR	L003F
	BRA	L002E
L0025:	MOVE.L	D0,A4
	MOVE.L	D0,A2
	MOVE.L	D0,L0109
	MOVE.L	A3,D1
	SUBQ.L	#1,D1
	MOVE.L	L0119(PC),A1
L0026:	MOVE.B	(A1)+,(A2)+
	DBF	D1,L0026
	SUB.L	#$10000,D1
	BPL.S	L0026
	MOVE.L	A4,A0
	BSR	L00BD
	LEA	100(A4),A2
	ADD.L	L00DD(PC),A2
	MOVE.L	A2,D0
	AND.W	#-2,D0
	MOVE.L	D0,L010F
	BSR	L0037
L0027:	MOVE.L	L010F(PC),A0
	MOVE.L	#$2710,D0
	BSR	L0038
	MOVE.L	D0,D4
	BEQ.S	L0028
	CMP.L	#$2710,D0
	BCC.S	L0029
L0028:	BSR	L003B
	MOVE.L	D4,D0
L0029:	MOVE.L	L010F(PC),A2
	SUBQ.W	#1,D0
	BMI.S	L002B
L002A:	MOVE.B	(A2)+,D1
	MOVE.B	(A4)+,D2
	CMP.B	D1,D2
	BNE.S	L002C
	DBF	D0,L002A
L002B:	CMP.L	#$2710,D4
	BEQ.S	L0027
	LEA	L00EC(PC),A0
	BSR	L003F
	BSR	L002D
	BRA.S	L002E
L002C:	LEA	L00ED(PC),A0
	BSR	L003F
	BSR	L002D
	BRA	L0032
L002D:	MOVE.L	L0109(PC),-(A7)
	MOVE.W	#$49,-(A7)
	TRAP	#1
	ADDQ.L	#6,A7
	RTS
L002E:	BSR	L0057
	CMP.B	#1,L0115
	BEQ.S	L002F
	MOVE.W	#$1C0,A4
	MOVE.L	A3,A5
	LEA	-28(A5,A4.W),A5
	MOVE.L	A5,D0
	ADDQ.L	#1,D0
	AND.W	#-2,D0
	MOVE.L	D0,L009A
	MOVE.L	A3,D0
	MOVEQ	#$78,D1
	SUB.L	D1,D0
	MOVE.L	D0,L009D
	MOVE.L	L00DD(PC),L009E
	BSR	L0039
	BMI	L0036
	LEA	L0099(PC),A5
	MOVE.W	#$1C0,A6
	BSR	L003A
	BMI	L0036
	MOVE.L	L0119(PC),A5
	MOVE.L	A3,D0
	ADDQ.L	#1,D0
	AND.W	#-2,D0
	MOVE.L	D0,A6
	BSR	L003A
	BMI	L0036
	LEA	L0116(PC),A5
	CLR.L	(A5)
	MOVE.W	#4,A6
	BSR	L003A
	BMI	L0036
	BSR	L003B
	BMI	L0036
	BRA.S	L0032
L002F:	BSR	L0039
	MOVE.L	L0119(PC),A5
	MOVE.L	A3,A6
	BSR	L003A
	BMI	L0036
	BSR	L003B
	BRA.S	L0032
L0030:	LEA	L00F6(PC),A0
	BSR	L003F
	BRA.S	L0032
L0031:	LEA	L00F7(PC),A0
	BSR	L003F
L0032:	MOVE.L	L0119(PC),-(A7)
	MOVE.W	#$49,-(A7)
	TRAP	#1
	ADDQ.L	#6,A7
	TST.L	D0
	BNE.S	L0036
	BSR	L0067
	MOVE.W	#$4F,-(A7)
	TRAP	#1
	ADDQ.L	#2,A7
	TST.L	D0
	BPL	L001D
L0033:	TST.W	L0106
	BEQ.S	L0034
	LEA	L00FC(PC),A0
	BSR	L005B
	CMP.W	#1,D0
	BEQ	L0009
	CMP.W	#2,D0
	BEQ.S	L0036
L0034:	LEA	L00DF(PC),A0
	BSR	L003F
	LEA	L00E4(PC),A0
	BSR	L003F
	BSR	L003C
	OR.B	#$20,D0
	CMP.B	#$6E,D0
	BEQ.S	L0036
	BRA	L0009
L0035:	LEA	L00E1(PC),A0
	BSR	L003F
	BSR	L003D
L0036:	RTS
L0037:	CLR.W	-(A7)
	PEA	L00DE(PC)
	MOVE.W	#$3D,-(A7)
	TRAP	#1
	ADDQ.L	#8,A7
	MOVE.W	D0,L0114
	TST.L	D0
	RTS
L0038:	PEA	(A0)
	MOVE.L	D0,-(A7)
	MOVE.W	L0114(PC),-(A7)
	MOVE.W	#$3F,-(A7)
	TRAP	#1
	ADD.W	#$C,A7
	TST.L	D0
	RTS
L0039:	MOVE.W	#0,-(A7)
	PEA	L00DE(PC)
	MOVE.W	#$3C,-(A7)
	TRAP	#1
	ADDQ.L	#8,A7
	MOVE.W	D0,L0114
	TST.L	D0
	RTS
L003A:	MOVE.L	A5,-(A7)
	MOVE.L	A6,-(A7)
	MOVE.W	L0114(PC),-(A7)
	MOVE.W	#$40,-(A7)
	TRAP	#1
	LEA	12(A7),A7
	TST.L	D0
	RTS
L003B:	MOVE.W	L0114(PC),-(A7)
	MOVE.W	#$3E,-(A7)
	TRAP	#1
	ADDQ.L	#4,A7
	TST.L	D0
	RTS
L003C:	MOVE.W	#1,-(A7)
	TRAP	#1
	ADDQ.L	#2,A7
	RTS
L003D:	MOVE.W	#7,-(A7)
	TRAP	#1
	ADDQ.L	#2,A7
	RTS
L003E:	MOVE.L	#$BFFFF,-(A7)
	TRAP	#$D
	ADDQ.L	#4,A7
	BTST	#3,D0
	RTS
L003F:	MOVE.L	A0,-(A7)
	MOVE.W	#9,-(A7)
	TRAP	#1
	ADDQ.L	#6,A7
	RTS
L0040:	PEA	L0041(PC)
	MOVE.W	#$26,-(A7)
	TRAP	#$E
	ADDQ.L	#6,A7
	RTS
L0041:	MOVE.L	$4BA.W,D0
	SUB.L	L0112(PC),D0
	MOVE.L	D0,L0111
	MOVE.L	$4BA.W,L0112
	RTS
L0042:	MOVEM.L	A0-A6/D0-D7,-(A7)
	LEA	L00F3(PC),A0
	BSR.S	L003F
	BSR.S	L0040
	MOVE.L	L0111(PC),D0
	DIVU	#$C8,D0
	SWAP	D0
	CLR.W	D0
	SWAP	D0
	DIVU	#$3C,D0
	MOVEQ	#0,D1
	MOVE.W	D0,D1
	SWAP	D0
	MOVEQ	#0,D2
	MOVE.W	D0,D2
	LEA	L0044(PC),A0
	CLR.L	(A0)
	CLR.L	2(A0)
L0043:	DIVU	#$A,D1
	SWAP	D1
	ADD.W	#$30,D1
	MOVE.W	D1,(A0)+
	CLR.W	D1
	SWAP	D1
	TST.W	D1
	BNE.S	L0043
	MOVE.L	#$200020,(A0)+
	LEA	L0045(PC),A0
	MOVE.W	-(A0),D0
	BSR	L005A
	MOVE.W	-(A0),D0
	BSR	L005A
	MOVE.W	-(A0),D0
	BSR	L005A
	MOVEQ	#$3A,D0
	BSR	L005A
	MOVE.L	D2,D0
	DIVU	#$A,D0
	ADD.W	#$30,D0
	BSR	L005A
	SWAP	D0
	ADD.W	#$30,D0
	BSR	L005A
	MOVEM.L	(A7)+,A0-A6/D0-D7
	RTS
L0044:	DS.W	3
L0045:	DS.W	5
L0046:	LEA	L00E8(PC),A1
	MOVE.L	L0064(PC),D0
	MOVEQ	#3,D2
L0047:	MOVEQ	#$F,D1
	AND.L	D0,D1
	CMP.W	#9,D1
	BLE.S	L0048
	ADD.W	#$27,D1
L0048:	ADD.W	#$30,D1
	MOVE.B	D1,-(A1)
	LSR.L	#4,D0
	DBF	D2,L0047
	LEA	L00E7(PC),A0
	BSR	L003F
	LEA	L0105(PC),A3
	MOVE.B	#4,(A3)
	PEA	(A3)
	MOVE.W	#$A,-(A7)
	TRAP	#1
	ADDQ.L	#6,A7
	MOVEQ	#0,D2
	MOVE.B	1(A3),D2
	BEQ.S	L004E
	ADD.L	D2,A3
	ADDQ.L	#2,A3
	MOVEQ	#0,D4
	MOVEQ	#0,D3
	SUBQ.W	#1,D2
	BMI.S	L0046
L0049:	MOVEQ	#0,D0
	MOVE.B	-(A3),D0
	SUB.B	#$30,D0
	BMI.S	L004A
	CMP.B	#9,D0
	BLE.S	L004B
	ADD.B	#$30,D0
	OR.B	#$20,D0
	SUB.B	#$57,D0
	CMP.B	#9,D0
	BLE.S	L004A
	CMP.B	#$F,D0
	BLE.S	L004B
L004A:	MOVEQ	#0,D0
L004B:	LSL.W	D3,D0
	ADD.L	D0,D4
	ADDQ.W	#4,D3
	DBF	D2,L0049
	MOVE.L	#$1528,D0
	CMP.L	D0,D4
	BCS.S	L004C
	MOVE.L	D0,D4
L004C:	CMP.W	#5,D4
	BCC.S	L004D
	MOVEQ	#5,D4
L004D:	MOVE.L	D4,L0064
L004E:	RTS
L004F:	MOVE.L	D0,-(A7)
	MOVE.L	L00DD(PC),D0
	LSR.L	#7,D0
	MOVE.L	D0,L0055
	MOVE.L	L0117(PC),L0054
	MOVE.W	#-1,L0056
	MOVE.L	(A7)+,D0
	RTS
L0050:	CMP.L	L0054(PC),A0
	BCS	L0053
	MOVEM.L	A0-A6/D0-D7,-(A7)
	MOVE.L	L0055(PC),D0
	ADD.L	D0,L0054
	MOVE.L	A0,D1
	MOVE.L	L0118(PC),D0
	MOVE.L	L0117(PC),D2
	SUB.L	D2,D1
	SUB.L	D2,D0
	BSR	L0058
	MULU	#$64,D1
	BSR	L0058
	TST.W	D0
	BEQ.S	L0052
	DIVU	D0,D1
	SWAP	D1
	CLR.W	D1
	SWAP	D1
	CMP.W	L0056(PC),D1
	BEQ.S	L0052
	MOVE.W	D1,L0056
	DIVU	#$A,D1
	MOVE.L	#$390039,D0
	SUB.L	D1,D0
	LEA	L00F0(PC),A0
	MOVE.B	D0,(A0)+
	SWAP	D0
	MOVE.B	D0,(A0)+
	LEA	L00EF(PC),A0
	BSR	L003F
	BSR	L003E
	BEQ.S	L0052
L0051:	BSR	L003E
	BNE.S	L0051
	MOVE.W	#-1,L011E
	MOVEM.L	(A7)+,A0-A6/D0-D7
	MOVE.L	A0,L0118
	BRA.S	L0053
L0052:	MOVEM.L	(A7)+,A0-A6/D0-D7
L0053:	RTS
L0054:	DC.L	0
L0055:	DC.L	0
L0056:	DC.W	0
L0057:	LEA	L00F4(PC),A0
	BSR	L003F
	MOVE.L	L00DD(PC),D0
	MOVE.L	L0113(PC),D1
	BSR	L0058
	MULU	#$64,D1
	BSR	L0058
	DIVU	D0,D1
	MOVE.L	D1,D0
	SWAP	D0
	CLR.W	D0
	SWAP	D0
	DIVU	#$A,D0
	ADD.L	#$300030,D0
	BSR	L005A
	SWAP	D0
	BSR	L005A
	LEA	L00F5(PC),A0
	BSR	L003F
	RTS
L0058:	SWAP	D0
	SWAP	D1
	TST.W	D0
	BNE.S	L0059
	TST.W	D1
	BNE.S	L0059
	SWAP	D0
	SWAP	D1
	RTS
L0059:	SWAP	D0
	SWAP	D1
	LSR.L	#1,D0
	LSR.L	#1,D1
	BRA.S	L0058
L005A:	MOVEM.L	A0-A3/D0-D3,-(A7)
	MOVE.W	D0,-(A7)
	MOVE.W	#2,-(A7)
	TRAP	#1
	ADDQ.L	#4,A7
	MOVEM.L	(A7)+,A0-A3/D0-D3
	RTS
L005B:	BSR	L005C
	MOVE.L	#$34010101,D0
	MOVE.W	#1,L0102
	MOVE.L	A0,L0100
	BSR	L0004
	MOVE.W	L0103(PC),-(A7)
	BSR	L005D
	MOVEQ	#0,D0
	MOVE.W	(A7)+,D0
	RTS
L005C:	MOVE.L	#$4E010101,D0
	MOVE.W	#$101,L0102
	BSR	L0004
	MOVE.L	#$4E010101,D0
	MOVE.W	#0,L0102
	BSR	L0004
	RTS
L005D:	MOVE.L	#$4E010101,D0
	MOVE.W	#$100,L0102
	BSR	L0004
	RTS
L005E:	CLR.W	L0108
	TST.W	L0107
	BEQ.S	L0062
	MOVE.L	L0117(PC),A1
	MOVE.L	L00DD(PC),D1
	MOVE.L	#$7D00,D0
	SUB.L	D0,D1
	BMI.S	L0063
	CMP.L	#$104,D1
	BCC.S	L0063
	ADD.L	D1,A1
	MOVE.W	#$F9F,D7
L005F:	MOVEM.W	(A1),D0-D3
	MOVEQ	#3,D6
	ADDQ.W	#8,A1
L0060:	MOVEQ	#3,D5
L0061:	ADD.W	D0,D0
	ADDX.W	D4,D4
	ADD.W	D1,D1
	ADDX.W	D4,D4
	ADD.W	D2,D2
	ADDX.W	D4,D4
	ADD.W	D3,D3
	ADDX.W	D4,D4
	DBF	D5,L0061
	MOVE.W	D4,-(A1)
	DBF	D6,L0060
	ADDQ.W	#8,A1
	DBF	D7,L005F
	MOVE.W	#1,L0108
L0062:	RTS
L0063:	LEA	L00F1(PC),A0
	BSR	L003F
	BRA.S	L0062
L0064:	DC.L	$1580		;OFFSET !!!
L0065:	PEA	$00030010
	MOVE.W	#$48,-(A7)
	TRAP	#1
	ADDQ.L	#6,A7
	TST.L	D0
	BGT.S	L0066
	MOVEQ	#-1,D0
L0066:	MOVE.L	D0,L010A
	RTS
L0067:	MOVE.L	L010A(PC),D0
	MOVE.W	#-1,L010A
	TST.L	D0
	BMI.S	L0066
	MOVE.L	D0,-(A7)
	MOVE.W	#$49,-(A7)
	TRAP	#1
	ADDQ.L	#6,A7
	TST.L	D0
	RTS
;
; LE PACKER COMMENCE ICI !!!!
;
L0068:	CLR.W	L011F
	CLR.L	L010B
	MOVE.L	#$8000,D0
	SUB.L	L0064(PC),D0
	MOVE.L	D0,L010C
	BSR	L004F
	MOVE.L	L0117(PC),A0
	MOVE.L	L00DD(PC),D0
	MOVE.L	L0119(PC),A1
	LEA	0(A0,D0.L),A2
	MOVE.L	A2,L0118
	MOVE.L	#$49434521,D7
	BSR	L0094
	ADDQ.L	#4,A1
	MOVE.L	L00DD(PC),D7
	BSR	L0094
	MOVEQ	#0,D5
	MOVEQ	#7,D6
	MOVEQ	#0,D7
	MOVEQ	#0,D4
	MOVE.W	L0108(PC),D1
	BSR	L0092
L0069:	BSR	L0050
	LEA	1033(A0),A4
	CMP.L	L0118(PC),A4
	BLE.S	L006A
	MOVE.L	L0118(PC),A4
L006A:	MOVE.L	A0,A3
	MOVE.B	(A3)+,D0
L006B:	CMP.B	(A3)+,D0
	BNE.S	L006C
	CMP.L	A4,A3
	BLT.S	L006B
L006C:	MOVE.L	A3,D1
	SUB.L	A0,D1
	SUBQ.L	#2,D1
	MOVE.L	D1,L011A
	CMP.L	#$409,D1
	BEQ	L007F
	MOVE.L	A0,A3
	ADD.L	L0064(PC),A3
	CMP.L	L0118(PC),A3
	BLE.S	L006D
	MOVE.L	L0118(PC),A3
L006D:	MOVEQ	#1,D4
	LEA	2(A0),A4
	TST.W	L010A
	BMI	L0072
	MOVE.L	A3,-(A7)
	MOVE.L	L010B(PC),A6
	MOVE.L	A0,D0
	SUB.L	A6,D0
	CMP.L	L010C(PC),D0
	BLT	L006F
	MOVE.L	A0,A6
	MOVE.L	A0,L010B
	MOVE.L	L010A(PC),A2
	BSR	L0095
	MOVE.L	A2,A4
	ADD.L	#$20002,A4
	LEA	1(A6),A5
	MOVEQ	#0,D0
	MOVEQ	#0,D1
	MOVEQ	#0,D2
L006E:	MOVEP.W	-1(A5),D1
	MOVE.B	(A5)+,D1
	MOVE.L	D1,A3
	ADD.L	A3,A3
	ADD.L	A2,A3
	MOVE.W	(A3),D2
	ADDQ.W	#2,(A3)
	MOVE.W	D0,0(A4,D2.L)
	ADDQ.W	#1,D0
	BPL.S	L006E
	BSR	L0095
L006F:	MOVE.L	A0,D0
	SUB.L	A6,D0
	MOVE.L	L010A(PC),A3
	MOVEQ	#0,D3
	MOVEP.W	0(A0),D3
	MOVE.B	1(A0),D3
	ADD.L	D3,D3
	MOVE.L	A3,A2
	ADD.L	#$20002,A2
	MOVE.L	A2,A4
	MOVEQ	#0,D1
	MOVE.W	0(A3,D3.L),D1
	ADD.L	D1,A2
L0070:	MOVEQ	#0,D0
	MOVE.W	(A2)+,D0
	ADD.L	A6,D0
	CMP.L	A0,D0
	BNE.S	L0070
	MOVE.L	A2,D0
	SUB.L	A4,D0
	MOVE.W	D0,0(A3,D3.L)
	MOVE.L	(A7)+,A3
L0071:	TST.W	L010A
	BMI.S	L0072
	MOVE.L	L010B(PC),A4
	ADD.W	(A2)+,A4
	CMP.L	A4,A3
	BLE	L007C
	MOVE.B	(A4)+,D0
	CMP.B	(A0),D0
	BNE	L007C
	MOVE.B	(A4),D1
	CMP.B	1(A0),D1
	BNE	L007C
	BRA.S	L0076
L0072:	MOVE.B	(A0),D0
	MOVE.B	1(A0),D1
L0073:	CMP.B	(A4)+,D0
	BEQ.S	L0075
L0074:	CMP.L	A4,A3
	BGT.S	L0073
	BRA.S	L007C
L0075:	CMP.B	(A4),D1
	BNE.S	L0074
L0076:	MOVE.L	A4,A6
	SUBQ.W	#1,A6
	MOVE.L	A6,D0
	MOVE.L	A0,A5
L0077:	CMPM.B	(A5)+,(A6)+
	BNE.S	L0078
	CMP.L	D0,A5
	BHI.S	L0078
	CMP.L	A6,A3
	BGT.S	L0077
L0078:	MOVE.L	A5,D1
	SUB.L	A0,D1
	SUBQ.L	#1,D1
	MOVE.L	A6,D2
	SUB.L	A5,D2
	SUB.L	D1,D2
	ADDQ.L	#1,D2
	MOVE.L	#$409,D0
	CMP.L	D0,D4
	BEQ.S	L007C
	CMP.L	D0,D1
	BLS.S	L0079
	SUB.L	D0,D1
	ADD.L	D1,D2
	MOVE.L	D0,D1
L0079:	CMP.L	D1,D4
	BGE.S	L007B
	CMP.W	#2,D1
	BLS.S	L007A
	CMP.W	#$111F,D2
	BHI.S	L007B
L007A:	MOVE.L	D1,D4
	MOVE.W	D1,L011B
	MOVE.W	D2,L011C
L007B:	CMP.L	A4,A3
	BGT	L0071
L007C:	MOVE.L	L011A(PC),D0
	CMP.W	#1,D0
	BLE.S	L007D
	CMP.L	D4,D0
	BGE.S	L007F
L007D:	MOVE.W	L011C(PC),D0
	MOVE.W	D4,D1
	CMP.W	#1,D1
	BEQ.S	L007E
	CMP.W	#2,D1
	BEQ.S	L0080
	BRA.S	L0081
L007E:	MOVE.B	(A0)+,(A1)+
	ADDQ.L	#1,D5
	SUBQ.W	#1,L011D
	BPL.S	L0083
	MOVEQ	#-$14,D0
	ADD.L	A0,D0
	SUB.L	A1,D0
	BMI.S	L0084
	MOVE.W	D0,L011D
	BRA.S	L0083
L007F:	MOVE.L	L011A(PC),D1
	MOVE.W	D1,L011B
	MOVEQ	#0,D0
	SUBQ.L	#2,D1
	BNE.S	L0081
L0080:	CMP.W	#$23F,D0
	BHI.S	L007E
	BSR	L0086
	BSR	L008D
	BRA.S	L0082
L0081:	BSR	L0086
	BSR	L008A
L0082:	BSR	L008F
	MOVEQ	#0,D5
	MOVE.W	L011B(PC),D0
	ADD.W	D0,A0
L0083:	MOVE.L	L0118(PC),D0
	SUB.L	A0,D0
	SUBQ.L	#3,D0
	BPL	L0069
L0084:	CMP.L	L0118(PC),A0
	BGE.S	L0085
	MOVE.B	(A0)+,(A1)+
	ADDQ.L	#1,D5
	BRA.S	L0084
L0085:	BSR	L0086
	BSET	D6,D7
	MOVE.B	D7,(A1)+
	SUB.L	L0119(PC),A1
	MOVE.L	A1,D0
	MOVE.L	D0,D7
	MOVE.L	L0119(PC),A1
	ADDQ.L	#4,A1
	BSR	L0094
	RTS
L0086:	CMP.L	#$810D,D5
	BLS.S	L0087
	MOVE.W	#-1,L011F
	MOVE.L	A0,L0118
L0087:	LEA	L0089(PC),A3
	MOVEQ	#6,D3
L0088:	MOVE.W	-(A3),D4
	CMP.W	D4,D5
	DBGE	D3,L0088
	SUB.W	D4,D5
	ADD.W	D3,D3
	LEA	L0089(PC),A3
	ADD.W	D3,A3
	MOVE.B	(A3)+,D2
	EXT.W	D2
	MOVEQ	#-1,D1
	LSL.L	D2,D1
	OR.W	D5,D1
	MOVEQ	#0,D5
	MOVE.B	(A3)+,D4
	EXT.W	D4
	SUBQ.W	#1,D4
	BRA	L0092
	DC.B	$00,$00
	DC.B	$00,$01,$00,$02,$00,$05,$00,$08
	DC.B	$00,$0F,$01,$0E
L0089:	DC.B	$01,$01,$01,$02,$02,$04,$02,$06
	DC.B	$03,$09,$08,$11,$0F,$20
L008A:	LEA	L008C(PC),A3
	MOVEQ	#2,D3
L008B:	ADD.W	D3,D3
	MOVE.W	0(A3,D3.W),D4
	LSR.W	#1,D3
	CMP.W	D4,D0
	DBGE	D3,L008B
	SUB.W	D4,D0
	ADD.W	D3,D3
	MOVE.W	6(A3,D3.W),D3
	MOVE.W	D3,D4
	LSR.W	#8,D3
	MOVEQ	#-1,D1
	LSL.W	D3,D1
	OR.W	D0,D1
	AND.W	#$F,D4
	BRA	L0092
L008C:	DC.B	$00,$00,$00,$20,$01,$20,$06,$06,$09,$08
	DC.B	$0C,$0D
L008D:	CMP.W	#$23F,D0
	BHI	L007E
	MOVE.W	D0,D1
	CMP.W	#$3F,D1
	BLE.S	L008E
	SUB.W	#$40,D1
	MOVEQ	#9,D4
	BSET	D4,D1
	BRA	L0092
L008E:	MOVEQ	#6,D4
	BRA.S	L0092
L008F:	LEA	L0091(PC),A3
	MOVE.W	L011B(PC),D0
	MOVEQ	#4,D5
L0090:	MOVE.B	0(A3,D5.W),D4
	EXT.W	D4
	CMP.W	D4,D0
	DBGE	D5,L0090
	SUB.W	D4,D0
	MOVE.B	5(A3,D5.W),D4
	EXT.W	D4
	MOVEQ	#-1,D1
	LSL.W	D4,D1
	OR.W	D0,D1
	ADD.W	D5,D4
	SUBQ.W	#1,D4
	BRA.S	L0092
L0091:	DC.B	$02,$03,$04,$06,$0A,$01,$01,$02
	DC.B	$03,$0A
L0092:	LSR.L	#1,D1
	ROXR.B	#1,D7
	DBF	D6,L0093
	MOVE.B	D7,(A1)+
	MOVEQ	#0,D7
	MOVEQ	#7,D6
L0093:	DBF	D4,L0092
	RTS
L0094:	ROL.L	#8,D7
	MOVE.B	D7,(A1)+
	ROL.L	#8,D7
	MOVE.B	D7,(A1)+
	ROL.L	#8,D7
	MOVE.B	D7,(A1)+
	ROL.L	#8,D7
	MOVE.B	D7,(A1)+
	RTS
L0095:	LEA	2(A2),A4
	MOVE.W	#$FFF,D0
	MOVEQ	#0,D1
L0096:	MOVE.L	D1,(A4)+
	MOVE.L	D1,(A4)+
	MOVE.L	D1,(A4)+
	MOVE.L	D1,(A4)+
	MOVE.L	D1,(A4)+
	MOVE.L	D1,(A4)+
	MOVE.L	D1,(A4)+
	MOVE.L	D1,(A4)+
	DBF	D0,L0096
	LEA	2(A2),A4
	LEA	1(A6),A5
	MOVE.W	#$7FFF,D0
	MOVEQ	#0,D1
L0097:	MOVEP.W	-1(A5),D1
	MOVE.B	(A5)+,D1
	MOVE.L	D1,A3
	ADD.L	A3,A3
	ADDQ.W	#2,0(A4,A3.L)
	DBF	D0,L0097
	CLR.W	-(A4)
	MOVE.W	#$1FFF,D0
L0098:	MOVE.W	(A4)+,D1
	ADD.W	D1,(A4)
	MOVE.W	(A4)+,D1
	ADD.W	D1,(A4)
	MOVE.W	(A4)+,D1
	ADD.W	D1,(A4)
	MOVE.W	(A4)+,D1
	ADD.W	D1,(A4)
	MOVE.W	(A4)+,D1
	ADD.W	D1,(A4)
	MOVE.W	(A4)+,D1
	ADD.W	D1,(A4)
	MOVE.W	(A4)+,D1
	ADD.W	D1,(A4)
	MOVE.W	(A4)+,D1
	ADD.W	D1,(A4)
	DBF	D0,L0098
	RTS
L0099:	DC.B	$60,$1A
L009A:	DC.B	$00,$00,$01,$A4,$00,$00,$00,$00,$00,$00
	DS.W	6
	DC.B	$00,$01,$FF,$FF
L009B:	BRA.S	L009C
	DC.B	'Pack-Ice'
L009C:	LEA	L00C5(PC),A4
	MOVE.L	A4,A5
	ADD.L	#-$21520532,A5
L009D	EQU	L009C+8
	MOVE.L	A4,A6
	ADD.L	#-$5212153,A6
L009E	EQU	L009C+16
	BSR	L00A8
	MOVE.L	4(A7),A5
	LEA	L009B(PC),A6
	LEA	28(A4),A3
L009F:	MOVEM.L	-26(A3),D0-D3
	LEA	0(A3,D0.L),A0
	ADD.L	D1,A0
	ADD.L	D3,A0
	MOVE.L	A6,D0
	MOVE.L	(A0)+,D1
	BEQ.S	L00A3
	ADD.L	D1,A3
	MOVEQ	#0,D1
L00A0:	ADD.L	D0,(A3)
L00A1:	MOVE.B	(A0)+,D1
	BEQ.S	L00A3
	CMP.B	#1,D1
	BNE.S	L00A2
	ADD.W	#$FE,A3
	BRA.S	L00A1
L00A2:	ADD.L	D1,A3
	BRA.S	L00A0
L00A3:	LEA	2(A4),A3
	ADDQ.L	#8,A5
	MOVE.L	(A5)+,A2
	MOVE.L	(A3),(A5)+
	MOVE.L	(A3),D2
	ADD.L	(A3)+,A2
	MOVE.L	A2,(A5)+
	MOVE.L	(A3),(A5)+
	ADD.L	(A3),D2
	ADD.L	(A3)+,A2
	MOVE.L	A2,(A5)+
	MOVE.L	(A3),(A5)+
	ADD.L	(A3)+,A2
	ADD.L	(A3),D2
	ADD.L	(A3)+,A2
	ADD.W	#$2CC,A2
	MOVEQ	#7,D0
	LEA	(A2),A0
	LEA	L00A5(PC),A3
L00A4:	MOVE.L	(A3)+,(A2)+
	DBF	D0,L00A4
	LEA	28(A4),A1
	LSR.L	#3,D2
	MOVE.L	A6,A3
	JMP	(A0)
L00A5:	MOVE.L	(A1)+,(A3)+
	MOVE.L	(A1)+,(A3)+
	SUBQ.L	#1,D2
	BPL.S	L00A5
L00A6:	MOVE.L	-232(A6),A3
	MOVE.L	-228(A6),D1
	LSR.L	#3,D1
	SUB.L	A0,A0
L00A7:	MOVE.L	A0,(A3)+
	MOVE.L	A0,(A3)+
	SUBQ.L	#1,D2
	BPL.S	L00A7
	JMP	(A6)
L00A8:	MOVE.B	-(A5),D7
L00A9:	BSR.S	L00AD
	BCC.S	L00AC
	MOVEQ	#0,D1
	BSR.S	L00AD
	BCC.S	L00AB
	LEA	L00BA(PC),A1
	MOVEQ	#4,D3
L00AA:	MOVE.L	-(A1),D0
	BSR.S	L00AF
	SWAP	D0
	CMP.W	D0,D1
	DBNE	D3,L00AA
	ADD.L	20(A1),D1
L00AB:	MOVE.B	-(A5),-(A6)
	DBF	D1,L00AB
L00AC:	CMP.L	A4,A6
	BGT.S	L00B2
	RTS
L00AD:	ADD.B	D7,D7
	BNE.S	L00AE
	MOVE.B	-(A5),D7
	ADDX.B	D7,D7
L00AE:	RTS
L00AF:	MOVEQ	#0,D1
L00B0:	ADD.B	D7,D7
	BNE.S	L00B1
	MOVE.B	-(A5),D7
	ADDX.B	D7,D7
L00B1:	ADDX.W	D1,D1
	DBF	D0,L00B0
	RTS
L00B2:	LEA	L00BB(PC),A1
	MOVEQ	#3,D2
L00B3:	BSR.S	L00AD
	DBCC	D2,L00B3
	MOVEQ	#0,D4
	MOVEQ	#0,D1
	MOVE.B	1(A1,D2.W),D0
	EXT.W	D0
	BMI.S	L00B4
	BSR.S	L00AF
L00B4:	MOVE.B	6(A1,D2.W),D4
	ADD.W	D1,D4
	BEQ.S	L00B6
	LEA	L00BC(PC),A1
	MOVEQ	#1,D2
L00B5:	BSR.S	L00AD
	DBCC	D2,L00B5
	MOVEQ	#0,D1
	MOVE.B	1(A1,D2.W),D0
	EXT.W	D0
	BSR.S	L00AF
	ADD.W	D2,D2
	ADD.W	6(A1,D2.W),D1
	BPL.S	L00B8
	SUB.W	D4,D1
	BRA.S	L00B8
L00B6:	MOVEQ	#0,D1
	MOVEQ	#5,D0
	MOVEQ	#-1,D2
	BSR.S	L00AD
	BCC.S	L00B7
	MOVEQ	#8,D0
	MOVEQ	#$3F,D2
L00B7:	BSR.S	L00AF
	ADD.W	D2,D1
L00B8:	LEA	2(A6,D4.W),A1
	ADD.W	D1,A1
	MOVE.B	-(A1),-(A6)
L00B9:	MOVE.B	-(A1),-(A6)
	DBF	D4,L00B9
	BRA	L00A9
	DC.B	$7F,$FF,$00,$0E,$00,$FF,$00,$07
	DC.B	$00,$07,$00,$02,$00,$03,$00,$01
	DC.B	$00,$03,$00,$01
L00BA:	DC.B	0,0
	DC.B	$01,$0D,$00,$00,$00,$0E,$00,$00
	DC.B	$00,$07,$00,$00,$00,$04,$00,$00
	DC.B	$00,$01
L00BB:	DC.B	$09,$01,$00,$FF,$FF,$08,$04,$02
	DC.B	$01,$00
L00BC:	DC.B	$0B,$04,$07,$00,$01,$1F,$FF,$FF
	DC.B	$00,$1F
L00BD:	LINK	A3,#-$78
	MOVEM.L	A0-A6/D0-D7,-(A7)
	LEA	120(A0),A4
	MOVE.L	A4,A6
	BSR.S	L00C6
	CMP.L	#$49434521,D0
	BNE	L00C5
	BSR.S	L00C6
	LEA	-8(A0,D0.L),A5
	BSR.S	L00C6
	MOVE.L	D0,(A7)
	ADD.L	D0,A6
	MOVE.L	A6,A1
	MOVEQ	#$77,D0
L00BE:	MOVE.B	-(A1),-(A3)
	DBF	D0,L00BE
	MOVE.L	A6,A3
	MOVE.B	-(A5),D7
	BSR.S	L00C8
	MOVE.L	A3,A5
	BSR.S	L00CC
	BCC.S	L00C2
	MOVE.W	#$F9F,D7
L00BF:	MOVEQ	#3,D6
L00C0:	MOVE.W	-(A3),D4
	MOVEQ	#3,D5
L00C1:	ADD.W	D4,D4
	ADDX.W	D0,D0
	ADD.W	D4,D4
	ADDX.W	D1,D1
	ADD.W	D4,D4
	ADDX.W	D2,D2
	ADD.W	D4,D4
	ADDX.W	D3,D3
	DBF	D5,L00C1
	DBF	D6,L00C0
	MOVEM.W	D0-D3,(A3)
	DBF	D7,L00BF
L00C2:	MOVEM.L	(A7),A0-A3/D0-D7
L00C3:	MOVE.B	(A4)+,(A0)+
	SUBQ.L	#1,D0
	BNE.S	L00C3
	MOVEQ	#$77,D0
L00C4:	MOVE.B	-(A3),-(A5)
	DBF	D0,L00C4
L00C5:	MOVEM.L	(A7)+,A0-A6/D0-D7
	UNLK	A3
	RTS
L00C6:	MOVEQ	#3,D1
L00C7:	LSL.L	#8,D0
	MOVE.B	(A0)+,D0
	DBF	D1,L00C7
	RTS
L00C8:	BSR.S	L00CC
	BCC.S	L00CB
	MOVEQ	#0,D1
	BSR.S	L00CC
	BCC.S	L00CA
	LEA	L00D9(PC),A1
	MOVEQ	#4,D3
L00C9:	MOVE.L	-(A1),D0
	BSR.S	L00CE
	SWAP	D0
	CMP.W	D0,D1
	DBNE	D3,L00C9
	ADD.L	20(A1),D1
L00CA:	MOVE.B	-(A5),-(A6)
	DBF	D1,L00CA
L00CB:	CMP.L	A4,A6
	BGT.S	L00D1
	RTS
L00CC:	ADD.B	D7,D7
	BNE.S	L00CD
	MOVE.B	-(A5),D7
	ADDX.B	D7,D7
L00CD:	RTS
L00CE:	MOVEQ	#0,D1
L00CF:	ADD.B	D7,D7
	BNE.S	L00D0
	MOVE.B	-(A5),D7
	ADDX.B	D7,D7
L00D0:	ADDX.W	D1,D1
	DBF	D0,L00CF
	RTS
L00D1:	LEA	L00DA(PC),A1
	MOVEQ	#3,D2
L00D2:	BSR.S	L00CC
	DBCC	D2,L00D2
	MOVEQ	#0,D4
	MOVEQ	#0,D1
	MOVE.B	1(A1,D2.W),D0
	EXT.W	D0
	BMI.S	L00D3
	BSR.S	L00CE
L00D3:	MOVE.B	6(A1,D2.W),D4
	ADD.W	D1,D4
	BEQ.S	L00D5
	LEA	L00DB(PC),A1
	MOVEQ	#1,D2
L00D4:	BSR.S	L00CC
	DBCC	D2,L00D4
	MOVEQ	#0,D1
	MOVE.B	1(A1,D2.W),D0
	EXT.W	D0
	BSR.S	L00CE
	ADD.W	D2,D2
	ADD.W	6(A1,D2.W),D1
	BPL.S	L00D7
	SUB.W	D4,D1
	BRA.S	L00D7
L00D5:	MOVEQ	#0,D1
	MOVEQ	#5,D0
	MOVEQ	#-1,D2
	BSR.S	L00CC
	BCC.S	L00D6
	MOVEQ	#8,D0
	MOVEQ	#$3F,D2
L00D6:	BSR.S	L00CE
	ADD.W	D2,D1
L00D7:	LEA	2(A6,D4.W),A1
	ADD.W	D1,A1
	MOVE.B	-(A1),-(A6)
L00D8:	MOVE.B	-(A1),-(A6)
	DBF	D4,L00D8
	BRA	L00C8
	DC.B	$7F,$FF,$00,$0E,$00,$FF,$00,$07
	DC.B	$00,$07,$00,$02,$00,$03,$00,$01
	DC.B	$00,$03,$00,$01
L00D9:	DC.B	0,0
	DC.B	$01,$0D,$00,$00,$00,$0E,$00,$00
	DC.B	$00,$07,$00,$00,$00,$04,$00,$00
	DC.B	$00,$01
L00DA:	DC.B	$09,$01,$00,$FF,$FF,$08,$04,$02
	DC.B	$01,$00
L00DB:	DC.B	$0B,$04,$07,$00,$01,$1F,$FF,$FF
	DC.B	$00,$1F,$00,$00,$00,$00,$00,$00
	DC.B	0,0
L00DC:	DS.W	13
L00DD:	DC.L	0
L00DE:	DS.B	18
	DC.B	$30,$00,$00,$00,$00,$00,$00,$00
	DS.W	21
	DC.B	$05,$00,$00,$00,$00,$00,$00,$00
L00DF:	DC.B	$0A,$0D,$00
L00E0:	DC.B	$0D,$0A,$0A
	DC.B	'Enter name of source file: ',$00,$0A,$0D
	DC.B	'Enter name of destination file: '
	DC.B	$00
L00E1:	DC.B	'Could not allocate enough memory',$0A,$0D,$00
L00E2:	DC.B	$0A,$0D,'Working: ',$00
L00E3:	DC.B	'P>',$00
L00E4:	DC.B	$0A,$0D,'Crunch another file (Y/n): ',$00
L00E5:	DC.B	$0D,$0A,$0A,'Relocate program after depacking (Y/n): ',$00
L00E6:	DC.B	$0D,$0A,$0A,'Additional picture compression (N/y): '
	DC.B	$00
L00E7:	DC.B	$0D,$0A,'Please enter the offset (Default: $0000'
L00E8:	DC.B	'): $',$00
L00E9:	DC.B	$0A,$0D,'1) Crunch data file (Default)',$0A,$0D
	DC.B	'2) Crunch executable file',$0A,$0D
	DC.B	'3) Set Parameters',$0A,$0D
	DC.B	'Please select: ',$00
L00EA:	DC.B	'No mem!',$00
L00EB:	DC.B	'    Verify: ',$00
L00EC:	DC.B	'OK! ',$00
L00ED:	DC.B	'Error!        [cancelled]',$00
L00EE:	DC.B	'    Data cannot be packed!  [cancelled]',$00
L00EF:	DC.B	$1B,'D',$1B,'D',$1B,'D',$1B,'D'
	DC.B	$1B,'D',$1B,'D',$1B,'D',$1B,'D'
	DC.B	$1B,'D',$1B,'D',$1B,'D',$1B,'D'
	DC.B	$1B,'D',$1B,'D',$1B,'D',$1B,'D'
	DC.B	$1B,'D',$1B,'D',$1B,'D',$1B,'D'
	DC.B	$1B,'D',$1B,'D',$1B,'D',$1B,'D'
	DC.B	$1B,'D',$1B,'D',$1B,'D',$1B,'D'
	DC.B	$1B,'D',$1B,'D',$1B,'D',$1B,'D'
	DC.B	$1B,'D',$1B,'D',$1B,'D',$1B,'D'
	DC.B	$1B,'D',$1B,'D',$1B,'D',$1B,'D'
	DC.B	$1B,'D',$1B,'D',$1B,'D',$1B,'D'
	DC.B	$1B,'D',$1B,'C',$1B,'C',$1B,'C'
	DC.B	$1B,'C',$1B,'C',$1B,'C',$1B,'C'
	DC.B	$1B,'C',$1B,'C',$1B,'C',$1B,'C'
	DC.B	$1B,'C',$1B,'C',$1B,'C',$1B,'C'
	DC.B	$1B,'C',$1B,'C',$1B,'C',$1B,'C'
	DC.B	$1B,'C',$1B,'C',$1B,'C',$1B,'C'
	DC.B	$1B,'CRemaining: '
L00F0:	DC.B	'99%',$00,$00
L00F1:	DC.B	$1B,'D',$1B,'D',$1B,'D',$1B,'D'
	DC.B	$1B,'D',$1B,'D',$1B,'D',$1B,'D'
	DC.B	$1B,'D',$1B,'D',$1B,'D',$1B,'D'
	DC.B	$1B,'D',$1B,'D',$1B,'D',$1B,'D'
	DC.B	$1B,'D',$1B,'D',$1B,'D',$1B,'D'
	DC.B	$1B,'D',$1B,'D',$1B,'D',$1B,'D'
	DC.B	$1B,'D',$1B,'C',$1B,'C',$1B,'C'
	DC.B	$1B,'C',$1B,'C',$1B,'C',$1B,'C'
	DC.B	$1B,'C',$1B,'C-',$00
L00F2:	DC.B	'~',$00
L00F3:	DC.B	$1B,'D',$1B,'D',$1B,'D',$1B,'D'
	DC.B	$1B,'D',$1B,'D',$1B,'D',$1B,'D'
	DC.B	$1B,'D',$1B,'D',$1B,'D',$1B,'D'
	DC.B	$1B,'D',$1B,'D',$1B,'D',$1B,'D'
	DC.B	$1B,'D',$1B,'D',$1B,'D',$1B,'D'
	DC.B	$1B,'D',$1B,'D',$1B,'D',$1B,'D'
	DC.B	$1B,'D',$1B,'D',$1B,'D',$1B,'D'
	DC.B	$1B,'D',$1B,'D',$1B,'D',$1B,'D'
	DC.B	$1B,'D',$1B,'D',$1B,'D',$1B,'D'
	DC.B	$1B,'D',$1B,'D',$1B,'D',$1B,'D'
	DC.B	$1B,'D',$1B,'D',$1B,'D',$1B,'D'
	DC.B	$1B,'D',$1B,'C',$1B,'C',$1B,'C'
	DC.B	$1B,'C',$1B,'C',$1B,'C',$1B,'C'
	DC.B	$1B,'C',$1B,'C',$1B,'C',$1B,'C'
	DC.B	$1B,'C',$1B,'C',$1B,'C',$1B,'C'
	DC.B	$1B,'C',$1B,'C',$1B,'C',$1B,'C'
	DC.B	$1B,'C',$1B,'C',$1B,'C',$1B,'C'
	DC.B	$1B,'CTime: '
	DC.B	$09,'      ',$08
	DC.B	$08,$08,$08,$08,$08,$08,$08,$08
	DC.B	$08,$00,$00
L00F4:	DC.B	'  Rate: ',$00
L00F5:	DC.B	'% [saving]',$00
L00F6:	DC.B	'   <ALT> was pressed. File is skipped.',$00
L00F7:	DC.B	'    Larger than original!   [cancelled]',$00
L00F8:	DC.B	$1B,'E',$1B,'f',$0A
	DC.B	' ~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~',$0D,$0A
	DC.B	' |   Version 2.31                                                            |',$0D,$0A
	DC.B	' {                          P A C K - I C E                                  }',$0D,$0A
	DC.B	' |                                                                           |',$0D,$0A
	DC.B	' {             This packer was written by Axe of Superior.                   }',$0D,$0A
	DC.B	' |       First version: 14.02.1990    Final changes: 19.02.1991              |',$0D,$0A
	DC.B	' {                                                                           }',$0D,$0A
	DC.B	' ~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~-~',$0D,$0A
	DC.B	$0A
	DC.B	0,0
L00FA:	DC.B	'[0][| What do you wish to pack?  |  - Data files |  - Executable files |'
	DC.B	'  - Set Parameters ][ DATA | EXEC | SETUP ]',$00
L00FB:	DC.B	'[0][| Relocate after decrunch?  |  ][ YES | NO ]'
	DC.B	$00
L00FC:	DC.B	'[2][| Do you wish to pack | another file?|][ YES | NO | ??? ]',$00
L00FD:	DC.B	'[0][| Do you wish to use an | additional algorithm  | for picture'
	DC.B	' compression? |][ NO | YES ]',$00,$00
	BSS
ZUEND:	DS.B	1294
L00FE	EQU	ZUEND+0	
L00FF	EQU	ZUEND+$20	
L0100	EQU	ZUEND+$3E	
L0101	EQU	ZUEND+$4A	
L0102	EQU	ZUEND+$4E	
L0103	EQU	ZUEND+$14E
L0104	EQU	ZUEND+$44E
L0105	EQU	ZUEND+$450
L0106	EQU	ZUEND+$456
L0107	EQU	ZUEND+$458
L0108	EQU	ZUEND+$45A
L0109	EQU	ZUEND+$45C
L010A	EQU	ZUEND+$460
L010B	EQU	ZUEND+$464
L010C	EQU	ZUEND+$468
L010D	EQU	ZUEND+$46C
L010E	EQU	ZUEND+$46E
L010F	EQU	ZUEND+$470
L0110	EQU	ZUEND+$474
L0111	EQU	ZUEND+$476
L0112	EQU	ZUEND+$47A
L0113	EQU	ZUEND+$47E
L0114	EQU	ZUEND+$482
L0115	EQU	ZUEND+$484
L0116	EQU	ZUEND+$486
L0117	EQU	ZUEND+$48E
L0118	EQU	ZUEND+$492
L0119	EQU	ZUEND+$496
L011A	EQU	ZUEND+$49A
L011B	EQU	ZUEND+$49E
L011C	EQU	ZUEND+$4A0
L011D	EQU	ZUEND+$4A2
L011E	EQU	ZUEND+$4A4
L011F	EQU	ZUEND+$4A6
L0120	EQU	ZUEND+$4A8
L0121	EQU	ZUEND+$4F8
L0122	EQU	ZUEND+$4FA
