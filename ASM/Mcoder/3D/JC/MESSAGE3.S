THIS IS THE UNIQUE PREVERSION -EXCLUSIVELY OWNED BY ILLEGAL- 
OF OUR SCREEN WHICH WILL BE RELEASED IN THE EUROPEAN DEMO. 
YOU CAN CHANGE THE ROTATIONS BY PRESSING THE ARROW KEYS, CLR-HOME, 
DELETE AND BACKSPACE. HELP AND UNDO ZOOM THE OBJECTS. 
+ AND - CHANGE THE OBJECT.            
THIS PIECE OF CODE WAS PROGRAMMED BY 3 OF THE BEST FRENCH CODERS : 
MCODER, ZIGGY STARDUST AND ALGERNON. 
HEY, THE LOST BOYS, YOU MUST RECKON OUR 3D IS THE FASTEST AT THE MOMENT 
BECAUSE WE CALCULATE EACH OBJECT IN REAL-TIME !!! 
OF COURSE, OUR AMBITION IS NOT ONLY TO MAKE DEMOS. IN FACT, WE ARE 
CODING A 3D GAME, AND OUR ROUTINES ARE MUCH MORE FASTER THAN 
THE ONES IN INTERPHASE !!!                    
BEFORE THE END OF THIS LITTLE SCROLL, WE MUST SAY THAT WE WILL USE 
SOME -REALLY- NEW TECHNIQUES IN OUR DEMO (FOR INSTANCE FILLED CIRCLES 
AND STENCILS AND MUCH MORE)...
                                                         
