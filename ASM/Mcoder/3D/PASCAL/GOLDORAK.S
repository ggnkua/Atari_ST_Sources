	opt	l2
	XDEF	Goldorak
	include	define.s

Goldorak:	dc.l	P_goldorak
	dc.l	0
	dc.l	Goldorak

P_goldorak:	dc.w	65
	dc.w	+$00,+$28,+$00
	dc.w	+$18,+$20,+$00
	dc.w	+$08,+$18,+$00
	dc.w	+$40,+$10,+$00
	dc.w	+$48,+$08,+$00
	dc.w	+$40,+$00,+$00
	dc.w	+$08,-$10,+$00
	dc.w	+$28,-$20,+$00
	dc.w	+$10,-$28,+$00
	dc.w	+$00,-$28,+$00
	dc.w	+$10,+$20,+$10
	dc.w	+$05,+$18,+$05
	dc.w	+$2D,+$10,+$2D
	dc.w	+$32,+$08,+$32
	dc.w	+$2D,+$00,+$2D
	dc.w	+$05,-$10,+$05
	dc.w	+$1C,-$20,+$1C
	dc.w	+$0B,-$28,+$0B
	dc.w	+$00,+$20,+$18
	dc.w	+$00,+$18,+$08
	dc.w	+$00,+$10,+$40
	dc.w	+$00,+$08,+$48
	dc.w	+$00,+$00,+$40
	dc.w	+$00,-$10,+$08
	dc.w	+$00,-$20,+$28
	dc.w	+$00,-$28,+$10
	dc.w	-$11,+$20,+$10
	dc.w	-$06,+$18,+$05
	dc.w	-$2D,+$10,+$2D
	dc.w	-$33,+$08,+$32
	dc.w	-$2D,+$00,+$2D
	dc.w	-$06,-$10,+$05
	dc.w	-$1C,-$20,+$1C
	dc.w	-$0B,-$28,+$0B
	dc.w	-$18,+$20,+$00
	dc.w	-$08,+$18,+$00
	dc.w	-$40,+$10,+$00
	dc.w	-$48,+$08,+$00
	dc.w	-$40,+$00,+$00
	dc.w	-$08,-$10,+$00
	dc.w	-$28,-$20,+$00
	dc.w	-$10,-$28,+$00
	dc.w	-$11,+$20,-$11
	dc.w	-$06,+$18,-$06
	dc.w	-$2D,+$10,-$2D
	dc.w	-$33,+$08,-$33
	dc.w	-$2D,+$00,-$2D
	dc.w	-$06,-$10,-$06
	dc.w	-$1C,-$20,-$1C
	dc.w	-$0B,-$28,-$0B
	dc.w	+$00,+$20,-$18
	dc.w	+$00,+$18,-$08
	dc.w	+$00,+$10,-$40
	dc.w	+$00,+$08,-$48
	dc.w	+$00,+$00,-$40
	dc.w	+$00,-$10,-$08
	dc.w	+$00,-$20,-$28
	dc.w	+$00,-$28,-$10
	dc.w	+$10,+$20,-$11
	dc.w	+$05,+$18,-$06
	dc.w	+$2D,+$10,-$2D
	dc.w	+$32,+$08,-$33
	dc.w	+$2D,+$00,-$2D
	dc.w	+$05,-$10,-$06
	dc.w	+$1C,-$20,-$1C
	dc.w	+$0B,-$28,-$0B
	dc.l	F_goldorak


F_goldorak:
	;7
	VERTICES	15,16,7,6,-1,-1,-1,-1
	COLOR	4
	dc.l	0
	VERTICES	23,24,16,15,-1,-1,-1,-1
	COLOR	2
	dc.l	0
	VERTICES	31,32,24,23,-1,-1,-1,-1
	COLOR	4
	dc.l	0
	VERTICES	39,40,32,31,-1,-1,-1,-1
	COLOR	2
	dc.l	0
	VERTICES	47,48,40,39,-1,-1,-1,-1
	COLOR	4
	dc.l	0
	VERTICES	55,56,48,47,-1,-1,-1,-1
	COLOR	2
	dc.l	0
	VERTICES	63,64,56,55,-1,-1,-1,-1
	COLOR	4
	dc.l	0
	VERTICES	6,7,64,63,-1,-1,-1,-1
	COLOR	2
	dc.l	0
	;3
	VERTICES	11,12,3,2,-1,-1,-1,-1
	COLOR	4
	dc.l	0
	VERTICES	19,20,12,11,-1,-1,-1,-1
	COLOR	2
	dc.l	0
	VERTICES	27,28,20,19,-1,-1,-1,-1
	COLOR	4
	dc.l	0
	VERTICES	35,36,28,27,-1,-1,-1,-1
	COLOR	2
	dc.l	0
	VERTICES	43,44,36,35,-1,-1,-1,-1
	COLOR	4
	dc.l	0
	VERTICES	51,52,44,43,-1,-1,-1,-1
	COLOR	2
	dc.l	0
	VERTICES	59,60,52,51,-1,-1,-1,-1
	COLOR	4
	dc.l	0
	VERTICES	2,3,60,59,-1,-1,-1,-1
	COLOR	2
	dc.l	0
	;2
	VERTICES	10,11,2,1,-1,-1,-1,-1
	COLOR	3
	dc.l	0
	VERTICES	18,19,11,10,-1,-1,-1,-1
	COLOR	1
	dc.l	0
	VERTICES	26,27,19,18,-1,-1,-1,-1
	COLOR	3
	dc.l	0
	VERTICES	34,35,27,26,-1,-1,-1,-1
	COLOR	1
	dc.l	0
	VERTICES	42,43,35,34,-1,-1,-1,-1
	COLOR	3
	dc.l	0
	VERTICES	50,51,43,42,-1,-1,-1,-1
	COLOR	1
	dc.l	0
	VERTICES	58,59,51,50,-1,-1,-1,-1
	COLOR	3
	dc.l	0
	VERTICES	1,2,59,58,-1,-1,-1,-1
	COLOR	1
	dc.l	0
	;6
	VERTICES	14,15,6,5,-1,-1,-1,-1
	COLOR	3
	dc.l	0
	VERTICES	22,23,15,14,-1,-1,-1,-1
	COLOR	1
	dc.l	0
	VERTICES	30,31,23,22,-1,-1,-1,-1
	COLOR	3
	dc.l	0
	VERTICES	38,39,31,30,-1,-1,-1,-1
	COLOR	1
	dc.l	0
	VERTICES	46,47,39,38,-1,-1,-1,-1
	COLOR	3
	dc.l	0
	VERTICES	54,55,47,46,-1,-1,-1,-1
	COLOR	1
	dc.l	0
	VERTICES	62,63,55,54,-1,-1,-1,-1
	COLOR	3
	dc.l	0
	VERTICES	5,6,63,62,-1,-1,-1,-1
	COLOR	1
	dc.l	0

	;4
	VERTICES	3,12,13,4,-1,-1,-1,-1
	COLOR	3
	dc.l	0
	VERTICES	12,20,21,13,-1,-1,-1,-1
	COLOR	1
	dc.l	0
	VERTICES	20,28,29,21,-1,-1,-1,-1
	COLOR	3
	dc.l	0
	VERTICES	28,36,37,29,-1,-1,-1,-1
	COLOR	1
	dc.l	0
	VERTICES	36,44,45,37,-1,-1,-1,-1
	COLOR	3
	dc.l	0
	VERTICES	44,52,53,45,-1,-1,-1,-1
	COLOR	1
	dc.l	0
	VERTICES	52,60,61,53,-1,-1,-1,-1
	COLOR	3
	dc.l	0
	VERTICES	60,3,4,61,-1,-1,-1,-1
	COLOR	1
	dc.l	0

	;5
	VERTICES	4,13,14,5,-1,-1,-1,-1
	COLOR	4
	dc.l	0
	VERTICES	13,21,22,14,-1,-1,-1,-1
	COLOR	2
	dc.l	0
	VERTICES	21,29,30,22,-1,-1,-1,-1
	COLOR	4
	dc.l	0
	VERTICES	29,37,38,30,-1,-1,-1,-1
	COLOR	2
	dc.l	0
	VERTICES	37,45,46,38,-1,-1,-1,-1
	COLOR	4
	dc.l	0
	VERTICES	45,53,54,46,-1,-1,-1,-1
	COLOR	2
	dc.l	0
	VERTICES	53,61,62,54,-1,-1,-1,-1
	COLOR	4
	dc.l	0
	VERTICES	61,4,5,62,-1,-1,-1,-1
	COLOR	2
	dc.l	0

	;8
	VERTICES	7,16,17,8,-1,-1,-1,-1
	COLOR	3
	dc.l	0
	VERTICES	16,24,25,17,-1,-1,-1,-1
	COLOR	1
	dc.l	0
	VERTICES	24,32,33,25,-1,-1,-1,-1
	COLOR	3
	dc.l	0
	VERTICES	32,40,41,33,-1,-1,-1,-1
	COLOR	1
	dc.l	0
	VERTICES	40,48,49,41,-1,-1,-1,-1
	COLOR	3
	dc.l	0
	VERTICES	48,56,57,49,-1,-1,-1,-1
	COLOR	1
	dc.l	0
	VERTICES	56,64,65,57,-1,-1,-1,-1
	COLOR	3
	dc.l	0
	VERTICES	64,7,8,65,-1,-1,-1,-1
	COLOR	1
	dc.l	0

	;1
	VERTICES	0,10,1,-1,-1,-1,-1,-1
	COLOR	4
	dc.l	0
	VERTICES	0,18,10,-1,-1,-1,-1,-1
	COLOR	2
	dc.l	0
	VERTICES	0,26,18,-1,-1,-1,-1,-1
	COLOR	4
	dc.l	0
	VERTICES	0,34,26,-1,-1,-1,-1,-1
	COLOR	2
	dc.l	0
	VERTICES	0,42,34,-1,-1,-1,-1,-1
	COLOR	4
	dc.l	0
	VERTICES	0,50,42,-1,-1,-1,-1,-1
	COLOR	2
	dc.l	0
	VERTICES	0,58,50,-1,-1,-1,-1,-1
	COLOR	4
	dc.l	0
	VERTICES	0,1,58,-1,-1,-1,-1,-1
	COLOR	2
	dc.l	0

	;9
	VERTICES	8,17,9,-1,-1,-1,-1,-1
	COLOR	4
	dc.l	0
	VERTICES	17,25,9,-1,-1,-1,-1,-1
	COLOR	2
	dc.l	0
	VERTICES	25,33,9,-1,-1,-1,-1,-1
	COLOR	4
	dc.l	0
	VERTICES	33,41,9,-1,-1,-1,-1,-1
	COLOR	2
	dc.l	0
	VERTICES	41,49,9,-1,-1,-1,-1,-1
	COLOR	4
	dc.l	0
	VERTICES	49,57,9,-1,-1,-1,-1,-1
	COLOR	2
	dc.l	0
	VERTICES	57,65,9,-1,-1,-1,-1,-1
	COLOR	4
	dc.l	0
	VERTICES	65,8,9,-1,-1,-1,-1,-1
	COLOR	2
	dc.l	0

	dc.w	-1
