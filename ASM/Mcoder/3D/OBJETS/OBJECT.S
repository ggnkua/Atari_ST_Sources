X1=$4AEFC
X2=$20E76

	DC.L	BASE1+$4AEFC-X1,BASE1+$4B0DC-X1
	DC.W	$167,3,$166,$27,$2C
	DC.L	BASE1+$4B190-X1,BASE1+$4B364-X1
	DC.W	1,4,3,$2B,$25
	DC.L	BASE1+$4B3FC-X1,BASE1+$4B5D0-X1
	DC.W	3,2,1,$26,$34
	DC.L	BASE1+$4B6A4-X1,BASE1+$4B884-X1
	DC.W	0,0,3,$2B,$27
	DC.L	BASE1+$4B924-X1,BASE1+$4BB04-X1
	DC.W	0,0,2,$27,$3B
	DC.L	BASE1-X1+$4BBF4,BASE1-X1+$4BE04
	DC.W	1,2,3,$2B,$31
	DC.L	BASE1-X1+$4BECC,BASE1-X1+$4C0D0
	DC.W	1,2,3,$2A,$28
	DC.L	BASE1-X1+$4C174,BASE1-X1+$4C384
	DC.W	1,1,$165,$2B,$37
	DC.L	BASE1-X1+$4C460,BASE1-X1+$4C604
	DC.W	$167,2,4,$22,$3A
	DC.L	BASE1-X1+$4C6F0,BASE1-X1+$4C8E8
	DC.W	1,1,1,$29,$2F
	DC.L	BASE1-X1+$4C9A8,BASE1-X1+$4CAF8
	DC.W	1,2,3,$1B,$17
	DC.L	BASE1-X1+$4CB58,BASE1-X1+$4CD20
	DC.W	1,2,$163,$25,$38
	DC.L	BASE1-X1+$4CE04,BASE1-X1+$4D014
	DC.W	1,2,3,$2B,$23
	DC.L	BASE1-X1+$4D0A4,BASE1-X1+$4D2C0
	DC.W	1,2,1,$2C,$27
	DC.L	BASE1-X1+$20E76,BASE1-X1+$21556
	DC.W	1,2,3,$2B,$2B
	DC.L	BASE1-X1+$4D8F0,BASE1-X1+$4DB0C
	DC.W	1,2,3,$2C,$30
	DC.L	BASE1-X1+$4D360,BASE1-X1+$4D528
	DC.W	1,2,3,$25,$29
	DC.L	BASE1-X1+$4D5D0,BASE1-X1+$4D828
	DC.W	2,2,4,$31,$31
	DC.L	BASE1-X1+$4DBD0,BASE1-X1+$4DD50
	DC.W	0,0,5,$1F,$23
	DC.L	BASE1-X1+$4DDE0,BASE1-X1+$4DF24
	DC.W	0,0,4,$1B,$1A
	DC.W	0,0,0,0

BASE1	INCBIN	OBJET2.BIN
BASE2	INCBIN	OBJET1.BIN
