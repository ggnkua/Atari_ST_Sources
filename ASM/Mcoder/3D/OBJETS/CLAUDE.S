tobjets:
	DC.L	ospider
ospider:
	DC.W	100		;X
	DC.W	50		;Y
	DC.W	-50		;Z
	DC.W	40		;theta
	DC.L	pspider
	
	DC.L	fspider

pspider:
	DC.W	-15,  25,  0
	DC.W	 25,  30,  0
	DC.W	-65,  10,  0
	DC.W	-15,  10,  5
	DC.W	 25,  10,  5
	DC.W	 40,  10,  0
	DC.W	-65, -10,  0
	DC.W	-15, -10,  5
	DC.W	 25, -10,  5
	DC.W	 40, -10,  0
	DC.W	-15, -25,  0
	DC.W	 25, -30,  0
	DC.W	-15,  25, -5
	DC.W	 25,  30, -5
	DC.W	-75,   5, -5
	DC.W	 40,  10, -5
	DC.W	-75,  -5, -5
	DC.W	 40, -10, -5
	DC.W	-15, -25, -5
	DC.W	 25, -30, -5
	DC.W	-10,   0,-15
	DC.W	 20,   0,-15
	DC.W	 0
fspider:
	DC.B	2,0,3,0,1
	DC.B	4,3,0,1,2
	DC.B	1,5,4,0,3
	DC.B	2,3,7,6,4
	DC.B	3,4,8,7,5
	DC.B	4,5,9,8,6
	DC.B	6,7,10,0,7
	DC.B	7,8,11,10,8
	DC.B	8,9,11,0,9
	DC.B	12,0,2,14,10
	DC.B	1,0,12,13,11
	DC.B	5,1,13,15,12
	DC.B	9,5,15,17,13
	DC.B	11,9,17,19,14
	DC.B	10,11,19,18,15
	DC.B	6,10,18,16,1
	DC.B	2,6,16,14,2
	DC.B	13,12,20,21,3
	DC.B	12,14,20,0,4
	DC.B	20,14,16,0,5
	DC.B	20,16,18,0,6
	DC.B	20,18,19,21,7
	DC.B	21,19,17,0,8
	DC.B	15,21,17,0,9
	DC.B	13,21,15,0,10
	DC.B	0
	EVEN
pdisk:
	DC.W	 -45,45,4
	DC.W	45,45,4
	DC.W	45,-50,4
	DC.W	-45,-50,4
	DC.W	 -45,45,0
	DC.W	45,45,0
	DC.W	45,-50,0
	DC.W	-45,-50,0
pdiskf:
	DC.W	-35,45,4
	DC.W	35,45,4
	DC.W	35,-10,4
	DC.W	-35,-10,4
	DC.W	-25,-20,4
	DC.W	25,-20,4
	DC.W	25,-50,4
	DC.W	-25,-50,4
	DC.W	35,-20,4
	DC.W	35,-50,4
	DC.W	-15,-25,4
	DC.W	-5,-25,4
	DC.W	-5,-45,4
	DC.W	-15,-45,4
	DC.W	37,40,4
	DC.W	42,40,4
	DC.W	42,36,4
	DC.W	37,36,4
pdiskd:
	DC.W	37,40,0
	DC.W	42,40,0
	DC.W	42,36,0
	DC.W	37,36,0
	DC.W	-35,45,0
	DC.W	35,45,0
	DC.W	35,32,0
	DC.W	-35,32,0
	DC.W	1,15,0
	DC.W	11,11,0
	DC.W	15,0,0
	DC.W	11,-11,0
	DC.W	1,-15,0
	DC.W	-11,-11,0
	DC.W	-15,0,0
	DC.W	-11,11,0
	DC.W	-25,-20,0
	DC.W	25,-20,0
	DC.W	25,-50,0
	DC.W	-25,-50,0
	DC.W	35,-20,0
	DC.W	35,-50,0
	DC.W	-15,-25,0
	DC.W	-5,-25,0
	DC.W	-5,-45,0
	DC.W	-15,-45,0
	DC.W	0
pcaisse:
	DC.W	-10,10,0
	DC.W	10,10,0
	DC.W	10,-10,0
	DC.W	-10,-10,0

	DC.W	-15,15,5
	DC.W	15,15,5
	DC.W	15,-15,5
	DC.W	-15,-15,5

	DC.W	-15,15,25
	DC.W	15,15,25
	DC.W	15,-15,25
	DC.W	-15,-15,25

	DC.W	-10,10,30
	DC.W	10,10,30
	DC.W	10,-10,30
	DC.W	-10,-10,30

	DC.W	0
pcube:
pchar:
	DC.W	-30,25,0
	DC.W	30,25,0
	DC.W	30,-25,0
	DC.W	-30,-25,0
	DC.W	-40,25,10
	DC.W	40,25,10
	DC.W	40,-25,10
	DC.W	-40,-25,10
	DC.W	-40,25,20
	DC.W	40,25,20
	DC.W	40,-25,20
	DC.W	-40,-25,20
	DC.W	-20,20,25
	DC.W	10,20,25
	DC.W	10,-20,25
	DC.W	-20,-20,25
	DC.W	0
pmonolyte:
	DC.W	-20,-5,0
	DC.W	20,-5,0
	DC.W	20,5,0
	DC.W	-20,5,0
	DC.W	-20,-5,90
	DC.W	20,-5,90
	DC.W	20,5,90
	DC.W	-20,5,90
	DC.W	0
pde:
	DC.W	-20,-20,-20
	DC.W	20,-20,-20
	DC.W	20,20,-20
	DC.W	-20,20,-20
	DC.W	-20,-20,20
	DC.W	20,-20,20
	DC.W	20,20,20
	DC.W	-20,20,20
	DC.W	0
pcone:
	DC.W	-15,35,0
	DC.W	15,35,0
	DC.W	35,15,0
	DC.W	35,-15,0
	DC.W	15,-35,0
	DC.W	-15,-35,0
	DC.W	-35,-15,0
	DC.W	-35,15,0
	DC.W	1,0,100
	DC.W	0
pplaque:
	DC.W	-30,-30,0
	DC.W	30,-30,0
	DC.W	30,30,0
	DC.W	-30,30,0
	DC.W	0
ptriangle:
	DC.W	1,0,30
	DC.W	1,22,0
	DC.W	20,-13,0
	DC.W	-20,-13,0
	DC.W	0
pmaison:
	DC.W	-50,-50,-50
	DC.W	 50,-50,-50
	DC.W	 50, 50,-50
	DC.W	-50, 50,-50	
	DC.W	-50,-50,  0
	DC.W	 50,-50,  0
	DC.W	 50, 50,  0
	DC.W	-50, 50,  0	
	DC.W	  1,  0, 80  
	DC.W	  0

fdisk:
	DC.B	2,3,0,1,1
	DC.B	7,6,5,4,1
	DC.B	1,5,6,2,2
	DC.B	2,6,7,3,2
	DC.B	7,4,0,3,2
	DC.B	1,0,4,5,2
fdiskf:
	DC.B	8,9,10,11,3
	DC.B	12,13,14,15,4
	DC.B	13,16,17,14,5
	DC.B	18,19,20,21,6
	DC.B	22,23,24,25,7
fdiskd:
	DC.B	29,28,27,26,3
	DC.B	33,32,31,30,4
	DC.B	34,41,40,35,5
	DC.B	35,40,39,36,6
	DC.B	36,39,38,37,7
	DC.B	43,42,45,44,8
	DC.B	46,43,44,47,9
	DC.B	49,48,51,50,10

	DC.B	0
fcube:
fchar:
;	DC.B	3,0,1,2,5
	DC.B	1,2,6,5,2
	DC.B	7,3,0,4,3
	DC.B	5,4,0,1,9
	DC.B	7,6,2,3,5
	DC.B	9,8,4,5,6
	DC.B	8,11,7,4,7
	DC.B	11,10,6,7,8
	DC.B	10,9,5,6,9
	DC.B	12,8,9,13,10
	DC.B	13,9,10,14,11
	DC.B	14,10,11,15,12
	DC.B	15,11,8,12,13
	DC.B	12,13,14,15,14
	DC.B    0
fde:
	DC.B	2,3,0,1
	DC.B	7,6,5,4
	DC.B	1,5,6,2
	DC.B	4,0,3,7
	DC.B	5,1,0,4
	DC.B	7,3,2,6
	DC.B	0
fcone:
	DC.B	7,0,8,0
	DC.B	8,0,1,0
	DC.B	1,2,8,0
	DC.B	8,2,3,0
	DC.B	3,4,8,0
	DC.B	8,4,5,0
	DC.B	5,6,8,0
	DC.B	8,6,7,0
	DC.B	7,0,8,0
	DC.B	0
fplaque:
	DC.B	2,3,0,1
	DC.B	1,0,3,2
	DC.B	0
ftriangle:
	DC.B	1,2,0,0
	DC.B	1,0,3,0
	DC.B	2,3,0,0
	DC.B	3,2,1,0
	DC.B	0
fmaison:
	DC.B	2,3,0,1,1
	DC.B	2,6,7,3,2
	DC.B	5,1,0,4,3
	DC.B	5,6,2,1,4
	DC.B	4,0,3,7,5
	DC.B	7,8,4,0,6
	DC.B	4,8,5,0,7
	DC.B	5,8,6,0,8
	DC.B	6,8,7,0,9	
	DC.B	0
	even
