	MOVE.L	#'CODE',D0
	MOVE	#$800/4-1,D1
	LEA	$80000,A0
CRYPTE:
	EOR.L	#$31415926,D0
	ADD.L	#$27182818,D0
	EOR.L	D0,(A0)+
	DBRA	D1,CRYPTE
	ILLEGAL
