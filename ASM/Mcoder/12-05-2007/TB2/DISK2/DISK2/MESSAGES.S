	lea	mess1,a0
convert:
	clr	d0
	move.b	(a0),d0
	bmi.s	.fini

	lea	.alphabet,a1
.search	move.b	(a1)+,d1
	bmi.s	.space
	cmp.b	d1,d0
	bne.s	.search
	move.l	a1,d0
	sub.l	#.alphabet+1,d0
	move.b	d0,(a0)+
	bra.S	convert
.space	clr.b	(a0)+
	bra.S	convert
.alphabet
	dc.b	" ![]"
	dc.b	"'(),.:;?0123456789"
	dc.b	"ABCDEFGHIJKLMNOPQRSTUVWXYZ-"
	DC.B	-1
	EVEN
.fini
	addq	#1,a0
	cmp.l	#finmess,a0
	blo.s	convert
	lea	messages,a0
	lea	finmess,a1
	illegal

messages:
	dc.w	mess1-messages		;1=MAIN-MENU
	dc.w	mess8-messages		;2=CYBERNETICS
	dc.w	mess9-messages		;3=DEFCON 4
	dc.w	mess2-messages		;4=EQUINOX
	dc.w	mess4-messages		;5=ART OF CODE 2
	dc.w	mess11-messages		;6=SILVERS
	dc.w	mess12-messages		;7=MISFITS
	dc.w	mess13-messages		;8=TSB
	dc.w	mess15-messages		;9=VOYAGERS
	dc.w	mess5-messages		;10=MCS
	dc.w	mess7-messages		;11=ARTIS MAGIA
	dc.w	mess3-messages		;12=ART OF CODE 1
	dc.w	mess10-messages		;13=HOLOCAUST
	dc.w	mess16-messages		;14=OUTLAWS
	dc.w	mess6-messages		;15=THE BLACK CATS
	dc.w	mess14-messages		;16=MEGABUSTERS
mess1:
	DC.B	"                                        PLEASE WAIT A WHILE, "
	DC.B	"I'M LOADING AND DEPACKING THE MAIN-MENU FOR THE TRANSBEAUCE DEMO 2 DISK 2. "
	DC.B	"PRESS THE SPACE BAR WHEN [LOADED] APPEARS. "
	DC.B	"THE TRANSBEAUCE DEMO 2 WAS THE BIGGEST DEMO-PARTY EVER ORGANISED "
	DC.B	"IN FRANCE. MORE THAN 30 SCREENS WERE MADE FOR ONCE AND THIS DISK "
	DC.B	"INCLUDES THE LESSER SCREENS, SO WE CALL IT [THE LESSER DEMOS]. "
	DC.B	"THIS LITTLE LOADER-SCREEN HAS BEEN "
	DC.B	"CODED AND DESIGNED BY XERCES (FROM [GENESIS]) "
	DC.B	"AND MCODER (FROM [THE LONELY CODER]), AND THE MUSIC IS "
	DC.B	"FROM MADMAX. "
	DC.B	"OTHER CREDITS : THE INTRODUCTION SCREEN WAS CODED BY TERENCE (FROM [THE PENDRAGONS]), "
	DC.B	"GRAPHICS BY THE SERGEANT (FROM [THE BUSHWACKERS]) AND BY KRAZY REX (FROM [ST CONNEXION]) "
	DC.B	"AND MUSIC BY THE BIG ALEC "
	DC.B	"(FROM [OFF-BEAT]). THE MAIN-MENU WAS MADE BY THE OVERLANDERS, READ ITS SCROLLER "
	DC.B	"FOR MORE INFORMATIONS... "
	DC.B	"ALL THE SCROLLERS IN THE LOADER WERE WRITTEN BY MCODER "
	DC.B	"AND INVOLVE ONLY ME (I'M REFERING TO THE FACT THAT I KNOW "
	DC.B	"ONLY A FEW GROUPS WHO PARTICIPATED IN THIS DISK...). "
	DC.B	"I WOULD LIKE TO THANK SOME PEOPLE WHO HELPED ME INDIRECTLY "
	DC.B	"FOR THIS DEMO : ALGERNON (THANK YOU FOR LETTING ME YOUR HARD-DISK "
	DC.B	"AND SO SORRY I SCRATCHED IT -I DID MY BEST TO REPAIR IT-), "
	DC.B	"ALTAIR (THANK YOU FOR YOUR PACKER ! WITHOUT IT, THIS DEMO WOULDN'T "
	DC.B	"HAVE FIT INTO ONE DISK !!!), XERCES (THANK YOU FOR DESIGNING THE LOADER "
	DC.B	"WHILE TAKING YOUR EXAMS) AND THAT'S ALL... "
	DC.B	-1
mess2:
	DC.B	"                                        PLEASE WAIT A WHILE, I'M LOADING AND DEPACKING THE EQUINOX SCREEN. "
	DC.B	"PRESS THE SPACE BAR WHEN [LOADED] APPEARS. "
	DC.B	"THIS SCREEN WAS CODED IN ONE NIGHT WHILE THE WHOLE TEAM "
	DC.B	"WAS COMPLETELY DRUNK !!! "
	DC.B	"WE ARE LOOKING FOR THEIR LONG-AWAITED-SOON-FINISHED MEGA-DEMO "
	DC.B	"(CALLED [THE VODKA DEMO] -GUESS WHY-) "
	DC.B	"WHICH ALREADY FEATURES SOME REALLY IMPRESSIVE SCREENS...     "
	DC.B	"HEY GUYS, WHAT ABOUT YOUR 3D SCREEN ?"
	DC.B	-1
mess3:
	DC.B	"                                        PLEASE WAIT A WHILE, I'M LOADING AND DEPACKING THE ART OF CODE SCREEN NUMBER 1. "
	DC.B	"PRESS THE SPACE BAR WHEN [LOADED] APPEARS. "
	DC.B	"THIS GROUP SIGNS HERE THEIR FIRST APPEARANCE IN A MEGADEMO WITH AN ORIGINAL SCREEN "
	DC.B	"CALLED KNUCKLE BUSTER 2 (EXCUSE ME FOR MY BEHAVIOUR AT THE TRANS 2 BUT I WAS SO UPSET). "
	DC.B	"ORIGINAL -IT'S MY PREFERED ON THIS DISK- BUT FUCKING SCREEN COZ I SCRATCHED "
	DC.B	"MY HARD-DISK (IN FACT ALGERNON'S HARD-DRIVE) "
	DC.B	"AND 3 OF MY SOURCE DISKS (AARGHH) WHILE TRYING TO COPY IT !!! "
	DC.B	"I SUSPECT THEY DID IT ON PURPOSE. "
	DC.B	"NO, I'M NOT PARANOIAC, NO, NO, NOT THE CAMISOLE, NOOOOOOOOOO..."
	DC.B	-1
mess4:
	DC.B	"                                        PLEASE WAIT A WHILE, I'M LOADING AND DEPACKING THE ART OF CODE SCREEN NUMBER 2. "
	DC.B	"PRESS THE SPACE BAR WHEN [LOADED] APPEARS. "
	DC.B	"REBELOTE, A NEW SCREEN FROM ART OF CODE WHICH WAS THE MOST PRODUCTIVE GROUP AT THIS PARTY "
	DC.B	"AFTER MCODER -ME- AND THE PENDRAGONS (BUT WE ARE VERY EXPENSIVE. AH, AH). "
	DC.B	-1
mess5:
	DC.B	"                                        PLEASE WAIT A WHILE, I'M LOADING AND DEPACKING THE MCS SCREEN CALLED [WALLS]. "
	DC.B	"PRESS THE SPACE BAR WHEN [LOADED] APPEARS. "
	DC.B	"MCS HAS WON SOMETHING AT THE TRANSBEAUCE 2 : ONE OF THEIR CODER WON THE DRINK COMPETITION "
	DC.B	"AGAINST EQUINOX !!! HE HAS EXPLODED STARLION AT VODKA'S ABSORPTION !!! "
	DC.B	"HE WAS THE FUCKING BEST DRINKER AT THIS DEMO-PARTY (ALTHOUGH HE'S NOT EXACTLY REPRESENTATIVE OF THIS GROUP). "
	DC.B	"SORRY, GUY, BUT YOUR SCREEN WAS TOO BIG AND DIDN'T WORK ON MY SHIFTERS "
	DC.B	"(OTHERWISE, MCS COULD HAVE 2 SCREENS IN THE DEMO)."
	DC.B	-1
mess6:
	DC.B	"                                        PLEASE WAIT A WHILE, I'M LOADING AND DEPACKING THE BLACK CATS SCREEN. "
	DC.B	"PRESS THE SPACE BAR WHEN [LOADED] APPEARS. "
	DC.B	"GOOD SURPRISE WITH THIS SCREEN WHICH WON A PRIZE. "
	DC.B	"SORRY, THE SCREEN COULDN'T RUN ON THE FIRST DISK BECAUSE OF ITS LENGTH. "
	DC.B	"THE SECOND PART OF THE DEMO IS A GREAT IDEA BASED UPON THE GRAPHICS OF GOTLIB. "
	DC.B	"FOR THE STRANGERS, GOTLIB IS A FRENCH DESIGNER WHICH IS WELL KNOWN "
	DC.B	"AND APPRECIATED FOR HIS [FRENCH] HUMOUR."
	DC.B	-1
mess7:
	DC.B	"                                        PLEASE WAIT A WHILE, I'M LOADING AND DEPACKING THE ARTIS MAGIA SCREEN. "
	DC.B	"PRESS THE SPACE BAR WHEN [LOADED] APPEARS. "
	DC.B	"READ THE SCROLL FOR MORE INFORMATIONS."
	DC.B	-1
mess8:
	DC.B	"                                        PLEASE WAIT A WHILE, I'M LOADING AND DEPACKING THE CYBERNETICS SCREEN. "
	DC.B	"PRESS THE SPACE BAR WHEN [LOADED] APPEARS. "
	DC.B	"A COOL SCREEN FROM A NEW GROUP (TO MY KNOWLEDGE)."
	DC.B	-1
mess9:
	DC.B	"                                        PLEASE WAIT A WHILE, I'M LOADING AND DEPACKING THE DEFCON 4 SCREEN. "
	DC.B	"PRESS THE SPACE BAR WHEN [LOADED] APPEARS. "
	DC.B	"NICE SCREEN. READ THE SCROLL FOR MORE INFORMATIONS. "
	DC.B	-1
mess10:
	DC.B	"                                        PLEASE WAIT A WHILE, I'M LOADING AND DEPACKING THE HOLOCAUST SCREEN. "
	DC.B	"PRESS THE SPACE BAR WHEN [LOADED] APPEARS. "
	DC.B	"A DEMO CALLED [ORIGINAL DEMO], I WOULD LIKE TO KNOW WHY..."
	DC.B	-1
mess11:
	DC.B	"                                        PLEASE WAIT A WHILE, I'M LOADING AND DEPACKING THE SILVERS SCREEN. "
	DC.B	"PRESS THE SPACE BAR WHEN [LOADED] APPEARS. "
	DC.B	"THEIR SECOND PARTICIPATION TO A MEGADEMO (AFTER THE EUROPEAN DEMOS)."
	DC.B	-1
mess12:
	DC.B	"                                        PLEASE WAIT A WHILE, I'M LOADING AND DEPACKING THE MISFITS SCREEN. "
	DC.B	"PRESS THE SPACE BAR WHEN [LOADED] APPEARS. "
	DC.B	"READ THE SCROLL FOR MORE INFORMATIONS."
	DC.B	-1
mess13:
	DC.B	"                                        PLEASE WAIT A WHILE, I'M LOADING AND DEPACKING THE TSB SCREEN. "
	DC.B	"PRESS THE SPACE BAR WHEN [LOADED] APPEARS. "
	DC.B	"WHAT MEANS TSB ??? "
	DC.B	"READ THE SCROLLS FOR MORE INFORMATIONS."
	DC.B	-1
mess14:
	DC.B	"                                        PLEASE WAIT A WHILE, I'M LOADING AND DEPACKING THE MEGABUSTERS SCREEN. "
	DC.B	"PRESS THE SPACE BAR WHEN [LOADED] APPEARS. "
	DC.B	"THEIR DEMO IS CALLED [UTS] -STRANGE NAME-. IF YOU WANT TO KNOW WHY, "
	DC.B	"READ THE SCROLL."
	DC.B	-1
mess15:
	DC.B	"                                        PLEASE WAIT A WHILE, I'M LOADING AND DEPACKING THE VOYAGERS SCREEN. "
	DC.B	"PRESS THE SPACE BAR WHEN [LOADED] APPEARS. "
	DC.B	"THIS GROUP IS THE ONE WHO MADE A MEGADEMO WITH .PRG SCREENS "
	DC.B	"(MY OLD SCREENS WERE HERE WITHOUT MY ADVICE, "
	DC.B	"THANK YOU TOMSTAR FROM THE STARFIRES...). "
	DC.B	"READ THE SCROLLS FOR MORE INFORMATIONS."
	DC.B	-1
mess16:
	DC.B	"                                        PLEASE WAIT A WHILE, I'M LOADING AND DEPACKING THE OUTLAWS SCREEN. "
	DC.B	"PRESS THE SPACE BAR WHEN [LOADED] APPEARS. "
	DC.B	"READ THE SCROLL FOR MORE INFORMATIONS."
	DC.B	-1
finmess:
	even
