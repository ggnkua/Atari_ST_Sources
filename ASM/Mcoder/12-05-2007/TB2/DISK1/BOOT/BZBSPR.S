
	DC.W	$F5FF,$FF00,$FFF,$F5FF
	DC.W	$F6FF,$F011,$FF,$F6FF
	DC.W	$57FF,$121,$100F,$F75F
	DC.W	$575F,$1222,$110F,$575F
	DC.W	$5760,$1232,$2100,$675F
	DC.W	$5675,$2343,$2215,$765F
	DC.W	$F572,$3343,$3211,$75FF
	DC.W	$F563,$3444,$3221,$65FF
	DC.W	$123,$4443,$3221,$100F
	DC.W	$123,$4444,$3221,$100F
	DC.W	$123,$3443,$3221,$100F
	DC.W	$22,$3333,$3221,$100F
	DC.W	$F011,$2223,$2211,$FF
	DC.W	$F001,$8822,$2881,$FF
	DC.W	$FF00,$8911,$1980,$FFF
	DC.W	$FF5F,0,$F,$5FFF
