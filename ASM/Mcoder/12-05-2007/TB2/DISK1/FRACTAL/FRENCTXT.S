
	dc.b	"      SO YOU TRIED TO LEAVE US ??  WHAT DO YOU THINK OF THIS LONG AND DEEP TRIP IN MANDELBROT AND JULIA'S LAND ?? "
	dc.b	" AS ALWAYS IN THE TRANSBEAUCE DEMOS, THE RESET DEMO WAS DONE BY MCODER (YES, RIGHT, I SAID MCODER !) "
	dc.b	" AND THIS GREAT AND WELL-KNOWN CODER IS NOW SLEEPING ON MY BED INSTEAD OF DEBUGGING THIS DEMO .... "
	DC.B	"I GUESS YOU'RE WONDERING WHO IS NOW TYPING THIS TEXT ?? DID YOU NOTICE THIS TEXT IS IN ENGLISH AND NOT IN FRANGLISH ?? "
	DC.B	" THAT IS TO SAY THAT I AM NOT ZIGGY STARDUST !   MCODER WORKED REALLY HARD ( REALLY ?? ) FOR THIS DEMO , HE CODED THE LOADER, THIS RESET SCREEN "
	DC.B	" AND ALL THE LOADING AND DEPACKING ROUTINES.     "
	DC.B	" AS I AM HERE I WILL TELL TO ALL THE PEOPLE COMPLAINING ABOUT THE BUGS IN THE MAIN MENU THAT IF THEY ARE ANGRY OR IF THEY WANT TO ANNOY ME THEY JUST HAVE TO"
	DC.B	" WRITE ME AND WITH GREAT PLEASURE WILL I SEND THEM THE GRAPHIX AND THE MUSIC AND ASK THEM TO DO JUST THE SAME ... EVEN WITH THE SAME BUGS I DON'T MIND ! "
	DC.B	"  OF COURSE WE COULD HAVE DEBUGGED IT BUT TIME HAS COME TO RELEASE THIS DEMO , OR KRAZY REX WILL SQUEEZE US . AND I MUST ADMIT THAT I AM COMPLETELY FED UP"
	DC.B	" WITH CODING THIS MENU. IN FACT THERE IS ENOUGH PROCESSOR TIME TO MAKE IT WORK WITH A 15 KHZ SOUNDTRACK ( A REAL SOUNDTRACK NOT A ULM SOUNDTRACK !) ."
	DC.B	"  AS FURY IS NOW READING I WILL ASK HIM TO WRITE SOME FEW SENTENCES INSTEAD OF TRYING TO BEAT MCODER IN LAZYNESS ....                  "
	DC.B	"ARH! THIS LITTLE GNOMISH FIEND (THAT IS, TERENCE) HAS SUCCEEDED IN MAKING "
	DC.B	"ME WRITE SOME CRAP IN DIS SCROLLER. I STILL DON'T "
	DC.B	"UNDERSTAND HOW, BUT HE DID IT ANYWAY. WELL, WHAT AM I "
	DC.B	"GONNA TELL YOU TO MAKE MY APPEARANCE HERE WORTH IT. "
	DC.B	"TOUGH SHIT! I'M BEING TOLD THAT MY ENGLISH IS SOOOO "
	DC.B	"PERFECT THAT NO ONE IN FRANCE'LL BE ABLE TO UNDERSTAND "
	DC.B	"MY SCROLL PART, SO I GUESS I'LL HAVE TO REACH A LOWER "
	DC.B	"LEVEL FOR MY FRENCH FELLOWS... HERE GOES... "
	DC.B	"ZIS DAIMO WAZ DONE FAUR ZE TRANSBEAUCE 2 (THIS WORD "
	DC.B	"IS FRENCH BY DEFINITION, SO I DON'T NEED TO GO "
	DC.B	"TO THE POOR ENGLISH LEVEL OF FRENCHIES), WITCH WAS "
	DC.B	"CONSTITUED OF AU LEAST (YES, AT LEAST) 250 FRENCHIES "
	DC.B	"IN TOTAL CALOR (UH! THAT'S SPANISH!) WHICH EARS WERE "
	DC.B	"BLASTED TO A PULPE BY A (DAMN MCODER! HE'S USING HIS "
	DC.B	"PC WITH ITS SCREEN RIGHT IN FRONT OF ME, AND AS THE "
	DC.B	"ST'S MONITOR IS SOMETHING LIKE 1 METER AWAY, I'M "
	DC.B	"HAVING LOTSA FUN WRITING THIS STUFF WHILE MISTAKING "
	DC.B	"THE PC MONITOR WITH THE ST'S ONE...) BY A UGLY "
	DC.B	"SOUND THAT WAS AT LEAST SHOUTING IN OUR EARS SO MUCH "
	DC.B	"THAT THINKING IN A GOOD WAY WAS COMPLETELY OUT OF "
	DC.B	"THE QUESTION TO CODE... UH! IT SEEMS I'LL HAVE TO "
	DC.B	"QUIT NOW AS WE'VE GOT A BUS TO TAKE RIGHT NOW!!! "
	DC.B	"WELL, BYE!!! AND YA'LL HERE MORE FROM ME IN "
	DC.B	"THE ICC 2 DEMO... SOOO LONG!!!... FURY OVER... "

	DC.B	"HELLO, HELLO, HERE IS SILVER OF THE PENDRAGONS ON THE "
	DC.B	"KEYBOARD. AT THE MOMENT, I AM TYPING ON THE KEYBOARD OF "
	DC.B	"THE 2080 ST OF MCODER AND THIS ST IS VERY STRANGE. IN FACT, "
	DC.B	"2 MINUTES AGO, I WAS WRITING THIS TEXT AND HIS DEVICE SWITCHED OFF "
	DC.B	"WITHOUT REASON AND IT SWITCHED ON ALONE AGAIN. IS IT NORMAL?? "
	DC.B	"NO, I DON'T THINK. NOW, WE KNOW THE SECRET OF M-CODER. THIS IS NOT HIM "
	DC.B	"WHO CODE BUT THIS IS HIS INTELLIGENT MACHINE. "
	DC.B	"    NOW, A LITTLE THINK TO MY BROTHER CRYSTAR WHO WORKED AT I.B.M. AT THE "
	DC.B	"MOMENT. POOR GUY WHO WOKE UP VERY EARLY THIS MORNING. ARF! ARF! "
	DC.B	"I WILL JOIN HIM NEXT WEEK SO ...          "
	DC.B	"ANOTHER THINK TO MY SISTER WHO LIKE HOLIDAYS. I AM SURE. "
	DC.B	"HELLO (VA FAIRE LA VAISSELLE !) NANIE!!! HOW ARE YOU TODAY???    ARF!!! ARF!!! I WANT TO SEE HIS HEAD WHEN "
	DC.B	"SHE SEES THAT. "
	DC.B	"IT IS TIME TO GO AWAY FOR ME SO...    GOODBYE EVERYBODY "