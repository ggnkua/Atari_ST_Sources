mainmenu:
	dc.b	"LOADING THE KICK ASS MAIN MENU. CREDITS AND OWNER'S MANUAL ARE TOO "
	dc.b	"LONG TO BE DISPLAYED HERE, SO PRESS HELP WHEN DECRUNCHED FOR USEFUL "
	dc.b	"INFO...     ",-1

undead:  
	dc.b	"THIS DEMO BY UNDEAD, A NEWCOMER ON THE ST SCENE, WAS RANKED NUMBER ONE "
	dc.b	"IN THE DEMO COMPETITION. ENJOY VERTICAL RASTERS AND PLASMA EFFECTS FOR "
	dc.b	"THE FIRST TIME ON THE ST!     ",-1

naos:
	dc.b	"LOADING THE DEMO-COMPETITIONS RUNNER UP, BY NAOS, THE WINNERS OF LAST "
	dc.b	"YEAR'S GEN4 CONTEST. NOTICE THE GREAT VERTICAL DISTORT-EFFECTS.      ",-1

genesis:
	dc.b	"YOU HAVE CHOSEN TO LOAD THE GENESIS-DEMO. IT LOOKS LIKE A MAIN MENU, "
	dc.b	"BUT IT IS NOT!      ",-1

dnt:
	dc.b	"THIS IS THE FIRST RELEASE BY DNT CREW, AND IT IS DEFINITELY NICE... "
	dc.b	"THERE WILL ALSO BE A DNT CREW SCREEN IN THE FORTHCOMING PHALEON DEMO"
	dc.b	"BY NEXT...      ",-1

oxygene:
	dc.b	"ANOTHER DEMO IN TWO PARTS, THIS TIME BY OXYGENE. WATCH OUT FOR THEIR "
	dc.b	"SOON-TO-BE RELEASED MEGADEMO! ",-1

legacy
	dc.b	"YEAH, LEGACY HAS MANAGED TO RELEASE A NEW SCREEN! HAVE YOU HEARD THEIR NEW "
	dc.b	"SLOGAN? LAZYNESS IS OUR BUSINESS! ",-1

vgt
	dc.b	"FISHBONE IS BACK WITH ANOTHER SMASHING GOODLOOKER, THIS TIME IN TWO "
	dc.b	"PARTS! AGAIN SOME ORIGINAL EFFECTS TO BE FOUND... ",-1

polter
	dc.b	"THIS IS ENERGY-FLOW DEMO, DEMO FOR YOUR SENSES, BY POLTERGEIST. THE "
	dc.b	"MUSIC IS BY JESPER KYD OF THE SILENTS (DENMARK!), NOT BY DR. AWESOME OF "
	dc.b	"THE CRUSADERS. ENJOY THIS NEW STYLISH POUELTERGOUESCHTECSH PRODUCTION! ",-1

fm:
	dc.b	"AGAIN AN EXAMPLE OF SYNCSCROLLING ON THE ST, THIS TIME BY FUTURE MINDS. "
	dc.b	"NICE GRAPHICS ALSO. ",-1

mad:
	dc.b	"NICE SCROLLER-EFFECTS AND SOUNDTRACKER MUSIC IN THIS MAD VISION SCREEN. ",-1

hyst:
	dc.b	"WIEDER EINEN DOT-SCROLLER, MIT PEACE UND LOVE SPRITES! THEIR GOLDEN AGE "
	dc.b	"DEMO IS ABOUT TO BE RELEASED, SO LOOK OUT FOR IT. ",-1

ziggy:
	dc.b	"OF COURSE THERE WAS A HIDDEN SCREEN IN THIS DEMO... IT'S A PREVIEW OF THE "
	dc.b	"YM-EDITOR BY ZIGGY AND MKOTER, TO BE RELEASED SOON. HAPPY LISTENING... ",-1
