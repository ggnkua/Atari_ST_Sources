 CODING AND BUGGING..TERENCE/PENDRAGONS
 DESIGN/GFX......KRAZY REX/ST CONNEXION
 MUSIC.........................FFT/NEXT
 
 ADDITIONAL WORK:
 
 6301 CODING......BELZEBUB/ST CONNEXION
 (PROGRAMMING OF THE KEYBOARDPROCESSOR)
 GFX.............GOLDFINGER/POLTERGEIST
 (THE ONES YOU'RE STARING AT RIGHT NOW)
 GFX...............PIXELKILLER/ECLIPSYS
 (THE TRANSBEAUCE LOGO IN THE MAINMENU)
 MAP EDITOR......MISTER BEE/OVERLANDERS