 
 THE TRANSBEAUCE PARTY 1991 WAS HELD BY
 LE SERGENT, POPOL AND MORODER BETWEEN
  MAY 1ST AND MAY 2ND IN CHATEAUDUN,
  FRANCE.

 ALMOST EVERY FRENCH CREW (250 PEOPLE!)
 ATTENTED TO THIS 24 HOUR MEETING.

 30 GROUPS (OUT OF 40) TOOK PART IN THE
 DEMO CONTEST, WHOSE WINNER WAS UNDEAD,
 A NEWCOMER ON THE ST SCENE, SCORING 65
 POINTS, FOLLOWED BY NAOS, 46 POINTS.