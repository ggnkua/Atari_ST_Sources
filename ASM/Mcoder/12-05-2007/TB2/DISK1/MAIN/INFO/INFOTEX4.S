 THIS PARTY-DEMO "DISK 1" INCLUDES SOME
 OF THE BEST SCREENS OF THE CHART. MANY
 OTHER GREAT SCREENS ARE TO BE FOUND IN
 THE TRANSBEAUCE PARTY DEMO 2 "DISK 2",
 WHICH'S COMPLETELY INDEPENDENT OF THIS
 ONE (DIFFERENT MENU, LOADER, ETC)...

 WE HOPE YOU'LL ENJOY THIS DEMO AS MUCH
 AS WE DID MAKING IT.


 RENDEZ-VOUS IN 1992!
                                   KRX.