	BRA.W	EFF0
	BRA.W	EFF1
	BRA.W	EFF2
	BRA.W	EFF3
	BRA.W	EFF4
	BRA.W	EFF5
	BRA.W	EFF6
	BRA.W	EFF7
	BRA.W	EFF8
	BRA.W	EFF9
	BRA.W	EFFA
	BRA.W	EFFB
	BRA.W	EFFC
	BRA.W	EFFD
	BRA.W	EFFE
	BRA.W	EFFF

EFF6:
	MOVE	D0,648(A6)
EFF5:
	MOVE	D0,170(A6)
	MOVE	D0,2090(A6)
EFF4:
	MOVE	D0,330(A6)
	MOVE	D0,1930(A6)
EFF3:
	MOVE	D0,490(A6)
	MOVE	D0,650(A6)
	MOVE	D0,1610(A6)
	MOVE	D0,1770(A6)
EFF2:
	MOVE	D0,810(A6)
	MOVE	D0,970(A6)
	MOVE	D0,1130(A6)
	MOVE	D0,1290(A6)
	MOVE	D0,1450(A6)
EFF0:
EFF1:
	MOVE	D0,2(A6)
	MOVE	D0,162(A6)
	MOVE	D0,322(A6)
	MOVE.L	D0,480(A6)
	MOVE.L	D0,640(A6)
	MOVE.L	D0,800(A6)
	MOVE.L	D0,960(A6)
	MOVE.L	D0,1120(A6)
	MOVE.L	D0,1280(A6)
	MOVE.L	D0,1440(A6)
	MOVE.L	D0,1600(A6)
	MOVE.L	D0,1760(A6)
	MOVE.L	D0,1920(A6)
	MOVE.L	D0,2080(A6)
	MOVE	D0,2240(A6)
	JMP	(A5)
EFF7:
	MOVE	D0,480(A6)
	MOVE	D0,2082(A6)
EFF8:
	MOVE	D0,2(A6)
	MOVE	D0,10(A6)
	MOVE	D0,162(A6)
	MOVE	D0,170(A6)
	MOVE	D0,322(A6)
	MOVE	D0,330(A6)
	MOVE	D0,482(A6)
	MOVE.L	D0,488(A6)
	MOVE	D0,642(A6)
	MOVE.L	D0,648(A6)
	MOVE.L	D0,800(A6)
	MOVE	D0,810(A6)
	MOVE.L	D0,960(A6)
	MOVE	D0,970(A6)
	MOVE.L	D0,1120(A6)
	MOVE	D0,1130(A6)
	MOVE.L	D0,1280(A6)
	MOVE	D0,1290(A6)
	MOVE.L	D0,1440(A6)
	MOVE	D0,1450(A6)
	MOVE.L	D0,1600(A6)
	MOVE	D0,1610(A6)
	MOVE.L	D0,1760(A6)
	MOVE	D0,1770(A6)
	MOVE.L	D0,1920(A6)
	MOVE	D0,1930(A6)
	MOVE	D0,2080(A6)
	MOVE	D0,2090(A6)
	MOVE	D0,2240(A6)
	MOVE	D0,2248(A6)
	JMP	(A5)
EFF9:
	MOVE	D0,1922(A6)
EFFA:
	MOVE	D0,2(A6)
	MOVE	D0,10(A6)
	MOVE	D0,162(A6)
	MOVE	D0,170(A6)
	MOVE	D0,322(A6)
	MOVE	D0,330(A6)
	MOVE	D0,482(A6)
	MOVE.L	D0,488(A6)
	MOVE	D0,642(A6)
	MOVE.L	D0,648(A6)
	MOVE.L	D0,800(A6)
	MOVE	D0,810(A6)
	MOVE.L	D0,960(A6)
	MOVE	D0,970(A6)
	MOVE.L	D0,1120(A6)
	MOVE	D0,1130(A6)
	MOVE.L	D0,1280(A6)
	MOVE	D0,1290(A6)
	MOVE.L	D0,1440(A6)
	MOVE	D0,1450(A6)
	MOVE.L	D0,1600(A6)
	MOVE	D0,1610(A6)
	MOVE.L	D0,1760(A6)
	MOVE	D0,1770(A6)
	MOVE	D0,1920(A6)
	MOVE	D0,1930(A6)
	MOVE	D0,2080(A6)
	MOVE.L	D0,2088(A6)
	MOVE	D0,2240(A6)
	MOVE	D0,2248(A6)
	JMP	(A5)
EFFB:
	MOVE	D0,10(A6)
	MOVE	D0,162(A6)
	MOVE	D0,170(A6)
	MOVE	D0,322(A6)
	MOVE	D0,330(A6)
	MOVE	D0,482(A6)
	MOVE.L	D0,488(A6)
	MOVE	D0,642(A6)
	MOVE.L	D0,648(A6)
	MOVE.L	D0,800(A6)
	MOVE	D0,810(A6)
	MOVE.L	D0,960(A6)
	MOVE	D0,970(A6)
	MOVE.L	D0,1120(A6)
	MOVE	D0,1130(A6)
	MOVE.L	D0,1280(A6)
	MOVE	D0,1290(A6)
	MOVE.L	D0,1440(A6)
	MOVE	D0,1450(A6)
	MOVE.L	D0,1600(A6)
	MOVE	D0,1610(A6)
	MOVE	D0,1760(A6)
	MOVE	D0,1770(A6)
	MOVE	D0,1920(A6)
	MOVE.L	D0,1928(A6)
	MOVE	D0,2080(A6)
	MOVE.L	D0,2088(A6)
	MOVE	D0,2248(A6)
	JMP	(A5)
EFFC:
	MOVE	D0,10(A6)
	MOVE	D0,162(A6)
	MOVE	D0,170(A6)
	MOVE	D0,322(A6)
	MOVE	D0,330(A6)
	MOVE	D0,482(A6)
	MOVE.L	D0,488(A6)
	MOVE	D0,642(A6)
	MOVE.L	D0,648(A6)
	MOVE.L	D0,800(A6)
	MOVE	D0,810(A6)
	MOVE.L	D0,960(A6)
	MOVE	D0,970(A6)
	MOVE.L	D0,1120(A6)
	MOVE	D0,1130(A6)
	MOVE.L	D0,1280(A6)
	MOVE	D0,1290(A6)
	MOVE.L	D0,1440(A6)
	MOVE	D0,1450(A6)
	MOVE	D0,1600(A6)
	MOVE	D0,1610(A6)
	MOVE	D0,1760(A6)
	MOVE.L	D0,1768(A6)
	MOVE	D0,1920(A6)
	MOVE.L	D0,1928(A6)
	MOVE	D0,2080(A6)
	MOVE.L	D0,2088(A6)
	MOVE	D0,2248(A6)
	JMP	(A5)
EFFD:
	MOVE	D0,10(A6)
	MOVE	D0,170(A6)
	MOVE	D0,322(A6)
	MOVE	D0,330(A6)
	MOVE	D0,482(A6)
	MOVE.L	D0,488(A6)
	MOVE	D0,642(A6)
	MOVE.L	D0,648(A6)
	MOVE.L	D0,800(A6)
	MOVE	D0,810(A6)
	MOVE.L	D0,960(A6)
	MOVE	D0,970(A6)
	MOVE.L	D0,1120(A6)
	MOVE	D0,1130(A6)
	MOVE.L	D0,1280(A6)
	MOVE	D0,1290(A6)
	MOVE	D0,1440(A6)
	MOVE	D0,1450(A6)
	MOVE	D0,1600(A6)
	MOVE.L	D0,1608(A6)
	MOVE	D0,1760(A6)
	MOVE.L	D0,1768(A6)
	MOVE	D0,1920(A6)
	MOVE.L	D0,1928(A6)
	MOVE.L	D0,2088(A6)
	MOVE	D0,2248(A6)
	JMP	(A5)
EFFE:
	MOVE	D0,10(A6)
	MOVE	D0,170(A6)
	MOVE	D0,330(A6)
	MOVE	D0,482(A6)
	MOVE.L	D0,488(A6)
	MOVE	D0,642(A6)
	MOVE.L	D0,648(A6)
	MOVE.L	D0,800(A6)
	MOVE	D0,810(A6)
	MOVE.L	D0,960(A6)
	MOVE	D0,970(A6)
	MOVE	D0,1120(A6)
	MOVE	D0,1130(A6)
	MOVE	D0,1280(A6)
	MOVE	D0,1290(A6)
	MOVE	D0,1440(A6)
	MOVE.L	D0,1448(A6)
	MOVE	D0,1600(A6)
	MOVE.L	D0,1608(A6)
	MOVE	D0,1760(A6)
	MOVE.L	D0,1768(A6)
	MOVE.L	D0,1928(A6)
	MOVE.L	D0,2088(A6)
	MOVE	D0,2248(A6)
	JMP	(A5)
EFFF:
	MOVE	D0,10(A6)
	MOVE	D0,170(A6)
	MOVE	D0,330(A6)
	MOVE.L	D0,488(A6)
	MOVE.L	D0,648(A6)
	MOVE	D0,800(A6)
	MOVE	D0,810(A6)
	MOVE	D0,960(A6)
	MOVE	D0,970(A6)
	MOVE	D0,1120(A6)
	MOVE.L	D0,1128(A6)
	MOVE	D0,1280(A6)
	MOVE.L	D0,1288(A6)
	MOVE	D0,1440(A6)
	MOVE.L	D0,1448(A6)
	MOVE.L	D0,1608(A6)
	MOVE.L	D0,1768(A6)
	MOVE.L	D0,1928(A6)
	MOVE.L	D0,2088(A6)
	MOVE	D0,2248(A6)
	JMP	(A5)
