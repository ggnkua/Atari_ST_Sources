	OPT	O+,OW-
	ORG	0
DRAW	MACRO
	IFEQ	(\2-\1-1)
	MOVEM	(\1-1)*4(A2),D0/D1/D2/D3
	ELSEIF
	IFEQ	(\1-\2-1)
	MOVEM	(\2-1)*4(A2),D0/D1/D2/D3
	ELSEIF
	MOVEM	(\1-1)*4(A2),D0/D1
	MOVEM	(\2-1)*4(A2),D2/D3
	ENDC
	ENDC
	LEA	\@5(PC),A6
	JMP	(A5)
\@5
	ENDM
DRAW2	MACRO
	IFEQ	(\2-\1-1)
	MOVEM	(\1)*4(A2),D0/D1/D2/D3
	ELSEIF
	IFEQ	(\1-\2-1)
	MOVEM	(\2)*4(A2),D0/D1/D2/D3
	ELSEIF
	MOVEM	(\1)*4(A2),D0/D1
	MOVEM	(\2)*4(A2),D2/D3
	ENDC
	ENDC
	LEA	\@5(PC),A6
	JMP	(A5)
\@5
	ENDM
ALL_OBJETS
	DC.L	OBJET20		;CUBE
	DC.L	OBJET21		;DISK
	DC.L	OBJET22		;VAISSEAU 1
	DC.L	OBJET23		;VAISSEAU 2
	DC.L	OBJET24		;VAISSEAU 3
	DC.L	OBJET1		;VOYAGER
	DC.L	OBJET2		;HORLOGE
	DC.L	OBJET3		;POELE
	DC.L	OBJET4		;MONDE
	DC.L	OBJET5		;FRANCE
	DC.L	OBJET6		;VAISSEAU 4
	DC.L	OBJET8		;ASSIETTE
	DC.L	OBJET9		;TINTIN
	DC.L	OBJET10		;MAISON
	DC.L	OBJET11		;CUBE+TETRAEDRE
	DC.L	OBJET12		;VILLE
	DC.L	OBJET14		;SALLE A MANGER
	DC.L	OBJET16		;DISQUETTE
	DC.L	OBJET19		;MAIN

	DC.L	0

OBJET20
	DC.W	8-1		;NB POINTS-1

	DC.W	$FFCE,$32,$FFCE
	DC.W	$FFCE,$FFCE,$FFCE
	DC.W	$32,$FFCE,$FFCE
	DC.W	$32,$32,$FFCE
	DC.W	$FFCE,$32,$32
	DC.W	$FFCE,$FFCE,$32
	DC.W	$32,$FFCE,$32
	DC.W	$32,$32,$32

	DRAW	1,4
	DRAW	4,3
	DRAW	3,2
	DRAW	2,1
	DRAW	5,8
	DRAW	8,7
	DRAW	7,6
	DRAW	6,5
	DRAW	1,5
	DRAW	4,8
	DRAW	3,7
	DRAW	2,6
	DRAW	1,3
	DRAW	2,4
	DRAW	5,7
	DRAW	6,8
	DRAW	2,5
	DRAW	1,6
	DRAW	4,7
	DRAW	3,8
	DRAW	2,7
	DRAW	6,3
	DRAW	1,8
	DRAW	5,4
	BRA	QUIT

OBJET21
	DC.W	24-1

	DC.W	$FFC4
	DC.W	$FFC4,$FFFD,$FFC4,$3C
	DC.W	$FFFD,$3C,$3C,$FFFD
	DC.W	$3C,$FFC4,$FFFD,$FFC4
	DC.W	$FFC4,3,$FFC4,$3C
	DC.W	3,$3C,$3C,3
	DC.W	$3C,$FFC4,3,$FFE2
	DC.W	$FFC4,$FFFD,$FFE2,$FFEC
	DC.W	$FFFD,$1E,$FFEC,$FFFD
	DC.W	$1E,$FFC4,$FFFD,$FFE2
	DC.W	$FFC4,3,$FFE2,$FFEC
	DC.W	3,$1E,$FFEC,3
	DC.W	$1E,$FFC4,3,$FFEC
	DC.W	$FFC9,$FFFD,$FFEC,$FFE9
	DC.W	$FFFD,$FFF9,$FFE9,$FFFD
	DC.W	$FFF9,$FFC9,$FFFD,$FFEC
	DC.W	$FFC9,3,$FFEC,$FFE9
	DC.W	3,$FFF9,$FFE9,3
	DC.W	$FFF9,$FFC9,3

	DRAW	1,2
	DRAW	2,3
	DRAW	3,4
	DRAW	4,1
	DRAW	5,6
	DRAW	6,7
	DRAW	7,8
	DRAW	8,5
	DRAW	1,5
	DRAW	2,6
	DRAW	3,7
	DRAW	4,8
	DRAW	9,10
	DRAW	10,11
	DRAW	11,12
	DRAW	13,14
	DRAW	14,15
	DRAW	15,16
	DRAW	17,18
	DRAW	18,19
	DRAW	19,20
	DRAW	20,17
	DRAW	21,22
	DRAW	22,23
	DRAW	23,24
	DRAW	24,21
	DRAW	9,13
	DRAW	12,16
	BRA	QUIT

OBJET22
	DC.W	21-1
	DC.W	$FFEC,0
	DC.W	$FFD8,$FFF4,$A,$FFD8
	DC.W	$C,$A,$FFD8,$14
	DC.W	0,$FFD8,$C,$FFF6
	DC.W	$FFD8,$FFF4,$FFF6,$FFD8
	DC.W	$FFEC,0,$28,$FFF4
	DC.W	$A,$28,$C,$A
	DC.W	$28,$14,0,$28
	DC.W	$C,$FFF6,$28,$FFF4
	DC.W	$FFF6,$28,0,0
	DC.W	$3C,$FFC4,$FFEC,$FFC4
	DC.W	$FFC4,$14,$FFC4,$3C
	DC.W	$FFEC,$FFC4,$3C,$14
	DC.W	$FFC4,$FFF7,0,$FFD8
	DC.W	0,5,$FFD8,9
	DC.W	0,$FFD8,0,$FFFB
	DC.W	$FFD8

	DRAW	1,2
	DRAW	2,3
	DRAW	3,4
	DRAW	4,5
	DRAW	5,6
	DRAW	6,1
	DRAW	7,8
	DRAW	8,9
	DRAW	9,10
	DRAW	10,11
	DRAW	11,12
	DRAW	12,7
	DRAW	13,7
	DRAW	13,8
	DRAW	13,9
	DRAW	13,10
	DRAW	13,11
	DRAW	13,12
	DRAW	1,7
	DRAW	2,8
	DRAW	3,9
	DRAW	4,10
	DRAW	5,11
	DRAW	6,12
	DRAW	1,14
	DRAW	14,7
	DRAW	1,15
	DRAW	15,7
	DRAW	4,17
	DRAW	17,10
	DRAW	4,16
	DRAW	16,10
	DRAW	18,19
	DRAW	19,20
	DRAW	20,21
	DRAW	21,18
	BRA	QUIT

OBJET23
	DC.W	28-1
	DC.W	$FFDD,$3C,$FFC4
	DC.W	$FFC4,$23,$FFC4,$FFC4
	DC.W	$FFDD,$FFC4,$FFDD,$FFC4
	DC.W	$FFC4,$FFDD,$3C,$3C
	DC.W	$FFC4,$23,$3C,$FFC4
	DC.W	$FFDD,$3C,$FFDD,$FFC4
	DC.W	$3C,$23,$3C,$FFC4
	DC.W	$3C,$23,$FFC4,$3C
	DC.W	$FFDD,$FFC4,$23,$FFC4
	DC.W	$FFC4,$23,$3C,$3C
	DC.W	$3C,$23,$3C,$3C
	DC.W	$FFDD,$3C,$23,$FFC4
	DC.W	$3C,$FFD8,0,$FFD8
	DC.W	$FFE8,$14,$FFD8,$18
	DC.W	$14,$FFD8,$28,0
	DC.W	$FFD8,$18,$FFEC,$FFD8
	DC.W	$FFE8,$FFEC,$FFD8,$FFD8
	DC.W	0,$28,$FFE8,$14
	DC.W	$28,$18,$14,$28
	DC.W	$28,0,$28,$18
	DC.W	$FFEC,$28,$FFE8,$FFEC
	DC.W	$28

	DRAW	1,2
	DRAW	2,3
	DRAW	3,4
	DRAW	5,6
	DRAW	6,7
	DRAW	7,8
	DRAW	1,5
	DRAW	2,6
	DRAW	3,7
	DRAW	4,8
	DRAW	9,10
	DRAW	10,11
	DRAW	11,12
	DRAW	13,14
	DRAW	14,15
	DRAW	15,16
	DRAW	9,13
	DRAW	10,14
	DRAW	11,15
	DRAW	12,16
	DRAW	17,18
	DRAW	18,19
	DRAW	19,20
	DRAW	20,21
	DRAW	21,22
	DRAW	22,17
	DRAW	23,24
	DRAW	24,25
	DRAW	25,26
	DRAW	26,27
	DRAW	27,28
	DRAW	28,23
	DRAW	17,23
	DRAW	18,24
	DRAW	19,25
	DRAW	20,26
	DRAW	21,27
	DRAW	22,28
	BRA	QUIT

OBJET24
	DC.W	18-1
	DC.W	$FFC4
	DC.W	0,$FFC4,0,$14
	DC.W	$FFC4,$3C,0,$FFC4
	DC.W	0,$FFEC,$FFC4,$FFF1
	DC.W	0,$FFC4,$FFFF,5
	DC.W	$FFC4,$FFFF,$FFFB,$FFC4
	DC.W	$F,0,$FFC4,1
	DC.W	5,$FFC4,1,$FFFB
	DC.W	$FFC4,0,0,$32
	DC.W	$FFFF,5,$1E,$FFFF
	DC.W	$A,0,$FFF1,8
	DC.W	0,1,5,$1E
	DC.W	1,$A,0,$F
	DC.W	8,0,0,0
	DC.W	$3C

	DRAW	1,2
	DRAW	2,3
	DRAW	3,4
	DRAW	4,1
	DRAW	5,6
	DRAW	6,7
	DRAW	7,5
	DRAW	8,9
	DRAW	9,10
	DRAW	10,8
	DRAW	12,13
	DRAW	13,14
	DRAW	14,12
	DRAW	15,16
	DRAW	16,17
	DRAW	17,15
	DRAW	1,18
	DRAW	2,18
	DRAW	3,18
	DRAW	4,18
	DRAW	11,18
	BRA	QUIT


OBJET1:
	DC.W	$27
	DC.W	$FFED,$1,$0
	DC.W	$FFD6,$FFF1,$0
	DC.W	$FFD5,$13,$0
	DC.W	$FF91,$13,$0
	DC.W	$FF92,$FFF1,$0
	DC.W	$6C,$13,$0
	DC.W	$6C,$FFF1,$0
	DC.W	$28,$FFF1,$0
	DC.W	$28,$13,$0
	DC.W	$11,$3,$0
	DC.W	$FFFF,$2,$20
	DC.W	$2,$FFFF,$34
	DC.W	$D,$FFF7,$1E
	DC.W	$4,$FFF1,$1F
	DC.W	$FFF9,$FFF1,$21
	DC.W	$FFF1,$FFF7,$23
	DC.W	$FFEE,$1,$26
	DC.W	$FFF2,$B,$27
	DC.W	$FFFA,$12,$26
	DC.W	$5,$12,$25
	DC.W	$D,$B,$22
	DC.W	$10,$1,$20
	DC.W	$13,$FFF2,$21
	DC.W	$7,$FFE9,$22
	DC.W	$FFF8,$FFE9,$24
	DC.W	$FFEC,$FFF2,$28
	DC.W	$FFE8,$1,$2B
	DC.W	$FFED,$F,$2D
	DC.W	$FFF9,$17,$2C
	DC.W	$8,$17,$2A
	DC.W	$14,$F,$26
	DC.W	$18,$1,$23
	DC.W	$10,$13,$1B
	DC.W	$10,$13,$FFE5
	DC.W	$FFED,$13,$FFE5
	DC.W	$FFED,$13,$1B
	DC.W	$10,$FFF0,$1B
	DC.W	$10,$FFF0,$FFE5
	DC.W	$FFED,$FFF0,$FFE5
	DC.W	$FFED,$FFF0,$1B
	DRAW2	$1,$0
	DRAW2	$1,$2
	DRAW2	$7,$9
	DRAW2	$7,$8
	DRAW2	$8,$9
	DRAW2	$2,$0
	DRAW2	$3,$4
	DRAW2	$5,$6
	DRAW2	$4,$1
	DRAW2	$3,$2
	DRAW2	$7,$6
	DRAW2	$8,$5
	DRAW2	$25,$21
	DRAW2	$22,$26
	DRAW2	$23,$27
	DRAW2	$24,$20
	DRAW2	$20,$21
	DRAW2	$22,$23
	DRAW2	$24,$25
	DRAW2	$26,$27
	DRAW2	$22,$21
	DRAW2	$25,$26
	DRAW2	$23,$20
	DRAW2	$24,$27
	DRAW2	$B,$A
	DRAW2	$C,$D
	DRAW2	$D,$E
	DRAW2	$E,$F
	DRAW2	$F,$10
	DRAW2	$10,$11
	DRAW2	$11,$12
	DRAW2	$12,$13
	DRAW2	$13,$14
	DRAW2	$14,$15
	DRAW2	$15,$C
	DRAW2	$16,$17
	DRAW2	$17,$18
	DRAW2	$18,$19
	DRAW2	$19,$1A
	DRAW2	$1A,$1B
	DRAW2	$1B,$1C
	DRAW2	$1C,$1D
	DRAW2	$1D,$1E
	DRAW2	$1E,$1F
	DRAW2	$16,$1F
	BRA	QUIT
OBJET2
	DC.W	$2B
	DC.W	$65,$FFF2,$FFC7
	DC.W	$3A,$FFF2,$FF9C
	DC.W	$FFFF,$FFF2,$FF8C
	DC.W	$FFC4,$FFF2,$FF9C
	DC.W	$FF99,$FFF2,$FFC7
	DC.W	$FF89,$FFF2,$2
	DC.W	$FF99,$FFF2,$3D
	DC.W	$FFC4,$FFF2,$68
	DC.W	$FFFF,$FFF2,$78
	DC.W	$3A,$FFF2,$68
	DC.W	$65,$FFF2,$3D
	DC.W	$75,$FFF2,$2
	DC.W	$75,$B,$2
	DC.W	$65,$B,$3D
	DC.W	$3A,$B,$68
	DC.W	$FFFF,$B,$78
	DC.W	$FFC4,$B,$68
	DC.W	$FF99,$B,$3D
	DC.W	$FF89,$B,$2
	DC.W	$FF99,$B,$FFC7
	DC.W	$FFC4,$B,$FF9C
	DC.W	$FFFF,$B,$FF8C
	DC.W	$3A,$B,$FF9C
	DC.W	$65,$B,$FFC7
	DC.W	$56,$B,$FFD0
	DC.W	$32,$B,$FFAB
	DC.W	$FFFF,$B,$FF9D
	DC.W	$FFCD,$B,$FFAB
	DC.W	$FFA8,$B,$FFD0
	DC.W	$FF9A,$B,$2
	DC.W	$FFA8,$B,$35
	DC.W	$FFCD,$B,$5A
	DC.W	$FFFF,$B,$67
	DC.W	$32,$B,$5A
	DC.W	$56,$B,$35
	DC.W	$64,$B,$2
	DC.W	$1,$B,$0
	DC.W	$3A,$F,$2C
	DC.W	$56,$F,$0
	DC.W	$1,$2,$3
	DC.W	$4,$5,$6
	DC.W	$7,$8,$9
	DC.W	$A,$B,$0
	DC.W	$D,$E,$F

	DRAW2	$0,$1
	DRAW2	$1,$2
	DRAW2	$2,$3
	DRAW2	$3,$4
	DRAW2	$4,$5
	DRAW2	$5,$6
	DRAW2	$6,$7
	DRAW2	$7,$8
	DRAW2	$8,$9
	DRAW2	$9,$A
	DRAW2	$A,$B
	DRAW2	$B,$0
	DRAW2	$C,$D
	DRAW2	$D,$E
	DRAW2	$E,$F
	DRAW2	$F,$10
	DRAW2	$10,$11
	DRAW2	$11,$12
	DRAW2	$12,$13
	DRAW2	$13,$14
	DRAW2	$14,$15
	DRAW2	$15,$16
	DRAW2	$16,$17
	DRAW2	$17,$C
	DRAW2	$18,$17
	DRAW2	$19,$16
	DRAW2	$1A,$15
	DRAW2	$1B,$14
	DRAW2	$1C,$13
	DRAW2	$1D,$12
	DRAW2	$1E,$11
	DRAW2	$1F,$10
	DRAW2	$20,$F
	DRAW2	$21,$E
	DRAW2	$22,$D
	DRAW2	$23,$C
	DRAW2	$24,$25
	DRAW2	$24,$26
	BRA	QUIT
OBJET3
	DC.W	$26
	DC.W	$1C,$FFC4,$FFFD
	DC.W	$13,$FFC3,$23
	DC.W	$FFFB,$FFC1,$3C
	DC.W	$FFD8,$FFBE,$45
	DC.W	$FFB5,$FFBB,$3C
	DC.W	$FF9C,$FFB9,$23
	DC.W	$FF92,$FFB8,$0
	DC.W	$FF9C,$FFB9,$FFDD
	DC.W	$FFB5,$FFBB,$FFC4
	DC.W	$FFD8,$FFBE,$FFBA
	DC.W	$FFFA,$FFC1,$FFC4
	DC.W	$13,$FFC3,$FFDE
	DC.W	$B,$FFB6,$FFE3
	DC.W	$FFF6,$FFB4,$FFCD
	DC.W	$FFD9,$FFB2,$FFC5
	DC.W	$FFBC,$FFAF,$FFCD
	DC.W	$FFA6,$FFAD,$FFE3
	DC.W	$FF9E,$FFAC,$0
	DC.W	$FFA6,$FFAD,$1D
	DC.W	$FFBC,$FFAF,$33
	DC.W	$FFD9,$FFB2,$3A
	DC.W	$FFF6,$FFB4,$33
	DC.W	$B,$FFB6,$1D
	DC.W	$13,$FFB7,$0
	DC.W	$1C,$FFC4,$2
	DC.W	$75,$FFE2,$2
	DC.W	$75,$FFE2,$FFFE
	DC.W	$D,$2,$0
	DC.W	$6,$3,$1D
	DC.W	$FFF1,$4,$32
	DC.W	$FFD6,$B,$3A
	DC.W	$FFBA,$12,$32
	DC.W	$FFAC,$23,$1D
	DC.W	$FFA8,$2B,$0
	DC.W	$FFAC,$23,$FFE3
	DC.W	$FFBA,$12,$FFCE
	DC.W	$FFD6,$B,$FFC6
	DC.W	$FFF1,$4,$FFCE
	DC.W	$6,$3,$FFE3

	DRAW2	$18,$0
	DRAW2	$0,$17
	DRAW2	$17,$18
	DRAW2	$0,$1
	DRAW2	$1,$2
	DRAW2	$2,$3
	DRAW2	$3,$4
	DRAW2	$4,$5
	DRAW2	$5,$6
	DRAW2	$6,$7
	DRAW2	$7,$8
	DRAW2	$8,$9
	DRAW2	$9,$A
	DRAW2	$A,$B
	DRAW2	$B,$0
	DRAW2	$C,$D
	DRAW2	$D,$E
	DRAW2	$E,$F
	DRAW2	$F,$10
	DRAW2	$10,$11
	DRAW2	$11,$12
	DRAW2	$12,$13
	DRAW2	$13,$14
	DRAW2	$14,$15
	DRAW2	$15,$16
	DRAW2	$16,$17
	DRAW2	$17,$C
	DRAW2	$16,$1
	DRAW2	$15,$2
	DRAW2	$14,$3
	DRAW2	$13,$4
	DRAW2	$12,$5
	DRAW2	$11,$6
	DRAW2	$10,$7
	DRAW2	$F,$8
	DRAW2	$E,$9
	DRAW2	$D,$A
	DRAW2	$C,$B
	DRAW2	$18,$19
	DRAW2	$19,$1A
	DRAW2	$1A,$0
	DRAW2	$1B,$1C
	DRAW2	$1C,$1D
	DRAW2	$1D,$1E
	DRAW2	$1E,$1F
	DRAW2	$1F,$20
	DRAW2	$20,$21
	DRAW2	$21,$22
	DRAW2	$22,$23
	DRAW2	$23,$24
	DRAW2	$24,$25
	DRAW2	$25,$26
	DRAW2	$26,$1B
	BRA	QUIT

OBJET4
	DC.W	$2B
	DC.W	$FFBC,$93,$FFEF
	DC.W	$FFB0,$7C,$FFDF
	DC.W	$7A,$6D,$FFE8
	DC.W	$54,$8B,$FFF6
	DC.W	$16,$90,$38
	DC.W	$FFC7,$8B,$23
	DC.W	$FFC7,$93,$FFCB
	DC.W	$27,$8B,$FFBB
	DC.W	$FFAF,$D,$FF7D
	DC.W	$6,$D,$FF61
	DC.W	$94,$D,$FFC8
	DC.W	$FFEE,$FF8E,$FFAB
	DC.W	$FFDD,$FFC2,$FF77
	DC.W	$69,$70,$18
	DC.W	$3C,$92,$1D
	DC.W	$FFF2,$92,$35
	DC.W	$FFF2,$92,$FFB6
	DC.W	$7E,$D,$4D
	DC.W	$6A,$35,$5C
	DC.W	$FFC4,$35,$74
	DC.W	$FFC4,$35,$FF77
	DC.W	$86,$35,$FFB6
	DC.W	$34,$D,$83
	DC.W	$9B,$D,$FFF6
	DC.W	$65,$FFA1,$16
	DC.W	$FFAC,$6E,$37
	DC.W	$29,$6E,$FF8B
	DC.W	$7E,$57,$19
	DC.W	$FFB7,$57,$FF90
	DC.W	$82,$57,$FFD2
	DC.W	$7D,$FFD4,$3B
	DC.W	$47,$32,$76
	DC.W	$1D,$32,$84
	DC.W	$FFEF,$FFE7,$FF68
	DC.W	$13,$36,$FF6B
	DC.W	$FFBE,$FFC2,$FF8B
	DC.W	$FFD1,$32,$FF6D
	DC.W	$FFB4,$FFE4,$FF8F
	DC.W	$FFF2,$4A,$FF71
	DC.W	$85,$FFD0,$FFF6
	DC.W	$6,$10,$7
	DC.W	$1A,$22,$26
	DC.W	$24,$9,$21
	DC.W	$C,$B,$23

	DRAW2	$0,$6
	DRAW2	$6,$10
	DRAW2	$10,$7
	DRAW2	$7,$1A
	DRAW2	$1A,$22
	DRAW2	$22,$26
	DRAW2	$26,$24
	DRAW2	$24,$9
	DRAW2	$9,$21
	DRAW2	$21,$C
	DRAW2	$C,$B
	DRAW2	$B,$23
	DRAW2	$23,$25
	DRAW2	$25,$8
	DRAW2	$8,$14
	DRAW2	$14,$1C
	DRAW2	$1C,$1
	DRAW2	$1,$0
	DRAW2	$4,$F
	DRAW2	$F,$5
	DRAW2	$5,$19
	DRAW2	$19,$13
	DRAW2	$13,$20
	DRAW2	$20,$16
	DRAW2	$16,$1F
	DRAW2	$1F,$12
	DRAW2	$12,$11
	DRAW2	$11,$1E
	DRAW2	$1E,$18
	DRAW2	$18,$27
	DRAW2	$27,$17
	DRAW2	$17,$A
	DRAW2	$A,$15
	DRAW2	$15,$1D
	DRAW2	$1D,$1B
	DRAW2	$1B,$D
	DRAW2	$D,$2
	DRAW2	$2,$3
	DRAW2	$3,$E
	DRAW2	$E,$4
	BRA	QUIT

OBJET5
	DC.W	$27
	DC.W	$FFFC,$70,$C
	DC.W	$2E,$50,$C
	DC.W	$62,$40,$C
	DC.W	$56,$FFFA,$C
	DC.W	$8,$FF94,$C
	DC.W	$10,$FFA8,$C
	DC.W	$61,$FFB0,$C
	DC.W	$3B,$FFB5,$C
	DC.W	$FFAF,$FFA4,$C
	DC.W	$FF89,$39,$C
	DC.W	$FFBB,$10,$C
	DC.W	$FFBB,$38,$C
	DC.W	$FF8B,$29,$C
	DC.W	$FFBB,$FFDE,$C
	DC.W	$FFC6,$FFD5,$C
	DC.W	$FFBD,$FFF1,$C
	DC.W	$FFCF,$3E,$C
	DC.W	$FFC3,$4E,$C
	DC.W	$FFB9,$4E,$C
	DC.W	$FFF6,$5F,$C
	DC.W	$FFF6,$5F,$FFF6
	DC.W	$FFB9,$4E,$FFF6
	DC.W	$FFC3,$4E,$FFF6
	DC.W	$FFCF,$3E,$FFF6
	DC.W	$FFBD,$FFF1,$FFF6
	DC.W	$FFC6,$FFD5,$FFF6
	DC.W	$FFBB,$FFDE,$FFF6
	DC.W	$FF8B,$29,$FFF6
	DC.W	$FFBB,$38,$FFF6
	DC.W	$FFBB,$10,$FFF6
	DC.W	$FF89,$39,$FFF6
	DC.W	$FFAF,$FFA4,$FFF6
	DC.W	$3B,$FFB5,$FFF6
	DC.W	$61,$FFB0,$FFF6
	DC.W	$10,$FFA8,$FFF6
	DC.W	$8,$FF94,$FFF6
	DC.W	$56,$FFFA,$FFF6
	DC.W	$62,$40,$FFF6
	DC.W	$2E,$50,$FFF6
	DC.W	$FFFC,$70,$FFF6

	DRAW2	$0,$1
	DRAW2	$1,$2
	DRAW2	$2,$3
	DRAW2	$3,$6
	DRAW2	$6,$7
	DRAW2	$7,$5
	DRAW2	$5,$4
	DRAW2	$4,$8
	DRAW2	$8,$D
	DRAW2	$D,$E
	DRAW2	$E,$F
	DRAW2	$F,$A
	DRAW2	$A,$C
	DRAW2	$C,$9
	DRAW2	$9,$B
	DRAW2	$B,$12
	DRAW2	$12,$11
	DRAW2	$11,$10
	DRAW2	$10,$13
	DRAW2	$13,$0
	DRAW2	$27,$26
	DRAW2	$26,$25
	DRAW2	$25,$24
	DRAW2	$24,$21
	DRAW2	$21,$20
	DRAW2	$20,$22
	DRAW2	$22,$23
	DRAW2	$23,$1F
	DRAW2	$1F,$1A
	DRAW2	$1A,$19
	DRAW2	$19,$18
	DRAW2	$18,$1D
	DRAW2	$1D,$1B
	DRAW2	$1B,$1E
	DRAW2	$1E,$1C
	DRAW2	$1C,$15
	DRAW2	$15,$16
	DRAW2	$16,$17
	DRAW2	$17,$14
	DRAW2	$14,$27
	DRAW2	$0,$27
	DRAW2	$1,$26
	DRAW2	$2,$25
	DRAW2	$3,$24
	DRAW2	$6,$21
	DRAW2	$7,$20
	DRAW2	$5,$22
	DRAW2	$4,$23
	DRAW2	$8,$1F
	DRAW2	$D,$1A
	DRAW2	$E,$19
	DRAW2	$F,$18
	DRAW2	$A,$1D
	DRAW2	$C,$1B
	DRAW2	$9,$1E
	DRAW2	$B,$1C
	DRAW2	$12,$15
	DRAW2	$11,$16
	DRAW2	$10,$17
	DRAW2	$13,$14
	BRA	QUIT

OBJET6
	DC.W	$2B
	DC.W	$6,$1,$1E
	DC.W	$6,$15,$15
	DC.W	$6,$1E,$1
	DC.W	$6,$15,$FFEC
	DC.W	$6,$1,$FFE4
	DC.W	$6,$FFEC,$FFEC
	DC.W	$6,$FFE3,$1
	DC.W	$6,$FFEC,$15
	DC.W	$5A,$0,$FFC5
	DC.W	$2D,$69,$FFC5
	DC.W	$FFD4,$69,$FFC5
	DC.W	$FFA7,$0,$FFC5
	DC.W	$FFD4,$FF97,$FFC5
	DC.W	$2D,$FF97,$FFC5
	DC.W	$2D,$FF97,$3E
	DC.W	$FFD4,$FF97,$3E
	DC.W	$FFA7,$0,$3E
	DC.W	$FFD4,$69,$3E
	DC.W	$2D,$69,$3E
	DC.W	$5A,$0,$3E
	DC.W	$FFFA,$FFEC,$15
	DC.W	$FFFA,$FFE3,$1
	DC.W	$FFFA,$FFEC,$FFEC
	DC.W	$FFFA,$1,$FFE4
	DC.W	$FFFA,$15,$FFEC
	DC.W	$FFFA,$1E,$1
	DC.W	$FFFA,$15,$15
	DC.W	$FFFA,$1,$1E
	DC.W	$FFEA,$FFF7,$A
	DC.W	$FFEA,$FFF3,$1
	DC.W	$FFEA,$FFF7,$FFF7
	DC.W	$FFEA,$1,$FFF3
	DC.W	$FFEA,$A,$FFF7
	DC.W	$FFEA,$E,$1
	DC.W	$FFEA,$A,$A
	DC.W	$FFEA,$1,$E
	DC.W	$15,$1,$E
	DC.W	$15,$A,$A
	DC.W	$15,$E,$1
	DC.W	$15,$A,$FFF7
	DC.W	$15,$1,$FFF3
	DC.W	$15,$FFF7,$FFF7
	DC.W	$15,$FFF3,$1
	DC.W	$15,$FFF7,$A

	DRAW2	$8,$9
	DRAW2	$9,$A
	DRAW2	$A,$B
	DRAW2	$B,$C
	DRAW2	$C,$D
	DRAW2	$D,$8
	DRAW2	$8,$B
	DRAW2	$D,$A
	DRAW2	$C,$9
	DRAW2	$E,$F
	DRAW2	$F,$10
	DRAW2	$10,$11
	DRAW2	$11,$12
	DRAW2	$12,$13
	DRAW2	$13,$E
	DRAW2	$E,$11
	DRAW2	$F,$12
	DRAW2	$10,$13
	DRAW2	$0,$1
	DRAW2	$1,$2
	DRAW2	$2,$3
	DRAW2	$3,$4
	DRAW2	$4,$5
	DRAW2	$5,$6
	DRAW2	$6,$7
	DRAW2	$7,$0
	DRAW2	$14,$15
	DRAW2	$15,$16
	DRAW2	$16,$17
	DRAW2	$17,$18
	DRAW2	$18,$19
	DRAW2	$19,$1A
	DRAW2	$1A,$1B
	DRAW2	$1B,$14
	DRAW2	$1C,$1D
	DRAW2	$1D,$1E
	DRAW2	$1E,$1F
	DRAW2	$1F,$20
	DRAW2	$20,$21
	DRAW2	$21,$22
	DRAW2	$22,$23
	DRAW2	$23,$1C
	DRAW2	$24,$25
	DRAW2	$25,$26
	DRAW2	$26,$27
	DRAW2	$27,$28
	DRAW2	$28,$29
	DRAW2	$29,$2A
	DRAW2	$2A,$2B
	DRAW2	$2B,$24
	BRA	QUIT

OBJET8
	DC.W	$2B
	DC.W	$FFF0,$FFFC,$F
	DC.W	$FFFE,$FFFC,$9
	DC.W	$FFF1,$FFFC,$1
	DC.W	$FFF6,$7,$9
	DC.W	$E,$E,$7
	DC.W	$5,$FFFC,$FFFC
	DC.W	$1A,$FFFC,$7
	DC.W	$3,$FFFC,$12
	DC.W	$70,$6D,$FFD5
	DC.W	$30,$37,$FFEB
	DC.W	$4B,$4F,$FFE3
	DC.W	$4A,$51,$FFE5
	DC.W	$24,$33,$FFF2
	DC.W	$6F,$73,$FFD9
	DC.W	$FFAD,$5E,$FFCF
	DC.W	$FFAF,$5E,$FFCD
	DC.W	$FFD6,$38,$FFE5
	DC.W	$FFD3,$38,$FFE9
	DC.W	$FFD9,$39,$FFF0
	DC.W	$FFDE,$3A,$FFE9
	DC.W	$FFE1,$35,$FFEF
	DC.W	$FFEC,$2B,$FFF7
	DC.W	$FFEE,$2B,$FFF5
	DC.W	$FFE3,$35,$FFED
	DC.W	$FFDF,$35,$FFF1
	DC.W	$FFEA,$2A,$FFFA
	DC.W	$FFE8,$2A,$FFFC
	DC.W	$FFDD,$34,$FFF3
	DC.W	$29,$FFFB,$1
	DC.W	$1D,$FFFB,$1D
	DC.W	$1,$FFFB,$29
	DC.W	$FFE5,$FFFB,$1D
	DC.W	$FFD9,$FFFB,$1
	DC.W	$FFE5,$FFFB,$FFE5
	DC.W	$1,$FFFB,$FFD9
	DC.W	$1D,$FFFB,$FFE5
	DC.W	$2E,$7,$FFD5
	DC.W	$1,$7,$FFC2
	DC.W	$FFD4,$7,$FFD5
	DC.W	$FFC2,$7,$1
	DC.W	$FFD4,$7,$2E
	DC.W	$1,$7,$40
	DC.W	$2E,$7,$2E
	DC.W	$40,$7,$1

	DRAW2	$2,$1
	DRAW2	$2,$3
	DRAW2	$3,$1
	DRAW2	$2,$0
	DRAW2	$1,$0
	DRAW2	$0,$3
	DRAW2	$4,$6
	DRAW2	$4,$5
	DRAW2	$5,$6
	DRAW2	$4,$7
	DRAW2	$6,$7
	DRAW2	$7,$5
	DRAW2	$1C,$1D
	DRAW2	$1D,$1E
	DRAW2	$1E,$1F
	DRAW2	$1F,$20
	DRAW2	$20,$21
	DRAW2	$21,$22
	DRAW2	$23,$22
	DRAW2	$23,$1C
	DRAW2	$24,$25
	DRAW2	$25,$26
	DRAW2	$26,$27
	DRAW2	$27,$28
	DRAW2	$28,$29
	DRAW2	$29,$2A
	DRAW2	$2A,$2B
	DRAW2	$2B,$24
	DRAW2	$23,$24
	DRAW2	$22,$25
	DRAW2	$21,$26
	DRAW2	$20,$27
	DRAW2	$1F,$28
	DRAW2	$1E,$29
	DRAW2	$1D,$2A
	DRAW2	$1C,$2B
	DRAW2	$8,$9
	DRAW2	$A,$B
	DRAW2	$D,$C
	DRAW2	$C,$9
	DRAW2	$8,$D
	DRAW2	$E,$F
	DRAW2	$E,$11
	DRAW2	$10,$11
	DRAW2	$10,$F
	DRAW2	$11,$12
	DRAW2	$12,$13
	DRAW2	$13,$10
	DRAW2	$13,$14
	DRAW2	$14,$15
	DRAW2	$16,$17
	DRAW2	$18,$19
	DRAW2	$1A,$1B
	DRAW2	$1B,$12
	DRAW2	$1B,$14
	DRAW2	$0,$2
	BRA	QUIT

OBJET9
	DC.W	$22
	DC.W	$2,$75,$0
	DC.W	$2,$58,$0
	DC.W	$14,$FFDA,$0
	DC.W	$FFF9,$FFDA,$F
	DC.W	$FFF9,$FFDA,$FFF0
	DC.W	$C,$FFDA,$F
	DC.W	$C,$FFDA,$FFF0
	DC.W	$FFF0,$FFDA,$0
	DC.W	$FFF0,$2C,$0
	DC.W	$C,$2C,$FFF0
	DC.W	$C,$2C,$F
	DC.W	$FFF9,$2C,$FFF0
	DC.W	$FFF9,$2C,$F
	DC.W	$14,$2C,$0
	DC.W	$FFFC,$FFBA,$FFF6
	DC.W	$FFFC,$FFBA,$A
	DC.W	$D,$FFBA,$0
	DC.W	$8,$FFBA,$A
	DC.W	$8,$FFBA,$FFF6
	DC.W	$FFF7,$FFBA,$0
	DC.W	$19,$FF90,$22
	DC.W	$15,$FF90,$1C
	DC.W	$18,$FF90,$FFDD
	DC.W	$14,$FF90,$FFE4
	DC.W	$FFD9,$FF90,$0
	DC.W	$FFE1,$FF90,$0
	DC.W	$1A,$FFAE,$24
	DC.W	$1A,$FFAE,$FFDB
	DC.W	$FFD7,$FFAE,$0
	DC.W	$FFE4,$FFAE,$0
	DC.W	$13,$FFAE,$FFE6
	DC.W	$14,$FFAE,$19
	DC.W	$16,$FFBB,$1F
	DC.W	$15,$FFBB,$FFE1
	DC.W	$FFDD,$FFBB,$0

	DRAW2	$0,$1
	DRAW2	$1,$B
	DRAW2	$B,$9
	DRAW2	$9,$1
	DRAW2	$B,$8
	DRAW2	$8,$1
	DRAW2	$8,$C
	DRAW2	$1,$C
	DRAW2	$1,$A
	DRAW2	$A,$C
	DRAW2	$D,$A
	DRAW2	$D,$1
	DRAW2	$9,$1
	DRAW2	$9,$D
	DRAW2	$2,$5
	DRAW2	$5,$3
	DRAW2	$3,$7
	DRAW2	$7,$4
	DRAW2	$4,$6
	DRAW2	$6,$2
	DRAW2	$7,$8
	DRAW2	$4,$B
	DRAW2	$6,$9
	DRAW2	$2,$D
	DRAW2	$5,$A
	DRAW2	$3,$C
	DRAW2	$E,$13
	DRAW2	$E,$12
	DRAW2	$10,$12
	DRAW2	$10,$11
	DRAW2	$11,$F
	DRAW2	$F,$13
	DRAW2	$7,$13
	DRAW2	$3,$F
	DRAW2	$11,$5
	DRAW2	$10,$2
	DRAW2	$12,$6
	DRAW2	$E,$4
	DRAW2	$14,$15
	DRAW2	$17,$16
	DRAW2	$19,$18
	DRAW2	$18,$1C
	DRAW2	$19,$1D
	DRAW2	$15,$1F
	DRAW2	$17,$1E
	DRAW2	$16,$1B
	DRAW2	$14,$1A
	DRAW2	$20,$5
	DRAW2	$7,$22
	DRAW2	$21,$6
	DRAW2	$20,$1F
	DRAW2	$20,$1A
	DRAW2	$1F,$11
	DRAW2	$1B,$21
	DRAW2	$1E,$21
	DRAW2	$22,$1D
	DRAW2	$22,$1C
	DRAW2	$1E,$12
	DRAW2	$1D,$11
	BRA	QUIT

OBJET10
	DC.W	$29
	DC.W	$2E,$33,$20
	DC.W	$2E,$33,$FFDE
	DC.W	$FFD1,$33,$FFDE
	DC.W	$FFD1,$33,$20
	DC.W	$2E,$0,$20
	DC.W	$2E,$0,$FFDE
	DC.W	$FFD1,$0,$FFDE
	DC.W	$FFD1,$0,$20
	DC.W	$FFE0,$57,$0
	DC.W	$20,$57,$0
	DC.W	$FFE4,$0,$FFDE
	DC.W	$FFFB,$0,$FFDE
	DC.W	$FFFB,$2B,$FFDE
	DC.W	$FFE4,$2B,$FFDE
	DC.W	$8,$2B,$FFDE
	DC.W	$1F,$2B,$FFDE
	DC.W	$1F,$11,$FFDE
	DC.W	$8,$11,$FFDE
	DC.W	$8,$21,$FFDD
	DC.W	$1F,$21,$FFDD
	DC.W	$14,$11,$FFDD
	DC.W	$14,$21,$FFDD
	DC.W	$0,$21,$20
	DC.W	$0,$11,$20
	DC.W	$FFF4,$21,$20
	DC.W	$C,$21,$20
	DC.W	$C,$11,$20
	DC.W	$FFF5,$11,$20
	DC.W	$FFF5,$2B,$20
	DC.W	$C,$2B,$20
	DC.W	$35,$46,$54
	DC.W	$35,$11,$54
	DC.W	$35,$0,$54
	DC.W	$41,$11,$5B
	DC.W	$38,$11,$47
	DC.W	$2A,$11,$59
	DC.W	$58,$11,$6
	DC.W	$66,$11,$FFF4
	DC.W	$6F,$11,$8
	DC.W	$63,$1,$1
	DC.W	$63,$11,$1
	DC.W	$63,$46,$1

	DRAW2	$22,$21
	DRAW2	$21,$23
	DRAW2	$1E,$1E
	DRAW2	$27,$28
	DRAW2	$1E,$23
	DRAW2	$1E,$21
	DRAW2	$1E,$22
	DRAW2	$29,$25
	DRAW2	$29,$26
	DRAW2	$29,$24
	DRAW2	$20,$1F
	DRAW2	$23,$22
	DRAW2	$25,$26
	DRAW2	$24,$26
	DRAW2	$29,$29
	DRAW2	$24,$25
	DRAW2	$8,$3
	DRAW2	$3,$2
	DRAW2	$2,$8
	DRAW2	$9,$1
	DRAW2	$1,$0
	DRAW2	$0,$9
	DRAW2	$2,$1
	DRAW2	$0,$3
	DRAW2	$0,$4
	DRAW2	$1,$5
	DRAW2	$2,$6
	DRAW2	$3,$7
	DRAW2	$7,$4
	DRAW2	$4,$5
	DRAW2	$5,$6
	DRAW2	$6,$7
	DRAW2	$8,$9
	DRAW2	$A,$D
	DRAW2	$B,$C
	DRAW2	$C,$D
	DRAW2	$E,$F
	DRAW2	$F,$10
	DRAW2	$10,$11
	DRAW2	$11,$E
	DRAW2	$12,$13
	DRAW2	$14,$15
	DRAW2	$1A,$1B
	DRAW2	$1B,$1C
	DRAW2	$1C,$1D
	DRAW2	$1D,$1A
	DRAW2	$16,$17
	DRAW2	$18,$19
	BRA	QUIT

OBJET11
	DC.W	$1B
	DC.W	$5A,$5A,$5A
	DC.W	$5A,$5A,$FFA6
	DC.W	$FFA6,$5A,$FFA6
	DC.W	$FFA6,$5A,$5A
	DC.W	$5A,$FFA6,$5A
	DC.W	$5A,$FFA6,$FFA6
	DC.W	$FFA6,$FFA6,$FFA6
	DC.W	$FFA6,$FFA6,$5A
	DC.W	$5A,$0,$0
	DC.W	$FFA6,$0,$0
	DC.W	$0,$5A,$0
	DC.W	$0,$FFA6,$0
	DC.W	$0,$0,$5A
	DC.W	$0,$0,$FFA6
	DC.W	$5A,$5A,$5A
	DC.W	$5A,$5A,$FFA6
	DC.W	$FFA6,$5A,$FFA6
	DC.W	$FFA6,$5A,$5A
	DC.W	$5A,$FFA6,$5A
	DC.W	$5A,$FFA6,$FFA6
	DC.W	$FFA6,$FFA6,$FFA6
	DC.W	$FFA6,$FFA6,$5A
	DC.W	$5A,$0,$0
	DC.W	$FFA6,$0,$0
	DC.W	$0,$5A,$0
	DC.W	$0,$FFA6,$0
	DC.W	$0,$0,$5A
	DC.W	$0,$0,$FFA6

	DRAW2	$0,$1
	DRAW2	$1,$2
	DRAW2	$2,$3
	DRAW2	$3,$0
	DRAW2	$4,$5
	DRAW2	$5,$6
	DRAW2	$6,$7
	DRAW2	$7,$4
	DRAW2	$0,$4
	DRAW2	$1,$5
	DRAW2	$2,$6
	DRAW2	$3,$7
	DRAW2	$8,$A
	DRAW2	$8,$B
	DRAW2	$8,$C
	DRAW2	$8,$D
	DRAW2	$9,$A
	DRAW2	$9,$B
	DRAW2	$9,$C
	DRAW2	$9,$D
	DRAW2	$D,$A
	DRAW2	$A,$C
	DRAW2	$B,$C
	DRAW2	$B,$D
	BRA	QUIT

OBJET12
	DC.W	$25
	DC.W	$19,$76,$17
	DC.W	$19,$6C,$18
	DC.W	$8,$51,$27
	DC.W	$29,$51,$27
	DC.W	$29,$51,$9
	DC.W	$8,$51,$9
	DC.W	$8,$B,$FFD7
	DC.W	$2A,$B,$FFD7
	DC.W	$8,$B,$FFF5
	DC.W	$FFF6,$16,$FFF5
	DC.W	$FFF6,$16,$FFD7
	DC.W	$FFD5,$16,$FFD7
	DC.W	$FFD6,$38,$9
	DC.W	$FFF6,$38,$9
	DC.W	$FFF6,$38,$27
	DC.W	$FFD6,$38,$27
	DC.W	$FFD5,$16,$FFF5
	DC.W	$2A,$B,$FFF5
	DC.W	$2A,$FFEC,$FFF5
	DC.W	$FFD5,$FFEC,$FFF5
	DC.W	$FFD6,$FFEC,$27
	DC.W	$FFF6,$FFEC,$27
	DC.W	$FFF6,$FFEC,$9
	DC.W	$FFD6,$FFEC,$9
	DC.W	$FFD5,$FFEC,$FFD7
	DC.W	$FFF6,$FFEC,$FFD7
	DC.W	$FFF6,$FFEC,$FFF5
	DC.W	$8,$FFEC,$FFF5
	DC.W	$2A,$FFEC,$FFD7
	DC.W	$8,$FFEC,$FFD7
	DC.W	$8,$FFEC,$9
	DC.W	$29,$FFEC,$9
	DC.W	$29,$FFEC,$27
	DC.W	$8,$FFEC,$27
	DC.W	$FFC2,$FFEB,$35
	DC.W	$3D,$FFEB,$35
	DC.W	$3D,$FFEB,$FFC7
	DC.W	$FFC2,$FFEB,$FFC7

	DRAW2	$1,$2
	DRAW2	$2,$3
	DRAW2	$3,$1
	DRAW2	$2,$5
	DRAW2	$5,$1
	DRAW2	$5,$4
	DRAW2	$4,$1
	DRAW2	$4,$3
	DRAW2	$0,$1
	DRAW2	$1E,$5
	DRAW2	$1F,$4
	DRAW2	$20,$3
	DRAW2	$21,$2
	DRAW2	$1E,$1F
	DRAW2	$1F,$20
	DRAW2	$20,$21
	DRAW2	$21,$1E
	DRAW2	$6,$7
	DRAW2	$7,$11
	DRAW2	$11,$8
	DRAW2	$8,$6
	DRAW2	$12,$1B
	DRAW2	$1B,$1D
	DRAW2	$1D,$1C
	DRAW2	$1C,$12
	DRAW2	$6,$1D
	DRAW2	$7,$1C
	DRAW2	$8,$1B
	DRAW2	$11,$12
	DRAW2	$22,$23
	DRAW2	$23,$24
	DRAW2	$24,$25
	DRAW2	$25,$22
	DRAW2	$9,$A
	DRAW2	$A,$B
	DRAW2	$B,$10
	DRAW2	$10,$9
	DRAW2	$18,$19
	DRAW2	$19,$1A
	DRAW2	$1A,$13
	DRAW2	$13,$18
	DRAW2	$9,$1A
	DRAW2	$A,$19
	DRAW2	$B,$18
	DRAW2	$10,$13
	DRAW2	$C,$D
	DRAW2	$D,$E
	DRAW2	$E,$F
	DRAW2	$F,$C
	DRAW2	$14,$15
	DRAW2	$15,$16
	DRAW2	$16,$17
	DRAW2	$17,$14
	DRAW2	$F,$14
	DRAW2	$E,$15
	DRAW2	$D,$16
	DRAW2	$C,$17
	BRA	QUIT

OBJET14
	DC.W	$2C
	DC.W	$FF7E,$0,$0
	DC.W	$FF7E,$0,$3C
	DC.W	$FF74,$A,$0
	DC.W	$FF74,$FFF6,$0
	DC.W	$FF88,$0,$0
	DC.W	$8C,$14,$0
	DC.W	$8C,$14,$1E
	DC.W	$8C,$FFEC,$0
	DC.W	$8C,$FFEC,$1E
	DC.W	$64,$14,$0
	DC.W	$64,$14,$1E
	DC.W	$64,$FFEC,$0
	DC.W	$64,$FFEC,$1E
	DC.W	$5E,$FFE6,$1E
	DC.W	$5E,$1A,$1E
	DC.W	$92,$FFE6,$1E
	DC.W	$92,$1A,$1E
	DC.W	$96,$FFE6,$3C
	DC.W	$96,$1A,$3C
	DC.W	$28,$FFEC,$0
	DC.W	$28,$FFEC,$28
	DC.W	$14,$FFD8,$0
	DC.W	$14,$FFD8,$28
	DC.W	$FFD8,$14,$0
	DC.W	$FFD8,$14,$28
	DC.W	$FFEC,$28,$0
	DC.W	$FFEC,$28,$28
	DC.W	$3C,$FFEC,$28
	DC.W	$14,$FFC4,$28
	DC.W	$FFC4,$14,$28
	DC.W	$FFEC,$3C,$28
	DC.W	$FF74,$FFE2,$3C
	DC.W	$FF74,$1E,$3C
	DC.W	$FF88,$FFE2,$3C
	DC.W	$FF88,$1E,$3C
	DC.W	$FF88,$FFE2,$64
	DC.W	$FF88,$1E,$64
	DC.W	$FF88,$FFE8,$42
	DC.W	$FF88,$FFE8,$5E
	DC.W	$FF88,$18,$42
	DC.W	$FF88,$18,$5E
	DC.W	$FF6A,$FFCE,$0
	DC.W	$FF6A,$32,$0
	DC.W	$96,$32,$0
	DC.W	$96,$FFCE,$0

	DRAW2	$0,$1
	DRAW2	$2,$3
	DRAW2	$3,$4
	DRAW2	$4,$2
	DRAW2	$5,$6
	DRAW2	$7,$8
	DRAW2	$9,$A
	DRAW2	$B,$C
	DRAW2	$D,$E
	DRAW2	$E,$10
	DRAW2	$10,$F
	DRAW2	$F,$D
	DRAW2	$F,$11
	DRAW2	$10,$12
	DRAW2	$11,$12
	DRAW2	$13,$14
	DRAW2	$15,$16
	DRAW2	$17,$18
	DRAW2	$19,$1A
	DRAW2	$1B,$1C
	DRAW2	$1C,$1D
	DRAW2	$1D,$1E
	DRAW2	$1E,$1B
	DRAW2	$1F,$20
	DRAW2	$20,$22
	DRAW2	$22,$21
	DRAW2	$21,$1F
	DRAW2	$1F,$23
	DRAW2	$20,$24
	DRAW2	$22,$24
	DRAW2	$21,$23
	DRAW2	$23,$24
	DRAW2	$25,$26
	DRAW2	$26,$28
	DRAW2	$28,$27
	DRAW2	$27,$25
	DRAW2	$29,$2A
	DRAW2	$2A,$2B
	DRAW2	$2B,$2C
	DRAW2	$2C,$29
	BRA	QUIT
OBJET16
	DC.W	$2C
	DC.W	$FF9C,$78,$5
	DC.W	$64,$78,$5
	DC.W	$64,$FF88,$5
	DC.W	$FFA6,$FF88,$5
	DC.W	$FF9C,$FF92,$5
	DC.W	$FFB0,$78,$5
	DC.W	$50,$78,$5
	DC.W	$32,$FF88,$5
	DC.W	$FFCE,$FF88,$5
	DC.W	$FFCE,$FFD8,$5
	DC.W	$32,$FFD8,$5
	DC.W	$FFF6,$FF92,$5
	DC.W	$FFD8,$FF92,$5
	DC.W	$FFD8,$FFD3,$5
	DC.W	$FFF6,$FFD3,$5
	DC.W	$FF9C,$78,$FFFB
	DC.W	$64,$78,$FFFB
	DC.W	$64,$FF88,$FFFB
	DC.W	$FFA6,$FF88,$FFFB
	DC.W	$FF9C,$FF92,$FFFB
	DC.W	$FFB0,$78,$FFFB
	DC.W	$50,$78,$FFFB
	DC.W	$32,$FF88,$FFFB
	DC.W	$FFCE,$FF88,$FFFB
	DC.W	$FFCE,$FFD8,$FFFB
	DC.W	$32,$FFD8,$FFFB
	DC.W	$FFF6,$FF92,$FFFB
	DC.W	$FFD8,$FF92,$FFFB
	DC.W	$FFD8,$FFD3,$FFFB
	DC.W	$FFF6,$FFD3,$FFFB
	DC.W	$50,$FFF1,$5
	DC.W	$FFB0,$FFF1,$5
	DC.W	$50,$50,$FFFB
	DC.W	$FFB0,$50,$FFFB
	DC.W	$FFE2,$32,$5
	DC.W	$0,$14,$5
	DC.W	$3C,$50,$5
	DC.W	$1E,$0,$FFFB
	DC.W	$15,$FFEB,$FFFB
	DC.W	$0,$FFE2,$FFFB
	DC.W	$FFEB,$FFEB,$FFFB
	DC.W	$FFE2,$0,$FFFB
	DC.W	$FFEB,$15,$FFFB
	DC.W	$0,$1E,$FFFB
	DC.W	$15,$15,$FFFB

	DRAW2	$0,$1
	DRAW2	$1,$2
	DRAW2	$2,$3
	DRAW2	$3,$4
	DRAW2	$4,$0
	DRAW2	$6,$1E
	DRAW2	$1E,$1F
	DRAW2	$1F,$5
	DRAW2	$7,$A
	DRAW2	$A,$9
	DRAW2	$9,$8
	DRAW2	$B,$C
	DRAW2	$C,$D
	DRAW2	$D,$E
	DRAW2	$E,$B
	DRAW2	$22,$23
	DRAW2	$23,$24
	DRAW2	$0,$F
	DRAW2	$5,$14
	DRAW2	$6,$15
	DRAW2	$1,$10
	DRAW2	$2,$11
	DRAW2	$7,$16
	DRAW2	$8,$17
	DRAW2	$3,$12
	DRAW2	$4,$13
	DRAW2	$F,$10
	DRAW2	$10,$11
	DRAW2	$11,$12
	DRAW2	$12,$13
	DRAW2	$13,$F
	DRAW2	$15,$20
	DRAW2	$20,$21
	DRAW2	$21,$14
	DRAW2	$16,$19
	DRAW2	$19,$18
	DRAW2	$18,$17
	DRAW2	$1A,$1B
	DRAW2	$1B,$1C
	DRAW2	$1C,$1D
	DRAW2	$1D,$1A
	DRAW2	$25,$26
	DRAW2	$26,$27
	DRAW2	$27,$28
	DRAW2	$28,$29
	DRAW2	$29,$2A
	DRAW2	$2A,$2B
	DRAW2	$2B,$2C
	DRAW2	$2C,$25
	BRA	QUIT
OBJET19
	DC.W	$1F
	DC.W	$FFCE,$FF88,$0
	DC.W	$FFCE,$FFCE,$0
	DC.W	$FFE2,$FFCE,$0
	DC.W	$FFB0,$FFEC,$0
	DC.W	$FFB0,$46,$0
	DC.W	$FFC4,$5A,$0
	DC.W	$FFD8,$5A,$0
	DC.W	$FFE2,$1E,$0
	DC.W	$FFC4,$1E,$0
	DC.W	$FFBA,$3C,$0
	DC.W	$FFBA,$A,$0
	DC.W	$FFE2,$6E,$0
	DC.W	$FFF6,$6E,$0
	DC.W	$0,$1E,$0
	DC.W	$0,$78,$0
	DC.W	$1E,$78,$0
	DC.W	$1E,$5A,$0
	DC.W	$14,$46,$0
	DC.W	$1E,$41,$0
	DC.W	$1E,$1E,$0
	DC.W	$3C,$78,$0
	DC.W	$46,$5A,$0
	DC.W	$50,$5A,$0
	DC.W	$64,$46,$0
	DC.W	$6E,$28,$0
	DC.W	$3C,$FFCE,$0
	DC.W	$14,$FFCE,$0
	DC.W	$0,$FFE2,$0
	DC.W	$14,$FFA6,$0
	DC.W	$3C,$FF88,$0
	DC.W	$32,$1E,$0
	DC.W	$3C,$32,$0

	DRAW2	$0,$1
	DRAW2	$1,$2
	DRAW2	$1,$3
	DRAW2	$3,$4
	DRAW2	$4,$5
	DRAW2	$5,$6
	DRAW2	$6,$7
	DRAW2	$7,$8
	DRAW2	$8,$9
	DRAW2	$8,$A
	DRAW2	$6,$B
	DRAW2	$B,$C
	DRAW2	$C,$D
	DRAW2	$C,$E
	DRAW2	$D,$7
	DRAW2	$E,$F
	DRAW2	$F,$10
	DRAW2	$10,$11
	DRAW2	$11,$12
	DRAW2	$12,$13
	DRAW2	$13,$D
	DRAW2	$F,$14
	DRAW2	$10,$15
	DRAW2	$14,$15
	DRAW2	$12,$1F
	DRAW2	$1F,$1E
	DRAW2	$1E,$13
	DRAW2	$15,$16
	DRAW2	$16,$17
	DRAW2	$17,$18
	DRAW2	$18,$19
	DRAW2	$19,$1A
	DRAW2	$1A,$1B
	DRAW2	$1A,$1C
	DRAW2	$19,$1D
	DRAW2	$1D,$0
	BRA	QUIT
OBJET25
	DC.W	$1B
	DC.W	$FFE2,$FFC4,$0
	DC.W	$FFE2,$A,$0
	DC.W	$A,$A,$0
	DC.W	$1E,$1E,$0
	DC.W	$1E,$32,$0
	DC.W	$A,$46,$0
	DC.W	$FFF6,$46,$0
	DC.W	$FFE2,$32,$0
	DC.W	$FFE2,$28,$0
	DC.W	$FFB0,$28,$0
	DC.W	$FFB0,$3C,$0
	DC.W	$FFBA,$5A,$0
	DC.W	$FFCE,$6E,$0
	DC.W	$FFEC,$78,$0
	DC.W	$14,$78,$0
	DC.W	$32,$6E,$0
	DC.W	$46,$5A,$0
	DC.W	$50,$3C,$0
	DC.W	$50,$14,$0
	DC.W	$46,$FFF6,$0
	DC.W	$32,$FFE2,$0
	DC.W	$14,$FFD8,$0
	DC.W	$14,$FFC4,$0
	DC.W	$14,$FFB0,$0
	DC.W	$14,$FF88,$0
	DC.W	$FFE2,$FF88,$0
	DC.W	$FFE2,$FFB0,$0
	DC.W	$1,$2,$3

	DRAW2	$0,$1
	DRAW2	$1,$2
	DRAW2	$2,$3
	DRAW2	$3,$4
	DRAW2	$4,$5
	DRAW2	$5,$6
	DRAW2	$6,$7
	DRAW2	$7,$8
	DRAW2	$8,$9
	DRAW2	$9,$A
	DRAW2	$A,$B
	DRAW2	$B,$C
	DRAW2	$C,$D
	DRAW2	$D,$E
	DRAW2	$E,$F
	DRAW2	$F,$10
	DRAW2	$10,$11
	DRAW2	$11,$12
	DRAW2	$12,$13
	DRAW2	$13,$14
	DRAW2	$14,$15
	DRAW2	$15,$16
	DRAW2	$16,$0
	DRAW2	$17,$18
	DRAW2	$18,$19
	DRAW2	$19,$1A
	DRAW2	$1A,$17
QUIT:
