WAIT	MACRO
	DCB.W	\1/4,$4E71
	ENDM

	PEA	L0(PC)
	MOVE	#$26,-(A7)
	TRAP	#$E
	ADDQ.L	#6,A7
	RTS
L0:	DC.W	$A00A
	LEA	$FFFFFA13.w,A6
	MOVE.B	(A6),D7
	MOVE.B	2(A6),D6
	CLR.B	(A6)
	CLR.B	2(A6)
	LEA	$FFFF8209.W,A0
	LEA	$FFFF8260.W,A1
	LEA	$FFFF820A.W,A2
	MOVE.B	(A1),D5
	CLR.B	D0
	MOVEQ	#2,D1
	LEA	$70.w,A5
	MOVE.L	(A5),A4
	LEA	L2(PC),A3
	MOVE.L	A3,(A5)
	MOVE.B	#$39,D4
	LEA	$FFFFFC02.W,A3
L1:	CMP.B	(A3),D4
	BNE.S	L1
	MOVE.L	A4,(A5)
	MOVE.B	D5,(A1)
	MOVE.B	D6,2(A6)
	MOVE.B	D7,(A6)
	RTS
L2:	MOVE	#$59B,D2
L3:	DBF	D2,L3
	MOVE.B	#$10,D2
	MOVE.B	D0,(A2)
	WAIT	32
	MOVE.B	D1,(A2)
L4:	MOVE.B	(A0),D3
	BEQ.S	L4
	SUB.B	D3,D2
	LSL.B	D2,D3
	WAIT	380
	MOVE	#$E2,D2
L5:	NOP
	MOVE.B	D1,(A1)
	MOVE.B	D0,(A1)
	WAIT	356
	MOVE.B	D0,(A2)
	MOVE.B	D1,(A2)
	WAIT	52
	MOVE.B	D1,(A1)
	NOP
	MOVE.B	D0,(A1)
	WAIT	36
	DBF	D2,L5
	MOVE.B	D1,(A1)
	MOVE.B	D0,(A1)
	WAIT	356
	MOVE.B	D0,(A2)
	MOVE.B	D1,(A2)
	MOVE	#$2C,D2
	WAIT	44
	MOVE.B	D1,(A1)
	NOP
	MOVE.B	D0,(A1)
	MOVE.B	D0,(A2)
	WAIT	36
	MOVE.B	D1,(A2)
L6:	MOVE.B	D1,(A1)
	MOVE.B	D0,(A1)
	WAIT	386
	MOVE.B	D0,(A2)
	MOVE.B	D1,(A2)
	WAIT	52
	MOVE.B	D1,(A1)
	NOP
	MOVE.B	D0,(A1)
	WAIT	40
	DBF	D2,L6
	RTE
