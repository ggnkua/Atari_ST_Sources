* rouleaux de 32 pixels de haut

; rouge
	dc.w	$300,$300,$400,$400,$500,$500,$600,$600,$700,$700,$744,$744,$755,$755,$766,$766
	dc.w	$766,$766,$755,$755,$744,$744,$700,$700,$600,$600,$500,$500,$400,$400,$300,$300
; vert
	dc.w	$030,$030,$040,$040,$050,$050,$060,$060,$070,$070,$474,$474,$575,$575,$676,$676
	dc.w	$676,$676,$575,$575,$474,$474,$070,$070,$060,$060,$050,$050,$040,$040,$030,$030
; bleu
	dc.w	$003,$003,$004,$004,$005,$005,$006,$006,$007,$007,$227,$337,$447,$447,$557,$557
	dc.w	$557,$557,$447,$447,$337,$227,$007,$007,$006,$006,$005,$005,$004,$004,$003,$003
; bleu_cl
	dc.w	$033,$033,$044,$044,$044,$055,$055,$066,$066,$077,$077,$477,$477,$577,$677,$677
	dc.w	$677,$677,$577,$577,$477,$477,$077,$077,$066,$066,$055,$055,$044,$044,$033,$033
; rose
	dc.w	$303,$303,$404,$404,$505,$505,$606,$606,$707,$707,$747,$747,$757,$757,$767,$767
	dc.w	$767,$767,$757,$757,$747,$747,$707,$707,$606,$606,$505,$505,$404,$404,$303,$303
; gris
	dc.w	$222,$222,$222,$333,$333,$333,$444,$444,$444,$555,$555,$555,$666,$666,$666,$777
	dc.w	$777,$666,$666,$666,$555,$555,$555,$444,$444,$444,$333,$333,$333,$222,$222,$222
;jaune
	dc.w	$330,$330,$440,$440,$550,$550,$660,$660,$770,$770,$774,$774,$775,$775,$776,$776
	dc.w	$776,$776,$775,$775,$774,$774,$770,$770,$660,$660,$550,$550,$440,$440,$330,$330
