* Donn‚es pour les d‚grad‚s

rouge	dc.w	$200,$300,$400,$500,$600,$700
	dc.w	$700,$600,$500,$400,$300,$200,$100
	
vert	dc.w	$020,$030,$040,$050,$060,$070
	dc.w	$070,$060,$050,$040,$030,$020,$010

bleu	dc.w	$002,$003,$004,$005,$006,$007
	dc.w	$006,$005,$004,$003,$002

gris	dc.w	$222,$333,$444,$555,$666,$777
	dc.w	$666,$555,$444,$333,$222

bleu_cl	dc.w	$022,$033,$044,$055,$066,$077
	dc.w	$066,$055,$044,$033,$022
	
jaune	dc.w	$220,$330,$440,$550,$660,$770
	dc.w	$660,$550,$440,$330,$220
	
rose	dc.w	$202,$303,$404,$505,$606,$707
	dc.w	$606,$505,$404,$303,$202

	dc.w	$002,$013,$024,$035,$046,$057
	dc.w	$046,$035,$024,$013,$002
	