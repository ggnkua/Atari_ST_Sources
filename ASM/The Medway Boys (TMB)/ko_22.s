; KO2 v1.2e loader!
;-------------------
; assemble it as PRG and put into AUTO directory under KICKOFF2.PRG name...
Begin:
	BRA	L0000
	DC.L	$57686174,$20746865,$20667563,$6B206172,$6520796F
	DC.L	$75206C6F,$6F6B696E,$6720666F,$72203F3F,$3F3F2049
	DC.L	$20686F70,$6520796F,$75277265,$206E6F74,$20676F69
	DC.L	$6E672074,$6F207269,$70207468,$6973206F,$66662021
	DC.L	$21212049,$6620796F,$75206172,$65207265,$6164696E
	DC.L	$67207468,$69732074,$6578742C,$20746865,$6E20796F
	DC.L	$75206172,$65206F62,$76696F75,$736C7920,$61206C61
	DC.L	$6D652066,$75636B20,$77686F20,$63616E27,$74206861
	DC.L	$636B2066,$6F722074,$68656D73,$656C7665,$732C2061
	DC.L	$6E642074,$68696E6B,$73206974,$27732065,$61736965
	DC.L	$7220746F,$20726970,$206F6666,$206F7468,$65722070
	DC.L	$656F706C,$65732077,$6F726B2E,$2E2E2E20,$20476F20
	DC.W	$4469,$6520,$2121,$2121,0
L0000:
	MOVE.L	#$10000,D1
	MOVEA.L	4(A7),A0
	ADDQ.L	#8,A0
	MOVE.L	(A0)+,D0
	SUB.L	D0,D1
	ADDI.L	#$1047C,D1
	MOVE.L	D1,(A0)+
	ADD.L	D0,D1
	MOVE.L	D1,(A0)+
	MOVE.L	#$3320,D0
	MOVE.L	D0,(A0)+
	ADD.L	D0,D1
	MOVE.L	D1,(A0)+
	MOVE.L	#$3F2C,(A0)+

	clr.w	-(a7)
	pea	$f8000
	pea	$f8000
	move.w	#5,-(a7)
	trap	#14
	lea	12(a7),a7

	PEA	L0021(pc)
	MOVE.W	#9,-(A7)
	TRAP	#1
	ADDQ.L	#6,A7
	MOVE.W	#7,-(A7)
	TRAP	#1
	ADDQ.L	#2,A7

; copy it somewhere upper, beacouse under $10000 loads data (KICK2.CLG) which
; unpacks over $20000, so the right code was replaced with another one, what
; was the cause of the BOMBs on the screen (game hanged up...)... :((
; but now it's fixed (by Pervert of course...)... :))

	lea	Exceed(pc),a0
	lea	$ef000,a1
	pea	(a1)
	move.w	#$1ff,d7
copy	move.l	(a0)+,(a1)+
	dbf	d7,copy
	rts

Exceed



	LEA	L0022(pc),A5
	LEA	$10000,A6
	BSR	L0001
	LEA	$10000,A0
	MOVE.L	#$B0A5,D0
	BSR	L0003
	MOVE.W	#$6004,$19906
	JMP	$10000
L0001:
	MOVE.W	#0,-(A7)
	PEA	(A5)
	MOVE.W	#$3D,-(A7)
	TRAP	#1
	ADDQ.L	#8,A7
L0002:
	TST.W	D0
	BMI	L0002
	MOVE.W	D0,D6
	PEA	(A6)
	MOVE.L	#$FFFFF,-(A7)
	MOVE.W	D6,-(A7)
	MOVE.W	#$3F,-(A7)
	TRAP	#1
	ADDA.L	#$C,A7
	MOVE.W	D6,-(A7)
	MOVE.W	#$3E,-(A7)
	TRAP	#1
	ADDQ.L	#4,A7
	RTS
L0003:
	MOVEM.L	A0-A6/D0-D7,-(A7)
	LEA	0(A0,D0.L),A5
	BSR	L000D
	CMPI.L	#$49636521,D7
	BEQ.S	L0005
L0004:	BRA	L0004
L0005:	ADDA.W	#$78,A0
	BSR.S	L000D
	MOVE.L	D7,(A7)
	LEA	0(A0,D7.L),A6
	MOVEA.L	A6,A3
	MOVEA.L	A6,A1
	LEA	L0021(PC),A2
	MOVEQ	#$77,D0
L0006:MOVE.B	-(A1),-(A2)
	DBF	D0,L0006
	BSR.S	L000D
	BSR.S	L0009
	MOVE.L	(A7),D0
	LEA	-120(A0),A1
L0007:MOVE.B	(A0)+,(A1)+
	DBF	D0,L0007
	SUBI.L	#$10000,D0
	BPL.S	L0007
	MOVEQ	#$77,D0
	LEA	L0021(PC),A2
L0008:MOVE.B	-(A2),-(A3)
	DBF	D0,L0008
	MOVEM.L	(A7)+,A0-A6/D0-D7
	RTS
L0009:BSR.S	L0011
	BCC.S	L000C
	MOVEQ	#0,D1
	BSR.S	L0011
	BCC.S	L000B
	LEA	L001E(PC),A1
	MOVEQ	#3,D3
L000A:MOVE.L	-(A1),D0
	BSR.S	L0014
	SWAP	D0
	CMP.W	D0,D1
	DBNE	D3,L000A
	ADD.L	16(A1),D1
L000B:MOVE.B	-(A5),-(A6)
	DBF	D1,L000B
L000C:CMPA.L	A0,A6
	BGT.S	L0016
	RTS
L000D:MOVEQ	#3,D0
L000E:MOVE.B	-(A5),D7
	ROR.L	#8,D7
	DBF	D0,L000E
	RTS
L000F:MOVE.W	A5,D7
	BTST	#0,D7
	BNE.S	L0010
	MOVE.L	-(A5),D7
	ADDX.L	D7,D7
	ADDX.W	D1,D1
	DBF	D0,L0015
	RTS
L0010:MOVE.L	-5(A5),D7
	LSL.L	#8,D7
	MOVE.B	-(A5),D7
	SUBQ.L	#3,A5
	ADD.L	D7,D7
	BSET	#0,D7
	ADDX.W	D1,D1
	DBF	D0,L0015
	RTS
L0011:ADD.L	D7,D7
	BEQ.S	L0012
	RTS
L0012:MOVE.W	A5,D7
	BTST	#0,D7
	BNE.S	L0013
	MOVE.L	-(A5),D7
	ADDX.L	D7,D7
	RTS
L0013:MOVE.L	-5(A5),D7
	LSL.L	#8,D7
	MOVE.B	-(A5),D7
	SUBQ.L	#3,A5
	ADD.L	D7,D7
	BSET	#0,D7
	RTS
L0014:MOVEQ	#0,D1
L0015:ADD.L	D7,D7
	BEQ.S	L000F
	ADDX.W	D1,D1
	DBF	D0,L0015
	RTS
L0016:LEA	L001F(PC),A1
	MOVEQ	#3,D2
L0017:BSR.S	L0011
	DBCC	D2,L0017
	MOVEQ	#0,D4
	MOVEQ	#0,D1
	MOVE.B	1(A1,D2.W),D0
	EXT.W	D0
	BMI.S	L0018
	BSR.S	L0014
L0018:MOVE.B	6(A1,D2.W),D4
	ADD.W	D1,D4
	BEQ.S	L001A
	LEA	L0020(PC),A1
	MOVEQ	#1,D2
L0019:BSR.S	L0011
	DBCC	D2,L0019
	MOVEQ	#0,D1
	MOVE.B	1(A1,D2.W),D0
	EXT.W	D0
	BSR.S	L0014
	ADD.W	D2,D2
	ADD.W	6(A1,D2.W),D1
	BRA.S	L001C
L001A:MOVEQ	#0,D1
	MOVEQ	#5,D0
	MOVEQ	#0,D2
	BSR.S	L0011
	BCC.S	L001B
	MOVEQ	#8,D0
	MOVEQ	#$40,D2
L001B:BSR.S	L0014
	ADD.W	D2,D1
L001C:LEA	2(A6,D4.W),A1
	ADDA.W	D1,A1
	MOVE.B	-(A1),-(A6)
L001D:MOVE.B	-(A1),-(A6)
	DBF	D4,L001D
	BRA	L0009
	DC.L	$3FF0009,$70002,$30001,$30001
L001E:DC.L	$E,7,4,1
L001F:DC.L	$90100FF,-$F7FBFE,$1000B04
L0020	EQU	*-2
	DC.L	$7000120,$20,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
	DC.L	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
L0021:DC.L	$1B661B45,$54686520,$4D656477,$61792042,$6F797320,$50726573,$656E740A,$D7E7E7E,$7E7E7E7E,$7E7E7E7E,$7E7E7E7E,$7E7E7E7E,$7E7E7E7E,$A0A0D4B,$49434B20,$4F464620,$32202D20
	DC.L	$31303020,$250A0A0D,$43726163,$6B656420,$62792054,$6865204D,$69676874,$7920436C,$6F670A0D,$5468616E,$6B732074,$6F204A6F,$62696C20,$666F7220,$74686520,$4F726967,$696E616C
	DC.L	$A0A0D41,$7320616E,$796F6E65,$2077686F,$206C6F6F,$6B656420,$61742074,$68697320,$67616D65,$2077696C,$6C0A0D6B,$6E6F772C,$20697420,$68616420,$61207665,$7279206E,$69636520
	DC.L	$70726F74,$65637469,$6F6E203A,$2D0A0D41,$206E6173,$74792065,$78746572,$6E616C20,$656E6372,$79707469,$6F6E2061,$726F756E,$64207468,$650A0D6D,$61696E20,$66696C65,$2C203220
	DC.L	$6469736B,$2070726F,$74656374,$696F6E20,$726F7574,$696E6573,$A0D616E,$64206C6F,$7473206F,$66206368,$65636B73,$756D7320,$2121210A,$A0D5761,$74636820,$6F757420,$666F7220
	DC.L	$6F746865,$72207665,$7273696F,$6E732074,$68617420,$646F6E27,$740A0D77,$6F726B20,$31303025,$2E204927,$76652070,$6C617965,$64207468,$69732076,$65727369,$6F6E2066,$6F720A0D
	DC.L	$6F766572,$20322068,$6F757273,$2C20616E,$64207472,$69656420,$6C6F6164,$696E672F,$73617669,$6E670A0D,$616C6C20,$74686520,$66696C65,$7320616E,$64206974,$20736565,$6D732074
	DC.L	$6F206265,$204F4B20,$2121210A,$A0D5468,$69732076,$65727369,$6F6E2068,$61732061,$6C6C2063,$6865636B,$73756D73,$2072656D,$6F766564,$20210A0D,$2849206D,$69737365,$64206F6E
	DC.L	$65202121,$290A0A0D,$50726573,$7320616E,$79206B65,$7920746F,$20737461,$7274206C,$6F616469,$6E672E2E,$2E006B69
L0022	EQU	*-2
	DC.L	$636B322E,$636C6700
