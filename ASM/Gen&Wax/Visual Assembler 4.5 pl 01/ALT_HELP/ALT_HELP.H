/* Indice du ressource pour ALT_HELP */

#define FORM_DIALOG 0   /* Formulaire/Dialogue */
#define BTON_CANCEL 1   /* BUTTON dans l'arbre FORM_DIALOG */
#define FD_TEXT_SELECT_F 6   /* TEXT dans l'arbre FORM_DIALOG */
#define BTON_TWO_FILES 7   /* BUTTON dans l'arbre FORM_DIALOG */
#define FIELD_SCREEN_X 10  /* FTEXT dans l'arbre FORM_DIALOG */
#define FIELD_SCREEN_Y 11  /* FTEXT dans l'arbre FORM_DIALOG */
#define FIELD_SCREEN_NBP 13  /* FTEXT dans l'arbre FORM_DIALOG */
#define FIELD_GRAB_X 15  /* FTEXT dans l'arbre FORM_DIALOG */
#define FIELD_GRAB_Y 16  /* FTEXT dans l'arbre FORM_DIALOG */
#define FIELD_GRAB_W 18  /* FTEXT dans l'arbre FORM_DIALOG */
#define FIELD_GRAB_H 19  /* FTEXT dans l'arbre FORM_DIALOG */
#define BTON_QUIT_STAY 22  /* BUTTON dans l'arbre FORM_DIALOG */

#define ALERT_NO_ACC_RUN 0   /* Chaine d'alerte */

#define ALERT_NOT_INSTAL 1   /* Chaine d'alerte */

#define ALERT_ALREADY_IN 2   /* Chaine d'alerte */
