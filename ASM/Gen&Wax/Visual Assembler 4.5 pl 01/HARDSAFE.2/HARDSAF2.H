/* Indice du ressource pour HARDSAF2 */

#define FORM_MAIN 0   /* Formulaire/Dialogue */
#define TEXTE_TIMER 7   /* FTEXT dans l'arbre FORM_MAIN */
#define BTON_ACTIVE_TIME 8   /* BOXCHAR dans l'arbre FORM_MAIN */
#define BTON_PARK_REMOVB 9   /* BOXCHAR dans l'arbre FORM_MAIN */
#define BTON_PARK_NOW 13  /* BUTTON dans l'arbre FORM_MAIN */
#define BTON_CLOSE 15  /* BUTTON dans l'arbre FORM_MAIN */
#define BTON_APPLY_TIME 17  /* BUTTON dans l'arbre FORM_MAIN */

#define WIND_DIALOG_ICON 1   /* Formulaire/Dialogue */

#define ALERT_NO_XHDI 0   /* Chaine d'alerte */

#define ALERT_BAD_CMD_LN 1   /* Chaine d'alerte */

#define ALERT_BAD_VERSIO 2   /* Chaine d'alerte */
