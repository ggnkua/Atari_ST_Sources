/* Indices du fichier ressource pour DOTS */

#define MENU_PRINCIPAL   0   /* Menu */
#define MNU_DESK_INFO    7   /* STRING dans l'arbre MENU_PRINCIPAL */
#define MNU_FILE_OPEN    16  /* STRING dans l'arbre MENU_PRINCIPAL */
#define MNU_FILE_QUIT    17  /* STRING dans l'arbre MENU_PRINCIPAL */

#define FORM_BACKGROUND  1   /* Formulaire/Dialogue */

#define FORM_CHOIX_OBJ   2   /* Formulaire/Dialogue */
#define FCHX_RBTON_FTH   1   /* BOX dans l'arbre FORM_CHOIX_OBJ */
#define FCHX_RBTON_SPH   3   /* BOXTEXT dans l'arbre FORM_CHOIX_OBJ */
#define FCHX_RBTON_TORE  4   /* BOXTEXT dans l'arbre FORM_CHOIX_OBJ */
#define FCHX_BTON_OK     5   /* BUTTON dans l'arbre FORM_CHOIX_OBJ */
#define FCHX_BTON_CANCEL 7   /* BUTTON dans l'arbre FORM_CHOIX_OBJ */

#define FORM_INFORMATION 3   /* Formulaire/Dialogue */

#define ALERT_NOT_4_8BIT 0   /* Chaine d'alerte */

#define ALERT_DSP_LOCKED 1   /* Chaine d'alerte */

#define ALERT_NO_MEMORY  2   /* Chaine d'alerte */

#define ALERT_FILE       3   /* Chaine d'alerte */

#define ALERT_NOT_56001  4   /* Chaine d'alerte */
