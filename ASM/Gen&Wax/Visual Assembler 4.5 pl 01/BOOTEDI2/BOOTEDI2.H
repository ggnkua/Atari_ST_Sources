/* Indices du fichier ressource pour BOOTEDI2 */

#define MENU_PRINCIPAL   0   /* Menu */
#define INFO_MENU        9   /* STRING dans l'arbre MENU_PRINCIPAL */
#define ACTIONS_VALIDATE 18  /* STRING dans l'arbre MENU_PRINCIPAL */
#define ACTIONS_KILL     19  /* STRING dans l'arbre MENU_PRINCIPAL */
#define ACTIONS_UPDATE   21  /* STRING dans l'arbre MENU_PRINCIPAL */
#define ACTIONS_LOAD     22  /* STRING dans l'arbre MENU_PRINCIPAL */
#define ACTIONS_WORKINGD 24  /* STRING dans l'arbre MENU_PRINCIPAL */
#define ACTIONS_TESTVIR  26  /* STRING dans l'arbre MENU_PRINCIPAL */
#define ACTIONS_QUIT     28  /* STRING dans l'arbre MENU_PRINCIPAL */
#define DATA_INT_PREDEF  30  /* STRING dans l'arbre MENU_PRINCIPAL */
#define DATA_INT_FILE    32  /* STRING dans l'arbre MENU_PRINCIPAL */
#define DATA_ARCHIVE     33  /* STRING dans l'arbre MENU_PRINCIPAL */
#define SPECIAL_RANDOM   35  /* STRING dans l'arbre MENU_PRINCIPAL */
#define SPECIAL_DUMP     36  /* STRING dans l'arbre MENU_PRINCIPAL */
#define SPECIAL_DEFINE_O 37  /* STRING dans l'arbre MENU_PRINCIPAL */

#define READ_ERROR_BIOS  1   /* Formulaire/Dialogue */
#define RETRY_REB        3   /* BUTTON dans l'arbre READ_ERROR_BIOS */
#define STOP_REB         4   /* BUTTON dans l'arbre READ_ERROR_BIOS */

#define INFORMATIONS     2   /* Formulaire/Dialogue */

#define ASK_OFFSET       3   /* Formulaire/Dialogue */
#define ASK_OFFSET_NUM   3   /* FTEXT dans l'arbre ASK_OFFSET */

#define INTEGRATE_GUW    4   /* Formulaire/Dialogue */
#define INTEGRATE_GUW_TX 3   /* FTEXT dans l'arbre INTEGRATE_GUW */

#define ASK_CHECKSUM_OFF 5   /* Formulaire/Dialogue */
#define CHECKSUM_OFFSET  3   /* FTEXT dans l'arbre ASK_CHECKSUM_OFF */

#define ATTACHED_MENU    6   /* Formulaire/Dialogue */
#define MNU_ATCH_BS      1   /* BOX dans l'arbre ATTACHED_MENU */
#define INTEGRATE_PLASMA 2   /* STRING dans l'arbre ATTACHED_MENU */
#define DATA_INTEGRATEGW 3   /* STRING dans l'arbre ATTACHED_MENU */
#define INTEGRATE_UNIX   4   /* STRING dans l'arbre ATTACHED_MENU */
#define INTEGRATE_WAX    5   /* STRING dans l'arbre ATTACHED_MENU */
#define INTEGRATE_JEREMY 6   /* STRING dans l'arbre ATTACHED_MENU */
#define INTEGRATE_IBM    7   /* STRING dans l'arbre ATTACHED_MENU */
