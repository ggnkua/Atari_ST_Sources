/* Indice du ressource pour START */

#define MENU_PRINCIPAL 0   /* Arbre menu */
#define MNU_FONTES 5   /* TITLE dans l'arbre MENU_PRINCIPAL */
#define MNU_DESK_INFO 8   /* STRING dans l'arbre MENU_PRINCIPAL */
#define MNU_FILE_WIND1 17  /* STRING dans l'arbre MENU_PRINCIPAL */
#define MNU_FILE_WIND2 18  /* STRING dans l'arbre MENU_PRINCIPAL */
#define MNU_FILE_WIND3 19  /* STRING dans l'arbre MENU_PRINCIPAL */
#define MNU_FILE_WIND4 20  /* STRING dans l'arbre MENU_PRINCIPAL */
#define MNU_FILE_WIND5 21  /* STRING dans l'arbre MENU_PRINCIPAL */
#define MNU_FILE_WIND6 22  /* STRING dans l'arbre MENU_PRINCIPAL */
#define MNU_FILE_WIND7 23  /* STRING dans l'arbre MENU_PRINCIPAL */
#define MNU_FILE_WIND8 24  /* STRING dans l'arbre MENU_PRINCIPAL */
#define MNU_FILE_WIND9 25  /* STRING dans l'arbre MENU_PRINCIPAL */
#define MNU_FILE_OPEN_WI 26  /* STRING dans l'arbre MENU_PRINCIPAL */
#define MNU_FILE_QUIT 27  /* STRING dans l'arbre MENU_PRINCIPAL */
#define MNU_FONTES_BITMP 29  /* STRING dans l'arbre MENU_PRINCIPAL */
#define MNU_FONTES_SCALB 30  /* STRING dans l'arbre MENU_PRINCIPAL */
#define MNU_FONTES_FLYIG 31  /* STRING dans l'arbre MENU_PRINCIPAL */

#define FORM_BACKGROUND 1   /* Formulaire/Dialogue */
#define FORM_BACKGROUND0 0   /* BOX dans l'arbre FORM_BACKGROUND */
#define FORM_BACKGROUND1 1   /* BUTTON dans l'arbre FORM_BACKGROUND */

#define FORM_TOOLBAR1 2   /* Formulaire/Dialogue */
#define TLOBJ_1  4   /* IMAGE dans l'arbre FORM_TOOLBAR1 */
#define TLOBJ_2  5   /* IMAGE dans l'arbre FORM_TOOLBAR1 */
#define TLOBJ_3  6   /* IMAGE dans l'arbre FORM_TOOLBAR1 */
#define TLOBJ_4  7   /* IMAGE dans l'arbre FORM_TOOLBAR1 */
#define TLOBJ_TXT 31  /* BOXTEXT dans l'arbre FORM_TOOLBAR1 */

#define FORMULAIRE3 3   /* Formulaire/Dialogue */
#define TEXT_DESCRIPT 3   /* FTEXT dans l'arbre FORMULAIRE3 */
#define TEXT_DESCRIPT2 4   /* FTEXT dans l'arbre FORMULAIRE3 */
#define TEXT_BANAL 5   /* TEXT dans l'arbre FORMULAIRE3 */
#define RADIO_1  8   /* BOX dans l'arbre FORMULAIRE3 */
#define BTON_YES 9   /* BUTTON dans l'arbre FORMULAIRE3 */
#define BTON_NO  10  /* BUTTON dans l'arbre FORMULAIRE3 */
#define BTON_PERHAPS 11  /* BUTTON dans l'arbre FORMULAIRE3 */
#define BTON_OPTION1 12  /* BUTTON dans l'arbre FORMULAIRE3 */
#define BTON_OPTION2 13  /* BUTTON dans l'arbre FORMULAIRE3 */
#define POP_QUALITY3D 15  /* BOXTEXT dans l'arbre FORMULAIRE3 */
#define POP_QUALITY 16  /* BOXTEXT dans l'arbre FORMULAIRE3 */
#define BTON_DESC_OK 18  /* BUTTON dans l'arbre FORMULAIRE3 */
#define BTON_ANNULE_DESC 20  /* BUTTON dans l'arbre FORMULAIRE3 */

#define FORM_TOOLBAR2 4   /* Formulaire/Dialogue */

#define FORM_TOOLBAR3 5   /* Formulaire/Dialogue */

#define FORM_TOOLBOX 6   /* Formulaire/Dialogue */

#define ICONIFY_1 7   /* Formulaire/Dialogue */

#define POPUPS   8   /* Formulaire/Dialogue */
#define POPUP_QUALITY 1   /* BOX dans l'arbre POPUPS */
#define POPUP_90 2   /* STRING dans l'arbre POPUPS */
#define POPUP_70 3   /* STRING dans l'arbre POPUPS */
#define POPUP_50 4   /* STRING dans l'arbre POPUPS */
#define POPUP_30 5   /* STRING dans l'arbre POPUPS */
#define POPUP_10 6   /* STRING dans l'arbre POPUPS */
#define POPUP_1  7   /* STRING dans l'arbre POPUPS */
#define POPUP_100 8   /* STRING dans l'arbre POPUPS */
#define POPUP_QUALITY3D 9   /* BOX dans l'arbre POPUPS */
#define POPUP_1003D 16  /* STRING dans l'arbre POPUPS */

#define MENUS_ATTACHES 9   /* Formulaire/Dialogue */
#define MENU_PERE1 1   /* BOX dans l'arbre MENUS_ATTACHES */
#define OBJ_MENU_PERE1 4   /* STRING dans l'arbre MENUS_ATTACHES */
#define MENU_PERE2 9   /* BOX dans l'arbre MENUS_ATTACHES */
#define OBJ_MENU_PERE2 16  /* STRING dans l'arbre MENUS_ATTACHES */
#define MNU_FATHER_WINDO 17  /* BOX dans l'arbre MENUS_ATTACHES */
#define MNU_WINDOW1 18  /* STRING dans l'arbre MENUS_ATTACHES */
#define MNU_WINDOW2 19  /* STRING dans l'arbre MENUS_ATTACHES */
#define MNU_WINDOW3 20  /* STRING dans l'arbre MENUS_ATTACHES */
#define MNU_WINDOW4 21  /* STRING dans l'arbre MENUS_ATTACHES */
#define MNU_WINDOW6 22  /* STRING dans l'arbre MENUS_ATTACHES */
#define MNU_WINDOW5 23  /* STRING dans l'arbre MENUS_ATTACHES */
#define MNU_WINDOW7 24  /* STRING dans l'arbre MENUS_ATTACHES */
#define MNU_WINDOW9 25  /* STRING dans l'arbre MENUS_ATTACHES */
#define MNU_WINDOW8 26  /* STRING dans l'arbre MENUS_ATTACHES */

#define FORM_GENERAL 10  /* Formulaire/Dialogue */
#define REDRAW_LVL1 1   /* BOX dans l'arbre FORM_GENERAL */
#define FGO_EDIT_TIMER 4   /* FTEXT dans l'arbre FORM_GENERAL */
#define FGO_RADIO_INIT_S 5   /* IBOX dans l'arbre FORM_GENERAL */
#define FGO_BTON_INIT_Y 6   /* BUTTON dans l'arbre FORM_GENERAL */
#define FGO_BTON_INIT_N 7   /* BUTTON dans l'arbre FORM_GENERAL */
#define FGO_BTON_INIT_A 8   /* BUTTON dans l'arbre FORM_GENERAL */
#define FGO_BTON_AUTO_SA 9   /* BOXCHAR dans l'arbre FORM_GENERAL */
#define FGO_TEXT_VOXPATH 12  /* TEXT dans l'arbre FORM_GENERAL */
#define FGO_TEXT_LOGPATH 13  /* TEXT dans l'arbre FORM_GENERAL */
#define FGO_TEXT_VOXCMD 15  /* TEXT dans l'arbre FORM_GENERAL */
#define FGO_BTON_LOG_ACT 16  /* BOXCHAR dans l'arbre FORM_GENERAL */
#define FGO_TEXT_SFAXPAT 19  /* TEXT dans l'arbre FORM_GENERAL */
#define FGO_TEXT_SFAXCMD 20  /* TEXT dans l'arbre FORM_GENERAL */
#define FGO_EDIT_FAX_ID 22  /* FTEXT dans l'arbre FORM_GENERAL */
#define FGO_BTON_OK 23  /* BUTTON dans l'arbre FORM_GENERAL */
#define FGO_BTON_SAVE 25  /* BUTTON dans l'arbre FORM_GENERAL */

#define ALERT1   0   /* Chaine d'alerte */

#define CAUTION  1   /* Chaine d'alerte */
