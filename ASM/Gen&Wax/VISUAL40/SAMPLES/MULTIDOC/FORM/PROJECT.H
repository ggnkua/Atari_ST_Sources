/* Indice du ressource pour PROJECT */

#define MENU_PRINCIPAL 0   /* Arbre menu */
#define MNU_DESK_INFO 7   /* STRING dans l'arbre MENU_PRINCIPAL */
#define MNU_FILE_OPEN1 16  /* STRING dans l'arbre MENU_PRINCIPAL */
#define MNU_FILE_OPEN2 17  /* STRING dans l'arbre MENU_PRINCIPAL */
#define MNU_FILE_QUIT 18  /* STRING dans l'arbre MENU_PRINCIPAL */

#define FORM_INFORMATION 1   /* Formulaire/Dialogue */

#define FORM_BACKGROUND 2   /* Formulaire/Dialogue */

#define FORM_GENERATION1 3   /* Formulaire/Dialogue */
#define TXT_CS_DATA_FILE 4   /* TEXT dans l'arbre FORM_GENERATION1 */
#define TXT_CS_DATA_MASK 7   /* TEXT dans l'arbre FORM_GENERATION1 */
#define TXT_CUT_LENGTH 10  /* FTEXT dans l'arbre FORM_GENERATION1 */
#define BTON_SCOTCH_FILE 16  /* BUTTON dans l'arbre FORM_GENERATION1 */
#define BTON_CUT_FILE 18  /* BUTTON dans l'arbre FORM_GENERATION1 */

#define FORM_GENERATION2 4   /* Formulaire/Dialogue */

#define ALERT1   0   /* Chaine d'alerte */
