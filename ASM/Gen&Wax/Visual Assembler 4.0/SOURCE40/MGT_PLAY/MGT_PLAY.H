/* Indice du ressource pour MGT_PLAY */

#define MENU_PRINCIPAL 0   /* Arbre menu */
#define MNU_DESK_INFO 7   /* STRING dans l'arbre MENU_PRINCIPAL */
#define MNU_FILE_LOAD 16  /* STRING dans l'arbre MENU_PRINCIPAL */
#define MNU_FILE_STOP 17  /* STRING dans l'arbre MENU_PRINCIPAL */
#define MNU_FILE_QUIT 19  /* STRING dans l'arbre MENU_PRINCIPAL */

#define FORM_BACKGROUND 1   /* Formulaire/Dialogue */

#define MGT_TOOLBOX 2   /* Formulaire/Dialogue */
#define BTON_EJECT 1   /* USERDEF dans l'arbre MGT_TOOLBOX */
#define BTON_PLAY 2   /* USERDEF dans l'arbre MGT_TOOLBOX */
#define BTON_PAUSE 3   /* USERDEF dans l'arbre MGT_TOOLBOX */
#define BTON_STOP 4   /* USERDEF dans l'arbre MGT_TOOLBOX */
#define BTON_PREV_TRACK 5   /* USERDEF dans l'arbre MGT_TOOLBOX */
#define BTON_PREV_TIME 6   /* USERDEF dans l'arbre MGT_TOOLBOX */
#define BTON_NEXT_TIME 7   /* USERDEF dans l'arbre MGT_TOOLBOX */
#define BTON_NEXT_TRACK 8   /* USERDEF dans l'arbre MGT_TOOLBOX */
#define TEXT_TIME 9   /* TEXT dans l'arbre MGT_TOOLBOX */

#define FORM_INFORMATION 3   /* Formulaire/Dialogue */
#define REGISTRED_USR_NM 6   /* TEXT dans l'arbre FORM_INFORMATION */

#define ALERT1   0   /* Chaine d'alerte */
