/* Indice du ressource pour PROJECT */

#define ALERT1   0   /* Chaine d'alerte */

#define ALERT2   1   /* Chaine d'alerte */

#define ALERT_NO_APP_RUN 2   /* Chaine d'alerte */

#define ALERT_VA_COPYRIG 3   /* Chaine d'alerte */
