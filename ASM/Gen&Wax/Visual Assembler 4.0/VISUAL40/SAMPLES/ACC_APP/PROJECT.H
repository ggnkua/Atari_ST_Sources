/* Indice du ressource pour PROJECT */

#define MENU_PRINCIPAL 0   /* Arbre menu */
#define MNU_DESK_INFO 7   /* STRING dans l'arbre MENU_PRINCIPAL */
#define MNU_FILE_OPEN 16  /* STRING dans l'arbre MENU_PRINCIPAL */
#define MNU_FILE_QUIT 17  /* STRING dans l'arbre MENU_PRINCIPAL */

#define FORM_INFORMATION 1   /* Formulaire/Dialogue */

#define FORM_BACKGROUND 2   /* Formulaire/Dialogue */

#define ALERT1   0   /* Chaine d'alerte */
