/* Indice du ressource pour SAMPLE */

#define MENU_PRINCIPAL 0   /* Arbre menu */

#define TRIDI    1   /* Formulaire/Dialogue */

#define BUTONS   2   /* Formulaire/Dialogue */
#define FGO_RADIO_INIT_S 1   /* IBOX dans l'arbre BUTONS */
#define FGO_BTON_INIT_Y 2   /* BUTTON dans l'arbre BUTONS */
#define FGO_BTON_INIT_N 3   /* BUTTON dans l'arbre BUTONS */
#define FGO_BTON_INIT_A 4   /* BUTTON dans l'arbre BUTONS */
#define FGO_BTON_AUTO_SA 5   /* BOXCHAR dans l'arbre BUTONS */
#define FGO_BTON_OK 6   /* BUTTON dans l'arbre BUTONS */
#define FGO_BTON_LOAD 8   /* BUTTON dans l'arbre BUTONS */
#define FMS_OK   10  /* BUTTON dans l'arbre BUTONS */
#define FMS_CANCEL 11  /* BUTTON dans l'arbre BUTONS */

#define TEXTS    3   /* Formulaire/Dialogue */
#define FGO_TEXT_BBSPATH 3   /* TEXT dans l'arbre TEXTS */
#define FSXY_TEXT_WIDTH 6   /* FBOXTEXT dans l'arbre TEXTS */
#define FSO_CPOP_FLOW 7   /* BOXTEXT dans l'arbre TEXTS */

#define POPUPS   4   /* Formulaire/Dialogue */
#define POPUP_HANDSHAKE 1   /* BOX dans l'arbre POPUPS */
#define SPOP_RTSCTS 2   /* STRING dans l'arbre POPUPS */
#define SPOP_XONXOFF 3   /* STRING dans l'arbre POPUPS */
#define SPOP_BOTH 4   /* STRING dans l'arbre POPUPS */

#define DRAW     5   /* Formulaire/Dialogue */

#define ALERTE   0   /* Chaine d'alerte */
