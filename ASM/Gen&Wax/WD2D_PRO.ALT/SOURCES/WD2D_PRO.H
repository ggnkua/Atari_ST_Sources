/* Indice du ressource pour WD2D_PRO */

#define MENU_PRINCIPAL 0   /* Arbre menu */
#define SPECIAL  8   /* TITLE dans l'arbre MENU_PRINCIPAL */
#define INFO_MENU 11  /* STRING dans l'arbre MENU_PRINCIPAL */
#define FILES_LOAD 20  /* STRING dans l'arbre MENU_PRINCIPAL */
#define FILES_INFO 21  /* STRING dans l'arbre MENU_PRINCIPAL */
#define FILES_LOOP 23  /* STRING dans l'arbre MENU_PRINCIPAL */
#define FILES_STOP 25  /* STRING dans l'arbre MENU_PRINCIPAL */
#define FILES_QUIT 27  /* STRING dans l'arbre MENU_PRINCIPAL */
#define FREQUENCY_1 29  /* STRING dans l'arbre MENU_PRINCIPAL */
#define FREQUENCY_2 30  /* STRING dans l'arbre MENU_PRINCIPAL */
#define FREQUENCY_3 31  /* STRING dans l'arbre MENU_PRINCIPAL */
#define FREQUENCY_4 32  /* STRING dans l'arbre MENU_PRINCIPAL */
#define FREQUENCY_5 33  /* STRING dans l'arbre MENU_PRINCIPAL */
#define FREQUENCY_6 34  /* STRING dans l'arbre MENU_PRINCIPAL */
#define FREQUENCY_7 35  /* STRING dans l'arbre MENU_PRINCIPAL */
#define FREQUENCY_8 36  /* STRING dans l'arbre MENU_PRINCIPAL */
#define FREQUENCY_9 38  /* STRING dans l'arbre MENU_PRINCIPAL */
#define FREQUENCY_0 39  /* STRING dans l'arbre MENU_PRINCIPAL */
#define METHOD_1 41  /* STRING dans l'arbre MENU_PRINCIPAL */
#define METHOD_2 42  /* STRING dans l'arbre MENU_PRINCIPAL */
#define METHOD_3 43  /* STRING dans l'arbre MENU_PRINCIPAL */
#define METHOD_4 45  /* STRING dans l'arbre MENU_PRINCIPAL */
#define SET_PARAMETER 46  /* STRING dans l'arbre MENU_PRINCIPAL */
#define CONVERSION_1 48  /* STRING dans l'arbre MENU_PRINCIPAL */
#define CONVERSION_2 49  /* STRING dans l'arbre MENU_PRINCIPAL */
#define CONVERSION_3 50  /* STRING dans l'arbre MENU_PRINCIPAL */
#define CONVERSION_4 52  /* STRING dans l'arbre MENU_PRINCIPAL */
#define CONVERSION_5 53  /* STRING dans l'arbre MENU_PRINCIPAL */
#define CONVERSION_6 54  /* STRING dans l'arbre MENU_PRINCIPAL */
#define CONVERSION_7 55  /* STRING dans l'arbre MENU_PRINCIPAL */
#define CONVERSION_8 57  /* STRING dans l'arbre MENU_PRINCIPAL */
#define SPECIAL_ANALYSE 59  /* STRING dans l'arbre MENU_PRINCIPAL */
#define SPECIAL_DISTORS 60  /* STRING dans l'arbre MENU_PRINCIPAL */

#define FORM_INFOS 1   /* Formulaire/Dialogue */

#define ANALYSE  2   /* Formulaire/Dialogue */
#define ABS_MAX_DELTA 3   /* TEXT dans l'arbre ANALYSE */
#define ABS_MIN_DELTA 5   /* TEXT dans l'arbre ANALYSE */
#define AVERAGE_DELTA 8   /* TEXT dans l'arbre ANALYSE */
#define DELTA_VARIANCE 9   /* TEXT dans l'arbre ANALYSE */
#define MORE     11  /* BUTTON dans l'arbre ANALYSE */
#define THANX    12  /* BUTTON dans l'arbre ANALYSE */

#define DISTORSION 3   /* Formulaire/Dialogue */
#define DIST_PER_MILE 3   /* TEXT dans l'arbre DISTORSION */
#define DMORE    5   /* BUTTON dans l'arbre DISTORSION */
#define DTHANX   6   /* BUTTON dans l'arbre DISTORSION */

#define SOUND_SEMAPHORE 4   /* Formulaire/Dialogue */

#define INFO_ON_FILE 5   /* Formulaire/Dialogue */
#define LENGTH_PACK_CODE 3   /* TEXT dans l'arbre INFO_ON_FILE */
#define TYPE_OF_SOUND 6   /* TEXT dans l'arbre INFO_ON_FILE */
#define PACKED_YES_NO 8   /* TEXT dans l'arbre INFO_ON_FILE */
#define MINUTES  10  /* TEXT dans l'arbre INFO_ON_FILE */
#define SECONDS  11  /* TEXT dans l'arbre INFO_ON_FILE */
#define FREQUENZ 13  /* TEXT dans l'arbre INFO_ON_FILE */
#define ADD_PACKT_YES_NO 15  /* TEXT dans l'arbre INFO_ON_FILE */
#define INFO_TITLE 17  /* TEXT dans l'arbre INFO_ON_FILE */
#define INFO_AUTHOR 19  /* TEXT dans l'arbre INFO_ON_FILE */

#define ASK_MILISECONDS 6   /* Formulaire/Dialogue */
#define VALUE_IN_MS 4   /* FTEXT dans l'arbre ASK_MILISECONDS */

#define MEMORY_PROBLEM 7   /* Formulaire/Dialogue */

#define BAD_DVS_HEADER 8   /* Formulaire/Dialogue */

#define DESCRIPTION 9   /* Formulaire/Dialogue */

#define ASK_TITLE_NAME 10  /* Formulaire/Dialogue */
#define ASKED_TITLE 4   /* FTEXT dans l'arbre ASK_TITLE_NAME */
#define ASKED_AUTHOR 6   /* FTEXT dans l'arbre ASK_TITLE_NAME */
