/* Indice du ressource pour HARDSAF2 */

#define FORM_MAIN 0   /* Formulaire/Dialogue */
#define BTON_PARK_NOW 4   /* BUTTON dans l'arbre FORM_MAIN */
#define BTON_CLOSE 6   /* BUTTON dans l'arbre FORM_MAIN */
#define TEXTE_TIMER 11  /* FTEXT dans l'arbre FORM_MAIN */
#define BTON_ACTIVE_TIME 12  /* BOXCHAR dans l'arbre FORM_MAIN */
#define BTON_PARK_REMOVB 13  /* BOXCHAR dans l'arbre FORM_MAIN */
#define BTON_APPLY_TIME 15  /* BUTTON dans l'arbre FORM_MAIN */

#define ALERT_NO_XHDI 0   /* Chaine d'alerte */

#define ALERT_BAD_CMD_LN 1   /* Chaine d'alerte */

#define ALERT_BAD_VERSIO 2   /* Chaine d'alerte */
