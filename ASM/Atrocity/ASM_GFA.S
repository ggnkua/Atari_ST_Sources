***************************
*** MULTI-CONVERT ASCII ***
***   (C) 1994 , ZANAK  ***
***       ATROCITY      ***
***************************

; RECUPERATION DES DONNEES
; ADRESSE DE DEPART

	LEA	ADR(PC),A0
	MOVE.L	4(SP),(A0)
; TAILLE DU FICHIER
	LEA	SIZE(PC),A0
	MOVE.L	8(SP),(A0)
; NOMBRE DE CARACTERE A ENLEVER
	LEA	NBR(PC),A0
	MOVE.L	12(SP),(A0)
		
SUPER	CLR.L	-(SP)
	MOVE.W	#$20,-(SP)
	TRAP	#1
	ADDQ.L	#6,SP
	MOVE.L	D0,-(SP)

CONVERT	MOVE.L	SIZE(PC),D1
	MOVE.L	ADR(PC),A0
	MOVE.L	ADR(PC),A1
	ADD.L	NBR(PC),A1
CONVERT2	MOVE.B	(A1)+,(A0)+
	DBF	D1,CONVERT2
	
	MOVE.L	NBR(PC),D1
CONVERT3	CLR.B	(A0)+
	DBF	D1,CONVERT3

EXIT	MOVE.W	#$20,-(SP)
	TRAP	#1
	ADDQ.L	#6,SP
		
	RTS
			
ADR	DC.L	0
SIZE	DC.L	0
NBR	DC.L	0