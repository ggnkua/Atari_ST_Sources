 TEXT 
Begin:
      BRA.S     L0000 
      ADDQ.W    #2,(A0) 
      SUBQ.W    #3,A5 
      MOVE.L    (A0),-(A5)
L0000:LEA       L0005(PC),A1
      MOVE.L    A0,(A1) 
      MOVEA.L   A0,A3 
      BNE.S     L0001 
      MOVEA.L   4(A7),A3
L0001:MOVEA.L   8(A3),A2
      SUBA.W    #$1C,A2 
      MOVE.L    L0012(PC),D1
      MOVEA.L   A2,A6 
      ADDA.L    D1,A6 
      MOVE.L    A6,D1 
      ADD.L     #$8000,D1 
      ADDQ.L    #1,D1 
      BCLR      #0,D1 
      MOVEA.L   D1,A1 
      MOVEA.L   16(A3),A0 
      MOVE.L    20(A3),D0 
      ADD.L     #$1F,D0 
      AND.B     #-$20,D0
      ADDA.L    D0,A0 
      LSR.L     #5,D0 
L0002:SUBQ.L    #1,D0 
      BMI.S     L0004 
L0003:SUBA.W    #$20,A0 
      MOVEM.L   (A0),A4-A5/D2-D7
      MOVEM.L   A4-A5/D2-D7,-(A1) 
      DBF       D0,L0003
      ADDQ.W    #1,D0 
      BRA.S     L0002 
L0004:MOVE.L    #0,D6 
L0005 EQU       *-4 
      MOVEA.L   A2,A4 
      LEA       L0007(PC),A0
      MOVEA.L   D1,A5 
      MOVE.W    #$62,D0 
L0006:MOVE.W    (A0)+,(A5)+ 
      DBF       D0,L0006
      MOVEA.L   D1,A5 
      JMP       (A5)
L0007:MOVE.B    (A1)+,D2
      MOVEQ     #7,D3 
L0008:ADD.B     D2,D2 
      BCC.S     L000B 
      MOVE.B    (A1)+,D4
      CLR.W     D5
      MOVE.B    D4,D5 
      LSL.W     #4,D5 
      MOVE.B    (A1)+,D5
      MOVEA.L   A4,A5 
      SUBA.W    D5,A5 
      ANDI.W    #$F,D4
      ADD.W     D4,D4 
      NEG.W     D4
      JMP       L0009(PC,D4.W)
      MOVE.B    (A5)+,(A4)+ 
      MOVE.B    (A5)+,(A4)+ 
      MOVE.B    (A5)+,(A4)+ 
      MOVE.B    (A5)+,(A4)+ 
      MOVE.B    (A5)+,(A4)+ 
      MOVE.B    (A5)+,(A4)+ 
      MOVE.B    (A5)+,(A4)+ 
      MOVE.B    (A5)+,(A4)+ 
      MOVE.B    (A5)+,(A4)+ 
      MOVE.B    (A5)+,(A4)+ 
      MOVE.B    (A5)+,(A4)+ 
      MOVE.B    (A5)+,(A4)+ 
      MOVE.B    (A5)+,(A4)+ 
      MOVE.B    (A5)+,(A4)+ 
      MOVE.B    (A5)+,(A4)+ 
L0009:MOVE.B    (A5)+,(A4)+ 
      MOVE.B    (A5)+,(A4)+ 
      MOVE.B    (A5)+,(A4)+ 
      CMPA.L    A4,A1 
      BGE.S     L000C 
L000A:BRA.S     L000A 
L000B:MOVE.B    (A1)+,(A4)+ 
L000C:CMPA.L    A4,A6 
      DBLS      D3,L0008
      BHI.S     L0007 
      LEA       2(A2),A4
      ADDQ.L    #8,A3 
      MOVEA.L   (A3)+,A1
      MOVEA.L   A1,A0 
      MOVE.L    (A4)+,D1
      MOVE.L    D1,(A3)+
      ADDA.L    D1,A1 
      MOVE.L    A1,(A3)+
      MOVE.L    (A4)+,D1
      MOVE.L    D1,(A3)+
      ADDA.L    D1,A1 
      MOVE.L    A1,(A3)+
      MOVE.L    (A4)+,D0
      MOVE.L    D0,(A3)+
      MOVE.W    26(A2),D0 
      MOVEQ     #6,D1 
L000D:CLR.L     (A2)+ 
      DBF       D1,L000D
      MOVE.L    A0,D1 
      TST.W     D0
      BNE.S     L0010 
      MOVEA.L   A1,A2 
      MOVE.L    (A2)+,D2
      BEQ.S     L0010 
L000E:ADDA.L    D2,A0 
      MOVEQ     #0,D2 
      ADD.L     D1,(A0) 
L000F:MOVE.B    (A2)+,D2
      BEQ.S     L0010 
      CMPI.W    #1,D2 
      BNE.S     L000E 
      LEA       254(A0),A0
      BRA.S     L000F 
L0010:MOVEA.L   D1,A0 
      LEA       L0011(PC),A2
      LEA       -8(A0),A3 
      MOVE.L    (A2)+,(A3)
      MOVE.L    (A2)+,4(A3) 
      LEA       L0013(PC),A2
      MOVEA.L   D6,A0 
      JMP       (A3)
L0011:DC.B      'B',$99,$B3,$CA,'m',$FA,'Nq'
L0012:DC.B      $00,$00,'}',$9D 
 DATA 
L0013:DC.B      $01,'`',$1A,$00,$00,'}2',$00
      DC.B      $01,$01,$18,'"M@',$02,$08 
      DC.B      $06,$05,'B',$A7,'?',$00,'<',$00 
      DC.B      ' NA\',$8F,$A0,'@',$0A
      DC.B      $00,$0A,$03,'NNT',$8F,'#' 
      DC.B      $00,$C0,$00,$00,$05,$8C,'?<'
      DC.B      $FF,'@',$FF,$00,$1C,'XNN' 
      DC.B      'X',$8F,'3',$80,$01,$12,$86,' ' 
      DC.B      ':',$05,'f2<',$00,$01,'4' 
      DC.B      'a',$00,$00,$84,'B',$B8,$00,$98 
      DC.B      $00,' <',$00,$00,$F9,$FF,$00
      DC.B      ' z',$05,'PB',$98,'S',$80 
      DC.B      $02,'j',$FA,'#',$F8,$01,$18,$00 
      DC.B      'f',$DC,$08,'#',$F8,$00,'p',$00 
      DC.B      'B',$88,'!',$FC,$80,$00,'t',$E0 
      DC.B      $00,'p3',$FC,$FF,$FF,$02,$00
      DC.B      $00,$02,'(Jy',$01,$06,'f' 
      DC.B      $10,$00,$FF,$F8,$0F,$12,'a',$00 
      DC.B      $01,$A4,$00,$0C,'8',$00,'9',$FC 
      DC.B      $02,'f',$D0,$00,'@',$E7,'F',$FC 
      DC.B      $27,$00,'#',$FA,' ',$04,$EC,$00 
      DC.B      $B4,'p!',$FA,$00,'8',$00,$01
      DC.B      $18,'F',$DF,' :',$04,$E0,$00
      DC.B      '2:',$04,$D6,'a',$06,$A0,$09
      DC.B      $02,'BgNA?',$01,$01 
      DC.B      $B0,'/',$11,$00,'/',$00,$00,$C2 
      DC.B      $05,'NN',$00,$C8,$00,'%N' 
      DC.B      'NO',$EF,$00,$10,'N',$01,'u'
      DC.B      'F',$FC,'%',$00,'N',$F9,$01,$F2 
      DC.B      ' F9',$00,'z,g',$00 
      DC.B      $01,'8',$00,$02,'y',$00,$03,$00 
      DC.B      $00,$09,$80,$00,'f',$00,$00,'h' 
      DC.B      $04,'y',$00,$06,$A0,$00,$0C,$88 
      DC.B      $01,$92,$09,$88,'j',$00,$00,$06 
      DC.B      $0A,$06,'y',$1C,' ',$01,$12,$04 
      DC.B      $1A,$8A,$AA,$02,$1A,$8A,$08,$1A 
      DC.B      $8A,$04,'4',$8C,$02,'4',$8C,$81 
      DC.B      $08,'4',$8C,$0C,$B9,$00,$03,$E8 
      DC.B      $10,'_',$01,$05,$98,'m',$00,$00 
      DC.B      $0C,$04,$06,$0E,$07,$06,$B9,$00 
      DC.B      $00,$14,$02,$18,$0F,'"',$03,'0' 
      DC.B      $01,' |',$00,$03,$8A,'r0' 
      DC.B      $00,$A4,$04,$09,$80,'S@k' 
      DC.B      $00,'>',$D1,$FC,$81,$01,'LQ'
      DC.B      $C8,$FF,$F8,'#',$C8,$00,$AE,'%' 
      DC.B      $82,'#',$00,$C6,$05,$94,$10,$90 
      DC.B      $90,$01,$0A,'(',$09,$82,$01,$0E 
      DC.B      ' ',$00,$D4,$05,$98,$D1,$94,$00 
      DC.B      '^',$05,$94,$12,'T*',$00,$D4
      DC.B      $06,'`',$A1,$10,'cF',$02,$0E
      DC.B      $06,'y',$00,$02,$00,$EA,$06,$86 
      DC.B      $0C,'y',$02,$D0,$01,$08,$00,$96 
      DC.B      $0A,'R',$04,$04,$0C,'A',$01,'F' 
      DC.B      $90,$D0,$01,'L',$86,$08,'t',$00 
      DC.B      '4',$10,$02,'L',$94,$06,$80,$00 
      DC.B      $00,$00,$19,$00,$D0,$82,'"',$00 
      DC.B      $02,$E0,$89,$11,$C1,$82,$03,$02 
      DC.B      $06,$01,$04,$11,$C0,$82,$0D,'B' 
      DC.B      $12,$B4,'Ns',$EF,'#6',$00 
      DC.B      'Z',$12,'&',$0C,$14,'.',$03,'Z' 
      DC.B      $13,':',$04,$1C,'U',$8A,$04,$1C 
      DC.B      $8A,$08,$1C,$8A,$04,'8',$8C,$04 
      DC.B      '8U',$8C,$08,'8',$8C,$04,'T'
      DC.B      $8E,$04,'T',$8E,$08,'T"Ž' 
      DC.B      'E',$10,$C4,$0C,'b',$D4,$01,$FA 
      DC.B      $88,'DG',$10,$D0,'(',$96,$D6
      DC.B      $11,$06,$8A,'I',$89,$10,$DC,'D' 
      DC.B      $CA,$D8,$11,$12,$8C,'K',$10,$E8 
      DC.B      $14,'`',$FE,$DA,$11,$1E,$8E,$03 
      DC.B      $CE,'"',$00,' ',$06,$81,$11,$92 
      DC.B      '!',$C0,$8A,'2',$11,$80,' ',$84 
      DC.B      $8A,';B8',$8A,'=!',$82
      DC.B      ' ',$86,$FF,$FF,$8A,'(1 ' 
      DC.B      $8E,$8A,$01,',1',$FC,$00,$02
      DC.B      $8A,'.',$00,$06,$00,$00,$8A,'0' 
      DC.B      '1',$FC,$0A,$00,$8A,'D6',$00
      DC.B      $12,$01,$8A,'8',$00,'0',$C0,$8A 
      DC.B      $1C,'<!',$C1,$0F,':',$0F,':'
      DC.B      $0F,':',$8A,'<',$08,'$',$00,'&' 
      DC.B      $01,$00,'t',$02,$8A,':',$BA,$00 
      DC.B      'z',$03,$0F,'z',$0D,'z',$00,$86 
      DC.B      ' ',$02,$86,'"',$04,'><',$00
      DC.B      $07,'(0R',$08,$88,$00,' ' 
      DC.B      'B',$D0,$D2,'!',$C4,$8A,'$',$0A 
      DC.B      '!',$C8,$8A,'2',$00,$A8,'|',$0B 
      DC.B      $9C,' `C',$0F,$1E,$07,$BA 
      DC.B      'E',$EA,$00,$04,$06,$84,' &'
      DC.B      $02,$80,$06,$83,$01,$06,'Q',$CF 
      DC.B      '9',$FF,$AC,$04,$94,$00,$8E,$05 
      DC.B      'd',$06,$98,$00,'dy',$D3,$0F
      DC.B      'd',$08,'d',$0F,$1E,$16,$1E,'G' 
      DC.B      $EB,$0F,'d',$A5,$04,$F8,$07,$07 
      DC.B      'd',$07,$90,$00,$C8,$D4,$0F,$C8 
      DC.B      $E6,$08,$C8,$0F,$1E,$16,$82,'I' 
      DC.B      $EC,$0F,$C8,$0F,'d',$05,'_',$A0 
      DC.B      $10,',',$D5,$1F,',',$18,',',$0F 
      DC.B      $1E,$0F,'d',$18,',',$00,'Nu'
      DC.B      'p',$00,$10,'8',$82,$05,'"',$E1 
      DC.B      'H',$00,$06,$07,$E1,$88,$00,$0C 
      DC.B      $09,$03,' @r',$FF,'0',$C1 
      DC.B      $0F,$02,$0F,$14,$00,'0',$C1,'2' 
      DC.B      '<',$00,$1E,'Q',$C9,'.',$FF,$FE 
      DC.B      $00,'4',$00,$0F,'4',$0F,'F',$01 
      DC.B      'XNzuT”@',$0C 
      DC.B      $06,$04,'X',$A7,$08,$00,$02,$10 
      DC.B      $AA,$00,$02,$18,$00,$02,' 0'
      DC.B      '�(',$00,$02,'0',$AA,$00,$02
      DC.B      '8',$00,$02,'@',$00,$02,'H',$00 
      DC.B      $02,'P',$AA,$00,$02,'X',$00,$02 
      DC.B      '`',$00,$02,'h',$00,$02,'p',$AA 
      DC.B      'P',$83,'x',$00,$02,$80,$00,$02 
      DC.B      $88,$00,$02,$90,$AA,$00,$02,$98 
      DC.B      $00,$02,$A0,$00,$02,$A8,$00,$02 
      DC.B      $B0,$AA,$00,$02,$B8,$00,$02,$C0 
      DC.B      $00,$02,$C8,$00,$02,$D0,$AA,$00 
      DC.B      $02,$D8,$00,$02,$E0,'P',$B1,$E8 
      DC.B      $00,$02,$F0,$BF,$00,$02,$F8,$00 
      DC.B      $02,$01,$08,$01,$10,$01,$18,$01 
      DC.B      ' ',$01,'(',$FF,$01,'0',$01,'8' 
      DC.B      $01,'@',$01,'H',$01,'P',$01,'X' 
      DC.B      $01,'`',$01,'h',$FF,$01,'p',$01 
      DC.B      'x',$01,$80,$01,$88,$01,$90,$01 
      DC.B      $98,$01,$A0,$01,$A8,$FF,$01,$B0 
      DC.B      $01,$B8,$01,$C0,$01,$C8,$01,$D0 
      DC.B      $01,$D8,$01,$E0,$01,$E8,$F9,$01 
      DC.B      $F0,'b',$AE,$01,$DD,$01,$C1,$00 
      DC.B      $A5,$01,$00,$00,$02,'P@',$00
      DC.B      $02,$80,$00,$02,$C0,$01,$C0,$02 
      DC.B      $94,'@',$E3,$02,'@',$00,$02,$80 
      DC.B      $00,$02,$C0,$02,'%',$C0,$03,'P' 
      DC.B      $DD,$03,'@',$00,$02,$80,$00,$02 
      DC.B      $05,$C0,$03,$C0,$04,$00,$00,$02 
      DC.B      '@',$00,$02,'A',$80,$00,$02,$C0 
      DC.B      $04,$C0,$05,$00,$00,$02,'P@'
      DC.B      $00,$02,$80,$00,$02,$C0,$05,$C0 
      DC.B      $06,$94,'`',$01,$06,'@',$00,$02 
      DC.B      $80,$00,$02,$C0,$06,$15,$C0,$07 
      DC.B      $00,$00,$02,'@',$00,$02,$80,$00 
      DC.B      $02,$7F,$C0,$00,$02,$01,$08,$01 
      DC.B      $10,$00,$18,$01,' ',$02,'(',$01 
      DC.B      '0',$FF,'`9',$01,'@',$02,'H'
      DC.B      $01,'P',$00,'X',$01,'`',$02,'h' 
      DC.B      $01,'p',$FF,$00,'x',$01,$80,$02 
      DC.B      $88,$01,$90,'`u',$01,$A0,$02
      DC.B      $A8,$01,$B0,$FF,'P',$9B,$01,$C0 
      DC.B      $02,$C8,$01,$D0,$00,$D8,$12,$85 
      DC.B      $11,$A9,$11,$CD,$FF,'q',$A7,$01 
      DC.B      $ED,$01,$E1,$01,$D5,$01,$C9,$01 
      DC.B      $BD,$01,$B1,$01,$A5,$AA,'!',$0D 
      DC.B      $09,$00,$02,$0A,$00,$02,$0B,$00 
      DC.B      $02,$0C,$AB,$00,$02,$0D,$00,$02 
      DC.B      $0E,$00,$02,$0F,$00,$02,'!)'
      DC.B      'U',$11,$00,$02,$12,$00,$02,$13 
      DC.B      $00,$02,$14,'`',$83,'V',$15,$00 
      DC.B      $02,$16,$00,$02,$17,$00,$02,'!' 
      DC.B      'E',$19,$AA,'P',$ED,$1A,$00,$02 
      DC.B      $1B,$00,$02,$1C,$00,$02,$1D,$AF 
      DC.B      $00,$02,$1E,$00,$02,$1F,$00,$02 
      DC.B      $01,$08,$01,$10,$01,$18,$FF,$01 
      DC.B      ' ',$01,'(',$01,'0!}',$01 
      DC.B      '@',$01,'H',$01,'P',$01,'X',$FF 
      DC.B      $01,'`',$01,'h',$01,'p!',$A1
      DC.B      $01,$80,$01,$88,$01,$90,$01,$98 
      DC.B      $FF,$01,$A0,$01,$A8,$01,$B0,'!' 
      DC.B      $C5,$12,'M',$11,'A',$11,'5',$11 
      DC.B      ')',$F0,$11,$1D,$11,$11,$11,$05 
      DC.B      '@',$FA,'A',$08,'A',$10,$00,$82 
      DC.B      $10,$82,$18,$C3,$18,$C3,'!',$00 
      DC.B      $04,'!',$04,')E)E1' 
      DC.B      $00,$86,'1',$86,'9',$C7,'9',$C7 
      DC.B      'B',$00,$08,'B',$08,'JIJ' 
      DC.B      'IR',$00,$8A,'R',$8A,'Z',$CB
      DC.B      'Z',$CB,'c',$00,$0C,'c',$0C,'k' 
      DC.B      'MkMs',$00,'ŽsŽ'
      DC.B      '{',$CF,'{',$CF,$84,$00,$10,$84 
      DC.B      $10,$8C,'Q',$8C,'Q',$94,$00,$92 
      DC.B      $94,$92,$9C,$D3,$9C,$D3,$A5,$00 
      DC.B      $14,$A5,$14,$AD,'U',$AD,'U',$B5 
      DC.B      $00,$96,$B5,$96,$BD,$D7,$BD,$D7 
      DC.B      $C6,$00,$18,$C6,$18,$CE,'Y',$CE 
      DC.B      'Y',$D6,$00,$9A,$D6,$9A,$DE,$DB 
      DC.B      $DE,$DB,$E7,$00,$1C,$E7,$1C,$EF 
      DC.B      ']',$EF,']',$F7,$01,$9E,$F7,$9E 
      DC.B      $FF,$DF,$FF,$DF,$01,$08,$FF,$01 
      DC.B      $10,$01,$18,$01,' ',$01,'(',$01 
      DC.B      '0',$01,'8',$01,'@',$01,'H',$FF 
      DC.B      $01,'P',$01,'X',$01,'`',$01,'h' 
      DC.B      $01,'p',$01,'x',$01,$80,$01,$88 
      DC.B      $FF,$01,$90,$01,$98,$01,$A0,$01 
      DC.B      $A8,$01,$B0,$01,$B8,$01,$C0,$01 
      DC.B      $C8,$FF,$01,$D0,$01,$D8,$01,$E0 
      DC.B      $01,$E8,$01,$F0,'4',$F6,$80,$82 
      DC.B      $90,$A0,$00,$FA,$01,$F4,'d',$00 
      DC.B      'd',$00,'f',$00,$80,'i',$00,'i' 
      DC.B      $00,'k',$80,'n',$00,$00,'n',$00 
      DC.B      'p',$80,'p',$80,'s',$04,$00,'u' 
      DC.B      $80,'u',$80,'1',$CE,'x',$00,$27 
      DC.B      'z',$80,$01,$02,'}',$00,$0F,$02 
      DC.B      $01,$14,$01,$1E,$D5,'1',$F6,$01 
      DC.B      '0s',$02,'<n',$00,'Hi'
      DC.B      $00,'R',$80,$01,'X_',$00,'\'
      DC.B      $80,'Z',$00,'W',$00,$80,'U',$00 
      DC.B      'R',$80,'P',$00,'M',$00,$80,'K' 
      DC.B      $00,'F',$00,'C',$80,'A',$00,$00 
      DC.B      '>',$80,'9',$80,'7',$00,'4',$00 
      DC.B      $80,'2',$00,'/',$80,'*',$80,'(' 
      DC.B      $00,$00,'%',$80,'#',$00,' ',$80 
      DC.B      $1E,$00,$00,$1B,$80,$19,$00,$16 
      DC.B      $80,$14,$01,$00,$11,$80,$0F,$00 
      DC.B      $0C,$80,'!q?',$07,$80,'1' 
      DC.B      'H2t',$80,'2',$0F,$02,'a' 
      DC.B      'x1',$92,$AA,'1n',$07,$02 
      DC.B      '2',$0C,$00,'<',$11,$00,'D',$16 
      DC.B      $AA,$00,'L',$1B,$00,'T ',$00
      DC.B      '\%',$00,'d*(',$80,'/'
      DC.B      $00,'p4',$00,'x9',$80,'>' 
      DC.B      $82,$00,$84,'C',$80,'F',$00,'K' 
      DC.B      $00,$94,'P',$AB,$00,$9C,'U',$00 
      DC.B      $A4,'Z',$00,$AC,'_',$10,$0C,$13 
      DC.B      $0E,$FF,$11,$0C,$1B,$0A,$1F,$06 
      DC.B      $1B,$06,$13,$08,$1B,$0A,$13,$0C 
      DC.B      $15,$0E,'Oa',$00,'`\',$80 
      DC.B      $13,$12,$11,$14,$13,$16,$11,$18 
      DC.B      $A1,$01,$02,'K',$00,'ŽK',$00
      DC.B      'H',$80,$0F,$02,'}H',$04,$1C
      DC.B      $01,'(Qv',$01,$B0,$07,$B2 
      DC.B      'a',$10,'j',$E0,$07,$B2,$11,$BA 
      DC.B      $11,$B4,$7F,$80,$82,$00,$84,$00 
      DC.B      $80,$87,$00,$8C,$00,$8E,$80,$91 
      DC.B      $00,$00,$93,$80,$96,$00,$9B,$00 
      DC.B      $9D,$00,$80,$A0,$00,$A2,$80,$A5 
      DC.B      $00,$A7,$00,$80,$AA,$00,$AC,$80 
      DC.B      $AF,$00,$B1,$00,$80,$B4,$00,$B6 
      DC.B      $80,$B9,$00,$BB,$00,$80,$BB,$80 
      DC.B      $BE,$00,$C0,$80,$C0,$12,$80,$C3 
      DC.B      $00,$01,$02,$C5,$80,$05,$02,$C8 
      DC.B      $EA,$08,$0C,$03,$1C,$01,'&',$BE 
      DC.B      $02,'2',$B9,$00,'<',$B4,$AA,$00 
      DC.B      'D',$AF,$00,'L',$AA,$00,'T',$A5 
      DC.B      $00,'\',$A0,$8A,$00,'d',$9B,$00 
      DC.B      $96,$00,'p',$91,$00,'x',$8C,'#' 
      DC.B      $00,$87,$00,$84,$82,$00,$7F,'"' 
      DC.B      '$# ',$FF,$27,$1E,$13,$0E 
      DC.B      '#',$1E,$19,$0A,$1F,$08,$1F,$08 
      DC.B      $1D,$0A,$13,$BE,$97,$15,$0E,$00 
      DC.B      $C4,$08,$02,$C6,$08,$02,'aw'
      DC.B      $05,$04,'W',$CA,$08,$02,$CC,$08 
      DC.B      $02,$CE,$08,$02,'a',$A3,$03,$04 
      DC.B      'W',$D2,$08,$02,$D4,$08,$02,$D6 
      DC.B      $08,$02,'a',$CD,$05,$04,'W',$DA 
      DC.B      $08,$02,$DC,$06,$02,$DE,$0A,$02 
      DC.B      'a',$F9,$03,$04,'W',$E2,$0A,$02 
      DC.B      $E4,$06,$02,$E6,$08,$02,'q#'
      DC.B      $05,$04,'W',$EA,$08,$02,$EC,$08 
      DC.B      $02,$EE,$08,$02,'qO',$05,$04
      DC.B      'W',$F2,$08,$02,$F4,$08,$02,$F6 
      DC.B      $0A,$02,'q}',$03,$04,'W',$FA
      DC.B      $08,$02,$FC,$0A,$02,$FE,$07,$02 
      DC.B      'r ',$05,$04,'U',$02,$08,$02
      DC.B      $04,$08,$02,$06,$08,$02,$08,$0A 
      DC.B      $02,'U',$0A,$08,$02,$0C,$08,$02 
      DC.B      $0E,$0A,$02,$10,$08,$02,'U',$12 
      DC.B      $08,$02,$14,$0A,$02,$16,$0A,$02 
      DC.B      $18,$08,$02,'U',$1A,$08,$02,$1C 
      DC.B      $0A,$02,$1E,$08,$02,' ',$0A,$02 
      DC.B      'U"',$0A,$02,'$',$08,$02,'&'
      DC.B      $0A,$02,'(',$0A,$02,'U*',$0A
      DC.B      $02,',',$0A,$02,'.',$0A,$02,'0' 
      DC.B      $0A,$02,'U2',$0A,$02,'4',$0A
      DC.B      $02,'6',$0A,$02,'8',$0C,$02,'W' 
      DC.B      ':',$0A,$02,'<',$0A,$02,'>',$0C 
      DC.B      $02,$81,$C8,$09,$04,'UB',$0A
      DC.B      $02,'D',$0C,$02,'F',$0C,$02,'H' 
      DC.B      $0C,$02,'UJ',$0C,$02,'L',$0C
      DC.B      $02,'N',$0C,$02,'P',$0E,$02,'U' 
      DC.B      'R',$0C,$02,'T',$0E,$02,'V',$0E 
      DC.B      $02,'X',$0E,$02,'TZ',$0E,$02
      DC.B      '\',$0E,$02,'^',$0F,$02,$01,'`' 
      DC.B      $92,$0F,$02,$01,'b',$0F,$02,$01 
      DC.B      'd',$0F,$02,$01,'Mf',$0F,$02
      DC.B      $01,'h',$0F,$02,$02,$14,'j',$0F 
      DC.B      $02,'6',$01,'l',$0F,$02,$02,$14 
      DC.B      'n',$0F,$02,$02,$14,'p',$DB,$0F 
      DC.B      $02,$02,$14,'r',$0F,$02,$06,$14 
      DC.B      't',$0F,$02,$04,$14,'mv',$0F
      DC.B      $02,$08,$14,'x',$0F,$02,$08,$14 
      DC.B      'z',$0F,$02,$B7,$0A,$14,'|',$0F 
      DC.B      $02,$0C,$14,'~',$0F,$02,$0F,$14 
      DC.B      $00,'&',$F7,$B1,'r',$0F,$04,$0F 
      DC.B      $16,$B1,$9A,$82,$0F,$02,$0F,$14 
      DC.B      $0E,'&{',$84,$0F,$02,$0F,$14
      DC.B      $0F,'&',$0A,'8',$86,$0F,$02,$0F 
      DC.B      $14,$FE,$0F,'&',$0F,'8',$0F,'J' 
      DC.B      $0F,'\',$0F,'n',$0F,$80,$0E,$92 
      DC.B      $88,$FF,$0F,$A4,$0F,$B6,$0F,$C8 
      DC.B      $0F,$DA,$0F,$EC,$0F,$FE,$1F,$10 
      DC.B      $1F,'"',$FF,$1F,'4',$1F,$8A,$1F 
      DC.B      $9C,$1F,$AE,$1C,$C0,'/',$04,'/' 
      DC.B      $16,'/(',$FF,'/f/x' 
      DC.B      '%',$8A,'/',$BA,'/',$CC,'!',$DE 
      DC.B      '?',$04,'=',$16,$FF,'?F;' 
      DC.B      'X?„9',$96,'?',$C0,'9'
      DC.B      $D2,'?',$F8,'E',$0A,$FF,'O.'
      DC.B      'G@ObCtO',$92 
      DC.B      'C',$A4,'O',$C2,'C',$D4,$BB,'O' 
      DC.B      $EE,'j_',$1A,'T,_F' 
      DC.B      'f_nP',$80,$BB,'_',$96
      DC.B      'b_',$BE,'P',$D0,'_',$E6,'^'
      DC.B      'o',$0C,'o0',$FF,'oTo'
      DC.B      'xo',$9C,'n',$BE,'o',$E0,'}'
      DC.B      $02,'}"}B',$FF,'}b' 
      DC.B      '}',$82,'}',$A2,'{',$C0,'}',$DE 
      DC.B      '}',$FE,$8B,$1C,$8B,'8',$FF,$8D 
      DC.B      'V',$8B,'t',$8B,$90,$8B,$AC,$8B 
      DC.B      $C8,$8B,$E4,$9B,$00,$9B,$1C,$FF 
      DC.B      $9B,'8',$9B,'T™n',$9B,$88 
      DC.B      $9B,$A4,$99,$BE,$9B,$D8,$99,$F2 
      DC.B      $FF,$A9,$0A,$AB,'$',$AB,'@',$A9 
      DC.B      'Z',$A9,'r',$AB,$8C,$A9,$A6,$A9 
      DC.B      $BE,$FF,$AB,$D8,$A9,$F2,$B9,$0A 
      DC.B      $B9,'"',$B8,':',$B9,'R',$BC,'l' 
      DC.B      $B9,$86,$FF,$B7,$9C,$BB,$B4,$B9 
      DC.B      $CE,$B9,$E6,$B9,$FE,$C9,$16,$C9 
      DC.B      '.',$C9,'F',$FF,$C9,'^',$C9,'v' 
      DC.B      $C7,$8C,$CB,$A4,$C7,$BC,$CB,$D4 
      DC.B      $C7,$EC,$D9,$02,$FF,$D9,$1A,$D9 
      DC.B      '2',$D9,'J',$D9,'b',$D7,'x',$D9 
      DC.B      $8E,$D9,$A6,$D9,$BE,$EA,$D9,$D6 
      DC.B      $D9,$EE,$E9,$06,$C2,$06,$02,$C0 
      DC.B      $08,$02,$BE,$AA,$08,$02,$BC,$08 
      DC.B      $02,$BA,$08,$02,$B8,$08,$02,$B6 
      DC.B      $AA,$06,$02,$B4,$08,$02,$B2,$08 
      DC.B      $02,$B0,$08,$02,$AE,$AA,$08,$02 
      DC.B      $AC,$08,$02,$AA,$06,$02,$A8,$0A 
      DC.B      $02,$A6,$AA,$06,$02,$A4,$0A,$02 
      DC.B      $A2,$06,$02,$A0,$08,$02,$9E,$AA 
      DC.B      $08,$02,$9C,$08,$02,$9A,$08,$02 
      DC.B      $98,$08,$02,$96,$AA,$08,$02,$94 
      DC.B      $08,$02,$92,$08,$02,$90,$0A,$02 
      DC.B      $8E,$AA,$06,$02,$8C,$08,$02,$8A 
      DC.B      $0A,$02,$88,$08,$02,$86,$AA,$08 
      DC.B      $02,$84,$08,$02,$82,$08,$02,$80 
      DC.B      $08,$02,'~',$AA,$0A,$02,'|',$08 
      DC.B      $02,'z',$08,$02,'x',$0A,$02,'v' 
      DC.B      $AA,$08,$02,'t',$08,$02,'r',$0A 
      DC.B      $02,'p',$0A,$02,'n',$AA,$08,$02 
      DC.B      'l',$08,$02,'j',$0A,$02,'h',$08 
      DC.B      $02,'f',$AA,$0A,$02,'d',$0A,$02 
      DC.B      'b',$0A,$02,'`',$08,$02,'^',$AA 
      DC.B      $0A,$02,'\',$0A,$02,'Z',$0A,$02 
      DC.B      'X',$0A,$02,'V',$AA,$0A,$02,'T' 
      DC.B      $0A,$02,'R',$0A,$02,'P',$0A,$02 
      DC.B      'N',$AA,$0C,$02,'L',$0A,$02,'J' 
      DC.B      $0A,$02,'H',$0C,$02,'F',$AA,$0C 
      DC.B      $02,'D',$0A,$02,'B',$0C,$02,'@' 
      DC.B      $0C,$02,'>',$AA,$0C,$02,'<',$0C 
      DC.B      $02,':',$0C,$02,'8',$0C,$02,'6' 
      DC.B      $AA,$0E,$02,'4',$0C,$02,'2',$0E 
      DC.B      $02,'0',$0E,$02,'.',$AA,$0E,$02 
      DC.B      ',',$0E,$02,'*',$0E,$02,'(',$0F 
      DC.B      $02,$00,'I&',$0F,$02,$00,'$'
      DC.B      $0F,$02,$00,'"',$0F,$02,'&',$00 
      DC.B      ' ',$0F,$02,$00,$1E,$0F,$02,$02 
      DC.B      $14,$1C,$9B,$0F,$02,$00,$1A,$0F 
      DC.B      $02,$02,$14,$18,$0F,$02,$02,$14 
      DC.B      'm',$16,$0F,$02,$02,$14,$14,$0F 
      DC.B      $02,$06,$14,$12,$0F,$02,$B6,$04 
      DC.B      $14,$10,$0F,$02,$08,$14,$0E,$0F 
      DC.B      $02,$08,$14,$0C,$DB,$0F,$02,$0A 
      DC.B      $14,$0A,$0F,$02,$0C,$14,$08,$0F 
      DC.B      $02,$0F,$14,$BB,$00,'&',$06,$0F 
      DC.B      $02,$0F,$14,$04,'&',$04,$0F,$02 
      DC.B      $0F,$14,$BF,$0E,'&',$02,$0F,$02 
      DC.B      $0F,$14,$0F,'&',$0A,'8',$0F,$01 
      DC.B      $0F,$13,$FF,$0F,'%',$0F,'7',$0F 
      DC.B      'I',$0F,'[',$0F,'m',$0F,$7F,$0F 
      DC.B      $91,$0F,$A3,$FF,$0F,$B5,$0F,$C7 
      DC.B      $0F,$D9,$0F,$EB,$0F,$FD,$1F,$0F 
      DC.B      $1F,'!',$1F,'3',$7F,$00,$1F,$8A 
      DC.B      $1F,$9C,$1F,$AE,$1C,$C0,'/',$04 
      DC.B      '/',$16,'/(',$FF,'/f/'
      DC.B      'x%',$8A,'/',$BA,'/',$CC,'!'
      DC.B      $DE,'?',$04,'=',$16,$FF,'?F'
      DC.B      ';X?„9',$96,'?',$C0 
      DC.B      '9',$D2,'?',$F8,'E',$0A,$FF,'O' 
      DC.B      '.G@ObCtO'
      DC.B      $92,'C',$A4,'O',$C2,'C',$D4,$BB 
      DC.B      'O',$EE,$1C,'_',$1A,'T,_' 
      DC.B      'F _nP',$80,$BB,'_' 
      DC.B      $96,'$_',$BE,'P',$D0,'_',$E6
      DC.B      '(o',$0C,'o0',$FF,'oT'
      DC.B      'oxo',$9C,'n',$BE,'o',$E0 
      DC.B      '}',$02,'}"}B',$FF,'}'
      DC.B      'b}',$82,'}',$A2,'{',$C0,'}'
      DC.B      $DE,'}',$FE,$8B,$1C,$8B,'8',$FF 
      DC.B      $8D,'V',$8B,'t',$8B,$90,$8B,$AC 
      DC.B      $8B,$C8,$8B,$E4,$9B,$00,$9B,$1C 
      DC.B      $FF,$9B,'8™R',$9B,'l',$9B 
      DC.B      $88,$9B,$A4,$99,$BE,$9B,$D8,$99 
      DC.B      $F2,$FF,$A9,$0A,$AB,'$',$AB,'@' 
      DC.B      $A9,'Z',$A9,'r',$AB,$8C,$A9,$A6 
      DC.B      $A9,$BE,$FF,$AB,$D8,$A9,$F2,$B9 
      DC.B      $0A,$B9,'"',$B9,':',$B9,'R',$BB 
      DC.B      'l',$B9,$86,$FF,$B7,$9C,$BB,$B4 
      DC.B      $B9,$CE,$B9,$E6,$B9,$FE,$C9,$16 
      DC.B      $C9,'.',$C9,'F',$FF,$C9,'^',$C9 
      DC.B      'v',$C7,$8C,$CB,$A4,$C7,$BC,$CB 
      DC.B      $D4,$C7,$EC,$D9,$02,$FF,$D9,$1A 
      DC.B      $D9,'2',$D9,'J',$D9,'b',$D7,'x' 
      DC.B      $D9,$8E,$D9,$A6,$D9,$BE,$FF,$D9 
      DC.B      $D6,$D9,$EE,$E7,$04,$E9,$1A,$EF 
      DC.B      '.',$07,$14,$E1,'N',$E9,'^',$F7 
      DC.B      $E9,'v',$E9,$8E,$E9,$A6,$E7,$BC 
      DC.B      $D0,$EA,$D4,$E9,$EC,$F9,$04,$DF 
      DC.B      $F9,$1C,$F9,'4',$DA,$F8,'L',$F1 
      DC.B      'V',$F9,'h',$F7,'~',$F1,$88,$BF 
      DC.B      $FB,$9A,$E2,$F8,$B4,$F1,$BE,$F9 
      DC.B      $CE,$F1,$DA,$F9,$EA,$F1,$F6,$D4 
      DC.B      $F1,$FE,$09,$04,$EC,$0E,$02,$EE 
      DC.B      $0F,$02,$00,$F0,$9B,$0F,$02,$00 
      DC.B      $F2,$0F,$02,$04,$14,$F4,$0F,$02 
      DC.B      $06,$14,'w',$F6,$0F,$02,$0F,$14 
      DC.B      $00,'&',$F8,$0F,$02,$0F,$14,$0F 
      DC.B      '&',$FE,$0F,'8',$0F,'J',$0F,'\' 
      DC.B      $0F,'n',$02,$80,$0F,$AC,$0F,$BE 
      DC.B      $F6,$FB,$0F,$EE,$18,$00,$1F,'$' 
      DC.B      $11,'6',$1F,'N',$F0,$1F,'v',$1C 
      DC.B      $9A,$FF,$1D,$B8,$1B,$D8,$1B,$F6 
      DC.B      ')',$12,').)H',$27,'`'
      DC.B      ')x',$FF,$27,$92,$27,$A8,$27
      DC.B      $BE,$27,$D4,$27,$EA,'5',$00,'7' 
      DC.B      $14,'5*',$FF,'7>5T' 
      DC.B      '?|5',$A4,'5',$B8,'5',$CC 
      DC.B      '5',$E0,'5',$F4,$FF,'C',$08,'E' 
      DC.B      $18,'E,E@CTE' 
      DC.B      'fEzC',$8C,$FF,'E',$A0
      DC.B      'E',$B2,'C',$C8,'E',$D8,'C',$EC 
      DC.B      'E',$FE,'S',$12,'S$',$FF,'U'
      DC.B      '6SJU\SpU'
      DC.B      '„S',$96,'S',$A8,'U',$BC,$FF
      DC.B      'S',$D0,'U',$E2,'S',$F6,'c',$08 
      DC.B      'e',$1A,'c0cBeT'
      DC.B      $FF,'cjc|eŽc' 
      DC.B      $A4,'c',$B8,'e',$CA,'c',$DE,'c' 
      DC.B      $F2,$FF,'u',$04,'s',$1A,'s.'
      DC.B      'uBsVsju~'
      DC.B      's',$94,$FF,'u',$A8,'s',$BE,'u' 
      DC.B      $D2,'s',$E8,'u',$FC,$83,$14,$85 
      DC.B      '(',$83,'>',$FF,$85,'T',$85,'l' 
      DC.B      $83,$82,$85,$98,$85,$B0,$85,$C8 
      DC.B      $85,$E0,$83,$F8,$FF,$95,$0E,$FD 
      DC.B      $FE,$FF,$EC,$FD,$DA,$FF,$C8,$FF 
      DC.B      $B0,$FF,$9C,$F9,$92,$FF,$FF,'z' 
      DC.B      $F9,'l',$FF,'R',$FF,'B',$FF,'$' 
      DC.B      $FF,$14,$FF,$02,$EF,$F0,$FF,$EF 
      DC.B      $DA,$EF,$C2,$EF,$A4,$EF,$AA,$EF 
      DC.B      '~',$EF,$8B,$EF,$9D,$EF,$AF,$FF 
      DC.B      $EF,$C1,$EF,$D3,$EF,$E5,$EF,$F7 
      DC.B      $DF,$CA,$FF,'^',$DF,$A4,$DF,$86 
      DC.B      $FF,$DF,'n',$DF,'X',$DF,'F',$DF 
      DC.B      '4',$DF,$14,$DF,$06,$CB,$F6,$CF 
      DC.B      $DC,$FF,$C9,$CE,$CF,$B6,$C9,$AC 
      DC.B      $CF,$98,$CF,$80,$CD,'n',$CF,'\' 
      DC.B      $CD,'J',$FF,$CB,'8',$CD,'&',$CD 
      DC.B      $16,$CB,$06,$BB,$F6,$BB,$E8,$BB 
      DC.B      $D8,$BB,$CA,$FF,$BB,$BC,$BB,$AE 
      DC.B      $BB,$A0,$B9,$92,$BB,$86,$BB,'x' 
      DC.B      $B9,'l',$BB,'`',$FF,$BB,'R',$B9 
      DC.B      'H',$BB,'<',$BB,'0',$BB,'&',$B9 
      DC.B      $1A,$BB,$10,$BB,$06,$FF,$AB,$FC 
      DC.B      $AB,$F0,$AB,$E6,$AB,$DC,$AB,$D4 
      DC.B      $AD,$CC,$AB,$C2,$AD,$BA,$FF,$AB 
      DC.B      $B2,$AD,$AA,$AD,$A2,$AF,$9E,$AF 
      DC.B      $82,$AF,'|',$AF,'v',$AF,'r',$FF 
      DC.B      $A9,'p',$AF,'j',$AB,'h',$AF,'d' 
      DC.B      $AF,'`',$AF,'\',$AF,'Z',$AF,'Z' 
      DC.B      $FF,$AF,'V',$AF,'T',$AF,'T',$AF 
      DC.B      'P',$AF,'X',$AF,'P',$AF,'`',$AF 
      DC.B      'N',$FF,$AF,'\',$AF,'n',$AF,$80 
      DC.B      $AF,$92,$AF,$A4,$AF,$B6,$AF,'N' 
      DC.B      $BF,$02,$FF,$AF,'P',$BF,'B',$AF 
      DC.B      'P',$AF,'T',$AF,'T',$BF,$CC,$BF 
      DC.B      $F0,$AF,'Z',$FF,$AF,'\',$AF,'^' 
      DC.B      $AF,'`',$AF,'d',$A9,'f',$AB,'h' 
      DC.B      $A9,'j',$AB,'n',$FF,$A9,'p',$A9 
      DC.B      'r',$A9,'t',$A7,'v',$AB,'z',$A7 
      DC.B      '|',$AB,$80,$A7,$82,$FF,$A9,$86 
      DC.B      $ED,$06,$E7,'0',$E9,'F',$E9,'^' 
      DC.B      $E9,'v',$E9,$8E,$E9,$A6,$FF,$E7 
      DC.B      $BC,$A7,$A8,$A9,$AC,$A7,$B0,$AB 
      DC.B      $B6,$A9,$BA,$A9,$C0,$F5,'R',$FF 
      DC.B      $F9,'h',$F7,'~',$A7,$D2,$F7,$A0 
      DC.B      $F7,$B4,$A7,$E2,$F7,$D4,$F9,$EA 
      DC.B      $FF,$A7,$F4,$07,$06,$A3,$FE,$09 
      DC.B      $06,$B5,$0A,$09,$08,$B3,$16,$0B 
      DC.B      $06,$FF,$B5,'$',$0F,$08,$B3,'6' 
      DC.B      $0F,$06,$B9,'L',$0F,$08,$0B,$1A 
      DC.B      $B3,'l',$FF,$0F,$06,$0F,$18,$0F 
      DC.B      '*',$0F,'<',$0F,'N',$0F,'`',$0F 
      DC.B      'r',$0F,$AC,$FF,$0F,$BE,'e',$84 
      DC.B      $0F,$F4,'i',$9A,$1B,',',$1F,'N' 
      DC.B      'g',$B6,$17,'~',$FF,$1B,$9A,$1D 
      DC.B      $B8,$1B,$D8,$1B,$F6,')',$12,')' 
      DC.B      '.)H',$27,'`',$FF,')x'
      DC.B      $27,$92,$27,$A8,$27,$BE,$27,$D4 
      DC.B      $27,$EA,'{',$02,$7F,$06,$FF,$7F 
      DC.B      $08,$7F,$08,$7F,$08,$7F,$06,$7F 
      DC.B      $02,'w',$00,'k',$FA,'k',$F6,$FE 
      DC.B      'm',$EE,'k',$E4,'k',$D8,'i',$C8 
      DC.B      'k',$B6,'kškf',$FA,$A9
      DC.B      $02,$02,$FC,$04,$02,$FE,$01,$02 
      DC.B      $01,$00,$04,$02,'U',$02,$02,$02 
      DC.B      $04,$02,$02,$06,$04,$02,$08,$02 
      DC.B      $02,'U',$0A,$02,$02,$0C,$04,$02 
      DC.B      $0E,$02,$02,$10,$02,$02,'U',$12 
      DC.B      $04,$02,$14,$02,$02,$16,$02,$02 
      DC.B      $18,$04,$02,'U',$1A,$02,$02,$1C 
      DC.B      $02,$02,$1E,$04,$02,' ',$02,$02 
      DC.B      'U"',$02,$02,'$',$04,$02,'&'
      DC.B      $02,$02,'(',$02,$02,'U*',$04
      DC.B      $02,',',$02,$02,'.',$04,$02,'0' 
      DC.B      $02,$02,'U2',$04,$02,'4',$02
      DC.B      $02,'6',$04,$02,'8',$02,$02,'U' 
      DC.B      ':',$04,$02,'<',$02,$02,'>',$04 
      DC.B      $02,'@',$04,$02,'UB',$02,$02
      DC.B      'D',$04,$02,'F',$04,$02,'H',$04 
      DC.B      $02,'UJ',$04,$02,'L',$02,$02
      DC.B      'N',$04,$02,'P',$04,$02,'UR'
      DC.B      $04,$02,'T',$04,$02,'V',$06,$02 
      DC.B      'X',$04,$02,'UZ',$04,$02,'\'
      DC.B      $06,$02,'^',$04,$02,'`',$04,$02 
      DC.B      'Ub',$06,$02,'d',$06,$02,'f'
      DC.B      $06,$02,'h',$06,$02,'Uj',$06
      DC.B      $02,'l',$06,$02,'n',$06,$02,'p' 
      DC.B      $08,$02,'Ur',$08,$02,'t',$08
      DC.B      $02,'v',$0A,$02,'x',$0A,$02,'U' 
      DC.B      'z',$0A,$02,'|',$0C,$02,'~',$0E 
      DC.B      $02,$80,$0F,$02,'6',$01,$82,$0F 
      DC.B      $02,$02,$14,$84,$0F,$02,$08,$14 
      DC.B      $86,$F7,$0F,$02,$0F,$14,$0F,'&' 
      DC.B      $0E,'8',$88,$0F,'J',$0F,'\',$0F 
      DC.B      'n',$FD,$0F,$80,$0F,$B0,$0A,$C2 
      DC.B      $0F,$E6,$03,$F8,$1F,$12,$80,$1F 
      DC.B      '8',$FF,$1E,'Z',$1B,'x',$1B,$94 
      DC.B      $1B,$B0,$19,$CA,$19,$E2,$19,$FA 
      DC.B      $27,$10,$FF,$27,'$',$27,'8',$27 
      DC.B      'L',$27,'`',$27,'t',$27,$88,'%' 
      DC.B      'š%',$AA,$FF,$27,$BC,'%',$CE
      DC.B      '%',$DE,$27,$F0,'5',$02,'5',$12 
      DC.B      '5"52',$FF,'3@5'
      DC.B      'N5^5n5~3'
      DC.B      $8C,'5š5',$AA,$FF,'3',$B8 
      DC.B      '5',$C6,'3',$D4,'5',$E2,'3',$F0 
      DC.B      '5',$FE,'C',$0C,'E',$1A,$FF,'C' 
      DC.B      '(E6CDCPE'
      DC.B      '^ClCxE',$86,$FF
      DC.B      'C”C',$A0,'E',$AE,'C',$BC 
      DC.B      'C',$C8,'E',$D6,'C',$E4,'C',$F0 
      DC.B      $FF,'E',$FE,'S',$0C,'S',$18,'U' 
      DC.B      '&S4S@TNS'
      DC.B      '\',$FF,'VjSx',$BB,'l'
      DC.B      $BB,'6',$BB,$16,$A9,$FE,$AB,$EC 
      DC.B      $AB,$DC,$FF,$AD,$CC,$AB,$C0,$AB 
      DC.B      $B6,$AD,$AC,$AB,$A4,$AD,$9A,$AD 
      DC.B      $92,$AF,$8C,$FF,$AD,$86,$AF,$80 
      DC.B      $AF,'z',$AF,'t',$A9,'r',$AF,'n' 
      DC.B      $AB,'j',$AF,'f',$FF,$AD,'d',$AF 
      DC.B      '^',$AF,'\',$AF,'Z',$AD,'Z',$AF 
      DC.B      'V',$AF,'T',$AF,'T',$FF,$AF,'P' 
      DC.B      $AF,'P',$AF,'R',$AF,'d',$AF,'N' 
      DC.B      $AF,'`',$AF,'r',$AF,$84,$FF,$AF 
      DC.B      $96,$AF,$A8,$AF,$BA,$AF,'N',$BF 
      DC.B      $06,$AF,'P',$BF,'F',$AF,'P',$FF 
      DC.B      $AF,'T',$AF,'T',$AF,'V',$AF,'Z' 
      DC.B      $AF,'Z',$AF,'\',$AF,'^',$AD,'`' 
      DC.B      $FF,$AD,'d',$A9,'f',$AB,'h',$A9 
      DC.B      'j',$AB,'n',$A9,'p',$A9,'r',$A9 
      DC.B      't',$FF,$A7,'v',$AB,'z',$A7,'|' 
      DC.B      $AB,$80,$A7,$82,$A9,$86,$A9,$8A 
      DC.B      $A9,$8C,$FF,$A7,$8E,$A3,$9A,$A3 
      DC.B      $90,$A3,$86,$A3,'~',$A3,'t',$A3 
      DC.B      'l',$A3,'d',$FF,$A3,'Z',$A3,'R' 
      DC.B      $A3,'J',$A3,'D',$A3,'<',$A3,'4' 
      DC.B      $A3,',',$A4,'$',$FF,$A4,$1C,$A3 
      DC.B      $16,$A3,$10,$A5,$08,$A3,$04,$95 
      DC.B      $FC,$93,$F4,$95,$F0,$FF,$95,$EA 
      DC.B      $95,$E4,$95,$E0,$95,$DA,$95,$D4 
      DC.B      $97,$CE,$95,$CA,$97,$C6,$FF,$9F 
      DC.B      $C0,$99,$BC,$99,$B8,$9F,$BA,$95 
      DC.B      $BA,$97,$BC,$99,$BE,$99,$C2,$FF 
      DC.B      $09,$08,$95,$CE,$0F,$08,$0F,$1A 
      DC.B      '{*',$0B,'N',$0B,'j',$07,$82
      DC.B      $FF,'w@wB}Du' 
      DC.B      'F{Dy@uB}'
      DC.B      '<',$FF,'y:w6w4'
      DC.B      'w0w,{&{ '
      DC.B      'w',$1C,$FF,'u',$18,'w',$14,'{' 
      DC.B      $0E,'w',$0A,'v',$06,'v',$02,'g' 
      DC.B      $FE,'g',$FA,$FF,'g',$F6,'g',$F2 
      DC.B      'i',$F0,'i',$EE,'m',$EA,$D3,'.' 
      DC.B      'e',$E8,'i',$E4,$FF,'o',$E6,'k' 
      DC.B      $E6,'g',$E8,'g',$EA,'i',$EE,'i' 
      DC.B      $F2,$07,$08,'9p',$FF,$0F,$0C
      DC.B      $0F,$1E,$0F,'0',$0D,'B',$0F,'d' 
      DC.B      $09,$82,$09,$9A,$07,$B0,$FF,$05 
      DC.B      $C2,$EF,'Z',$E9,'Z',$E5,'\',$E9 
      DC.B      'X',$E3,'Z',$E9,'V',$EF,'R',$FF 
      DC.B      $E7,'P',$E7,'L',$E7,'H',$E7,'D' 
      DC.B      $E7,'B',$E7,'<',$E5,'8',$E7,'4' 
      DC.B      $FF,$E7,'2',$EB,',G*',$E5 
      DC.B      '"',$E7,' ',$EB,$1A,$EB,$14,$E7 
      DC.B      $10,$FF,$E9,$0C,'K:',$E5,$06
      DC.B      'O>O@',$DB,$FC,'OB' 
      DC.B      'OD',$FF,'9',$C2,'OFO'
      DC.B      'JOHOZOHO'
      DC.B      'FOF',$FF,'OD',$BF,$86
      DC.B      'KBO@O>',$B3,'v'
      DC.B      'K:I6',$FF,$B5,'`I' 
      DC.B      '2I0',$B3,'LG*K'
      DC.B      '&',$B5,'.D',$1E,$FF,'H',$1A
      DC.B      $B3,$12,$B3,$0A,$B3,$02,$A3,$FA 
      DC.B      $A3,$F2,$A3,$EA,$A3,$E2,$FF,$A3 
      DC.B      $DA,$A3,$D0,$A3,$C8,$A3,$BE,$A3 
      DC.B      $B6,$A3,$AC,$A3,$A0,$A3,$94,$FF 
      DC.B      $A3,$88,$A3,'|',$A3,'p',$A3,'b' 
      DC.B      $A3,'T',$A3,'D',$A3,'2',$A3,$1E 
      DC.B      $F1,$A3,$06,$93,$EC,$93,$C8,$93 
      DC.B      $8C,$8C,$00,$8A,$00,$02,'D',$88 
      DC.B      $00,$02,$86,$00,$84,$00,$02,$82 
      DC.B      $00,'Q',$80,$00,$02,'~',$00,$02 
      DC.B      '|',$00,'z',$00,$02,'Qx',$00
      DC.B      $02,'v',$00,$02,'t',$00,'r',$00 
      DC.B      $02,'Ep',$00,$02,'n',$00,'l'
      DC.B      $00,$02,'j',$00,$02,'Uh',$00
      DC.B      $02,'f',$00,$02,'d',$00,$02,'b' 
      DC.B      $00,$02,'U`',$00,$02,'^',$00
      DC.B      $02,'\',$00,$02,'Z',$00,$02,'U' 
      DC.B      'X',$00,$02,'V',$00,$02,'T',$00 
      DC.B      $02,'R',$00,$02,'UP',$02,$02
      DC.B      'N',$00,$02,'L',$00,$02,'J',$02 
      DC.B      $02,'UH',$00,$02,'F',$02,$02
      DC.B      'D',$02,$02,'B',$02,$02,'U@'
      DC.B      $02,$02,'>',$02,$02,'<',$02,$02 
      DC.B      ':',$04,$02,'U8',$04,$02,'6'
      DC.B      $04,$02,'4',$06,$02,'2',$06,$02 
      DC.B      'S0',$0A,$02,'.',$0F,$02,$00
      DC.B      ',',$0F,$02,$0F,$14,$FB,$0A,'&' 
      DC.B      $0F,'F',$01,'X',$0B,'j',$07,$82 
      DC.B      '2',$08,$98,$05,$AA,'{6',$06
      DC.B      $BC,$05,$CC,$03,$DA,$03,$E6,'>' 
      DC.B      $04,$F4,$13,$00,$BD,$13,$0C,'D' 
      DC.B      $14,$1A,$11,'$',$13,'.',$11,'8' 
      DC.B      'L',$12,'BuN',$14,'N',$11 
      DC.B      'X',$11,'`T',$12,'jV',$12 
      DC.B      't',$B7,$11,'|Z',$12,$86,$11
      DC.B      'Ž^',$12,$98,$11,$A0,$11,$A8
      DC.B      'ud',$12,$B2,$11,$BA,$11,$C2
      DC.B      'j',$12,$CC,'n',$02,$02,$DB,$11 
      DC.B      $DC,$11,$E4,'t',$10,$EC,$11,$F2 
      DC.B      'v',$12,$FC,'!',$04,'u|',$02
      DC.B      $02,'!',$14,'!',$1C,$80,' $'
      DC.B      $82,'",w',$86,$02,$02,'!' 
      DC.B      '<!D',$8C,$02,$02,$B7,'`' 
      DC.B      $B7,'&',$FF,$B7,$02,$A7,$E6,$A9 
      DC.B      $D2,$A7,$C0,$A9,$AE,$AB,$A0,$AB 
      DC.B      $92,$AD,$8A,$FF,$AD,$82,$AF,'|' 
      DC.B      $AF,'|',$0D,$02,$A7,$82,$0F,$0A 
      DC.B      $09,$1C,$E7,'$',$FF,$0F,'2',$0B 
      DC.B      'D',$0F,'d',$A9,$FE,$B9,$16,$B7 
      DC.B      '.',$EF,'T',$EB,'R',$FF,$EB,'N' 
      DC.B      $EB,'F',$E9,'<',$E7,'0',$E9,'"' 
      DC.B      $E7,$10,$D7,$FA,$D7,$DA,$FF,$D7 
      DC.B      $A2,$13,$CC,'G',$1A,$11,$EA,'C' 
      DC.B      $1E,'C E"!',$1A,$FF 
      DC.B      'I&A(I*!Z'
      DC.B      'E.K0K2G4'
      DC.B      $FF,'G6C8M:C' 
      DC.B      '<O>52O@O'
      DC.B      'B',$FF,'KBODOF'
      DC.B      'OFOHOTOf'
      DC.B      'OH',$FF,'OFODG'
      DC.B      'DOBGBO@O'
      DC.B      '>C<',$FF,'K:I6'
      DC.B      'E4I2I0C.'
      DC.B      'G*K&',$FF,'E"E'
      DC.B      $1E,'G',$1A,$F3,'v',$F3,'8',$F3 
      DC.B      $10,$E3,$F0,$E3,$D6,$FF,$E3,$BE 
      DC.B      $E3,$A6,$E3,$92,$E3,'~',$E3,'l' 
      DC.B      $E3,'Z',$E3,'H',$E3,'6',$FF,$E3 
      DC.B      '$',$EF,$10,$EF,$10,$EF,$10,$EF 
      DC.B      $10,$EF,$10,$EF,$10,$EF,$10,$FF 
      DC.B      $EF,$10,$EF,$10,$EF,$10,$EF,$10 
      DC.B      $EF,$10,$EF,$10,$EF,$10,$EF,$10 
      DC.B      $FF,$EF,$10,$EF,$10,$EF,$12,$EF 
      DC.B      $10,$EF,'"',$EF,$10,$EF,'Z',$EF 
      DC.B      $10,$FF,$EF,$10,$EF,$10,$EF,$10 
      DC.B      $EF,$10,$EF,$10,$EF,$10,$EF,$10 
      DC.B      $EF,$10,$FF,$EF,$10,$EF,$10,$EF 
      DC.B      $10,$EF,$10,$EF,$10,$EF,$10,$EF 
      DC.B      $10,$EF,$10,$FF,$EF,$10,$EF,$10 
      DC.B      $EF,$10,$EF,$10,$EF,$10,$EF,$10 
      DC.B      $EF,$10,$EF,$10,$FF,$EF,$10,$EF 
      DC.B      $18,$EF,'*',$EF,'<',$EF,'N',$EF 
      DC.B      $10,$EF,$10,$EF,$10,$FF,$EF,$10 
      DC.B      $EF,$10,$EF,$10,$EF,$10,$EF,$10 
      DC.B      $EF,$10,$EF,$10,$EF,$10,$FF,$EF 
      DC.B      $10,$EF,$10,$EF,$10,$EF,$10,$EF 
      DC.B      $10,$EF,$10,$EF,$10,$EF,$10,$FF 
      DC.B      $EF,$10,$EF,$10,$EF,$10,$EF,$10 
      DC.B      $EF,$10,$EF,$10,$EF,$10,$EF,$10 
      DC.B      $FF,$EF,$12,$EF,'$',$EF,$10,$EF 
      DC.B      $10,$EF,$10,$EF,$10,$EF,$10,$EF 
      DC.B      $10,$FF,$EF,$10,$EF,$10,$EF,$10 
      DC.B      $EF,$10,$EF,$10,$EF,$10,$EF,$10 
      DC.B      $EF,$10,$FF,$EF,$10,$EF,$10,$EF 
      DC.B      $10,$EF,$10,$EF,$10,$EF,$10,$EF 
      DC.B      $10,$EF,$10,$FF,$EF,$10,$EF,$10 
      DC.B      $EF,$10,$EF,$10,$EF,$10,$EF,$10 
      DC.B      $EF,$10,$EF,$10,$FF,$EF,$10,$EF 
      DC.B      $10,$EF,$10,$EF,$10,$EF,$10,$EF 
      DC.B      $10,$EF,$12,$EF,$10,$FF,$EF,'"' 
      DC.B      $EF,$10,$EF,'Z',$EF,$10,$EF,$10 
      DC.B      $EF,$10,$EF,$10,$EF,$10,$FF,$EF 
      DC.B      $10,$EF,$10,$EF,$10,$EF,$10,$EF 
      DC.B      $10,$EF,$10,$EF,$10,$EF,$10,$FF 
      DC.B      $EF,$10,$EF,$10,$EF,$10,$EF,$10 
      DC.B      $EF,$10,$EF,$10,$EF,$10,$EF,$10 
      DC.B      $FF,$EF,$10,$EF,$10,$EF,$10,$EF 
      DC.B      $10,$EF,$10,$EF,$18,$EF,$10,$EF 
      DC.B      '<',$FF,$EF,'N',$EF,$10,$EF,$10 
      DC.B      $EF,$10,$EF,$10,$EF,$10,$EF,$10 
      DC.B      $EF,$10,$FF,$EF,$10,$EF,$10,$EF 
      DC.B      $10,$EF,$10,$EF,$10,$EF,$10,$EF 
      DC.B      $10,$EF,$10,$FF,$EF,$10,$EF,$10 
      DC.B      $EF,$10,$EF,$10,$EF,$10,$EF,$10 
      DC.B      $EF,$10,$EF,$10,$FF,$EF,$10,$EF 
      DC.B      $10,$EF,$10,$EF,$10,$EF,$12,$EF 
      DC.B      '$',$EF,$10,$EF,$10,$FF,$EF,$10 
      DC.B      $EF,$10,$EF,$10,$EF,$10,$EF,$10 
      DC.B      $EF,$10,$EF,$10,$EF,$10,$FF,$EF 
      DC.B      $10,$EF,$10,$EF,$10,$EF,$10,$EF 
      DC.B      $10,$EF,$10,$EF,$10,$EF,$10,$FF 
      DC.B      $EF,$10,$ED,$10,$AF,$82,$AF,'|' 
      DC.B      $AF,'|',$AB,'~',$A9,$82,$A7,$84 
      DC.B      $FF,$A9,$88,$A9,$8C,$A7,$90,$A9 
      DC.B      $96,$AB,$9C,$A3,$9E,$07,$04,$B5 
      DC.B      $EA,$FF,$A3,$AA,$07,$04,$C3,$0C 
      DC.B      $A7,$B8,$A9,$BE,$A9,$C4,$A7,$CA 
      DC.B      $05,$04,$FF,$C3,'b',$A7,$D8,$05 
      DC.B      $04,$C3,$84,$A7,$E6,$05,$04,$C3 
      DC.B      $A6,$05,$06,$FF,$F1,$0C,$03,$04 
      DC.B      $C3,$C8,$B7,$02,$07,$04,$C1,$EA 
      DC.B      $04,$04,$B4,$14,$FF,$B7,$1A,$05 
      DC.B      $04,$D1,$1C,$05,$04,$D3,'.',$B7 
      DC.B      '0',$07,$04,$D3,'R',$FF,$B7,'@' 
      DC.B      $05,$04,$F1,'n',$07,$04,$D3,$86 
      DC.B      $B7,'X',$05,$04,$F1,$8A,$FF,$07 
      DC.B      $04,$F1,$94,$07,$04,$D3,$CC,$B7 
      DC.B      'z',$05,$04,$D3,$EE,$05,$06,$FF 
      DC.B      $F1,$BA,$05,$04,$F1,$C2,$07,$04 
      DC.B      $E3,'$',$05,$06,$F1,$D6,$05,$04 
      DC.B      $FF,$F1,$DE,$07,$04,$E3,'Z',$05 
      DC.B      $06,$F1,$F2,$07,$04,$E3,$80,$05 
      DC.B      $06,$FF,$E1,$92,$07,$04,$E3,$A6 
      DC.B      $05,$06,$E3,$BA,$05,$06,$E1,$CC 
      DC.B      $07,$04,$FF,$E3,$E0,$05,$06,$E3 
      DC.B      $F4,$07,$06,$F3,$0A,$05,$06,$F3 
      DC.B      $1E,$05,$06,$FF,$F1,'0',$09,$04 
      DC.B      $F3,'F',$07,$06,$F5,'^',$C9,'2' 
      DC.B      $07,$06,$F3,$88,$FF,$07,$06,$F5 
      DC.B      $A0,$CB,'N',$07,$06,$F5,$CE,$CD 
      DC.B      '`',$CF,'h',$CF,'p',$FA,$CF,'v' 
      DC.B      $CF,'|',$CF,$80,$CF,'|',$C3,$88 
      DC.B      '\',$0E,$02,'^',$92,$0F,$02,$01 
      DC.B      '`',$0F,$02,$01,'b',$0F,$02,$01 
      DC.B      'Id',$0F,$02,$01,'f',$0F,$02
      DC.B      $01,'h',$0F,$02,$A6,$02,$14,'j' 
      DC.B      $0F,$02,$01,'l',$0F,$02,$02,$14 
      DC.B      'n',$DB,$0F,$02,$02,$14,'p',$0F 
      DC.B      $02,$02,$14,'r',$0F,$02,$06,$14 
      DC.B      'mt',$0F,$02,$04,$14,'v',$0F
      DC.B      $02,$08,$14,'x',$0F,$02,$B6,$08 
      DC.B      $14,'z',$0F,$02,$0A,$14,'|',$0F 
      DC.B      $02,$0C,$14,'~',$EE,$0F,$02,$0F 
      DC.B      $14,$00,'&',$80,$0F,$02,$0F,$14 
      DC.B      $04,'&',$82,$EF,$0F,$02,$0F,$14 
      DC.B      $0E,'&',$84,$0F,$02,$0F,$14,$0F 
      DC.B      '&',$0A,'8',$7F,$86,$0F,$02,$0F 
      DC.B      $14,$0F,'&',$0F,'8',$0F,'J',$0F 
      DC.B      '\',$0F,'n',$DF,$0F,$80,$0E,$92 
      DC.B      $88,$0F,$A4,$0F,$B6,$0F,$C8,$0F 
      DC.B      $DA,$0F,$EC,$FF,$0F,$FE,$1F,$10 
      DC.B      $1F,'"',$1F,'4',$1F,$8A,$1F,$9C 
      DC.B      $1F,$AE,$1C,$C0,$FF,'/',$04,'/' 
      DC.B      $16,'/(/f/x%' 
      DC.B      $8A,'/',$BA,'/',$CC,$FF,'!',$DE 
      DC.B      '?',$04,'=',$16,'?F;X'
      DC.B      '?„9',$96,'?',$C0,$FF,'9' 
      DC.B      $D2,'?',$F8,'E',$0A,'O.G' 
      DC.B      '@ObCtO',$92,$F7
      DC.B      'C',$A4,'O',$C2,'C',$D4,'O',$EE 
      DC.B      'j_',$1A,'T,_Fw'
      DC.B      'f_nP',$80,'_',$96,'b'
      DC.B      '_',$BE,'P',$D0,'_',$E6,$7F,'^' 
      DC.B      'o',$0C,'o0oTox'
      DC.B      'o',$9C,'n',$BE,'o',$E0,$FF,'}' 
      DC.B      $02,'}"}B}b}' 
      DC.B      $82,'}',$A2,'{',$C0,'}',$DE,$FF 
      DC.B      '}',$FE,$8B,$1C,$8B,'8',$8D,'V' 
      DC.B      $8B,'t',$8B,$90,$8B,$AC,$8B,$C8 
      DC.B      $FF,$8B,$E4,$9B,$00,$9B,$1C,$9B 
      DC.B      '8',$9B,'T™n',$9B,$88,$9B 
      DC.B      $A4,$FF,$99,$BE,$9B,$D8,$99,$F2 
      DC.B      $A9,$0A,$AB,'$',$AB,'@',$A9,'Z' 
      DC.B      $A9,'r',$FF,$AB,$8C,$A9,$A6,$A9 
      DC.B      $BE,$AB,$D8,$A9,$F2,$B9,$0A,$B9 
      DC.B      '"',$B8,':',$FF,$B9,'R',$BC,'l' 
      DC.B      $B9,$86,$B7,$9C,$BB,$B4,$B9,$CE 
      DC.B      $B9,$E6,$B9,$FE,$FF,$C9,$16,$C9 
      DC.B      '.',$C9,'F',$C9,'^',$C9,'v',$C7 
      DC.B      $8C,$CB,$A4,$C7,$BC,$FF,$CB,$D4 
      DC.B      $C7,$EC,$D9,$02,$D9,$1A,$D9,'2' 
      DC.B      $D9,'J',$D9,'b',$D7,'x',$FD,$D9 
      DC.B      $8E,$D9,$A6,$D9,$BE,$D9,$D6,$D9 
      DC.B      $EE,$E9,$06,$C2,$06,$02,'w',$C0 
      DC.B      $08,$02,$E1,'D',$05,$04,$BC,$08 
      DC.B      $02,$E1,'b',$05,$04,'w',$B8,$08 
      DC.B      $02,$E1,$80,$03,$04,$B4,$08,$02 
      DC.B      $E1,$9C,$05,$04,'w',$B0,$08,$02 
      DC.B      $E1,$BA,$05,$04,$AC,$08,$02,$E1 
      DC.B      $D8,$03,$04,'w',$A8,$0A,$02,$E1 
      DC.B      $F6,$03,$04,$A4,$0A,$02,$F1,$14 
      DC.B      $03,$04,'w',$A0,$08,$02,$F1,'0' 
      DC.B      $05,$04,$9C,$08,$02,$F1,'N',$05 
      DC.B      $04,'w',$98,$08,$02,$F1,'l',$05 
      DC.B      $04,$94,$08,$02,$F1,$8A,$05,$04 
      DC.B      'w',$90,$0A,$02,$F1,$AA,$03,$04 
      DC.B      $8C,$08,$02,$F1,$C6,$07,$04,$DD 
      DC.B      $F1,$D8,$05,$04,$86,$08,$02,$F1 
      DC.B      $F6,$05,$04,$82,$08,$02,'U',$80 
      DC.B      $08,$02,'~',$0A,$02,'|',$08,$02 
      DC.B      'z',$08,$02,'Ux',$0A,$02,'v'
      DC.B      $08,$02,'t',$08,$02,'r',$0A,$02 
      DC.B      'Up',$0A,$02,'n',$08,$02,'l'
      DC.B      $08,$02,'j',$0A,$02,'Uh',$08
      DC.B      $02,'f',$0A,$02,'d',$0A,$02,'b' 
      DC.B      $0A,$02,'U`',$08,$02,'^',$0A
      DC.B      $02,'\',$0A,$02,'Z',$0A,$02,'U' 
      DC.B      'X',$0A,$02,'V',$0A,$02,'T',$0A 
      DC.B      $02,'R',$0A,$02,'UP',$0A,$02
      DC.B      'N',$0C,$02,'L',$0A,$02,'J',$0A 
      DC.B      $02,'UH',$0C,$02,'F',$0C,$02
      DC.B      'D',$0A,$02,'B',$0C,$02,'U@'
      DC.B      $0C,$02,'>',$0C,$02,'<',$0C,$02 
      DC.B      ':',$0C,$02,'U8',$0C,$02,'6'
      DC.B      $0E,$02,'4',$0C,$02,'2',$0E,$02 
      DC.B      'U0',$0E,$02,'.',$0E,$02,','
      DC.B      $0E,$02,'*',$0E,$02,'I(',$0F
      DC.B      $02,$00,'&',$0F,$02,$00,'$',$0F 
      DC.B      $02,'$',$00,'"',$0F,$02,$00,' ' 
      DC.B      $0F,$02,$00,$1E,$D3,$0F,$02,$02 
      DC.B      $14,$1C,$0F,$02,$00,$1A,$0F,$02 
      DC.B      $02,$14,'m',$18,$0F,$02,$02,$14 
      DC.B      $16,$0F,$02,$02,$14,$14,$0F,$02 
      DC.B      $B6,$06,$14,$12,$0F,$02,$04,$14 
      DC.B      $10,$0F,$02,$08,$14,$0E,$DB,$0F 
      DC.B      $02,$08,$14,$0C,$0F,$02,$0A,$14 
      DC.B      $0A,$0F,$02,$0C,$14,'w',$08,$0F 
      DC.B      $02,$0F,$14,$00,'&',$06,$0F,$02 
      DC.B      $0F,$14,$04,'&w',$04,$0F,$02
      DC.B      $0F,$14,$0E,'&',$02,$0F,$02,$0F 
      DC.B      $14,$0F,'&',$FF,$0A,'8',$0F,$01 
      DC.B      $0F,$13,$0F,'%',$0F,'7',$0F,'I' 
      DC.B      $0F,'[',$0F,'m',$FF,$0F,$7F,$0F 
      DC.B      $91,$0F,$A3,$0F,$B5,$0F,$C7,$0F 
      DC.B      $D9,$0F,$EB,$0F,$FD,$EF,$1F,$0F 
      DC.B      $1F,'!',$1F,'3',$00,$1F,$8A,$1F 
      DC.B      $9C,$1F,$AE,$1C,$C0,$FF,'/',$04 
      DC.B      '/',$16,'/(/f/x'
      DC.B      '%',$8A,'/',$BA,'/',$CC,$FF,'!' 
      DC.B      $DE,'?',$04,'=',$16,'?F;' 
      DC.B      'X?„9',$96,'?',$C0,$FF
      DC.B      '9',$D2,'?',$F8,'E',$0A,'O.'
      DC.B      'G@ObCtO',$92 
      DC.B      $F7,'C',$A4,'O',$C2,'C',$D4,'O' 
      DC.B      $EE,$1C,'_',$1A,'T,_F'
      DC.B      'w _nP',$80,'_',$96 
      DC.B      '$_',$BE,'P',$D0,'_',$E6,$7F
      DC.B      '(o',$0C,'o0oTo'
      DC.B      'xo',$9C,'n',$BE,'o',$E0,$FF
      DC.B      '}',$02,'}"}B}b'
      DC.B      '}',$82,'}',$A2,'{',$C0,'}',$DE 
      DC.B      $FF,'}',$FE,$8B,$1C,$8B,'8',$8D 
      DC.B      'V',$8B,'t',$8B,$90,$8B,$AC,$8B 
      DC.B      $C8,$FF,$8B,$E4,$9B,$00,$9B,$1C 
      DC.B      $9B,'8™R',$9B,'l',$9B,$88 
      DC.B      $9B,$A4,$FF,$99,$BE,$9B,$D8,$99 
      DC.B      $F2,$A9,$0A,$AB,'$',$AB,'@',$A9 
      DC.B      'Z',$A9,'r',$FF,$AB,$8C,$A9,$A6 
      DC.B      $A9,$BE,$AB,$D8,$A9,$F2,$B9,$0A 
      DC.B      $B9,'"',$B9,':',$FF,$B9,'R',$BB 
      DC.B      'l',$B9,$86,$B7,$9C,$BB,$B4,$B9 
      DC.B      $CE,$B9,$E6,$B9,$FE,$FF,$C9,$16 
      DC.B      $C9,'.',$C9,'F',$C9,'^',$C9,'v' 
      DC.B      $C7,$8C,$CB,$A4,$C7,$BC,$FF,$CB 
      DC.B      $D4,$C7,$EC,$D9,$02,$D9,$1A,$D9 
      DC.B      '2',$D9,'J',$D9,'b',$D7,'x',$FF 
      DC.B      $D9,$8E,$D9,$A6,$D9,$BE,$D9,$D6 
      DC.B      $D9,$EE,$E7,$04,$E9,$1A,$E5,'2' 
      DC.B      $00,$00,$00,$16,$12,'(',$08,$06 
      DC.B      $0A,$00,$06,$0C,$06,'b',$0C,$0C 
      DC.B      $06,$0C,'@',$08,$02,$03,$0A,$0E 
      DC.B      $0A,$0A,$0E,$06,$08,$06,$16,$06 
      DC.B      $04,$00,$02,$06,$06,$0E,$00,$08 
      DC.B      $08,$0C,$06,$06,$0A,' ',$10,'<' 
      DC.B      $08,$0C,$00,$0A,$03,$03,$00,$17 
      DC.B      $03,$03,$C0,'d',$00,'dd',$D0
      DC.B      $04,$04,$01,$01,$01,$00,$F4,$00 
 BSS
      DS.B      2305474 
ZUEND: END
