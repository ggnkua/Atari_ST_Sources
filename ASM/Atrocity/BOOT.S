*** BOOT1 ATROCITY / ATLANTIDE ***
***         BY ZANAK           ***
	
FALCON_1	LEA	$FFFF9800.W,A0
	MOVE.L	#11110011,D0
	MOVE.B	#$F,D1
FALCON_11	SUB.L	D0,A0
	DBF	D1,FALCON_11
	
	LEA	$FFFF9804.W,A0
	MOVE.W	#$FF,D0
FALCON_111	MOVE.L	#$FFFF00FF,(A0)+
	DBF	D0,FALCON_111
	
	LEA	TEXTE_BOOT1(PC),A1	
	MOVE.L	A1,-(SP)
	MOVE.W	#9,-(SP)
	TRAP	#1
	ADDQ.L	#6,SP
	
	MOVE.W	#64,-(SP)
	MOVE.W	#$1E,-(SP)
	TRAP	#14
	ADDQ.L	#4,SP
	
	RTS
	
TEXTE_BOOT1	DC.B	'    *** ATROCITY / ATLANTIDE ***',10,13,10,13,0
	EVEN
	
	