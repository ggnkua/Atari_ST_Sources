;L0000 EQU Begin-$601E 
 TEXT 
Begin:
      MOVEM.L   A0-A3,-(A7) 
      LEA       L0026(PC),A6
      TST.B     (A6)
      BEQ.S     L0003 
      MOVE.L    #$30004,-(A7) 
      TRAP      #$E 
      ADDQ.W    #2,A7 
      MOVEA.L   D0,A2 
      MOVE.W    #$15D,D1
L0001:CLR.L     (A2)+ 
      DBF       D1,L0001
      TRAP      #$E 
      ADDQ.W    #2,A7 
      TST.W     D0
      BEQ.S     L0002 
      ADDI.B    #$14,3(A6)
L0002:PEA       (A6)
      MOVE.W    #9,-(A7) 	;CCONWS 
      TRAP      #1
      ADDQ.W    #6,A7 
L0003:MOVEA.L   20(A7),A5 
      MOVEA.L   16(A5),A0 
      MOVEA.L   8(A5),A6
      LEA       1024(A6),A3 
      BSR       L000B 
      NOP 
      NOP 
      MOVEA.L   #$8686,A0 
      ADDA.L    A3,A0 
      MOVE.L    8(A5),D0
      LEA       28(A3),A1 
      TST.L     (A0)
      BEQ.S     L0007 
      ADDA.L    (A0)+,A1
L0004:ADD.L     D0,(A1) 
L0005:MOVEQ     #0,D1 
      MOVE.B    (A0)+,D1
      SUBQ.W    #1,D1 
      BMI.S     L0007 
      BNE.S     L0006 
      LEA       254(A1),A1
      BRA.S     L0005 
L0006:LEA       1(A1,D1.L),A1 
      BRA.S     L0004 
L0007:MOVE.L    2(A3),12(A5)
      MOVE.L    6(A3),20(A5)
      MOVE.L    10(A3),28(A5) 
      MOVEM.L   8(A5),D0-D1 
      ADD.L     D0,D1 
      MOVE.L    D1,16(A5) 
      MOVE.L    20(A5),D0 
      ADD.L     D0,D1 
      MOVE.L    D1,24(A5) 
      MOVEQ     #$13,D2 
      LEA       L000B(PC),A1
L0008:MOVE.W    -(A1),-(A7) 
      DBF       D2,L0008
      LEA       28(A3),A1 
      MOVEA.L   A6,A3 
      JMP       (A7)
      LEA       40(A7),A7 
L0009:MOVE.L    (A1)+,(A3)+ 
      SUBQ.L    #4,D7 
      BCC.S     L0009 
      MOVEM.L   24(A5),A3/A0
      LEA       0(A0,A3.L),A3 
L000A:CLR.L     (A0)+ 
      CMPA.L    A3,A0 
      BLT.S     L000A 
      MOVEA.L   24(A5),A4 
      MOVEA.L   16(A5),A5 
      MOVEM.L   (A7)+,A0-A3 
      JMP       (A6)
L000B:MOVEA.L   #$869F,A2 
      MOVE.L    A2,D7 
      ADDA.L    A3,A2 
      BSR       L0020 
L000C:BSR.S     L0013 
      BCS.S     L0019 
      BSR.S     L0013 
      BCS.S     L000D 
      MOVE.B    -(A0),-(A2) 
      BRA       L001F 
L000D:BSR.S     L0013 
      BCS.S     L000E 
      MOVEQ     #1,D2 
      BRA.S     L0011 
L000E:LEA       L0025(PC),A4
L000F:MOVE.L    (A4)+,D1
      BSR.S     L0016 
      SUBQ.W    #1,D2 
      BPL.S     L0010 
      BRA.S     L000F 
L0010:SWAP      D1
      ADD.W     D1,D2 
L0011:MOVE.B    -(A0),-(A2) 
      DBF       D2,L0011
      BRA       L001F 
L0012:MOVEQ     #1,D1 
      BSR.S     L0016 
      MOVE.B    0(A4,D2.W),D1 
      ADD.W     D2,D2 
      EXT.W     D1
      MOVE.W    4(A4,D2.W),D4 
      BSR.S     L0016 
      ADD.W     D4,D2 
      RTS 
L0013:ADD.L     D0,D0 
      BEQ.S     L0014 
      RTS 
L0014:BSR.S     L0020 
      ADDX.L    D0,D0 
      RTS 
L0015:BSR.S     L0020 
      ADDX.L    D0,D0 
      BRA.S     L0018 
L0016:CLR.W     D2
L0017:ADD.L     D0,D0 
      BEQ.S     L0015 
L0018:ADDX.L    D2,D2 
      DBF       D1,L0017
      RTS 
L0019:BSR.S     L0013 
      BCS.S     L001A 
      MOVEQ     #1,D3 
      MOVEQ     #7,D1 
      BSR.S     L0016 
      BRA.S     L001E 
L001A:LEA       L0024(PC),A4
      BSR.S     L0013 
      BCS.S     L001B 
      MOVEQ     #2,D3 
      BRA.S     L001D 
L001B:MOVEQ     #1,D1 
      BSR.S     L0016 
      SUBQ.W    #1,D2 
      BMI.S     L001C 
      MOVEQ     #3,D3 
      ADD.W     D2,D3 
      BRA.S     L001D 
L001C:LEA       L0023(PC),A4
      BSR.S     L0012 
      MOVE.W    D2,D3 
      LEA       L0022(PC),A4
L001D:BSR.S     L0012 
L001E:MOVE.B    -1(A2,D2.W),-(A2) 
      DBF       D3,L001E
L001F:CMPA.L    A2,A3 
      BLT       L000C 
      RTS 
L0020:MOVEQ     #3,D6 
L0021:LSL.L     #8,D0 
      MOVE.B    -(A0),D0
      DBF       D6,L0021
      MOVE      #$10,CCR
      RTS 
L0022:DC.B      $04,$07,$08,$0C,$00,$01,$00,'!' 
      DC.B      $01,'!',$03,'!' 
L0023:DC.B      $01,$02,$04,$08,$00,$06,$00,$0A 
      DC.B      $00,$12,$00,'2' 
L0024:DC.B      $03,$04,$06,$08,$00,$01,$00,$11 
      DC.B      $00,'1',$00,$B1 
L0025:DC.B      $00,$02,$00,$01,$00,$05,$00,$02 
      DC.B      $00,$0C,$00,$03,$00,$1B,$00,$04 
L0026:DC.B      $1B,'Y *Sent' 
      DC.B      'ry v2.05'
      DC.B      ' by Eagl'
      DC.B      'e',$00,'`',$1A,$B8,$81,$B2,':' 
      DC.B      $B5,'!P',$EE,'n',$00,'*o' 
      DC.B      $04,$0A,$A0,'x -',$E3,'T' 
      DC.B      $1E,$0E,$14,$D0,$AD,$00,$1C,$06 
      DC.B      $80,$C4,'P/',$16,$E3,$B0,'Q'
      DC.B      $0D,'BgJ',$D8,'V',$06,$C5 
      DC.B      $80,$01,'U',$D7,'Ub',$00,$8C
      DC.B      $84,$C6,$16,']',$0B,$BB,'m',$0C 
      DC.B      'B',$A7,$16,'3',$D1,$B7,' N'
      DC.B      'A\O#',$8B,$95,$C3,$EA
      DC.B      $1A,'B;G',$9A,'Žw',$1D
      DC.B      $02,$ED,'=XXO3',$C0 
      DC.B      'r',$19,$0E,']a<',$27,'.' 
      DC.B      $C0,$D5,$0E,'^',$F2,'k0',$04
      DC.B      $03,$F0,$C1,'<',$A6,'/9',$F8
      DC.B      ':s',$0F,'1',$F8,$05,$0F,$17
      DC.B      $82,$01,'@1q',$82,$AD,'S' 
      DC.B      $CD,'X',$A8,'0',$82,$AA,$04,'x' 
      DC.B      't',$0A,$BF,'`',$82,$A6,'B',$B8 
      DC.B      ' x',$04,'N0<|',$FF 
      DC.B      'B',$1D,$A3,'d2',$C8,'"',$E3
      DC.B      'c',$89,$FE,$ED,$8B,$C1,$82,$12 
      DC.B      $7F,$CF,$B0,$89,'pA',$FA,$03
      DC.B      $B4,$7F,'2',$98,'Q',$CE,$FF,$FC 
      DC.B      'Q',$CF,$FF,$F4,'w',$09,'m',$16 
      DC.B      $D2,$84,$86,$B4,$8B,'R"H' 
      DC.B      'j#',$F8,$E1,$E1,'&',$A1,$86
      DC.B      'n',$04,$AE,$00,'pp',$00,'!'
      DC.B      $C0,$FA,$06,'x',$01,'<',$81,$AA 
      DC.B      $D9,$03,$FE,'*o',$FF,$FF,' '
      DC.B      '8',$8C,'@',$01,$FA,$0C,'9',$FC 
      DC.B      '$',$04,'Ca',$B6,$B0,$B8,$04
      DC.B      'bg',$FA,'Fx',$98,$00,$E8 
      DC.B      '%I/',$C6,'RFk',$08 
      DC.B      $C7,'A',$04,'-”8;',$BA
      DC.B      $BC,'l',$12,$AF,$A7,'+"',$FC
      DC.B      $10,$00,'`',$0C,$1C,$0C,$E5,$A0 
      DC.B      $01,$A2,$02,'g',$F8,'!',$C5,$A2 
      DC.B      $04,$06,$85,$00,'_',$92,$EF,$00 
      DC.B      'Co',$00,$02,'X y',$00
      DC.B      $00,$8A,'t',$D0,$FC,'&',$16,'C' 
      DC.B      $F8,$A2,$06,'><',$00,$A9,'P'
      DC.B      $C1,$12,$FB,'Nq0',$D1,'A' 
      DC.B      $E8,$01,',',$E7,$C3,$1F,'S',$FD 
      DC.B      $C2,'N',$FA,$FD,'@!',$F9,'j'
      DC.B      $00,'p q',$EC,$B0,$AB,'n' 
      DC.B      $08,'8',$FC,$00,'g',$06,$12,'8' 
      DC.B      $FC,$02,'`',$F2,'!',$C0,$FA,$06 
      DC.B      '~',$FF,'Q',$CF,$FF,$FE,$F5,$06 
      DC.B      '"',$82,$07,'TO5FM' 
      DC.B      'u[XO"8',$04,'6'
      DC.B      $92,$80,$04,$81,$84,'cb',$99
      DC.B      $02,$01,$00,$F8,'?9',$82,$03
      DC.B      $86,$9D,'r',$03,'/',$01,$CC,'a' 
      DC.B      $04,$D4,$05,$0E,$C8,$9C,'<',$17 
      DC.B      '<',$27,$10,'^',$E0,$AD,$02,$9C 
      DC.B      '/',$86,'t?',$D2,$E7,'p',$1B
      DC.B      $00,'?<',$00,']NNO' 
      DC.B      $EF,$00,$0A,'B',$A7,'NAb' 
      DC.B      'R',$B8,$04,'fNsd:' 
      DC.B      '\demo.lo'
      DC.B      'd',$FA,$80,$0D,'6',$B0,$EF,'^' 
      DC.B      $CC,'9',$14,'p',$E9,'>',$B0,$81 
      DC.B      $02,$A0,$09,'`',$09,':',$14,$C3 
      DC.B      $E9,$E4,$87,$04,$DE,'M',$E0,$DB 
      DC.B      $1C,'B(',$AE,'`',$F0,'Eo' 
      DC.B      '”{',$8C,$FB,$89,$FB,'wK' 
      DC.B      $E6,$15,'!',$A0,$10,$B9,$86,'P' 
      DC.B      'H',$93,$8D,' ',$81,$12,'`',$12 
      DC.B      $11,$A0,$11,'m',$E8,'n$',$86
      DC.B      $C7,$E4,$DD,'9',$E7,'||',$E9
      DC.B      ']',$0C,'"',$18,'tR',$AA,'|'
      DC.B      '%/',$BB,$02,$8E,$17,$CB,'G'
      DC.B      $DD,$BB,$C6,$03,$10,$E6,$A1,'w' 
      DC.B      'EG',$0E,$11,'`',$19,$EE,$C8
      DC.B      $8D,'@',$04,$05,'<',$B2,$1A,'`' 
      DC.B      $1A,'[',$CF,'=N',$E0,$DF,'9'
      DC.B      'y',$93,$FB,$93,'{w',$C3,$15
      DC.B      $0C,'s',$AE,$BA,$EC,$0D,'ox'
      DC.B      '8',$AD,$FC,'!',$BB,'!_u' 
      DC.B      'Bv00b',$DC,']',$CA 
      DC.B      '+',$F2,'L',$E2,'C',$FF,$E7,'9' 
      DC.B      $FE,$11,$DD,$F0,$93,$F1,$D7,$C1 
      DC.B      $C3,$81,$E0,'#',$A0,'#`"' 
      DC.B      $E0,$1A,' ',$09,$CB,$A2,$DC,$CF 
      DC.B      $03,$F2,'n&',$BE,$0D,'n',$BC
      DC.B      'km{',$EF,$C9,$DD,$19,'(' 
      DC.B      $94,$B2,$8C,'q',$A0,$A3,'7',$CA 
      DC.B      '=',$9C,'Z',$FE,$DD,$C7,'k',$DD 
      DC.B      $E4,'C',$0D,'-d&1',$01
      DC.B      $E0,'[',$01,'$',$B7,$80,'2',$B7 
      DC.B      $CA,'>OxN',$8B,'c',$98
      DC.B      ')',$A0,'1',$E0,'1',$A0,$F4,$EF 
      DC.B      $F0,'Ux',$C1,$C7,')',$A0,$09
      DC.B      ' ',$11,$FC,$E9,$DF,'A$`' 
      DC.B      $D8,'t+',$F0,$A0,$1A,$E0,$11
      DC.B      'Q',$EE,$12,'P',$E0,$BA,'2e'
      DC.B      'W',$F9,$97,$E4,'x',$E0,'{7'
      DC.B      $1B,'s',$AE,$F7,'WM',$EE,$AD
      DC.B      'u',$A5,'4',$06,$0A,$E8,$A2,'J' 
      DC.B      'i',$FE,'%.',$B7,$D2,'~g' 
      DC.B      '`e',$01,$A7,$01,$E9,$02,'+'
      DC.B      $DE,$E4,'.',$16,'k',$02,'j',$10 
      DC.B      $DE,$D8,$0D,$E8,$00,$E5,$0C,$B9 
      DC.B      $0A,'/',$F1,$99,$BE,';',$E0,$10 
      DC.B      '6',$B9,'[c J',$13,$B8
      DC.B      $05,$D9,')`šr',$7F,'y'
      DC.B      $0F,$27,'p',$19,'`',$12,' ',$1B 
      DC.B      ' $ - ',$9F,$DC,$C9 
      DC.B      $08,'5',$E0,'4',$94,$BE,'D',$DD 
      DC.B      '#`',$1A,'`',$19,$E0,$11,$E0
      DC.B      'b',$1A,'R',$1E,$E2,$E1,'!',$9E 
      DC.B      $D6,$DF,$01,$DF,'km„0'
      DC.B      $9C,$F3,$06,$0F,$C7,'0LA' 
      DC.B      $03,$05,$BD,$F7,$B5,$B6,'s',$AE 
      DC.B      'Z',$EB,$D4,$D7,$C1,$EB,$C4,'}' 
      DC.B      $F2,$0F,'@',$F9,'w',$8F,$E3,$B3 
      DC.B      $88,$87,'M/6',$85,$FC,$12 
      DC.B      'p',$03,'/',$10,$DE,$D8,$15,$02 
      DC.B      $AC,$01,$A8,'%',$00,$E4,$D0,'U' 
      DC.B      $DD,'-',$A2,'0',$81,$DB,'z!'
      DC.B      $D6,$97,$DE,'YJ',$BA,'Y',$BA
      DC.B      $09,$84,'`| t',$F6,$CA
      DC.B      $EB,$AE,$BA,$E1,$05,$00,$E0,$09 
      DC.B      $A0,$12,'`',$1B,$FF,'.',$B8,$D8 
      DC.B      ',',$A0,'+',$E0,'"',$A0,$1A,' ' 
      DC.B      $11,$E2,$EF,$0E,$27,$A3,$B5,$BC 
      DC.B      $E1,$02,$86,'Sx',$D3,$FF,'6'
      DC.B      'x',$AD,'u',$C6,'8x7',$13 
      DC.B      'w',$DE,$FB,$CE,'y',$04,'J_'
      DC.B      $D1,$FB,']',$E2,$E1,'I',$F9,'w' 
      DC.B      $1D,$00,$A3,$02,')',$02,$EE,$03 
      DC.B      $B1,$97,$89,'a',$10,$B6,'&',$0E 
      DC.B      '>�u',$B0,$02,$ED,$02,$AB 
      DC.B      $A9,$BA,$7F,'Qg',$01,'%',$00
      DC.B      $A1,'v',$8B,'r',$17,$8A,$02,'6' 
      DC.B      $F9,'R',$E0,'k',$A0,$9D,' S'
      DC.B      $E8,$10,$14,$9D,$BF,$14,$D9,$E1 
      DC.B      $0D,$07,$F7,';`',$A0,$1B,$E1
      DC.B      '<',$D9,'k',$F1,'w',$C3,$E9,'"' 
      DC.B      '`',$19,$A0,'}rw',$E5,$09 
      DC.B      $9F,$BA,$7F,$B2,$FF,$08,'8',$8D 
      DC.B      'O',$EE,$DD,'s',$AE,$84,'0',$A5 
      DC.B      '4L<',$AC,$E9,$DF,$DF,$EF 
      DC.B      $82,'|',$BC,'N',$FE,$00,$E4,$01 
      DC.B      $A8,'] wM',$B2,$05,'8'
      DC.B      '7',$14,'j',$C9,$BA,$05,'z',$05 
      DC.B      '9F0',$E8,$AF,$B5,'p',$EA 
      DC.B      'f',$EA,'&',$E9,$00,$E3,$00,$CA 
      DC.B      $9E,'(',$F7,$A1,$E6,')$',$FA
      DC.B      'c`',$8C,$A0,$A5,$DB,$F4,$FF
      DC.B      $06,$BE,'`',$A5,$A0,$8C,'K',$DF 
      DC.B      $16,'N',$E0,$E4,$86,'S',$F8,$D3 
      DC.B      $FD,$1D,$E0,$E2,'D',$D9,$FC,'`' 
      DC.B      $82,$EF,$93,$FB,'!',$A0,$D3,$BB 
      DC.B      $C6,$1B,$1E,$F5,$1F,$E5,$DE,$B0 
      DC.B      '7',$F9,'7',$FD,'w',$83,$94,$B2 
      DC.B      $87,$AB,$1B,'<',$C6,'8\_' 
      DC.B      '{',$E5,$EE,'w',$C1,$C3,$A3,$F2 
      DC.B      $EF,$1E,'&',$02,'*',$03,'p',$04 
      DC.B      'u<',$17,$1B,$D9,'_',$02,$C1
      DC.B      $A7,$FC,$05,'y',$05,'8',$04,'3' 
      DC.B      $03,$F1,'k',$C7,$A2,'l',$A2,'f' 
      DC.B      $01,'$',$08,$E3,$08,$E1,'! '
      DC.B      'n1',$12,$E5,'J`c ' 
      DC.B      '{',$E0,$9D,' ',$BE,$D7,' ',$CE 
      DC.B      $E0,'!',$D9,'`',$17,'`ku' 
      DC.B      $AF,$A8,$9B,'1',$A0,$18,$DC,'F' 
      DC.B      $A3,$8E,$00,$A0,$01,$05,$DD,$9E 
      DC.B      $DC,$E0,$1B,$E0,'5',$A0,'6`'
      DC.B      '6 ',$E5,'`#',$D0,'4',$E0 
      DC.B      ', + *`)',$E1 
      DC.B      'K',$86,'m',$19,' ',$11,$D5,'=' 
      DC.B      $E5,$DE,$00,'`',$C2,$09,'\@'
      DC.B      'u',$97,$B8,$89,'1',$A6,$84,'0' 
      DC.B      $9C,$F3,'zr',$D7,$D0,'=',$B9
      DC.B      $1B,'(',$E7,'<',$CE,'y',$94,$B2 
      DC.B      '{',$EF,'c,',$A0,$BF,$CE,$DF
      DC.B      '0p',$C3,$99,'x@',$C9,$BF 
      DC.B      $02,$AD,$03,$F3,$E9,$B8,$8A,'N' 
      DC.B      $05,$FB,'~',$06,'=',$05,$FC,'C' 
      DC.B      'u',$93,$F1,$B1,'7',$0E,$06,$0E 
      DC.B      $02,')',$01,$A7,$01,'%',$09,'#' 
      DC.B      $11,'"',$19,'!)`R',$B7
      DC.B      $02,$E6,'!„`',$AD,$A0,$CE 
      DC.B      'e',$F7,$1B,$EC,$DF,'`Z',$E0
      DC.B      $AF,$C2,$1B,'\9',$E0,'!',$E4
      DC.B      '6',$19,'m`',$A0,$09,' ',$09
      DC.B      $E0,$12,$A0,'#',$A0,',',$E4,$A8 
      DC.B      $CB,$10,'`',$A0,'$0',$BF,'4'
      DC.B      $B9,$7F,$17,'<',$CA,$16,'0',$CA 
      DC.B      $19,'&',$CA,$FE,$BB,'B(R' 
      DC.B      $AA,'km',$A5,'4"',$0F,$A3 
      DC.B      'P',$D6,$BA,$F7,$BE,$0E,$8A,'@' 
      DC.B      $F1,$8B,'/',$BD,$FE,$8C,'q',$0A 
      DC.B      ']r',$C1,'1',$A6,$D5,';',$D8
      DC.B      $C8,$01,$E9,$03,'.',$04,'t',$BF 
      DC.B      $CB,$E4,'a',$06,'<',$1A,$EA,';' 
      DC.B      ' >y',$04,$F7,$03,$F2,$03 
      DC.B      'p',$02,$AB,$01,$E8,$01,'e',$09 
      DC.B      '$',$19,'b!a1',$27,$EA
      DC.B      'F',$B0,'[ | ',$94,$E0
      DC.B      $BE,' ',$96,$C7,$10,'$',$D7,' ' 
      DC.B      $BE,'0',$EA,$BD,$C1,' ',$CB,'.' 
      DC.B      $E8,$92,'B ',$AB,$A8,$F7,$27
      DC.B      $09,' ',$11,$A0,$1A,'`#`' 
      DC.B      ',',$E0,$7F,'2',$04,$09,'`5'
      DC.B      ' 4',$A0,'4`3',$E0,'*'
      DC.B      '`<&`',$13,'* ',$E0 
      DC.B      ')',$A0,'P',$81,$9B,$80,'!`'
      DC.B      $19,' ',$10,$E0,$A0,'a�y' 
      DC.B      $D8,$0F,$F6,$EE,$82,'s',$AE,$94 
      DC.B      $B2,$A5,'4',$C6,'8?',$B9,'s'
      DC.B      '8',$F6,$E4,$DF,$F4,$BD,$F7,$AD 
      DC.B      'uZ',$EB,$EE,$9E,$DC,$F5,']'
      DC.B      $F0,$F0,$A0,$DC,'M',$EF,$18,$03 
      DC.B      '/',$05,'z',$06,'=WQ '
      DC.B      $BA,'>',$EF,$84,$1C,'s',$05,'9' 
      DC.B      $04,'u',$03,$F2,$02,$ED,$02,')' 
      DC.B      $09,$A6,$11,'d',$19,'b1',$09
      DC.B      $8C,'J<',$A0,'c`„`' 
      DC.B      $9D,' ',$C6,'`$C',$F0,$C9 
      DC.B      $DF,'`',$C6,$BF,$C1,$BB,'ck'
      DC.B      $A0,'R',$E0,'J`',$10,$A0,$87
      DC.B      'E',$BD,$EB,$A1,$1A,'!#!' 
      DC.B      '+;',$E0,'a',$04,$E1,'4',$A1
      DC.B      '4a4!3',$A1,'2',$E1 
      DC.B      '*',$A1,'*a"(',$E0,$80
      DC.B      '*!',$E1,$09,$A8,$C0,$B0,'!'
      DC.B      'a',$19,'!',$10,$E1,$10,$A1,'*' 
      DC.B      $E0,'X',$D0,'uL',$F2,'W{' 
      DC.B      $EF,$9C,$F3,$F1,$BB,$E0,$AE,$CE 
      DC.B      'y',$B5,$B6,$BB,$89,';w',$D5
      DC.B      $FD,'.x;',$87,$AF,$13,$C8 
      DC.B      $BF,$99,$E4,'*|',$A7,'x',$80
      DC.B      $05,$FD,$05,$BA,'qv',$1D,$B8
      DC.B      $04,'3',$03,'.',$11,$A4,'!',$A2 
      DC.B      ')',$A1,':',$EE,$C9,']',$AC,'s' 
      DC.B      $A0,$8C,$A0,$A5,'`',$CE,$A0,$E7 
      DC.B      '`',$E5,$B2,$EF,$82,$CE,'s',$E0 
      DC.B      '[ R',$A0,$03,$EF,$8E,$1D 
      DC.B      $16,$F5,$FE,$1D,$E1,$11,'b',$19 
      DC.B      $E2,'"',$A2,'+c3',$E3,'c' 
      DC.B      '4#3',$A3,'3p',$B3,$C0
      DC.B      $87,$E3,$A3,'2c!H',$E0
      DC.B      '&2#1',$E3,')',$A3,')'
      DC.B      $A0,$04,'|',$02,'c!#',$19 
      DC.B      '#>',$1F,$83,'/c',$A0,$BB 
      DC.B      $89,'c,',$F0,$FA,$AB,$EE,'&'
      DC.B      $CE,'/',$BE,$DF,$1D,$FE,$E4,'>' 
      DC.B      $E5,$BF,$E5,'/',$E0,$95,'{',$95 
      DC.B      $7F,'z',$85,'w7',$DC,';',$02
      DC.B      'k',$03,'p',$04,$B6,$C6,$C3,$9E 
      DC.B      'l',$05,'C',$FD,$E8,'>',$02,$12 
      DC.B      'xx',$7F,$BB,$05,$E4,$C9,$06
      DC.B      $04,'t',$03,'o',$02,$AB,$0A,'(' 
      DC.B      $19,$A5,'!',$A3,'1',$E1,'B '
      DC.B      '{',$E0,$94,$E0,$AD,'\',$02,$F3 
      DC.B      $F0,$D6,$E0,$B6,'-',$FE,'nx'
      DC.B      '| c`Z',$E0,'9',$E0 
      DC.B      ')`',$18,$E0,$DB,$B1,$CF,$AE
      DC.B      '`!',$E3,'*d3$;'
      DC.B      'š',$27,'w1;',$E5,'C',$A5 
      DC.B      ';',$05,$03,'K',$C0,$E6,$A6,$A0 
      DC.B      $80,$04,$A6,':fB:&' 
      DC.B      '1',$E6,'F',$C0,$16,'x',$B7,$B0 
      DC.B      $07,$16,'Z',$EB,'s',$AE,$8C,'q' 
      DC.B      '7',$D1,$DE,'0',$C6,'8',$08,$D5 
      DC.B      $F4,$FF,$DD,'pt',$9F,'9',$E7
      DC.B      $DC,$CB,$DC,'%1',$A6,$A0,$02
      DC.B      $C1,$AF,'!$',$DC,'u',$F5,'_'
      DC.B      'N',$E1,$DF,$1C,$AC,$03,$B1,$F2 
      DC.B      $F6,$1D,$F0,'PW0',$F8,'}' 
      DC.B      '~',$F2,$0A,'H`',$FB,$9E,'l'
      DC.B      $9E,$EC,'p',$0A,'i',$19,$E5,')' 
      DC.B      $E3,':!J`„ ',$9D
      DC.B      ' ',$B5,$E0,$B1,$B6,$CC,$C3,'0' 
      DC.B      $06,$11,$0C,$EF,$E0,$D7,' ',$BA 
      DC.B      $F0,$15,$BC,'k',$A0,'c B' 
      DC.B      ' ',$EC,$A2,$1B,$F6,$A1,$19,'"' 
      DC.B      ')',$A4,'2eB',$E6,'Kg'
      DC.B      'K',$A7,'K',$E7,'K',$E4,$DF,'d' 
      DC.B      $13,$A8,$98,$80,$F6,'BS)' 
      DC.B      $AF,$80,'j|Z',$EA,$00,'8' 
      DC.B      'A',$27,$10,'|',$A1,$E1,'$',$82 
      DC.B      $C8,'!',$94,$B2,$B7,$EA,'f',$F0 
      DC.B      $A8,'w{',$E5,'c,}r' 
      DC.B      $E7,'V',$A3,$1E,$EA,$02,':('
      DC.B      ' ',$82,'R',$AA,'JiB('
      DC.B      'A',$0F,$9B,'r!$',$D7,$94 
      DC.B      '{x',$AC,$C2,$BF,'{',$9C,$EF
      DC.B      $10,$87,$B0,$FC,$C9,$1D,'B',$C6 
      DC.B      '=',$05,$FC,$05,'8',$03,$BE,$E3 
      DC.B      $FE,$B1,$02,$EC,$0A,'i',$1A,'%' 
      DC.B      '*#:!R',$A0,'k`'
      DC.B      '„`',$A5,'`',$BE,' ',$9E,$EC
      DC.B      $04,$FB,$A0,$0E,'q',$9E,$EC,'`' 
      DC.B      's',$E0,'c`A',$D7,'=',$D9 
      DC.B      $A0,$19,'#)',$A5,':gJ'
      DC.B      $E8,'Si[',$AA,'|',$17,$FC 
      DC.B      'L[',$EA,'c',$EB,'@',$09,$A8
      DC.B      $C0,$AB,'[kk',$AD,'M@'
      DC.B      $E9,$FB,'|/',$B1,$AB,$CC,'?'
      DC.B      $A2,$C1,'!l',$F8,$83,$EE,'!'
      DC.B      $8B,$D6,$82,$DB,$F4,$1F,$0C,$0E 
      DC.B      $C6,'8.j',$95,$A5,'PC'
      DC.B      $05,$83,'c,/',$A1,$80,'*' 
      DC.B      'km',$F2,$CF,'q',$D7,'9',$E7
      DC.B      ')e',$94,$BB,$9B,'z',$0F,$0F
      DC.B      $F8,'7',$D8,$F1,$EF,$16,'o',$B2 
      DC.B      $BF,$BA,$0F,'/',$F8,'w',$0A,$EC 
      DC.B      $12,$A9,$1A,'e2#Ba' 
      DC.B      'Z',$E0,'s',$A0,$8C,$A0,$C3,$09 
      DC.B      $8C,$C2,$A0,$E7,$27,$F7,$00,'p' 
      DC.B      '`',$AD,$A0,'=',$B9,'7t|' 
      DC.B      ' k',$A0,'J`1',$C5,$BE
      DC.B      $03,'Ž!$1',$E6,'Jh' 
      DC.B      '[*c',$AC,'h',$19,$83,$C1 
      DC.B      't.l-k',$ED,$0F,$FB 
      DC.B      $B1,'c',$94,$F2,'>zW',$C6 
      DC.B      '.`',$C5,$1F,'RprE' 
      DC.B      $0C,'>',$8A,'*v3',$B8,$80 
      DC.B      $E1,$0C,$1E,$F3,$0E,'!',$82,'A' 
      DC.B      '{',$EF,$C7,'P@',$F5,$ED,'I'
      DC.B      $FE,$11,'s',$AE,'Z',$EB,'Ji'
      DC.B      '1',$A6,$FE,$A0,$8E,$F1,$10,$A2 
      DC.B      '):',$BF,$0B,$02,$ED,$BB,'r'
      DC.B      '=',$D9,$F3,$0D,$06,'N',$A1,$81 
      DC.B      $02,'F',$D9,$06,';',$06,'<+'
      DC.B      $E8,$FA,'Ne2cJ',$A1 
      DC.B      'c {',$E0,$94,$E0,$B5,$A0 
      DC.B      $C6,'q',$01,'[',$FC,$C6,$A0,$AD 
      DC.B      ']',$E2,$ED,$C9,$84,$A0,$E6,$C9 
      DC.B      $9D,$27,';',$AC,$9F,$FC,'9',$E7 
      DC.B      'R',$AA,'kls',$EE,$8C,$B1 
      DC.B      $84,$B0,$C7,$FC,$0D,$BA,'|o'
      DC.B      '„0',$13,$D0,$11,$09,$A2,$BB
      DC.B      $93,$FE,$FA,'V',$EC,'A',$AF,$D8 
      DC.B      $27,$F6,')',$F7,$E0,$93,'x',$EB 
      DC.B      $DD,$1C,'>',$D0,$E0,$C4,$8C,'q' 
      DC.B      '2',$18,'|',$05,$F8,';x',$F4
      DC.B      '?',$CA,$E0,'QJi',$10,$A2 
      DC.B      $FE,$F2,$13,'O',$03,$F2,'}7'
      DC.B      $E4,$FA,$0E,$C8,$BB,'9x|' 
      DC.B      $C7,$9D,$EF,'c`| ',$9C
      DC.B      $E0,$16,$0F,'{r`',$DF,'g' 
      DC.B      '0 \?7',$BB,$E8,$8C 
      DC.B      '`s',$E0,'R',$E0,'9',$E0,'!'
      DC.B      '`',$08,'a',$96,'A*E)'
      DC.B      'eB(s',$AE,$84,'p',$1D
      DC.B      $A0,$0E,'A',$9D,'3',$01,$A5,$A0 
      DC.B      $80,$8C,$B1,$F4,$CA,$CC,$8B,$F6 
      DC.B      $BE,'7',$C6,'x',$BD,$C7,'~',$93 
      DC.B      $EE,$81,$E0,$E7,$0C,$AE,$A0,$81 
      DC.B      $AF,'~',$E1,$DE,$CD,$C4,$C3,'K' 
      DC.B      $9C,$F3,'<',$E8,$1A,$F0,$CF,$E6 
      DC.B      $F0,$07,'c,Z',$EB,$F7,$F0 
      DC.B      $86,';',$18,$E3,'<',$15,$F8,$BB 
      DC.B      '.',$C7,$F9,$CE,'q',$B9,$01,$09 
      DC.B      $DC,']',$F0,$1D,$F7,$EF,$12,$A9 
      DC.B      '"R',$E1,$80,$B7,$27,'[ ' 
      DC.B      $B5,'O',$F6,'z',$1C,$D7,' ',$18 
      DC.B      '.}',$9F,$A5,'`',$8C,$A0,'|'
      DC.B      ' [ ',$DC,$C7,$9E,$DC,'%' 
      DC.B      '}r7R',$A9,'km„'
      DC.B      '0',$94,$F2,'t',$AC,$C9,$DD,$A5 
      DC.B      'tA',$05,$15,'tx/',$F6
      DC.B      $01,'pp',$01,'+',$F6,$E0,'W'
      DC.B      $FD,'O',$F9,$BF,$FE,$89,'{@'
      DC.B      $13,$7F,$F1,$87,'P',$C1,$A0,'s' 
      DC.B      $D8,$E4,$7F,$0D,'N<',$E2,$FD
      DC.B      $C5,$AD,'u',$94,$B2,'{',$EF,'1' 
      DC.B      $A6,'=',$0C,'P',$D9,'3',$F9,$1D 
      DC.B      $91,$F3,']',$F0,'(',$FB,$BA,$05 
      DC.B      $FA,$A0,$B7,$EB,$84,$BB,$05,'8' 
      DC.B      $04,$B5,$03,$F1,$0B,',',$BB,'K' 
      DC.B      $F6,$E4,':',$A3,'S!k',$A0 
      DC.B      $84,'`',$9D,'`',$B6,' ~',$06
      DC.B      'a',$93,$D6,$A0,$BE,' ',$7F,$F0 
      DC.B      $91,$B7,'| c`B='
      DC.B      $B9,$BF,$EF,$8C,'q',$18,$17,$9E 
      DC.B      'M',$EF,'S',$FF,')-^',$02 
      DC.B      $0E,$1E,$D0,$C4,'%',$1C,'/x'
      DC.B      $88,$FB,'wG',$1E,$F4,$01,$F7
      DC.B      $EE,$82,'G6',$BC,$C5,$9F,$D1
      DC.B      '(„0B()e '
      DC.B      $F7,$B0,'(',$9B,$EF,$94,'<',$BC 
      DC.B      $E0,'A',$D7,'w',$BA,$04,'u',$03 
      DC.B      $B0,$0B,'+',$1A,$A9,'*f',$BB
L0027:DC.B      $E0,$80,'[s',$E0,$8C,$A0,$A5
      BRA.S     L0027 
      DC.B      $E4,$1E,'Fa',$A0,'qx',$A0 
      DC.B      $84,'`c',$9F,'l',$C8,'m)' 
      DC.B      $A0,'O',$B6,$BE,$1B,'R',$AA,'s' 
      DC.B      $AE,$94,$B1,$AD,'u|',$AC,$E9
      DC.B      'Q',$FE,$DF,$E0,$C6,$01,$8E,$B7 
      DC.B      $DD,$7F,$B7,$F8,'m',$8D,$CF,'z' 
      DC.B      $81,$BB,$80,$F5,$FE,$BD,'5',$1E 
      DC.B      $E5,$EF,'h',$94,$BB,'Ji1' 
      DC.B      $A6,$A0,'N',$CE,$EF,'o',$04,'t' 
      DC.B      $80,$BC,'}',$07,'<',$BC,$CB,$9D 
      DC.B      $C2,$FB,$02,$12,'@\',$BA,$0C
      DC.B      $F7,$AF,$12,$EB,$1A,$A8,'*e'
      DC.B      'B',$A3,'[!| ',$94,$E0
      DC.B      $AD,$DE,$F6,'d',$13,$D8,$D4,$DD 
      DC.B      $F4,'@',$F0,$F0,$06,$9C,$E0,$8C 
      DC.B      '`k`J`Gw',$EC 
      DC.B      $BB,'R',$AA,'{',$EF,$94,$B2,$E1 
      DC.B      'a',$0E,'~',$B7,$E4,$D9,$0D,$7F 
      DC.B      '.',$F8,'w',$89,$BF,'z@',$89
      DC.B      '[',$F8,$DD,$F0,'n',$0E,$7F,$F9 
      DC.B      $07,$08,'_',$A5,'4',$B0,'W”'
      DC.B      'RB(',$18,$E3,$08,'a',$F1 
      DC.B      $19,$F6,'M',$BA,'"',$A7,'=',$E0 
      DC.B      $06,'<',$8D,'gP',$D9,$BA,$0C
      DC.B      $F6,$0C,'t',$0B,'o',$01,$7F,'r' 
      DC.B      $17,'h{',$B2,'yr[',$95
      DC.B      $E7,$C9,'f',$CB,'~|',$D3,$BD
      DC.B      $80,$DF,$05,$87,$8C,$A0,'k',$A0 
      DC.B      'J',$A0,'1',$A0,$00,' ',$17,']' 
      DC.B      'r',$CB,$BE,'[|',$F1,$FD,$A1
      DC.B      $C1,$BF,'k',$FC,$E9,$9F,$FE,$07 
      DC.B      $FF,$AA,$7F,'7',$BC,$B6,$C4,'c' 
      DC.B      $0B,'>',$E3,$FE,']',$F0,'K',$0E 
      DC.B      $0F,$0C,$1F,'q',$CF,$DB,'km'
      DC.B      'Ji',$18,$E3,$BF,$FE,'08' 
      DC.B      $BF,$C1,'A',$FE,'~',$1D,$E2,',' 
      DC.B      '===0�g',$97,$F6
      DC.B      $27,'{',$9E,$DC,$12,$AA,$1A,'(' 
      DC.B      '*%B',$A2,'ca| '
      DC.B      $9D,' ',$B5,$E0,$09,$EC,'q',$D3 
      DC.B      '}',$93,$BB,$BC,$F6,'>',$D9,$BB 
      DC.B      $94,$A0,'s',$A0,'R',$A0,'1;'
      DC.B      't',$8B,'}g',$E5,$0B,$0C,$BE
      DC.B      $E5,'_',$F0,'o',$82,$DF,'3x'
      DC.B      '8',$83,'?',$F9,$9B,$B8,$0D,$1E 
      DC.B      $FE,$DD,$E2,$81,$E1,$87,$05,'g' 
      DC.B      $B4,$C1,$DD,')e',$18,$E3,'O'
      DC.B      '=',$DD,'w.',$04,'4',$04,$F7
      DC.B      $8E,$BF,$EF,$14,'~',$17,$90,'^' 
      DC.B      $A2,'>y',$14,$B6,$14,'s',$13
      DC.B      'n',$1A,'j"',$27,'*$',$03 
      DC.B      $CE,$93,$1D,$84,'`',$9D,'`O'
      DC.B      $EE,$ED,$B0,$80,$0E,'J',$B6,$88 
      DC.B      $BF,$81,$C3,$CE,'`',$0B,$8E,$BE 
      DC.B      $C0,'R',$E0,'9',$E0,$FB,$E4,$EE 
      DC.B      $BE,$BB,$F2,$DE,$EF,$FA,$1F,$F4 
      DC.B      'Of',$F0,$CC,$F0,$11,'w',$03
      DC.B      $01,$FF,$F3,$E1,'_',$DC,$E2,$07 
      DC.B      $FF,$A1,$1E,$08,'^',$EF,$84,'0' 
      DC.B      'c,1',$A6,'?[',$F0,'0'
      DC.B      '~',$05,$FC,$0D,'z',$14,$F7,$1C 
      DC.B      't',$1B,$F0,'"',$AA,'"',$27,')' 
      DC.B      $E4,'Bb[ ',$8C,'9',$BF
      DC.B      $E3,'r',$05,'cp',$EA,'~r' 
      DC.B      'gP',$A5,'B',$02,$FD,'E',$E0
      DC.B      $BE,'A=',$F9,$17,'s',$E0,'Z'
      DC.B      $E0,':',$D9,$E0,$BE,$EF,'Z',$EB 
      DC.B      '{',$EF,$9C,$F3,$84,$87,'=',$FD 
      DC.B      $BB,'!gq',$F4,$B7,$0B,$1E 
      DC.B      $E5,'_R',$F0,$A6,$FF,$F0,$06
      DC.B      $F7,$BE,$17,'P',$BB,$FE,$0A,$0E 
      DC.B      $FE,$CD,$E0,$C1,'?',$F0,$8F,'f' 
      DC.B      $F0,$06,'wQ',$9F,$FC,'s',$AE
      DC.B      $01,$95,$9D,$DF,'t',$05,'8',$05 
      DC.B      $BB,$06,'>',$09,$B9,$D8,'w='
      DC.B      $0D,$BB,$15,'8',$1C,$B4,$1C,'1' 
      DC.B      '"',$AB,'"h2%Bb'
      DC.B      'ca',$94,$E0,'Dž`',$1C
      DC.B      $C6,$12,$E8,'/',$DF,$95,$01,$A7 
      DC.B      $CB,'~',$C6,'r',$27,$D0,'_|'
      DC.B      ' [ B ',$8A,'nw'
      DC.B      $C3,$BE,$1B,'N',$E8,'wG',$DE
      DC.B      'P',$F0,$0E,'p',$F0,$F0,$82,$D7 
      DC.B      'w',$B8,$85,$B1,$0D,$FF,'.',$F1 
      DC.B      'Wp',$F0,$E3,$06,$BF,',x' 
      DC.B      $D0,$C7,$0B,$1E,$D8,$9C,$F3,'{' 
      DC.B      $EF,'B()e',$E0,'c',$DF
      DC.B      '9/',$04,'4',$DE,$BE,'s<' 
      DC.B      $0D,$FC,$15,'y',$1C,$F6,'$s'
      DC.B      '#',$AE,'*',$EA,':',$A6,'R',$E3 
      DC.B      's',$E2,$9D,'!',$BD,'0|',$C8
      DC.B      'N',$A0,$CE,$A0,$BE,'0',$0B,']' 
      DC.B      $D4,$A5,$A0,$AD,$AD,$C0,$8D,'9' 
      DC.B      ',',$A0,$BF,';',$9D,'`„`' 
      DC.B      'c`J`',$EE,'c',$DF,$15
      DC.B      'yC',$C1,$BF,'K',$BC,$BB,$E0
      DC.B      $E1,'%',$9E,$DC,$E1,'Q',$EF,$10 
      DC.B      $86,$B8,'?',$F9,'C',$F8,$DD,$E2 
      DC.B      $C1,$DF,$E6,$F0,$A0,$27,$17,'<' 
      DC.B      $A5,'41',$A6,$EE,$D7,$93,$BB
      DC.B      $BE,'s',$F2,$A3,'/',$B9,$07,$FF 
      DC.B      $0E,'<',$15,$BA,$1D,'7$',$B4
      DC.B      '+',$F0,'++:',$E7,'Sd'
      DC.B      '|"',$A5,'a',$C6,'!',$C7,'V'
      DC.B      '0',$01,$D6,$E0,$C6,$A0,$A5,'`' 
      DC.B      $9D,' ]',$94,$BB,'s',$B0,$C9
      DC.B      $9D,'@',$CE,$A5,$A0,$84,$A0,'k' 
      DC.B      '`Jw)',$B2,$C5,$BE,$93
      DC.B      $F2,$A0,$B7,$FC,'%',$05,$8F,$F2 
      DC.B      $FF,$EE,$F1,'S',$D7,'P',$EF,'}' 
      DC.B      '@',$B9,$18,$DB,'"',$DF,$E6,$F0 
      DC.B      $F0,$86,'w',$BF,$8C,'qJi' 
      DC.B      '3',$EA,$AB,$FB,$7F,'N',$C9,$83 
      DC.B      $CE,$E1,$97,$DC,$03,$0E,'}',$15 
      DC.B      $FB,$1D,'y$',$F5,',13'
      DC.B      $AD,'Cic',$E5,$8C,$A3,$B5 
      DC.B      $E2,$CE,$A1,$C0,$D5,'U0',$DF
      DC.B      ' ',$01,'5',$F2,$94,$AD,'M '
      DC.B      $8D,$BB,$0B,$AE,$AF,$BD,$AD,$E0 
      DC.B      $8C,$A0,'k',$A0,'R',$A0,'c',$DF 
      DC.B      '5',$F9,$C5,$FF,']',$E2,'A',$FF 
      DC.B      $F5,$EF,$1E,$07,$F2,$BB,$27,$FF 
      DC.B      $06,'79žt~x',$27
      DC.B      $E4,'<',$D9,'~',$07,$9D,$C3,$F3 
      DC.B      '<K ',$B8,$BA,$0E,'}',$BA 
      DC.B      '%7,',$B3,';',$EE,'K',$EA 
      DC.B      'l&',$95,'$',$B6,'"',$D6,$E1
      DC.B      'z',$B2,$0B,'L',$C0,'(w',$0A
      DC.B      $C6,$B6,' ',$BE,'`',$C6,$09,$BB 
      DC.B      $DF,$95,$DD,$E4,$AE,'/',$B5,$E0 
      DC.B      $94,$E0,'s',$E0,'R',$E0,$BC,'c' 
      DC.B      $DF,$05,'y}',$13,$FF,'n',$C8
      DC.B      'O',$C0,$8B,$7F,'7',$C8,$BF,$1B 
      DC.B      '^',$EA,$DF,'5žY',$F0,$EF 
      DC.B      $1E,$FF,$06,$0B,$F9,'w}|' 
      DC.B      $C3,$83,'N`',$C6,$1B,$9E,$E3
      DC.B      $0E,'=',$16,'<',$1D,$FA,'%w'
      DC.B      '4',$F4,'<oT+t',$A7 
      DC.B      $95,'d',$BE,'c',$D7,'!',$A0,$E7 
      DC.B      '`',$DF,' ',$D6,$AE,'`#',$87
      DC.B      $CE,$E0,$05,'^',$0A,$E2,$D7,' ' 
      DC.B      $B6,' ',$9D,' | [K' 
      DC.B      '`',$8F,';',$D9,'w',$8A,$0B,$FA 
      DC.B      ']”W',$FA,$7F,'W',$E4,$0C 
      DC.B      $C6,'v',$F1,$CC,$82,$7F,$17,'<' 
      DC.B      $EA,$BF,$18,$1C,$FC,$B2,$C5,$BF 
      DC.B      $93,'r~',$BB,$0B,$0E,'ox' 
      DC.B      $C0,$9F,$FE,'%',$FB,'-',$B8,'5' 
      DC.B      '4D',$F0,'e-}i',$A5 
      DC.B      $E6,$C6,$A3,$DF,'a',$0D,',',$F4 
      DC.B      $8F,'.',$A0,$83,$DB,$DF,'`',$BE 
      DC.B      '`',$A5,'`„`c%N'
      DC.B      $F6,$0D,'V',$FC,$BB,$C4,$EB,$0B 
      DC.B      $FE,']',$E3,'7',$FF,$DF,$A5,'4' 
      DC.B      $05,$B9,'n',$DE,'c',$C1,$8B,$7F 
      DC.B      $D7,'x',$D4,$7F,'x',$C1,$9B,$FC 
      DC.B      $BF,'k',$FC,$9B,'o',$04,'3@'
      DC.B      $DE,$BE,$D9,$F8,$93,$7F,'75'
      DC.B      $F9,'=uM1mm',$85
      DC.B      $AA,$A6,'&',$C6,$E3,$DF,'8',$F8 
      DC.B      $93,$FF,$80,'}',$87,$B8,$E7,$A0 
      DC.B      $DF,'`',$C6,$A0,$AD,$A0,$8C,$A0 
      DC.B      'k',$80,$8A,'.q',$B2,'o0' 
      DC.B      $F0,$EF,$82,$BC,$F4,$BF,'[',$BC 
      DC.B      $EC,'?',$CA,$BD,$A1,$C5,$8F,$19 
      DC.B      '<',$B6,$C3,$BF,';',$F2,$F0,$82 
      DC.B      $C7,$BC,'/',$FD,$7F,$94,$B2,'Z' 
      DC.B      $EB,'Ji7<',$EC,';',$FA
      DC.B      '&',$0F,'/q',$86,$EC,$BF,$13
      DC.B      'E',$B6,'Uru',$AD,$8D,$EA 
      DC.B      $AE,'f',$CF,'#~',$F6,$9D,$92
      DC.B      '`',$CE,$A0,$B5,$E0,$94,$E0,'s' 
      DC.B      $A0,$93,'}',$B7,$F8,$C3,$FE,$DD 
      DC.B      $F0,$89,$FD,$BB,$C7,'o',$FC,$C3 
      DC.B      $1B,$FC,$E9,'?',$C4,$FD,$BB,$C7 
      DC.B      'C',$DC,$BF,'k<',$BC,$C4,$BB
      DC.B      '[{',$EF,$1C,'SG',$85,'B' 
      DC.B      '(',$A7,$BE,'S',$F2,'p',$0A,$0F 
      DC.B      '<',$BF,'M',$F6,$DF,']',$F2,'}' 
      DC.B      $ED,$96,'*',$B6,$A6,$CF,'c',$E7 
      DC.B      $A1,$0D,'?',$FB,'.',$D6,$E0,$BD 
      DC.B      $E0,$9C,$E0,'{',$E0,$C9,$C7,$BE 
      DC.B      'K',$FC,$9B,$C1,$BF,$1B,'^',$B1 
      DC.B      $9F,'t',$F8,$DE,$7F,$D0,$C3,';' 
      DC.B      $FC,$BB,'%',$BF,'q',$17,$F0,$BB 
      DC.B      $C5,$BB,$DC,$8F,'.`',$83,$FB
      DC.B      'q',$C3,'iE',$95,'O<',$E9 
      DC.B      $FC,$CE,$C9,$A3,$EC,$FA,$03,$B3 
      DC.B      'c/=',$F9,'M',$F6,'e',$F2 
      DC.B      $86,'-',$96,'j',$B6,$E6,$D7,'c' 
      DC.B      $DD,'?',$F9,$0B,$D8,$93,$7F,' ' 
      DC.B      $D7,' ',$BE,' ',$A5,' „ ' 
      DC.B      $C8,$D1,'Uw9',$E7,'R',$AA 
      DC.B      's',$AE,$84,'0',$EC,$C9,$7F,$EC 
      DC.B      $C9,'?h',$FF,'n',$F1,'K',$7F
      DC.B      $08,$BB,$19,'\',$C5,$85,$86,'W' 
      DC.B      $82,$C7,$82,$87,$A7,$B9,$27,$17 
      DC.B      '|',$C1,$DD,$D6,$EF,$82,'W6'
      DC.B      '<',$F8,$0D,$EE,$94,$B2,'c,'
      DC.B      'B()e7',$FE,'o',$FB 
      DC.B      $D8,'wL',$1E,':^p',$96
      DC.B      $EC,$9B,$EC,$BF,$0B,'U',$F6,'m' 
      DC.B      $F2,'Žm',$9E,$AA,$BF,$E1,'N'
      DC.B      $F6,$E4,$CE,$A8,'/=',$00,$BC
      DC.B      $CA,$9E,$B2,$E0,$DF,$83,$8E,$BF 
      DC.B      $04,$AD,$A0,$8C,'`',$08,'a',$DD 
      DC.B      'aO',$FE,'R',$AA,$FA,'.q' 
      DC.B      $07,$BF,$0B,$F2,'n',$06,$DF,'u' 
      DC.B      $08,'k',$DC,$BF,'[',$F2,$A6,$FF 
      DC.B      $1C,$FF,$EF,$86,$BF,$FD,$C1,$1F 
      DC.B      $F1,$CF,'q',$7F,$DB,'Z',$EB,'9' 
      DC.B      $E7,$01,'u',$DF,$01,$B1,$04,'4' 
      DC.B      'y',$FB,$0E,'x',$D0,$F5,'Mz'
      DC.B      ';',$06,'<',$0E,'<',$1E,'<',$D0 
      DC.B      $09,'~',$D8,$A6,'w',$C3,'yr'
      DC.B      $A3,$E7,$A1,'oi',$EE,'K7' 
      DC.B      'P@{',$D6,$E0,$E7,'%`'
      DC.B      $D5,';',$EF,$8C,$A0,$00,' ',$10 
      DC.B      $A2,$81,$F9,$0E,'x',$98,$A3,$DF 
      DC.B      '=>',$FA,$A9,$FE,$F7,$7F,$E6
      DC.B      $DF,$D0,'p',$0B,$17,$18,$BC,$D2 
      DC.B      $FD,$C9,$9F,$C2,$EF,$86,$E7,$B8 
      DC.B      $13,$FB,$E1,$9F,$FF,$9E,$E0,$1F 
      DC.B      $FA,$81,$E1,$0A,'N„0R'
      DC.B      $AA,$17,$FC,$C0,$DD,'!$',$D9
      DC.B      $A9,$EF,$1C,$B0,$03,$F3,'o',$DF 
      DC.B      $01,'?{g',$F0,$A2,$B3,$0E 
      DC.B      '}d_t',$AF,$F9,']',$F6
      DC.B      'u',$F2,$96,$27,$FB,$B0,$EF,$DF 
      DC.B      'a',$80,'k',$ED,'n',$BE,$B2,$15 
      DC.B      $0C,'>S6',$BC,$EC,$DF,' ' 
      DC.B      $E7,'`',$E7,$A0,$B5,$E0,$94,$E0 
      DC.B      $86,$F9,$8B,$AF,$FB,$EE,$F1,'Q' 
      DC.B      $7F,$F2,$17,$F0,$F2,$FD,$BB,$C5 
      DC.B      $1B,$0A,$FE,']',$F0,$11,$F7,$27 
      DC.B      'w',$0A,'K',$FD,$B3,$E0,$7F,$EE 
      DC.B      $0C,'n',$82,$83,'3+',$EB,$DD
      DC.B      $1F,$09,$1E,$08,$E7,'<',$8E,$E0 
      DC.B      $90,$BF,'{',$EF,'R',$AA,$14,$C5 
      DC.B      $D4,'}',$C7,$E4,'W',$FF,'|I'
      DC.B      $0F,':',$DD,'}.;E',$F8
      DC.B      ']',$F5,'u',$F1,$9E,'m',$05,$7F 
      DC.B      $B2,$CD,$D7,'c',$D7,'!',$9E,$DC 
      DC.B      $9D,$87,$C6,'4',$D9,$0A,$1A,$AD 
      DC.B      $E0,'(',$E0,$D5,$BB,$C6,$A0,$D7 
      DC.B      ' ',$E0,$05,$C1,'&',$DF,'`',$CE 
      DC.B      '`+',$B2,$BF,'1',$A6,$0B,$AE
      DC.B      $27,$F7,'S',$F7,$EF,$1A,$D7,$F0 
      DC.B      $CF,$BD,$A1,$C6,'K',$FD,$BB,$C4 
      DC.B      'G',$DD,'B',$09,$9F,$FC,$05,$FC 
      DC.B      $F5,'cp',$F0,$1B,'wco'
      DC.B      $DC,'5|r',$FF,'r',$0F,$04 
      DC.B      $FF,'q',$7F,'rw4s',$AE
      DC.B      'B(',$C1,$DD,$D9,')p',$E7 
      DC.B      'w',$8E,$F3,$FB,'d',$CF,'w',$C2 
      DC.B      '}',$19,$0C,$04,'g',$0E,'~',$1E 
      DC.B      '|.:E',$F7,']',$F4,'u'
      DC.B      $F0,$9E,'l',$AE,$AA,$C7,'&',$CF 
      DC.B      '#',$C6,$E1,$BE,$A0,$C9,$9F,$C1 
      DC.B      $9A,$DC,$15,'40',$A0,'`0' 
      DC.B      'U7',$F0,$B5,$E0,$D7,'*',$CA
      DC.B      $9F,'%km',$FB,$BB,$C5,$F5 
      DC.B      $DE,$FB,$E4,$1E,$EA,$FA,'nx'
      DC.B      '>',$83,$7F,$97,$E4,$A3,'>',$F3 
      DC.B      $9E,$E3,$FE,$DD,$F0,$D8,$86,';' 
      DC.B      'Kk',$88,$7F,$D4,$7F,'`x' 
      DC.B      $90,'{',$D3,$BF,$A8,$86,'9',$E7 
      DC.B      $FA,$A9,$A6,$F7,'o',$03,$F2,$05 
      DC.B      '8',$EF,$1C,$7F,$DF,')',$1E,$08 
      DC.B      $FE,$0E,'}',$1E,'{.9E'
      DC.B      $F6,']',$F3,'u',$EF,$9E,',',$AE 
      DC.B      $A9,$BE,$E6,$C6,$E3,$BE,$A1,$B6 
      DC.B      'L',$E0,$0B,'&ac',$05,$0D 
      DC.B      $14,'p',$CA,$9D,$95,' ',$A5,'`' 
      DC.B      '^',$A7,'.',$82,$D6,$E0,$04,$CA 
      DC.B      $DF,$EF,'Ji',$12,$D7,'w',$89
      DC.B      $F7,$BA,$BB,$18,$F4,$E6,$82,'[' 
      DC.B      'x',$E6,'o',$E0,$A9,$E3,'{',$E3 
      DC.B      '?',$E2,$CF,$A0,$B4,$12,$0A,$B8 
      DC.B      $F6,$9E,$EA,'9',$FE,$9B,$1D,'~' 
      DC.B      $B7,'G',$B9,'khax',$8B
      DC.B      $E7,'<',$17,$B9,$C3,'+R',$AA
      DC.B      'H',$13,$DE,$D5,'M',$E0,$DE,'1' 
      DC.B      $03,'.',$03,$B1,$05,'7',$05,$BB 
      DC.B      '>',$16,'u',$07,$0E,'<',$1E,':' 
      DC.B      '-',$F8,'E',$B5,']',$B2,'u',$AE 
      DC.B      $9E,'+',$AE,'i',$BE,$A6,$BE,$A3 
      DC.B      $B6,'!',$AD,$A0,$82,$BC,$C9,'f' 
      DC.B      $8C,'0',$7F,'I',$1C,$A0,'k`'
      DC.B      $B8,$E1,'Ko',$B5,$94,$BD,'e'
      DC.B      'C ',$CE,$A0,$C6,'`',$E0,$E3
      DC.B      $F7,$BB,')e',$E0,'"4',$D5 
      DC.B      '}',$CF,'}',$D7,'!',$DC,'}',$15 
      DC.B      $7F,$DE,'{',$7F,$C7,$BD,$F7,'Y' 
      DC.B      $A4,'0',$EA,$DD,'@',$01,']',$84 
      DC.B      $90,$C1,$88,'=',$B5,$B6,$E4,$DD 
      DC.B      'A',$11,$9B,$E3,$BF,$E7,$FF,$E1 
      DC.B      'o',$EB,$81,$BF,$85,$E1,'%',$9E 
      DC.B      $E4,$DE,$D6,$BA,$E4,$AE,$B9,$9D 
      DC.B      'B(P',$E1,$D9,'t',$EF,$1D 
      DC.B      $E3,'Q',$B0,$04,'t',$05,'z',$05 
      DC.B      $FC,$B7,'Xx',$88,$07,$82,$CB
      DC.B      $EB,'=',$0D,$FB,$1D,$B8,'-',$B6 
      DC.B      'Es]pum',$95,$EA
      DC.B      $A6,'(',$B6,'f',$B6,'#',$AD,$A1 
      DC.B      $9D,'.',$83,$BD,$D9,'|(',$D8
      DC.B      'd',$0B,'[ cs',$D8,$A2
      DC.B      'lz',$94,$A0,$A5,$A0,$EC,'f'
      DC.B      ' ',$02,$BE,' ',$B5,$E0,$9D,$BE 
      DC.B      $A7,'{E!$',$F5,$E4,'n'
      DC.B      '"',$83,$BB,$BF,$EB,$BE,$EB,'S' 
      DC.B      $EF,$0D,$05,'/',$FD,'Of',$F0
      DC.B      $12,$CE,'yw',$03,$05,$14,$84
      DC.B      '!',$EE,'@',$AE,$F9,$EF,$B8,$0B 
      DC.B      $88,$A1,$AE,$AF,$0C,'.',$A0,$B9 
      DC.B      '$F',$B9,$AB,'j',$A1,$84,'S'
      DC.B      $EE,$00,$E0,$FF,'t',$17,'\',$D1 
      DC.B      '1',$A6,$B9,']',$DD,$04,$02,$AC 
      DC.B      $03,'o',$04,'3',$EE,$1D,$E3,'a' 
      DC.B      'Q',$EE,$14,'&',$7F,$0E,'>',$01 
      DC.B      $E0,'~',$06,'=',$0D,$B9,$1D,'w' 
      DC.B      '-4E2\',$EF,'u,'
      DC.B      $8D,'i',$9D,$A7,$AD,$E5,$AD,$A3 
      DC.B      $A5,'a',$CD,']',$05,$13,'`',$91 
      DC.B      $C2,'&',$1B,$A0,'[ k`'
      DC.B      $03,$03,$83,$AF,'`',$9C,$E0,$8B 
      DC.B      $B2,$9B,$81,$AD,$A0,$94,$E0,$02 
      DC.B      $CA,'_=',$18,$E3,'9',$E7,$B9
      DC.B      $CB,'PY',$19,$E9,'.',$E1,$E8
      DC.B      $EF,$FE,$E0,$FB,$8F,'{',$AF,'K' 
      DC.B      $E8,'`',$D9,$BF,$80,$A5,'n',$BD 
      DC.B      $F7,'m',$E1,$BB,' \',$FA,'_'
      DC.B      $F3,$DF,'q',$17,$10,$C3,$04,$0E 
      DC.B      'G',$D5,'\[',$C3,$CE,'y',$0B
      DC.B      $AE,')w',$F7,$BE,$EF,'}',$04
      DC.B      $83,$EE,$EC,$85,$17,$D2,$B0,')' 
      DC.B      'e',$DD,'Uu',$13,$02,'j',$02
      DC.B      $ED,$03,$B1,$04,'u',$B8,'w',$8C 
      DC.B      $8F,'M',$D9,$14,'B',$FD,$88,'`' 
      DC.B      $D0,$09,$FC,$05,$FB,$05,$BA,$0D 
      DC.B      '6',$1C,$F5,',qD/\' 
      DC.B      'ldj|',$E8,$8C,$E6,$9D
      DC.B      '%',$9D,'#',$94,$A1,$FC,'sW'
      DC.B      $C1,$E0,'J',$A0,'0l',$B2,'o'
      DC.B      'B`Z',$E0,$02,'j',$CA,']' 
      DC.B      '{',$E0,$94,$A0,$EE,'JA',$11
      DC.B      $A5,'`',$9D,' ',$E8,$F0,'}',$B2 
      DC.B      'a',$10,$A2,'!$1',$A6,$C5 
      DC.B      $FA,$DE,'C}',$F6,'}g',$DF 
      DC.B      'u',$08,'M\s',$EF,$F5,$D1 
      DC.B      $7F,$03,$05,$84,'0\',$FB,$D7
      DC.B      $A0,$AD,'u',$BB,$9A,$DC,')',$F4 
      DC.B      'q',$CD,'?',$EE,$9F,'Es!' 
      DC.B      '|',$E5,$F0,$B5,$B6,$C6,'8r'
      DC.B      $0E,'w',$0A,$E7,'<',$DE,$FB,$D6 
      DC.B      $BA,$1A,'(`Xw',$89,'w'
      DC.B      'W',$01,$E8,$02,$AB,$03,'.',$03 
      DC.B      $F2,$04,$B5,$B8,'w',$8C,$97,'A' 
      DC.B      $B8,'8',$10,'x',$05,'8',$05,'7' 
      DC.B      $04,$F7,$04,$F6,$04,$B4,$0C,'s' 
      DC.B      $1C,'1+',$EF,';',$AC,'K',$AA
      DC.B      '[',$E9,'k',$E7,'t&|$'
      DC.B      '„c|!',$DC,$00,$18,$86
      DC.B      'c ',$82,$90,'A',$04,'9',$E0
      DC.B      ': B J`R',$A0 
      DC.B      'k`s',$05,$0C,'0',$03,' ' 
      DC.B      $8C,'`',$8C,$A0,$84,'`k',$A0
      DC.B      $08,'A',$10,$82,'!',$04,'1',$86 
      DC.B      'B',$08,'Z',$CB,$C9,' =',$1B
      DC.B      's/u',$06,$BF,$DC,$05,$1C 
      DC.B      $84,$10,$94,$92,'r',$17,$81,$12 
      DC.B      $8C,'QP',$BB,$EE,'a',$D0,$07
      DC.B      $DD,$19,$94,$B2,'4P0J'
      DC.B      $B8,$E8,'.a„0',$DC,'?'
      DC.B      $8D,$12,$10,'C',$0A,'!l',$F2
      DC.B      $BF,'q/y',$1F,'/',$AD,'u' 
      DC.B      $B8,$14,'4P',$CE,'y',$C6,'8'
      DC.B      $BD,$F7,$C0,'0{',$E1,$10,$A2
      DC.B      'm',$F0,'7U',$DD,$01,$F7,$8E
      DC.B      $AC,$F1,'({',$A6,$DC,$03,'C'
      DC.B      'XTS',$04,$12,$04,$11,$0B 
      DC.B      $D0,$13,$8F,$1B,'Ž#L3'
      DC.B      $0A,'C',$08,'KGSFc' 
      DC.B      'EcDcC[',$02,'Z'
      DC.B      $C1,'R�t',$02,$C0,$0D,'9' 
      DC.B      $C0,$80,'y(',$03,$A7,$EC,$A3
      DC.B      $EC,'B@c',$00,$89,$B2,$0F 
      DC.B      $DC,'B',$00,'!@',$F4,'uM' 
      DC.B      $F7,'JI',$93,$1D,$E5,'.',$07
      DC.B      $9F,'n!',$83,$02,$1A,'Xc' 
      DC.B      $0C,'kM{',$CF,'s',$8E,$E4 
      DC.B      $EE,$82,$EE,'v?',$E8,'Q',$EE
      DC.B      $01,'?',$8C,'@Ž:',$88,$02 
      DC.B      'F',$B9,$BF,$F9,'cH!',$84 
      DC.B      $0A,$86,$B8,$1F,$BD,$E7,$F8,'{' 
      DC.B      $EF,$8C,'qW',$B9,';',$05,$AD
      DC.B      'u',$A5,'4',$9C,$F3,$84,'0',$0D 
      DC.B      $14,'p',$8C,$DE,'%',$7F,'S',$BF 
      DC.B      '+',$F2,'()',$0E,$03,'O{' 
      DC.B      $AA,$EC,$06,$D1,$03,$90,$0B,$8F 
      DC.B      $0B,'N',$13,'M',$1B,$0C,'#',$0B 
      DC.B      '2',$C9,':',$C8,'C',$07,'K',$06 
      DC.B      'R',$C5,'R',$C4,'a@',$F1,$06
      DC.B      'R',$C3,'JBB',$01,'9',$C1 
      DC.B      '1',$13,'pL@@',$0C,$14
      DC.B      $10,$01,$00,'J@',$A3,$EC,$1B
      DC.B      $82,'Z',$C0,'R',$80,'9',$C0,'!' 
      DC.B      $01,$02,'"',$A0,$D8,'9',$93,$7F 
      DC.B      '”;',$08,$C6,$12,$FA,$02,'I'
      DC.B      'B',$08,'JI',$86,$8C,$80,$0E
      DC.B      'Z',$CB,'R',$8A,$C1,$A0,$BB,'P' 
      DC.B      $FF,$0B,$06,'?u',$01,'a',$8C
      DC.B      $04,$F7,'1',$D5,$E3,$FC,'1',$A4 
      DC.B      $B0,$CE,$1D,$C1,$A0,$E7,$B8,$97 
      DC.B      'c,',$17,$1C,'B){',$EF
      DC.B      's',$AE,'kmZ',$EB,'h',$A0 
      DC.B      $80,'cK',$EE,$0F,$EE,$C4,'Z'
      DC.B      $FB,'M',$E4,$01,'e',$01,$A7,$02 
      DC.B      $0A,$02,'K',$02,$8C,$02,$CD,'"' 
      DC.B      $0F,$B0,'@',$03,$0D,$0B,$0D,$12 
      DC.B      $CC,$1A,$CB,$E2,'N@',$D7,'*'
      DC.B      $C8,'2',$C8,':',$C8,'B',$C7,'B' 
      DC.B      $C6,'B',$85,'BD:',$03,'9' 
      DC.B      $C3,'1',$E4,'~&',$A0,$82,'!'
      DC.B      'A!B',$98,$80,$18,$E8,'A' 
      DC.B      ')',$80,'1',$C0,':',$01,'BA'
      DC.B      'B@:',$00,')',$81,$18,$C1 
      DC.B      $10,$81,$02,$93,$05,$BD,',',$D6 
      DC.B      $DF,$C4,':',$08,'P7P@'
      DC.B      $1D,'$<#',$BC,$F4,$15,'<' 
      DC.B      ')/8',$8B,$F6,'9',$C7,$02 
      DC.B      'j',$D0,']A',$09,$1B,'v',$08
      DC.B      'S',$7F,$D4,$97,'~',$EB,$02,$08 
      DC.B      'aJ@',$0E,$05,')eB' 
      DC.B      '(',$14,$85,$10,'JR',$AA,'J'
      DC.B      'i9',$E7,'1',$A6,'!$',$18 
      DC.B      $E3,$C1,$E0,$9F,'}',$B8,$07,$80 
      DC.B      $7F,$E3,$01,'%',$01,$87,$01,$C8 
      DC.B      $17,$E4,'b',$AE,$02,'J',$0A,'w' 
      DC.B      $00,$F1,'&J',$12,$8A,$1A,$8A
      DC.B      '"',$CA,'"',$C9,'+',$09,$A0,$D9 
      DC.B      $D2,$1D,$08,';',$07,':',$C6,':' 
      DC.B      $85,':D:',$F4,$B2,'6w'
      DC.B      $82,')',$05,$C5,'a',$DB,'!)'
      DC.B      $C3,'2',$03,'M',$D9,$ED,$08,':' 
      DC.B      $83,'2C',$94,$80,$8A,$B2,$82
      DC.B      $27,$CA,$FF,$C9,'?',$E7,$83,$9E 
      DC.B      $D3,'Gor?yb',$FD
      DC.B      $C6,$85,$C0,$03,$B0,$F0,$19,';' 
      DC.B      $90,$F8,$8F,$FB,$86,$BF,$AE,$13 
      DC.B      $F6,$10,$A2,'/v',$F0,'5',$E7
      DC.B      $9F,'^',$F0,$04,$00,$9B,$A4,$07 
      DC.B      '1',$86,'E]',$B9,'6',$05,$EF
      DC.B      $DB,$05,$FF,$A2,$00,$E3,$01,$05 
      DC.B      $01,'F',$01,$86,$A6,$91,$0B,'H' 
      DC.B      $01,$C7,$09,$C7,$12,$16,'H',$FC 
      DC.B      $09,$08,$1A,'H"',$89,$09,$F8
      DC.B      'šl',$02,'H3G',$C6,$C0
      DC.B      '[',$94,$CD,$83,')C',$98,$1D
      DC.B      $F7,$DF,$C4,'*',$04,'2D',$0E
      DC.B      $DD,$CF,$EE,$C4,'7',$98,$C0,'Q' 
      DC.B      $C3,'1',$C3,')',$83,'!B',$19
      DC.B      $02,$EE,'O@',$97,$EA,$0E,$E5
      DC.B      $9E,$7F,$EF,$D7,$BC,$80,'K',$EE 
      DC.B      $13,$C7,$F6,$C4,$0D,'+„s' 
      DC.B      $B6,$88,$CC,$D9,$87,$9B,$DC,$09 
      DC.B      $D4,'p',$ED,$19,$05,$1F,$07,$FD 
      DC.B      '%E"',$05,'p',$9B,$FA,$8F 
      DC.B      $81,$08,$F2,$DF,$B2,'W@8' 
      DC.B      $84,$81,$C4,'[lp',$D5,$FD 
      DC.B      $B1,$FF 
      MOVE.L    D0,-(A0)
      BSR       Begin-$601E 
 
      DC.B      $0E,$C9,$05,$0C,$EB,$B2,$03,$C2 
      DC.B      $04,$01,'E',$09,'E',$11,$86,$19 
      DC.B      $C7,'"G*',$C8,$11,$F0,$AC 
      DC.B      $C9,$89,$C9,'&',$00,$9C,'e',$87 
      DC.B      $86,'2F',$9B,$A8,$BB,'9x' 
      DC.B      'x',$A1,$9B,$05,'2',$EC,'u',$94 
      DC.B      $BE,$C5,'3F3',$C5,'2„'
      DC.B      '2',$04,$10,$D8,$E8,'}',$83,')' 
      DC.B      $83,'Qv',$13,$F0,$02,$19,$09
      DC.B      $C9,'V',$AA,'=',$A3,'v',$AD,$1B 
      DC.B      $04,'y3�)',$14,$B6,$C9
      DC.B      $DF,$D8,'}[DWo',$EC 
      DC.B      $99,$83,'_b_!',$C4,'"'
      DC.B      $85,'+G+',$07,'*a;' 
      DC.B      $02,'_',$04,$19,$04,$18,'V_'
      DC.B      $D8,'N',$C3,$10,$82,$C0,'&',$E0 
      DC.B      $D5,$C2,$82,$1D,'t',$02,'3',$81 
      DC.B      $08,$98,$C0,$E2,$A0,$E8,$18,$FE 
      DC.B      ']B',$92,$1B,'K@',$82,$01 
      DC.B      $04,$09,$04,$11,$85,$19,$C6,'"' 
      DC.B      $87,'+',$08,'8Q',$EE,'gJ' 
      DC.B      $AD,$F6,$04,'~',$D9,$C6,'2',$F5 
      DC.B      $06,'=',$D9,'F',$C8,'E',$C1,',' 
      DC.B      $B9,'?',$C6,$D9,'8',$E2,'/;'
      DC.B      $C7,';',$87,':',$C5,':',$85,':' 
      DC.B      $05,'1',$C4,$81,$FC,$9E,$09,')' 
      DC.B      '„!',$D8,$12,'v',$06,'B',$09
      DC.B      'B',$0D,'l�MD',$BC,$D8
      DC.B      $05,'$',$C5,$A1,$85,$C5,$C1,';' 
      DC.B      $C9,';',$C8,'&w',$89,$A8,$A9
      DC.B      $9B,$D5,';',$F7,$C3,'y',$EE,$19 
      DC.B      'CE+',$06,'AW',$93,$DD
      DC.B      $07,'R',$DC,$AF,'m',$06,'D',$19 
      DC.B      $AA,'n',$A6,'l',$19,$03,$89,$19 
      DC.B      'X',$02,$11,$02,$09,$02,$BA,$C0 
      DC.B      'O',$FE,$DD,'%',$F9,'w',$01,'K' 
      DC.B      'N',$00,'8',$AF,'Q',$B6,$80,$00 
      DC.B      $C3,$09,$85,'"',$06,'M',$D0,$B6 
      DC.B      'j',$C8,$D3,'dG',$DF,'D',$CB
      DC.B      $AB,$EE,'J',$EA,$07,'F)',$C6
      DC.B      $A8,'wJ',$BA,')',$85,'2',$06
      DC.B      $09,$A8,'&w;',$08,$A9,$09 
      DC.B      $97,$0C,$89,'D',$08,'CFB' 
      DC.B      $85,$A6,'6',$8C,']2',$05,')'
      DC.B      $04,$94,$80,',',$F4,'H',$9F,$EC 
      DC.B      $C3,$11,$C4,$12,$90,$8C,'&',$C6 
      DC.B      $06,$12,'H',$02,$A3,$09,'/',$8C 
      DC.B      'mM',$FA,'{',$CC,$AA,$AA,$0B
      DC.B      $ED,$88,$04,$19,$C4,$FF,$87,'{' 
      DC.B      $D3,'*',$86,$D0,'X',$A1,'{',$87 
      DC.B      $EC,'^',$D5,'\',$05,'!',$C5,'!' 
      DC.B      $85,'!5',$B1,'a',$02,$84,'"'
      DC.B      '`',$95,'-',$10,$C2,$08,$81,'`' 
      DC.B      $94,$ED,'&',$BA,$BB,'$',$FF,$EE 
      DC.B      $C9,$C3,$13,$C3,$09,$03,$FE,'d' 
      DC.B      $B7,$8F,'I',$AE,$DA,'yr',$8F
      DC.B      $01,$07,'_H',$BD,$97,$DD,$C1
      DC.B      '2G*',$06,')',$86,$F2,$11 
      DC.B      $C8,$92,':',$87,';',$07,';',$C7 
      DC.B      $0A,'MKM',$0A,'{X',$D3
      DC.B      $FD,'FC',$06,':',$86,'2',$85
      DC.B      '2',$B4,$8D,$B2,$C7,$1E,'v',$05 
      DC.B      $0D,$04,$1A,$14,'P',$1F,$0D,'c' 
      DC.B      '`"}',$87,'D',$DD,' ['
      DC.B      $DF,'%',$BB,$C9,$0B,$8A,'&',$CA 
      DC.B      $A6,$E4,'G2',$16,$B5,$0A,'b'
      DC.B      '#',$C6,'"',$1B,$18,$10,$85,'E' 
      DC.B      $AC,$80,'4',$D9,$88,'<J',$8A
      DC.B      '4',$08,$ED,$C9,'nS',$86,'*'
      DC.B      'F"',$06,'"',$05,'"6',$AC 
      DC.B      $08,'(E',$1A,$04,$19,$83,$16
      DC.B      $F4,$27,$E5,'w',$12,$E6,$E1,$00 
      DC.B      $82,'C"F',$01,$D7,$93,$DD 
      DC.B      $A0,$F4,'2',$8A,$C1,$8F,$EC,$9F 
      DC.B      $DC,$A3,$EC,$A3,$87,'2',$07,'1' 
      DC.B      $C6,$EE,'&',$A0,$9A,$C7,';G'
      DC.B      $EC,$1B,$83,'MM',$8B,'E',$0A
      DC.B      'DHC',$C7,'C',$87,$EF,$02 
      DC.B      $96,$09,';',$06,'3(',$01,$F1
      DC.B      $91,$86,$85,'J',$02,$83,$A5,$8C 
      DC.B      '4',$06,$1E,'H^J>',$F5
      DC.B      '%wd',$05,$8C,'E',$0B,'l' 
      DC.B      $F9,'v',$98,'}',$8A,'{š+' 
      DC.B      ';',$85,$CC,$D9,'*',$E8,$89,',' 
      DC.B      $A2,$CB,'x',$12,$F4,$FE,'G',$E5 
      DC.B      '>p',$13,'*',$C7,'"',$C7,'t'
      DC.B      $27,'`',$94,$C6,$1A,$04,$DD,$A4 
      DC.B      $FC,$8E,$00,'A',$08,$C2,$11,$83 
      DC.B      '"',$C6,$C2,'<',$CA,'~LC' 
      DC.B      '>',$1B,$FF,'wZJ1',$83
      DC.B      '~w2',$C8,'2G2',$07 
      DC.B      '9',$C7,$0B,$C9,$E2,$98,':',$87 
      DC.B      'C',$08,'C',$C8,'D',$89,$BF,'c' 
      DC.B      'M',$EF,$8B,'M',$F6,'D',$D9,'H' 
      DC.B      'D',$08,$87,'-0W',$B7,'G' 
      DC.B      $06,'+G',$B5,'^',$12,$B8,','
      DC.B      '5',$D9,$83,'6',$02,$EE,$D9,'%' 
      DC.B      $FF,'o',$FF,$E4,$CE,'/',$BE,$8D 
      DC.B      '=M',$EB,'7',$FB,$E9,$9E,'A'
      DC.B      '+',$09,'y™B',$7F,$F1,$FC 
      DC.B      'N',$F8,$B0,'}',$F4,'+H+' 
      DC.B      $C8,'{C',$15,'R',$B1,$FC,'.'
      DC.B      $96,$F3,$D6,'xr',$01,$00,'A'
      DC.B      $09,$02,$11,$C4,'+',$07,$8F,$0B 
      DC.B      'H',$F6,']',$E1,$0B,']',$89,$D0 
      DC.B      $18,'( ;',$C9,'3',$08,'2' 
      DC.B      $88,':G:',$07,$90,'=',$EF 
      DC.B      'e',$88,'D',$09,'M',$F6,$AD,$E6 
      DC.B      '>',$00,$0C,'<D',$88,$08,$CA
      DC.B      ']�yJ',$88,'iZ',$9A 
      DC.B      $C0,$87,'3',$C9,'4j',$B2,'O'
      DC.B      'h',$91,'[s',$7F,'KM',$CC 
      DC.B      'N',$0D,$F2,$CF,$DF,$C0,$FF,'3' 
      DC.B      '{',$EB,'.',$0E,$F8,'š4',$08
      DC.B      'm',$A0,'JVp',$CB,'~',$B2 
      DC.B      $7F,'z',$8F,$B9,$09,$11,$0C,'L' 
      DC.B      $D0,'{Q',$7F,$D7,$01,$02,'a'
      DC.B      $CE,$93,$CD,'w',$88,'?',$DD,'/' 
      DC.B      $DD,$0F,$FB,'G[',$98,$D5,$09
      DC.B      '3H2',$C8,':',$88,'a',$02 
      DC.B      $D2,'dHC',$8B,$DC,$DD,';' 
      DC.B      $D1,$BD,$C9,'~',$C9,$D0,$9D,'Z' 
      DC.B      $04,$1C,$D9,$A3,$DC,$C8,';',$C8 
      DC.B      $1F,$EC,'V',$C2,'=J',$E0,$02
      DC.B      $EA,$1B,'K',$8C,'8',$F4,$0A,$E8 
      DC.B      $EC,$8D,$BD,$C0,$E0,$DF,'`',$C5 
      DC.B      $CB,$ED,$C4,$89,'O',$EE,'E7'
      DC.B      $FE,$CE,$DC,$1B,$0A,$EE,$04,'=' 
      DC.B      $19,$87,'"',$85,$0C,$BC,'}g'
      DC.B      $E5,$94,$C6,$BF,$81,$09,$01,$12 
      DC.B      $03,'+G',$1B,'r1',$04,$89 
      DC.B      'LhF',$09,';',$C9,$11,'P' 
      DC.B      'K',$04,$88,'3H;',$08,'B' 
      DC.B      $C8,$FE,$E4,$AF,$A8,'IL',$CA
      DC.B      'X',$93,'}s'
      JSR       (A0)
      DC.B      $A0,$FB,'+',$0C,'J',$A0,$BF,$9C 
      DC.B      'L',$85,$BD,$B0,'G',$F9,$0B,$88 
      DC.B      'dM',$9F,'M',$D9,$FF,'7',$17
      DC.B      $8F,$BA,$BF,'[',$FC,$9B,'K',$8D 
      DC.B      '?',$D9,$F3,'Id+',$0A,$84 
      DC.B      $07,$EE,$81,$AF,'I3G"'
      DC.B      'E',$19,$C4,'w',$A7,'V',$EC,$09 
      DC.B      $01,$11,$C3,'+',$06,$BB,$0D,$F3 
      DC.B      '0',$CA,$0E,$07,$03,$E9,'Vs'
      DC.B      'xf?',$D9,$FF,$BD,$88,';' 
      DC.B      'HCIC',$D3,$F9,$E4,$1E
      DC.B      'MKUF',$E5,$CA,$DD,$0B
      DC.B      'FLNMz:',$F0,'{'
      DC.B      $B2,$FF,'f',$F0,$AF,'{',$C1,'>' 
      DC.B      $C2,$1D,$C9,$FB,'F',$82,$7F,$C7 
      DC.B      '8',$16,'6',$D9,'?',$F9,$8B,$1A 
      DC.B      $B6,'4',$C9,'5',$09,$CF,$FC,$1B 
      DC.B      $E8,'I',$9E,$EC,'"w<',$8A 
      DC.B      $FC,$85,'PON',$0C,$EE,$82 
      DC.B      '4',$C1,$07,'"',$05,$19,$84,$06 
      DC.B      $97,$DD,$E7,$E4,'w',$1A,$E6,$C1 
      DC.B      $11,$83,'"',$C6,'3',$88,'<c'
      DC.B      'q',$F6,$E1,'J',$A0,'Sv',$FF
      DC.B      $F7,'?',$B4,'?',$88,'C',$C9,'D' 
      DC.B      $B9,';',$1D,'9',$0B,$CC,$E4,$F7 
      DC.B      'f',$D1,'F',$0C,'N]',$C4,'V'
      DC.B      $B3,$1F,$F4,'w',$C2,$1B,$08,$BC 
      DC.B      'd',$04,'O',$BD,$C7,$AE,$E8,$A1 
      DC.B      $FB,$BB,$C0,'o',$EC,$E0,$F3,'{' 
      DC.B      'd',$0A,$EB,$CA,'V',$FF,$C9,'4' 
      DC.B      $C9,'d',$DF,'d',$DF,$0E,$EE,$8A 
      DC.B      $BB,$FD,$9F,$D0,$AF,'~',$B2,$FD 
      DC.B      'U2',$C7,'!',$C5,$19,'D',$14
      DC.B      'N>',$C3,'@žl',$BE,$C1
      DC.B      'N',$BE,']',$E3,$07,'~g',$E4
      DC.B      $11,'C"E+',$07,'aQ' 
      DC.B      $F6,$81,$E0,$9B,$FE,'/',$08,'}' 
      DC.B      $D8,$CD,$EE,'DJ;',$E2,$F2 
      DC.B      $E4,$DE,$F8,'Y',$87,$90,$C2,$C0 
      DC.B      '.2(`”-',$A1,$80
      DC.B      ';M',$7F,$EA,'"',$02,'J"' 
      DC.B      $87,$EF,'p',$7F,$F2,$B7,$F6,$CC 
      DC.B      'E',$CB,'=',$8A,'E',$8B,$C9,$BD 
      DC.B      $09,$E8,$06,$EC,$92,$BB,$E6,'~' 
      DC.B      $C8,'n',$89,$B2,'9',$B8,'Q]'
      DC.B      'w',$9F,'xH3GM',$CC 
      DC.B      'V',$0D,'on',$E2,$E9,'H*' 
      DC.B      $86,'!',$85,$19,$03,$FC,'m',$BA 
      DC.B      $17,'s',$F2,';&',$0F,'<',$FE
      DC.B      $DD,'@',$08,$81,$08,$C2,$19,$C4 
      DC.B      $91,$8B,$8D,$DF,'HX',$F8,$C4
      DC.B      $E0,'-',$05,$1F,$B2,$87,$F6,'1' 
      DC.B      $FB,$BB,$E0,'+',$FF,'t',$01,'E' 
      DC.B      $B4,$CB,'D',$CB,$B7,'%',$EC,$02 
      DC.B      $02,$F9,'s q',$0A,'Y|'
      DC.B      $B0,$03,$EE,$BE,'K',$CE,$00,'g' 
      DC.B      $D0,$8B,'=J5',$09,'=',$BE 
      DC.B      $09,$D8,$0C,'E',$FC,'q',$0F,'<' 
      DC.B      'I',$BA,$AA,$0B,$BB,'4',$08,$FC 
      DC.B      '*',$C4,$B6,$15,'TE',$AF,'M'
      DC.B      $8C,'mA',$19,$95,'U',$CD,'M'
      DC.B      $80,$8D,'UX',$06,'!D',$10 
      DC.B      $C3,$D9,'}',$DF,'Iy|',$1F 
      DC.B      $FF,$82,$19,'C',$EE,$C8,$9B,$A9 
      DC.B      '*',$C7,$B2,$F0,$E7,$A6,$89,$80 
      DC.B      $DF,$F4,'X8',$B4,'?',$DA,$08
      DC.B      'D+&',$E0,$B5,'Ž``' 
      DC.B      $11,$C9,$0A,'<J',$09,$B1,$11
      DC.B      'PA',$FF,$99,$C1,$0C,$F0,'^'
      DC.B      $EF,$B4,$0F,$BA,$C1,$C9,$89,$E6 
      DC.B      'dN=E',$0B,'4',$89,','
      DC.B      'H,',$E8,'r',$F0,$D1,'D',$8A
      DC.B      'z',$D6,$0A,':<',$8A,'4I' 
      DC.B      '+',$89,'o',$C9,'F',$C8,';7'
      DC.B      $DA,$96,$A7,$C6,'3H',$AC,'N'
      DC.B      $B8,$B7,'KM',$8C,'D',$CA,';'
      DC.B      $C9,'2',$86,$27,$BB,$F9,$1B,$04 
      DC.B      $10,$C2,$08,'A',$D6,'t?@' 
      DC.B      $93,'_',$84,$FC,$81,$BB,'"',$97 
      DC.B      $95,'"E',$88,'(w',$8D,'4' 
      DC.B      $0D,$1D,$08,'Ž#',$85,$0A,$96
      DC.B      '<',$9E,$0B,'{4',$08,$D0,'U'
      DC.B      $F3,'3',$08,'v',$89,'- :' 
      DC.B      $06,$82,$AB,'4',$C8,' ',$19,$C4 
      DC.B      $C7,$1B,$EC,$83,$1D,$19,'/',$C2 
      DC.B      $05,'I',$88,'#Gd',$E4,$1B 
      DC.B      $BC,'+H3',$88,$0E,$C1,$A0 
      DC.B      $C7,$C8,$DD,'(z',$E3,$BE,'t'
      DC.B      'P',$CF,$86,'3G',$12,$DE,$10
      DC.B      '$MLE',$0B,'<IF'
      DC.B      '!D0',$AC,$E9,'n',$82,'M' 
      DC.B      '7',$A1,'vxI',$FE,$CD,'@' 
      DC.B      $08,'A',$10,'%G',$ED,'q',$19
      DC.B      $84,'7e',$CB,'O',$1A,'S=' 
      DC.B      $E8,'3',$87,$0A,'9',$E1,'O',$D9 
      DC.B      $C1,$99,$AF,'+',$06,$85,'y',$D5 
      DC.B      $CC,$CC,'J',$06,'=',$E6,$83,$CE 
      DC.B      '!',$83,$07,'G',$81,$09,$0C,$92 
      DC.B      '*',$C6,'*MA',$1C,$13,$FA 
      DC.B      $93,$0F,$00,'#',$07,'F',$1A,'F' 
      DC.B      $D7,$C8,'K@',$18,'D0',$E8 
      DC.B      '#',$06,'"',$C6,'"',$86,$C5,'a' 
      DC.B      'q',$01,'GQC',$05,$0D,$05 
      DC.B      '"F',$CA,'D',$CB,'<',$8A,'3'
      DC.B      $C9,'3',$07,$DC,$9E,$EC,$C9,$19 
      DC.B      'D',$81,$D8,$D5,$CB,$CD,$93,$FF 
      DC.B      $0A,$18,$C9,$BF,$F3,$F2,$C0,$D3 
      DC.B      'wT',$83,'D',$13,$B0,$07,$86
      DC.B      $05,$D0,$C7,'$',$F4,'-',$AF,$BC 
      DC.B      $80,'E',$1A,$85,'-f0K'
      DC.B      $1E,'\',$EB,$05,$8D,'`',$E2,$1B 
      DC.B      $1A,'D',$1A,$04,'_t',$09,$A8
      DC.B      $C4,$19,$C0,$EA,$F5,$93,$12,$05 
      DC.B      $11,$C5,'O',$FD,$A0,$BB,'D',$11 
      DC.B      $84,$C0,$04,$B6,$A4,$12,$04,$C4 
      DC.B      $07,']',$81,$89,$0B,$B8,$A0,'U' 
      DC.B      $19,$84,$B7,$04,'|',$B2,'E+'
      DC.B      $07,'D',$8A,$9B,$81,$02,$AA,'H' 
      DC.B      '*',$87,'!',$85,$19,$03,$C9,$16 
      DC.B      'k',$B1,$BF,'+1',$0F,$C2,'u'
      DC.B      'g',$A1,'C_@',$07,$8F,$11 
      DC.B      'C',$11,$83,'.`',$F1,$ED,$12
      DC.B      $03,$11,$8A,'.',$01,'!',$D2,$C1 
      DC.B      'B',$FB,$82,$05,$02,$27,$90,$D6 
      DC.B      '_z',$00,'B',$11,'8',$02,$D2
      DC.B      $EB,'iv',$95,$1D,'t',$0E,$83
      DC.B      $BF,$03,$08,$C3,$F4,$16,'x',$E8 
      DC.B      $03,'CB',$04,'&0',$E0,$10 
      DC.B      $C2,$D6,$B8,'k',$CA,$11,$03,'D' 
      DC.B      '!',$C5,'"',$05,'+',$06,';',$C9 
      DC.B      'D',$0A,'<',$09,'3',$88,'2',$C7 
      DC.B      ']Qv�!D',$18,$F9
      DC.B      $DB,$CC,'m',$BA,$0F,'O',$C9,$0B 
      DC.B      $FC,'n',$C9,$AF,$0B,$AE,$18,$FE 
      DC.B      ']',$E2,$CD,$80,$0F,':',$87,$83 
      DC.B      '@N',$E0,$91,'OA^@' 
      DC.B      'ž^',$81,$00,$C1,'x',$82,'.'
      DC.B      $00,$F0,'D',$F0,$91,$03,$AF,$E0 
      DC.B      $AF,$0B,$A8,$E2,$CC,$09,$01,$0A 
      DC.B      '>',$85,$89,$82,$08,$C2,$0F,':' 
      DC.B      $C1,$97,$09,$C1,$08,$81,$80,$E8 
      DC.B      '+`+',$B2,$83,$CE,$C3,$10 
      DC.B      $C3,$19,'D',$19,$84,$88,';',$C9 
      DC.B      $A1,$D8,$93,'}',$07,'*F)' 
      DC.B      $C5,'!',$04,'k',$B2,$C5,$9E,$EC 
      DC.B      $9B,$EC,$B3,'z',$94,$8A,$BC,$D4 
      DC.B      $19,'z<',$B8,$E0,$81,$C6,$D9
      DC.B      $ED,'l8',$C0,$CB,$15,$9C,$04
      DC.B      $0F,'\',$95,$F0,$C0,$91,$9F,$FD 
      DC.B      $A7,'6',$BC,$00,$F1,$11,$05,$27 
      DC.B      'A',$08,$82,$11,$03,$11,'C',$1A 
      DC.B      $04,'*',$C6,';H;',$88,'3' 
      DC.B      'G2',$C6,'*E!',$C5,'g'
      DC.B      $01,$A5,'a',$18,$82,$10,'A',$82 
      DC.B      $C1,$EB,'V',$FC,'SK',$FC,';'
      DC.B      '*',$8F,'q',$A7,$B0,$E9,$81,'#' 
      DC.B      '"',$E0,$04,'&0',$DC,$DB,'%'
      DC.B      $FF,$15,$FB,$C0,$F0,'F',$F0,$0A 
      DC.B      $F7,$D6,$82,$EB,$BA,'!',$E1,'O' 
      DC.B      '`xE',$89,$0F,$BE,$07,$82 
      DC.B      $FC,$C6,'=0',$BC,$C3,'}',$A3
      DC.B      $E0,$DB,$01,$0F,$04,$0F,'B',$18 
      DC.B      $C3,'!',$85,'2',$87,'2',$C7,'*' 
      DC.B      $06,'!E „ Cz' 
      DC.B      '/',$B0,$A0,$83,$9B,$D6,$07,$BE 
      DC.B      $B4,$E0,$13,$E1,$DF,')',$B9,$00 
      DC.B      $80,'X',$DB,'r%$',$E2,$E0 
      DC.B      $13,$98,'#',$C0,$04,$84,$B7,$D8 
      DC.B      $CF,'\',$09,$FE,$18,$1E,'t',$27 
      DC.B      '&',$10,$04,$83,'N`e',$D8 
      DC.B      $19,$FF,$A7,'_',$DE,'p',$03,$0F 
      DC.B      $FA,'&',$FB,'%',$F7,$C0,$E3,'7' 
      DC.B      $EE,'A7',$B6,$C3,$1D,'Z',$04
      DC.B      $BF,$0B,$02,$DE,'d#',$E0,$92
      DC.B      $AD,'o',$F0,'$8%',$B1,'P' 
      DC.B      $10,$06,$B9,$07,'_',$DD,'0',$AA 
      DC.B      'w',$AA,$DE,$C7,$13,$1E,$08,$9E 
      DC.B      'u',$DF,$DD,$08,'p',$EF,$1C,$C7 
      DC.B      $DB,$D7,'W',$B0,'e',$0E,'Ož'
      DC.B      '%r',$87,$C1,$C0,$09,$FE,$B4
      DC.B      $B2,'(',$18,'*',$AF,$9E,$1E,$FA 
      DC.B      'A',$7F,$BA,'+',$80,$0A,$06,$1F 
      DC.B      ' (_',$B9,$D5,$C8,'&',$CD 
      DC.B      $27,'gv',$E1,$83,$9D,'B',$08
      DC.B      $05,'T',$D0,$04,'@',$01,$0F,$1A 
      DC.B      '0',$06,$14,'%b`H',$09
      DC.B      '@',$08,'8',$07,'(',$05,$C8,$11 
      DC.B      $0C,$FA,$08,$01,$10,$02,$18,$03 
      DC.B      ' ',$03,'(',$04,$98,$82,'A/'
      DC.B      '8',$05,'H',$13,'P',$1E,'"',$27 
      DC.B      ' ',$02,'R(',$A0,$83,'?',$EE
      DC.B      'X',$C1,'G',$17,'G( ',$E1 
      DC.B      $F6,'lg<',$E0,$C1,$DF,$08 
      DC.B      'z',$27,'0',$FC,$08,'#',$10,'%' 
      DC.B      '; w/.',$B7,$D9,$83 
      DC.B      $C9,'() ',$27,$18,'&y'
      DC.B      $CA,$0E,$0B,'|',$E0,$DF,$E2,$9E 
      DC.B      't;',$18,$F2,$02,':X('
      DC.B      'X@',$04,'t/',$90,'@',$02 
      DC.B      $C0,'0',$95,$DD,$B8,'A)',$12
      DC.B      'B',$18,$04,'2',$D5,'1',$A4,$F0 
      DC.B      $EA,$1D,$C1,$A0,$9B,'y{',$27
      DC.B      $B3,$F4,$EE,$E0,$F3,$97,'n',$A0 
      DC.B      'h-',$80,$10,$EA,$E8,$02,'"'
      DC.B      '+`',$87,'?',$B4,$DF,'" ' 
      DC.B      '#0%(',$01,$7F,'M6' 
      DC.B      'h*+',$1E,'*',$F0,$08,$80 
      DC.B      $08,'!',$01,$C4,$CD,$9D,$BA,$0F 
      DC.B      $0F,'x',$98,$CD,'b ',$F8,$95
      DC.B      $10,'=',$81,$8F,$B2,$10,'$',$18 
      DC.B      ']',$F5,$CE,$F1,$D6,'t',$C7,$FC 
      DC.B      '8.0,',$C0,'^',$B3,'s'
      DC.B      ' PA',$CC,$0D,$18,'% '
      DC.B      $27,'(*(,<',$B6,'b' 
      DC.B      ';',$18,'|',$07,$15,'102' 
      DC.B      'T',$D0,$1D,$C4,$D8,$C1,'A',$F6 
      DC.B      '@.P,X-h.'
      DC.B      $DC,'";',$06,$88,'1',$A4,$81
      DC.B      $02,$CA,'P*B',$09,$1D,$94 
      DC.B      '8',$27,$81,$02,$AA,$C9,'`',$9D 
      DC.B      $ED,$02,$8F,'$',$0E,$A1,$80,$0A 
      DC.B      $1A,'(`',$90,$BB,$B3,$E0,'2'
      DC.B      'k',$ED,$93,$18,'#',$BB,$93,$92 
      DC.B      'Q+',$88,'-',$98,'/',$C5,$A6
      DC.B      $FB,$05,$A8,$86,'3',$18,'t',$A0 
      DC.B      $02,$A3,$8B,$AB,'/x,m'
      DC.B      $ED,$E6,'4(%',$CA,'V',$D3 
      DC.B      $83,'0$(O`',$13,'p' 
      DC.B      $10,'"',$08,'!',$CA,$DE,'}',$83 
      DC.B      '0/83',$87,$DC,'5',$D9
      DC.B      $05,'{BG00',$D9,$8A 
      DC.B      $B2,$0B,'( (()('
      DC.B      '.',$87,$E1,'K',$93,$FD,$A8,$0B 
      DC.B      $08,'65!/7',$02,'8' 
      DC.B      '4',$EA,$E6,'f',$10,$C1,$A0,$EF 
      DC.B      $D8,'H4P2`0p' 
      DC.B      '0',$88,'2',$98,$F0,'Z',$D6,$F3 
      DC.B      'x/',$B1,'n',$A3,$18,'P*' 
      DC.B      '@(H)',$14,$81,'N_' 
      DC.B      '{',$E5,$F5,$F7,$E9,'W',$EE,$0A 
      DC.B      $1A,'( ',$BC,$A8,'5b',$B0 
      DC.B      $C3,$9E,$D9,$1E,'{',$C3,'%',$FD 
      DC.B      $1B,$8C,'8p+',$B0,'1*'
      DC.B      $0A,'D',$F9,$1B,'x|',$EA,$96
      DC.B      '5',$EA,'}`',$ED,'&',$CD,'f'
      DC.B      '0',$90,'@',$02,'+H',$CB,'`'
      DC.B      $D1,$09,$27,'@&0$',$18
      DC.B      '"',$FA,$B3,'U',$DF,'5',$11,'9' 
      DC.B      $88,'T',$04,'<',$A1,'-8/' 
      DC.B      '8-',$94,$D0,$15,$16,'*0' 
      DC.B      '+01@3',$D0,$E9,$DB 
      DC.B      $96,$EE,$09,$94,$10,'7[p' 
      DC.B      '1P86@',$B4,$C5,$DE 
      DC.B      $C3,'7',$EE,'96X4p' 
      DC.B      $F6,$CA,$ED,'$3',$98,'5',$A8
      DC.B      $C8,':t=/',$11,$B0,'6'
      DC.B      'h-5',$F5,'.',$02,'P+'
      DC.B      'x/',$90,'!',$13,'~',$1B,'7'
      DC.B      $95,'P',$D2,$E4,$1E,$E5,'/',$A0 
      DC.B      $B7,$FC,$F6,$FC,$0B,$C8,$AC,$B3 
      DC.B      $E2,'z',$FB,'M0',$C0,'3',$C7
      DC.B      $9B,$83,$06,$E8,$0A,'H',$E0,'(' 
      DC.B      $B8,'2',$A0,'0',$88,'.',$FB,';' 
      DC.B      $C5,$C3,'P),d',$10,'A'
      DC.B      $09,'(!',$B3,$F6,'*',$08,'/'
      DC.B      'p+h*P(0%'
      DC.B      '�(*F',$27,' +8'
      DC.B      $EB,'w@',$EE,$DA,$DC,$0B,'~'
      DC.B      '8H5@2@0',$0F 
      DC.B      '5',$14,'+-8.84'
      DC.B      ',',$A0,$C3,$97,$17,'{',$03,$05 
      DC.B      $D4,$10,$C2,$EF,$16,'?n',$F8
      DC.B      $D0,';',$E0,'=w',$8A,';',$17
      DC.B      $B8,'7',$A0,'4W',$DD,')h' 
      DC.B      '`,',$A0,$80,$F2,$17,$A8,'9'
      DC.B      '_zq',$92,$AF,'w',$06,$BF 
      DC.B      '{',$9C,$D9,$27,$7F,'l',$BF,'[' 
      DC.B      $A8,'0',$C8,'7',$E0,$BC,'}',$97 
      DC.B      $B8,$9A,$EC,$A0,$1F,'5',$D9,$E8 
      DC.B      'K',$EE,'x-',$93,$BB,'4',$0C
      DC.B      '`*p+-',$BE,';',$B2 
      DC.B      '9h+H',$27,'(r',$BF 
      DC.B      $F1,$7F,'& *81',$DF 
      DC.B      $E0,' ',$7F,'-',$17,$FC,$AD,'H' 
      DC.B      $1E,'u',$13,'e/@0@' 
      DC.B      $17,$16,$D0,$F9,'6',$CB,$DC,$DD 
      DC.B      $F4,'=n!',$DF,'-`5' 
      DC.B      'p4',$88,'4',$A8,'6',$C0,'<'
      DC.B      '9',$19,$88,'<>',$D9,$FE,$12
      DC.B      $B0,$B8,'7',$98,'0p7u'
      DC.B      '!',$10,'1',$A0,'40',$B9,'l'
      DC.B      '">]@s-lr'
      DC.B      $E7,$D7,'[x',$11,$FC,'.',$B8
      DC.B      $B8,$00,' ',$08,$D0,'R',$DB,$BE 
      DC.B      $03,'n$',$8A,$A0,'/',$C0,'3'
      DC.B      $E0,$EF,';',$E0,$FA,'6',$F9,$F3 
      DC.B      $1B,'3',$FC,'6',$1B,$0E,$9F,$DC 
      DC.B      $83,'n',$80,',',$88,'-',$90,'.' 
      DC.B      $B0,'a',$98,$BB,',',$D9,'/',$EE 
      DC.B      $F4,$C2,$FB,'t',$7F,'& )' 
      DC.B      '80H7',$E4,'ak',$EE 
      DC.B      $15,'%',$1E,'1',$E5,'N 7' 
      DC.B      '7',$BF,$FE,$CA,'{I',$FC,$BB
      DC.B      'X4h3',$80,'3',$A0,'5'
      DC.B      $B8,'"',$DF,$B8,$C9,';',$E8,'>' 
      DC.B      $F0,'`t',$01,$FD,$B0,'6',$98
      DC.B      '3',$E7,$AE,$A1,'#',$80,'0',$88 
      DC.B      $B0,$91,$DB,'d',$87,$BD,$13,$08 
      DC.B      '!',$BA,'M',$EF,$CD,$0D,$FE,$CA 
      DC.B      $E0,$D0,$8A,$AB,'p.',$10,$AD
      DC.B      $9E,$DC,'y8&P)p'
      DC.B      '+',$B2,$C3,'D',$B4,$E8,'6',$F0 
      DC.B      $C9,$DF,'_',$D9,$DB,'t',$07,'N' 
      DC.B      $F2,$B7,$90,'\',$7F,$97,$DE,$83 
      DC.B      $CE,'o',$93,'2',$C8,$BD,$F4,$AE 
      DC.B      '%',$C8,'4[_=',$DD,'0'
      DC.B      $80,',X)0% (' 
      DC.B      '8/@a',$DF,$05,'y',$18
      DC.B      $85,'B',$EE,':',$17,$DC,'B',$A2 
      DC.B      '32H3',$EC,$09,$DC,$8E
      DC.B      $EC,'n',$0E,$FF,'786.'
      DC.B      '8',$02,$EA,'6X3`1' 
      DC.B      'x1',$90,'3',$B0,';',$C7,$CB
      DC.B      '<=',$E8,'=',$84,$91,$27,$7F
      DC.B      'Y',$88,$A1,$82,$98,'3',$12,$10 
      DC.B      $C5,'&',$F7,$B0,'w',$02,$D8,';' 
      DC.B      $95,$E3,$BE,$F3,$DF,$F3,$FE,']' 
      DC.B      $90,'2`,pd',$A9,'u' 
      DC.B      ' #0&H(h+'
      DC.B      'O',$FE,'c',$DF,'31',$0E,'*'
      DC.B      $02,$A2,$18,'t',$0A,$A8,')',$B2 
      DC.B      $8F,$EE,$98,'0',$BB,$03,'.r'
      DC.B      $C0,'i',$B2,$A1,$15,'p',$C4,'~' 
      DC.B      $B2,$A0,'X((%y',$B2 
      DC.B      $DD,'w$ &8.@' 
      DC.B      $FE,$9E,$EC,$C2,$F7,$D5,'_',$B3 
      DC.B      'Ol',$A0,'4',$80,$EC,$8C,$AF
      DC.B      $BC,$A9,$7F,$FA,':H87'
      DC.B      'H',$ED,';',$E0,$D2,$16,$C1,$0C 
      DC.B      $F7,'5P1X/p0' 
      DC.B      $88,'2',$0D,'wk',$C9,$C0,','
      DC.B      $E4,$81,$C0,$E8,'=',$9B,$DC,'%' 
      DC.B      'a',$A9,$CF,'w',$F8,$D2,$7F,$D0 
      DC.B      '{',$D0,'s',$DC,$C1,$FD,'n8'
      DC.B      $B1,$88,'1P*#0%'
      DC.B      $EE,';',$E0,$ED,'2;',$E0,'|'
      DC.B      $A7,'28O',$F6,'O/',$B7
      DC.B      $80,'K6',$88,$08,$12,$18,'_'
      DC.B      $B8,'3l',$9F,$DC,$E5,$AD,$B6
      DC.B      'M',$EE,$FA,'~7',$FC,$10,'#'
      DC.B      ' &0-',$BB,'A',$1E,$F6
      DC.B      'd',$AF,$E1,$93,$FF,$C0 
      JSR       -32191(A7)
      DC.B      'g',$D1,'9C6',$C0,'g7'
      DC.B      $DC,$9F,$FC,'185@6' 
      DC.B      'H8P',$C0,$B0,$EF,$80,'w' 
      DC.B      $B8,$D3,'0P.`0',$98 
      DC.B      '4',$0B,$AF,$93,$B3,'=',$B9,$FF 
      DC.B      $FA,$D4,'?',$89,$91,$E0,$02,'2' 
      DC.B      $C8,'o',$93,'?',$83,$08,'6',$BD 
      DC.B      $F3,'+',$AD,$B9,$DE,'@',$27,'`' 
      DC.B      '*~W',$E4,'Ž4',$C3,$EF
      DC.B      $14,$C7,$A0,'0',$A0,'/Cx' 
      DC.B      $DD,$93,$80,'{',$D3,';A-' 
      DC.B      $D7,$97,$EF,$12,$FF,$EE,'pm'
      DC.B      $BD,$FD,'n',$C8,$10,'0,@' 
      DC.B      'y',$B2,$DB,$93,$7F,'&',$B8,$84 
      DC.B      '<$',$0E,'>',$8A,'m',$FE,'5'
      DC.B      $FE,'9O',$EE,'<',$D9,'4|' 
      DC.B      $A7,$B8,$B2,'PO6O',$F6
      DC.B      'P-`.x',$EF,$C9,$1E 
      DC.B      $C2,$EF,$86,$9B,$D8,$CE,$E0,$0C 
      DC.B      'Z',$C0,'8',$18,'|p',$A5,'m'
      DC.B      $D0,$9F,$DC,$E9,$FD,'N',$C8,'!' 
      DC.B      $18,'"',$9B,$92,$DF,'5',$E0,'6' 
      DC.B      $D0,'5',$A8,'0',$A0,$EE,'<T'
      DC.B      $B1,$90,'=',$D9,'<',$D9,'x,'
      DC.B      '+',$02,'*0',$1A,$90,'/',$A8
      DC.B      '1',$C0,'3',$E8,$D2,$1B,$A6,' ' 
      DC.B      $B3,$05,$FE,$E4,$AE,$AD,$B7,$DF 
      DC.B      $08,'#',$18,$E0,'!o',$DF,$05
      DC.B      '9',$86,'G',$17,'PB',$01,'<'
      DC.B      'y',$F9,$BB,$C5,$CB,$EC,$EF,$82 
      DC.B      'H',$98,'3',$B8,$9C,$EF,$84,$B7 
      DC.B      $EF,$18,$8F,$F2,$0F,$0C,$FF,'.' 
      DC.B      '8�Q',$EF,$DF,'-',$AE,$EE 
      DC.B      $08,'w',$C1,'y',$F2,'&X)' 
      DC.B      $88,'-',$7F,$12,'>',$F9,$C8,'3' 
      DC.B      $C0,'G',$BD,$B3,$D8,$A8,'0',$98 
      DC.B      '/',$A2,'l',$07,'!ph*'
      DC.B      $B9,'4',$D9,$E2,',7',$EA,$06
      DC.B      '^',$D8,'v',$1D,$E4,$C9,$1E,$F9 
      DC.B      $FF,$EE,$F0,$EF,$88,$FC,$9B,'A' 
      DC.B      $BE,$F4,$E0,$C7,':',$88,'P8'
      DC.B      $DF,'`',$C4,$F5,'-X',$9D,$92
      DC.B      $EB,$C9,'7',$9F,$EF,$1A,$8F,$E0 
      DC.B      '<r',$0F,$04,$97,$C8,'9',$84
      DC.B      $E0,$EA,$C9,']@~',$A5,$FD 
      DC.B      'n8',$BE,$10,$DF,'L',$9C,$27
      DC.B      '8',$A8,'1',$9B,$27,'[E}' 
      DC.B      $17,$DC,$C4,$B0,'1',$A0,'0',$88 
      DC.B      '.x,h)',$7F,$14,$C9 
      DC.B      $9A,$EC,'=',$C4,$80,'-',$98,'0' 
      DC.B      $B0,'2',$17,$C3,'0r0',$B9 
      DC.B      $FD,$AE,'q',$08,'$',$10,$27,$BE 
      DC.B      $03,'r',$F7,$1D,$91,$07,$7F,$1A 
      DC.B      $BC,$F8,'w/H.P.'
      DC.B      'p0',$90,'M>',$86,$E6,$93 
      DC.B      '-',$E1,'w',$8B,$83,$18,$08,$E8 
      DC.B      '=',$AE,$EF,$12,$E7,'p.',$F7
      DC.B      $BB,$C6,$F5,' #0%H' 
      DC.B      $27,$DD,$F0,'0',$0E,$A8,'0',$D5 
      DC.B      $F7,$BF,$EB,'5S6(',$C2
      DC.B      $C8,'3',$90,'.x+`*' 
      DC.B      '+u',$C3,'šh+x-'
      DC.B      $90,'0',$A8,'2',$C8,$DC,$A3,$DC 
      DC.B      $C9,$BE,'s',$9C,$DB,'6',$EF,'*' 
      DC.B      '9',$DF,'PU9',$DF,$1D,$B9 
      DC.B      $BB,$DF,$01,$90,'2',$97,$89,' ' 
      DC.B      'r',$18,'^',$E3,$81,$E0,$16,$92 
      DC.B      $FB,$A0,'4',$E4,'/',$01,$F9,$0D 
      DC.B      $F9,$FF,$AE,'0',$C8,$F9,'N',$F8 
      DC.B      '7',$83,'G',$B9,$E8,'6',$D0,$CB 
      DC.B      'C',$BE,$1B,$DE,'tG',$BD,'X'
      DC.B      '*p,',$88,'/',$A8,'2',$C0 
      DC.B      '4',$97,$89,$FB,$1D,'/',$E2,$00 
      DC.B      $FB,$9D,':',$93,$13,'s`',$C9
      DC.B      $BF,$0B,$9C,'3',$DA,$27,$DB,'_' 
      DC.B      '.X',$BE,$13,'rQ6',$C8
      DC.B      '9',$E0,'<',$FA,$E4,$FE,$CA,$0B 
      DC.B      $F2,'o&',$B0,'6',$AE,$EF,$82
      DC.B      $87,$B8,$7F,$17,$9C,'x/H' 
      DC.B      ')X',$F7,']',$E2,'@|',$07 
      DC.B      $FC,$E9,$7F,$E9,'_',$C4,$27,'w' 
      DC.B      $12,$9F,'@(',$FC,'E',$14,'P'
      DC.B      '*h,',$80,'.',$A0,'1',$C0 
      DC.B      'O',$F6,$D8,'w',$B8,'2',$88,$EB 
      DC.B      $C9,$FE,$00,'#',$06,$13,$B9,$BE 
      DC.B      'S<',$CA,'=p',$E4,$DF,$14 
      DC.B      '@H6',$CE,'w@.t'
      DC.B      $BF,'[',$DC,$C5,$AC,'w',$01,$C7 
      DC.B      'k',$FC,$BB,$C1,$9F,$FC,$BF,'x' 
      DC.B      '/',$19,$E4,$FA,$0E,'"H',$27
      DC.B      'q',$90,$14,$87,'O',$EE,$BD,$1E 
      DC.B      $F4,'[',$A7,$97,$98,'_',$0E,$D5 
      DC.B      $E5,'P)h;',$C4,$F5,'m'
      DC.B      '5P9',$DF,$0D,$98,$B7,'(' 
      DC.B      $FB,'v6~',$DD,$E2,$DF,'3' 
      DC.B      $05,$A7,$C9,$1D,$DF,$EF,$92,'\' 
      DC.B      $C4,$AC,'w',$01,$A7,$DC,$C3,'k' 
      DC.B      $C0,'8',$FC,$E9,'_O',$EE,$02
      DC.B      $F2,$1B,$E2,$FE,$DD,$E2,'P*'
      DC.B      'H',$27,'x,',$B0,'1',$FA,'.'
      DC.B      $F1,$B0,$EF,$82,$A3,$D8,$D8,'d' 
      DC.B      '/',$D9,$F0,'4',$A8,'1X)' 
      DC.B      'H',$DB,$E6,$DE,'[@',$27,'@'
      DC.B      '(P',$80,'.',$D3,$FD,$9E,'l'
      DC.B      '3=',$D9,'|G$',$08,'&'
      DC.B      '(,81',$E5,'bO',$F6 
      DC.B      $E5,$0C,$DE,$EB,$81,' ',$FF,'.' 
      DC.B      '2q',$7F,$F9,$06,'4@',$03 
      DC.B      $FF,'n',$B8,'/X/hp' 
      DC.B      'u',$DF,$01,$C8,$E7,$CA,$AE,'r' 
      DC.B      $E0,'<7Q',$E1,'-',$FE,']' 
      DC.B      'pm',$98,'3',$09,$F4,'W',$DF
      DC.B      $18,'#0%P',$27,'%y' 
      DC.B      $D8,'w',$E8,'6',$E0,'5',$C3,'Y' 
      DC.B      't',$F4,$FA,$8B,$A2,$86,$A0,'-' 
      DC.B      'hP',$AA,'9',$BB,$27,$E9,$F6
      DC.B      $17,'}H)`+',$DD,$93 
      DC.B      $FD,']h',$C6,$B5,'e',$C5,$00
      DC.B      $FE,'.',$C8,$F9,$AE,$F1,'r',$06 
      DC.B      $7F,'o',$F0,$F0,$12,'?{',$FF
      DC.B      '1.',$B8,$80,'@@68' 
      DC.B      $F8,']',$E2,$ED,'/P0',$88 
      DC.B      $C9,']',$94,$EA,$C0,'8',$C9,'>' 
      DC.B      $E8,$12,$C8,'9P',$14,'N',$BD
      DC.B      $87,'7',$1C,$C3,$27,$7F,$04,$83 
      DC.B      $08,$FE,']',$92,$F3,'%',$80,',' 
      DC.B      $E4,$0E,$88,'z4',$B2,$F9,'.'
      DC.B      '8',$C8,'3',$A8,$89,$F2,$D0,'_' 
      DC.B      '.`*,',$C5,'_5',$FD 
      DC.B      '/',$D9,'OX',$90,'.6',$DF 
      DC.B      $01,$B9,'P(($',$B4,'u'
      DC.B      $DF,'=',$08,'#',$10,'&(+' 
      DC.B      'H4',$1E,'&',$A3,$9E,':<' 
      DC.B      'l',$02,$EF,'"',$EB,$09,$AF,$F5 
      DC.B      $F1,$82,$7F,'74',$1C,$03,$9B
      DC.B      $DC,'82',$F5,'t?',$F3,$FE 
      DC.B      $E4,$7F,'c@.X07'
      DC.B      'J',$E9,'s',$0F,':',$82,'M',$C0 
      DC.B      '8',$EE,'C',$EE,$82,$90,$C1,'p' 
      DC.B      $06,$7F,$FA,'g',$D0,$DC,$27,$7F 
      DC.B      'n',$80,'0X+',$A5,$FD,'.' 
      DC.B      'q',$10,'! #',$17,'t~'
      DC.B      $1D,'X(',$88,'-',$B0,$E8,$89
      DC.B      $EF,$C9,$E6,'1',$1B,'<',$DC,'S' 
      DC.B      $FC,$DD,$AE,$F0,'8',$27,'H('
      DC.B      $27,$BB,$C9,$DD,'x-Q',$AB 
      DC.B      $90,$F7,'X)',$EF,$16,$C7,'V'
      DC.B      ',8',$DF,$19,$B9,$BE,'K|' 
      DC.B      $BC,$E0,'G',$9F,$F2,$8F,'r',$7F 
      DC.B      $F2,$C7,$F0,';',$E0,$01,'06'
      DC.B      $F2,$E4,$CE,'w@H',$89,$F3 
      DC.B      'd',$F3,$E4,'n',$E6,'w',$C2,'M' 
      DC.B      'lr',$8F,'rou',$05,$83
      DC.B      $FF,']`,',$93,$AB,$AB,$27 
      DC.B      ' ',$10,'!(#@&`'
      DC.B      '*',$90,'.{',$B3,$EF,$16,$A0
      DC.B      '0',$90,$07,$B1,'5',$DD,'`)'
      DC.B      'P',$B7,$A6,$BB,$C9,'`+',$80
      DC.B      '-',$98,'0',$FE,$C9,'>L',$C0
      DC.B      '3',$DA,$EF,$86,'KX*X'
      DC.B      'k',$E5,$ED,'(wB',$CE,'w' 
      DC.B      $88,$9F,$17,$FC,$10,'\',$C0,'(' 
      DC.B      ';',$F7,$EF,$12,$87,'/A',$04
      DC.B      $9F,'l3žlžlq' 
      DC.B      'k',$DC,$C1,':H6H2' 
      DC.B      '@0P.`/x='
      DC.B      '+',$BB,$9F,$FC,$19,'D',$B0,$C9 
      DC.B      $DD,$C3,$B5,$FF,$D5,$FF,'.',$88 
      DC.B      '1q',$01,'%',$E1,'w',$89,$A3
      DC.B      'K',$18,'"($@&',$EC 
      DC.B      'w',$C3,$C3,$98,'/',$B8,'2',$D0 
      DC.B      '4|',$DF,$05,'w',$F1,$C9,$E6
      DC.B      $88,'.x',$B0,'usx&' 
      DC.B      'P)h+',$80,'.',$93,';'
      DC.B      $F6,$86,$B8,'AHl',$C2,$C8 
      DC.B      '3x-`+',$95,$95,$B0 
      DC.B      $0E,$10,'%',$DC,$EF,$1E,$D7,'-' 
      DC.B      '@',$93,$AD,'n',$F0,$F0,'*',$FF 
      DC.B      $C0,'=',$F0,'(',$7F,$BE,'40'
      DC.B      'S',$9C,$C0,'4',$D9,$19,$EF,$DF 
      DC.B      '6H3H0P/h'
      DC.B      $05,$27,'v',$0C,'1',$98,'M',$F5 
      DC.B      $D9,$02,$E2,$88,$A2,$82,$80,'0' 
      DC.B      $06,$0A,'(',$0C,'5',$CC,'o8'
      DC.B      $86,$DF,'%',$CE,$ED,$C7,';',$82 
      DC.B      'h-',$DF,$0D,'WW',$08,'O' 
      DC.B      $EE,'<',$D9,'&z',$88,$E1,'B'
      DC.B      '�',$7F,$07,$C8,$1C,'g',$9F,$DC 
      DC.B      '-p+@',$27,'0',$1B,$84
      DC.B      '*',$B6,'@(X)p,'
      DC.B      $88,'.&',$FB,$C9,'}',$C0,$0C
      DC.B      'B',$A4,$FD,'5',$A8,'1',$80,'-' 
      DC.B      'h,.8',$D2,$86,$89,$FB
      DC.B      $1D,$90,'& )0.H'
      DC.B      '6?',$18,$F5,$1D,$E2,'[',$FE
      DC.B      $C1,$CF,'q',$27,'1<',$F5,'O'
      DC.B      $1D,$06,'281',$A3,$EE,$D6 
      DC.B      'd7',$BD,$DF,$BC,$9B,$FB,$E4
      DC.B      $EE,'1X0h0',$88,$AB 
      DC.B      $AE,'a=',$13,$18,$F5,$DE,$F6
      DC.B      $1F,'t~',$F1,'U',$D1,$C4,'3'
      DC.B      $FF,$FB,$0E,$FF,'.',$B8,$B4,$EE 
      DC.B      '~',$17,$1C,'! #',$DD,'o' 
      DC.B      $B0,$F0,'(',$A8,'0',$C8,'3',$E0 
      DC.B      '5',$96,'g',$C3,'bXC',$C1 
      DC.B      'E',$B8,'2h*',$94,$86,$EA 
      DC.B      $8A,'HE',$9E,$EC,$A6,'H(' 
      DC.B      $FB,$C9,'^',$EE,'x,',$98,'/'
      DC.B      ':',$08,$A5,$D5,$F0,'7',$B6,$E9 
      DC.B      ']',$CA,$B0,'/x-J',$8B
      DC.B      $A6,'M*0/',$DC,$EF,$84
      DC.B      $BC,$0D,$EC,$83,'e',$DC,'&',$F0 
      DC.B      $80,$F0,')',$F7,$9B,$F7,$A8,$F7 
      DC.B      $D3,'9',$C7,$17,'qc2H'
      DC.B      'n',$FC,$C5,$97,'?',$27,'w',$01 
      DC.B      $99,'4P2X1p1' 
      DC.B      $88,'2',$B1,$9F,$DC,$C9,$F6,$19 
      DC.B      $1C,$C5,$27,'w',$1A,$05,'h-'
      DC.B      'T”;„$',$82,'( '
      DC.B      $E0,'<',$85,$02,'7',$C6,']',$C0 
      DC.B      $EF,$82,$1C,$DD,$EF,$82,' ',$93 
      DC.B      'w?',$D9,',',$A8,'P(@'
      DC.B      $27,$FA,$8E,$C8,$1D,'(%',$82
      DC.B      $02,'J',$DF,'`+',$27,'wQ' 
      DC.B      'K!„#w',$E0,'l',$C2 
      DC.B      $09,$B1,$90,'*GO',$BE,$03 
      DC.B      $27,'0ržl',$9E,$EC,$05
      DC.B      'L|o',$B2,$19,'\r',$0F
      DC.B      $FA,$8D,$1D,$E5,'~',$E6,$1F,'t' 
      DC.B      $0A,$BF,'>P?k',$DC,$C0
      DC.B      '6c',$83,$EB,$EB,'6',$D3,$FB
      DC.B      $93,'?',$FB,$05,$27,$91,'A',$04 
      DC.B      $09,$F4,'`,W',$E1,$05,'/' 
      DC.B      '{Os',$8F,'y',$87,'7',$EA 
      DC.B      $B0,':',$1D,'/',$89,'r',$F8,'?' 
      DC.B      $D8,';',$97,$BF,$FA,'.',$B8,$BF 
      DC.B      $DF,$0D,$B0,'1',$17,$8F,',',$F6 
      DC.B      $FE,'w',$C1,$D5,'(}',$B2,'Q'
      DC.B      $B0,$E9,$1D,'[}h,',$88
      DC.B      $9F,$DC,$DB,$D3,$D0,$FD,']',$E3 
      DC.B      '|',$DC,$D0,$92,$FB,'5',$9D,$91 
      DC.B      'SX@',$0D,']l',$B2,$93
      DC.B      $DE,$83,$DF,'v',$A7,$B9,$93,$1B 
      DC.B      $E5,$1E,'H7t',$0A,'K',$16 
      DC.B      '5�)69',$B6,$82,$06 
      DC.B      $0A,'=P<P6X3' 
      DC.B      'h2x2',$90,$D8,'n',$DC
      DC.B      $C9,'(',$0D,$BC,'_u',$1B,$D3
      DC.B      $DE,$0D,$14,$90,$DF,'(',$7F,$05 
      DC.B      $CF,$FE,$C1,$F5,'w',$E9,$1D,'^' 
      DC.B      'n',$C8,'9',$E0,'<',$F0,'>',$E8 
      DC.B      '=',$A5,'u',$04,':',$C0,'8|'
      DC.B      $05,',',$BA,$00,' ',$08,'@',$ED 
      DC.B      $C9,'V',$91,$27,$DB,'H!',$C8
      DC.B      '3',$A5,'`',$D0,$7F,$C0,'3`'
      DC.B      '_',$EE,$AA,$0B,$AA,$F5,$F7,'M' 
      DC.B      '$)7O',$F6,$B0,$90,'K'
      DC.B      $D4,'m-',$F8,'7',$F0,'7',$B6
      DC.B      $08,$06,$DD,$E1,$EB,$EC,'w,'
      DC.B      'H4H',$0E,$85,$8A,'7h'
      DC.B      $01,'5d',$F6,$DF,$EC,$03,'H'
      DC.B      $E7,$DC,$9F,$0C,$86,' ',$06,$9D 
      DC.B      'B',$08,$9B,$EC,'4P8w'
      DC.B      'l',$9C,'U;P:P9'
      DC.B      'P7P5X3`1'
      DC.B      'p1',$88,'a',$01,$09,$EC,'g'
      DC.B      $03,$05,'d',$B1,'`',$E7,$F0,'@' 
      DC.B      '(',$EC,'_U',$FF,$88,'1',$92
      DC.B      'P@',$0E,$C1,$D5,$90,'@q' 
      DC.B      $83,$DC,$A5,$B8,'7',$D0,':',$E0 
      DC.B      '<',$D8,';u',$04,':~',$FD 
      DC.B      $15,$D7,$DC,'" ',$27,'{E' 
      DC.B      $BD,')x,',$A0,'0',$B8,'2' 
      DC.B      $D8,$8B,')H`',$D8,'5',$14 
      DC.B      $A5,$AF,$BF,$98,'/p,X'
      DC.B      ')@',$27,'c',$E0,'6',$D9,'P'
      DC.B      $DF,$01,$E7,$E4,$90,'.',$D0,'5' 
      DC.B      $E0,$96,$85,$D8,$B6,$E8,'6',$E0 
      DC.B      '5',$B8,'3',$00,'pg',$AF,$FC
      DC.B      '5',$F7,';(/@2 '
      DC.B      'g',$CD,'n',$05,'- ',$87,'5'
      DC.B      $CC,'~',$D9,$FF,'~',$C1,$A7,$DC 
      DC.B      '9_6P@@1J'
      DC.B      $9D,'%wH5H7',$F0
      DC.B      $85,$D6,$05,'8H6H4' 
      DC.B      'H3P1X0h0'
      DC.B      $80,'1',$90,$9E,$C0,$06,'m',$01 
      DC.B      'Y',$0C,'tH)orW'
      DC.B      $D0,'@(X+',$F5,'u',$0E
      DC.B      '>',$98,'3]g',$FE,$18,$80 
      DC.B      '0',$A8,'5',$B8,'7',$D2,'+j'
      DC.B      $1D,$C8,'9',$C0,'8',$B0,'6�'
      DC.B      'a',$F8,$0A,$10,'!K',$EE,$93
      DC.B      $BB,'H',$27,$88,'.',$A2,$DE,'e' 
      DC.B      $A1,$1C,$CC,'}',$14,$B0,'2',$88 
      DC.B      'I',$14,$BE,'`(8*',$AC
      DC.B      'Tm ',$B2,$05,$E4,$C4,'H' 
      DC.B      '(h*',$B0,'1',$C0,'3',$C8 
      DC.B      $DE,'E',$B9,$BF,$D0,'4',$C8,'3' 
      DC.B      $C0,'2',$00,$F0,'0~x,'
      DC.B      $89,$D5,'w',$8F,$18,'&+',$CA
      DC.B      $E6,$B0,$A0,$1B,'šC1',$12 
      DC.B      $D9,$0F,'q+0,u',$9B 
      DC.B      $85,$10,'@3@5b',$A8 
      DC.B      $A0,'K828',$C2,'v',$EF
      DC.B      $91,'8/81838' 
      DC.B      $0D,$AD,'X',$D0,'4@2@'
      DC.B      '1@0H.P-X'
      DC.B      'x0',$CF,$A6,'l',$19,'(',$A0
      DC.B      $8D,'*x/',$AA,$BB,$E0,'A' 
      DC.B      $0F,'sw',$90,$C4,$A0,'3(' 
      DC.B      'n',$92,$FB,$94,$88,'1',$98,'3' 
      DC.B      $A0,'4',$90,'2',$80,'0',$BF,$0B 
      DC.B      'z',$18,'X+',$B1,'z',$F2,$27
      DC.B      $B1,$EF,$8E,$B2,'s]A',$03 
      DC.B      $A0,'0',$05,$94,$88,$01,';',$86 
      DC.B      $EC,'6',$D9,$87,$01,$0F,'X)'
      DC.B      '/',$B8,$B8,$B5,$98,'/P',$0E
      DC.B      $06,$82,$B0,'1',$A8,'0',$90,'.' 
      DC.B      $80,'-#',$A0,$98,$B3,$DF,$01
      DC.B      $B9,'š',$27,$A4,$CC,'a',$C1,'N' 
      DC.B      'c@',$C0,')',$F3,'l',$01,'y'
      DC.B      '()s',$D7,$C8,$10,'0b'
      DC.B      $98,$EA,$8C,'.(-(,' 
      DC.B      $FC,$08,$DC,$B2,'+0-0'
      DC.B      '.0/8.8-8'
      DC.B      ',8+@',$05,'|A7'
      DC.B      'C',$D1,'L1-h',$15,$D8
      DC.B      $C5,$81,$BF,$C9,$BF,$E4,$0F,'s' 
      DC.B      'w',$F7,$C5,$FD,$CC,'}',$C9,'}' 
      DC.B      $CA,$1D,'p.x/h-'
      DC.B      '`,B',$06,$15,$F4,'0a'
      DC.B      $E1,'}',$F2,'71',$CA,$DD,'B'
      DC.B      ' s*',$06,$C1,$A0,$9B,'p' 
      DC.B      '+`(',$D8,'@',$A5,$C9,'}' 
      DC.B      $90,$C3,$EF,'%z',$B4,$E5,'V'
      DC.B      'h+p',$C2,'v8',$E8,$80
      DC.B      'x,`)X',$04,'~',$1D 
      DC.B      $B6,$AE,$DF,'=~y',$93,'i' 
      DC.B      'a',$27,'q',$01,'!L',$FA,$9C
      DC.B      $BF,$27,$80,'@',$98,'8*)' 
      DC.B      $18,$F8,$04,$16,$82,$27,' ('
      DC.B      ' ) A',$7F,$02,$12,'*'
      DC.B      '()0',$08,$DE,$04,'$8'
      DC.B      '0',$13,'!',$AE,$E2,$C0,'~',$CD 
      DC.B      $C4,'S',$F6,'2',$7F,$04,'G',$FE 
      DC.B      $AB,$DC,$19,'DP*H)' 
      DC.B      '@(0',$E8,'a',$15,$EE,'O' 
      DC.B      $EE,'w',$EE,'Q',$EE,$16,'8',$27 
      DC.B      $B2,$EB,$04,$82,$93,$A8,$A2,$86 
      DC.B      '*',$EE,$FA,'v',$C1,$0F,$FC,'5' 
      DC.B      '8%@&@|',$0C,$06
      DC.B      $80,'P(HK@',$F0,$FC 
      DC.B      $B0,$D7,$F3,$BB,$C7,$07,$ED,'W' 
      DC.B      $BD,$A3,$F8,$E2,'$%@p'
      DC.B      $02,$13,'&',$08,'%@\',$02 
      DC.B      '"',$10,'% ,',$0A,'H',$18 
      DC.B      '& q',$04,'D (@'
      DC.B      '&',$9A,$C4,'8',$27,'AW',$AF
      DC.B      $A3,$98,$E4,'_S',$F0,$F9,$12
      DC.B      $AF,$D8,'_',$FE,$B0,'0&W' 
      DC.B      '0',$F8,$12,'(%P<~' 
      DC.B      $17,'|',$CA,$DD,'B0%',$09 
      DC.B      $03,$8B,$AB,$E6,$B1,'.l',$F8
      DC.B      $82,'}',$82,' MT',$1F,$08 
      DC.B      '(NQ?[',$F0,$EF,$84 
      DC.B      $FC,$D4,$03,$8F,'+',$18,'|<'
      DC.B      $03,$00,$8C,$83,'`',$D0,$08,'e' 
      DC.B      $0C,' N',$10,'@8',$8F,$0F 
      DC.B      ' $',$04,'WD',$C1,'[='
      DC.B      $83,'G',$9E,$B1,$7F,$16,'wp'
      DC.B      $C4,$FF,$F5,'{>',$D0,'8',$88
      DC.B      $05,$05,$0F,$0B,$F1,$E7,'"#'
      DC.B      $18,$07,'&',$B0,$02,$7F,$15,$F0 
      DC.B      $EF,$86,'< a',$00,$CE,'G' 
      DC.B      $8E,$07,$10,'"]',$07,'5>' 
      DC.B      'S',$91,$7F,$82,$FC,$A0,$E1,$1C 
      DC.B      '!',$08,$06,$8C,'\',$DF,$08,'!' 
      DC.B      '43',$D7,'``',$E6,$DE,'=' 
      DC.B      $FE,']',$FF,$F9,'k',$8B,$E6,$DE 
      DC.B      '=',$FE,$DD,$AE,'9',$C0,$F1,$EF 
      DC.B      $FA,$CF,'_',$E3,'4',$FF,$F7,$BB 
      DC.B      $FE,$F3,$D7,'6',$CD,$FF,$FD,$8E 
      DC.B      $F9,'<',$A0,'l',$00,'Z~',$A4
      DC.B      $00,$CF,$89,$00,$03,$F8,$A8,'o' 
      DC.B      $82,$CE,'@',$BF,'T',$1E,'m',$9B 
      DC.B      $BE,$F4,$1F,$84,'i',$FE,$B8,':' 
      DC.B      $04,'W',$8B,$18,'H',$A0,$88,$DC 
      DC.B      '4BL',$0F,'W',$BB,$ED,$FE 
      DC.B      $ED,'e',$0E,' L',$8A,$D2,$ED
      DC.B      $F4,'U',$EC,$FC,$03,$FE,'d',$06 
      DC.B      $80,'w',$7F,$E1,'[ca',$08 
      DC.B      'ZkaFz',$07,'c2'
      DC.B      $0F,$F6,'-',$FF,$FE,$AC,$04,$B7 
      DC.B      $96,$87,$C1,'nX[',$10,$BE 
      DC.B      'Y5GP',$00,'Q?E'
      DC.B      $17,$C2,$80,$06,$FC,$83,'x',$07 
      DC.B      '^',$88,$EE,$18,'t0',$10,'y'
      DC.B      $08,$F4,$AB,$12,'4V',$C2,'`'
      DC.B      '/',$96,'}',$08,'N+',$01,$F3
      DC.B      'Nf',$C7,$01,'@',$A0,$05,$FF
      DC.B      $A1,'E',$A4,$D7,$80,$0F,$FF,$98 
      DC.B      $00,'#',$19,$D6,$C9,'QQ',$8B
      DC.B      $08,'E+g',$D5,$88,$9D,$8E 
      DC.B      $08,'G+W',$9F,'#',$FD,'r' 
      DC.B      'b',$06,'o',$05,$F4,'"',$00,$FF 
      DC.B      $FF,'f',$9E,$C5,'d',$27,$01,$C9 
      JMP       76(A0)
      DC.B      $E9,$A1,'!',$84,$00,$8B,$15,'v' 
      DC.B      '<',$B1,'!',$86,$00,'a',$00,'@' 
      DC.B      '`?',$FF,'e',$BE,$C2,$AD,'p'
      DC.B      $02,'Fd',$F4,$05,$C5,'"',$97
      DC.B      $00,'+',$EC,' |,}b' 
      DC.B      $82,$AA,$C7,'"',$F3,$00,$06,'U' 
      DC.B      $80,$C6,' ',$16,$0B,$91,$B8,$81 
      DC.B      $9A,$9C,$99,'"',$AE,$00,'M',$DB 
      DC.B      $C2,$E3,'!',$DE,$AA,' ',$00,$BF 
      DC.B      '^',$EE,$00,'"',$05,$10,'"/'
      DC.B      'f!',$DA,$00,$0A,$A9,$81,$C3
      DC.B      $0C,'T0',$C4,$08,$EA,'kO' 
      DC.B      $DC,$00,$0C,$00,'}',$00,'4',$1A 
      DC.B      $04,$06,$12,$06,$18,$1E,$06,$84 
      DC.B      $08,$06,$86,$01,$01,'Z',$08,'&' 
      DC.B      $1E,$18,$18,$00,$06,$CB,$02,'\' 
      DC.B      $00,$00,$00,'a' 
ZUEND: END
