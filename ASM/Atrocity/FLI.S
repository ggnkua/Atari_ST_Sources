
	OPT	O+
	
	SECTION TEXT

	MOVE.L	#ANIM,D0
	MOVE.L	D0,D1
	ADD.L	#240008,D1
	LEA	4(SP),SP
	MOVE.L	D0,(SP)+
	MOVE.L	D1,(SP)+
	LEA	-12(SP),SP
	BRA.S	FLI
	
	SECTION DATA
	
FLI	INCBIN	E:\FLI\PLAY_FLI.PRG
	EVEN
	
ANIM	INCBIN	E:\FLI\CLOWN.FLI
	EVEN
	