SYSTEME	MOVE.L	SP,A5
	LEA.L	PILE,SP
	MOVE.L	4(A5),A5
	MOVE.L	$C(A5),D0
	ADD.L	$14(A5),D0
	ADD.L	#$100,D0
	MOVE.L	D0,-(SP)
	MOVE.L	A5,-(SP)
	MOVE.W	#$4A,-(SP)
	TRAP	#1
	ADD.L	#12,SP
	