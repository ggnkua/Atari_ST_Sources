	
	LEA	TEXT,A5
	SUBA.L	#$100,A5
	TST.L	($24,A5)
	BNE.B	$1AECF2
	CLR.W	DATA
	LEA	$1B281C,A7
	MOVE.L	$1B2656,-(A7)
	MOVE.W	#$48,-(A7)
	TRAP	#1
	ADDQ.W	#6,A7
	TST.L	D0
	BEQ.B	$1AECE6
	MOVEA.L	D0,A7
	ADDA.L	$1B2656,A7
	BRA.B	$1AED28
	MOVE.L	($C,A5),D0
	ADD.L	($14,A5),D0
	ADD.L	($1C,A5),D0
	ADD.L	$1B2656,D0
	ADDI.L	#$100,D0
	MOVE.L	D0,D1
	ADD.L	A5,D1
	AND.L	#-2,D1
	MOVEA.L	D1,A7
	MOVE.L	D0,-(A7)
	MOVE.L	A5,-(A7)
	CLR.W	-(A7)
	MOVE.W	#$4A,-(A7)
	TRAP	#1
	ADDA.L	#$C,A7
	MOVE.L	A5,$1B2942
	MOVEA.L	$1B2942,A0
	MOVE.L	($2C,A0),-(A7)
	PEA	($80,A0)
	JSR	$1B0E6E
	ADDQ.L	#8,A7
	MOVE.L	$1B28D0,-(A7)
	MOVE.L	$1B2872,-(A7)
	MOVE.W	$1B2AF8,-(A7)
	JSR	$1B0D0C
	ADDQ.L	#2,A7
	MOVE.W	#0,-(A7)
	JSR	$1B199A
	MOVEM.L	D0/D7-A2,-(A7)
	CMPI.W	#1,$1B2576
	BEQ.B	$1AEDD6
	TST.W	$1B2574
	BNE.B	$1AED88
	MOVE.W	$1B2576,$1B2574
	MOVE.W	$1B2572,-(A7)
	MOVE.W	$1B2574,-(A7)
	JSR	$1B0564
	ADDQ.W	#4,A7
	MOVE.W	D0,-(A7)
	JSR	$1B04EC
	ADDQ.W	#2,A7
	MOVEA.L	$1B289C,A1
	LEA	($C,A0),A0
	JSR	$1AF78A
	SUBQ.W	#1,$1B2574
	MOVE.L	$1B289C,-(A7)
	MOVE.L	$1B2A28,-(A7)
	MOVE.W	#$C8,-(A7)
	JSR	$1B0AAC
	LEA	($A,A7),A7
	MOVEM.L	(A7)+,D0/D7-A2
	RTS
	MOVEM.L	D0/D7-A2,-(A7)
	CMPI.W	#1,$1B2576
	BEQ.B	$1AEE4E
	MOVE.W	$1B2572,-(A7)
	MOVE.W	$1B2574,-(A7)
	ADDQ.W	#1,(A7)
	JSR	$1B0564
	ADDQ.W	#4,A7
	MOVE.W	D0,-(A7)
	JSR	$1B04EC
	ADDQ.W	#2,A7
	MOVEA.L	$1B289C,A1
	LEA	($C,A0),A0
	JSR	$1AF78A
	ADDQ.W	#1,$1B2574
	MOVE.W	$1B2574,D0
	CMP.W	$1B2576,D0
	BNE.B	$1AEE34
	CLR.W	$1B2574
	MOVE.L	$1B289C,-(A7)
	MOVE.L	$1B2A28,-(A7)
	MOVE.W	#$C8,-(A7)
	JSR	$1B0AAC
	LEA	($A,A7),A7
	MOVEM.L	(A7)+,D0/D7-A2
	RTS
	BRA.B	$1AEE4E
	MOVEM.L	D6-A1,-(A7)
	CMPI.W	#1,$1B2576
	BEQ	$1AEEF6
	CMP.W	$1B2576,D0
	BGT.B	$1AEEDC
	TST.W	D0
	BLE.B	$1AEEDC
	MOVE.W	D0,D6
	CLR.W	$1B2574
	MOVE.W	$1B2572,-(A7)
	MOVE.W	$1B2574,-(A7)
	JSR	$1B0564
	ADDQ.W	#4,A7
	MOVE.W	D0,-(A7)
	JSR	$1B04EC
	ADDQ.W	#2,A7
	JSR	$1AF872
	SUBQ.W	#1,D6
	BEQ.B	$1AEEDC
	SUBQ.W	#1,D6
	ADDQ.W	#1,$1B2574
	MOVE.W	$1B2572,-(A7)
	MOVE.W	$1B2574,-(A7)
	JSR	$1B0564
	ADDQ.W	#4,A7
	MOVE.W	D0,-(A7)
	JSR	$1B04EC
	ADDQ.W	#2,A7
	MOVEA.L	$1B289C,A1
	LEA	($C,A0),A0
	JSR	$1AF78A
	DBF	D6,$1AEEA4
	MOVE.L	$1B289C,-(A7)
	MOVE.L	$1B2A28,-(A7)
	MOVE.W	#$C8,-(A7)
	JSR	$1B0AAC
	LEA	($A,A7),A7
	MOVEM.L	(A7)+,D6-A1
	RTS
	MOVEM.L	D0/D6-A1,-(A7)
	CMPI.W	#1,$1B2576
	BEQ	$1AF13C
	JSR	$1AF316
	TST.B	D0
	BEQ.B	$1AEF30
	MOVE.W	$1B2576,D0
	JSR	$1AEE56
	MOVEQ	#-1,D6
	MOVE.W	$1B2576,$1B2574
	BRA.B	$1AEF5C
	CLR.W	$1B2574
	MOVE.W	$1B2572,-(A7)
	MOVE.W	$1B2574,-(A7)
	JSR	$1B0564
	ADDQ.W	#4,A7
	MOVE.W	D0,-(A7)
	JSR	$1B04EC
	ADDQ.W	#2,A7
	JSR	$1AF872
	MOVEQ	#1,D6
	MOVE.L	$1B289C,-(A7)
	MOVE.L	$1B2A28,-(A7)
	MOVE.W	#$C8,-(A7)
	JSR	$1B0AAC
	LEA	($A,A7),A7
	JSR	$1AF37E
	JSR	$1AF38A
	SF	$1B2980
	TST.B	$1B2980
	BEQ.B	$1AEF88
	MOVE.L	$1B2A28,-(A7)
	MOVE.L	$1B289C,-(A7)
	MOVE.W	#$C8,-(A7)
	JSR	$1B0AAC
	LEA	($A,A7),A7
	MOVE.W	$1B28A6,D7
	SUBQ.W	#1,D7
	BEQ.B	$1AEFEA
	SUBQ.W	#1,D7
	SF	$1B2980
	MOVEM.L	D1-D3/A0-A2,-(A7)
	MOVE.W	#$FF,-(A7)
	MOVE.W	#6,-(A7)
	TRAP	#1
	ADDQ.L	#4,A7
	MOVEM.L	(A7)+,D1-D3/A0-A2
	TST.L	D0
	BEQ.B	$1AEFDE
	BSR	$1AF0A0
	TST.B	D0
	BNE	$1AF0F2
	TST.B	$1B2980
	BEQ.B	$1AEFBC
	DBF	D7,$1AEFB6
	MOVEM.L	D1-D3/A0-A2,-(A7)
	MOVE.W	#$FF,-(A7)
	MOVE.W	#6,-(A7)
	TRAP	#1
	ADDQ.L	#4,A7
	MOVEM.L	(A7)+,D1-D3/A0-A2
	TST.L	D0
	BEQ.B	$1AF00C
	BSR	$1AF0A0
	TST.B	D0
	BNE	$1AF0F2
	ADD.W	D6,$1B2574
	TST.W	D6
	BPL.B	$1AF03A
	TST.W	$1B2574
	BGT.B	$1AF062
	TST.B	$1B2876
	BNE.B	$1AF030
	ADDQ.W	#1,$1B2574
	BRA	$1AF0F2
	MOVE.W	$1B2576,$1B2574
	MOVE.W	$1B2576,D0
	CMP.W	$1B2574,D0
	BGE.B	$1AF062
	TST.B	$1B2876
	BNE.B	$1AF05A
	SUBQ.W	#1,$1B2574
	BRA	$1AF0F2
	MOVE.W	#1,$1B2574
	MOVE.W	$1B2572,-(A7)
	MOVE.W	$1B2574,-(A7)
	JSR	$1B0564
	ADDQ.W	#4,A7
	MOVE.W	D0,-(A7)
	JSR	$1B04EC
	ADDQ.W	#2,A7
	MOVEA.L	$1B289C,A1
	LEA	($C,A0),A0
	JSR	$1AF78A
	JSR	$1AF38A
	SF	$1B2980
	BRA	$1AEF88
	CMPI.B	#$72,D0
	BNE.B	$1AF0C2
	TST.W	D6
	BMI.B	$1AF0B6
	MOVEQ	#-1,D6
	ADDQ.W	#1,$1B2574
	SF	D0
	RTS
	MOVEQ	#1,D6
	SUBQ.W	#1,$1B2574
	SF	D0
	RTS
	SWAP	D0
	CMPI.B	#$4D,D0
	BNE.B	$1AF0DE
	MOVE.W	$1B28A6,D0
	SUBQ.W	#1,D0
	BEQ.B	$1AF0DA
	MOVE.W	D0,$1B28A6
	SF	D0
	RTS
	CMPI.B	#$4B,D0
	BNE.B	$1AF0EE
	ADDQ.W	#1,$1B28A6
	SF	D0
	RTS
	ST	D0
	RTS
	JSR	$1AF3C2
	TST.W	D6
	BPL.B	$1AF10E
	SUBQ.W	#1,$1B2574
	BGT.B	$1AF10E
	MOVE.W	$1B2576,$1B2574
	MOVE.W	$1B2576,D0
	CMP.W	$1B2574,D0
	BNE.B	$1AF136
	CLR.W	$1B2574
	MOVE.W	$1B2572,-(A7)
	MOVE.W	$1B2574,-(A7)
	JSR	$1B0564
	ADDQ.W	#4,A7
	JSR	$1AF34E
	MOVEM.L	(A7)+,D0/D6-A1
	RTS
	MOVEM.L	D0/D6-A1,-(A7)
	CMPI.W	#1,$1B2576
	BEQ	$1AF310
	JSR	$1AF316
	CLR.W	$1B2574
	MOVE.W	$1B2572,-(A7)
	MOVE.W	$1B2574,-(A7)
	JSR	$1B0564
	ADDQ.W	#4,A7
	MOVE.W	D0,-(A7)
	JSR	$1B04EC
	ADDQ.W	#2,A7
	JSR	$1AF872
	MOVE.L	$1B289C,-(A7)
	MOVE.L	$1B2A28,-(A7)
	MOVE.W	#$C8,-(A7)
	JSR	$1B0AAC
	LEA	($A,A7),A7
	MOVEQ	#1,D6
	JSR	$1AF37E
	JSR	$1AF38A
	SF	$1B2980
	TST.B	$1B2980
	BEQ.B	$1AF1B0
	MOVE.L	$1B2A28,-(A7)
	MOVE.L	$1B289C,-(A7)
	MOVE.W	#$C8,-(A7)
	JSR	$1B0AAC
	LEA	($A,A7),A7
	MOVE.W	$1B28A6,D7
	SUBQ.W	#1,D7
	BEQ.B	$1AF20A
	SUBQ.W	#1,D7
	SF	$1B2980
	MOVEM.L	D1-D3/A0-A2,-(A7)
	MOVE.W	#$FF,-(A7)
	MOVE.W	#6,-(A7)
	TRAP	#1
	ADDQ.L	#4,A7
	MOVEM.L	(A7)+,D1-D3/A0-A2
	TST.L	D0
	BNE	$1AF2A4
	TST.B	$1B2980
	BEQ.B	$1AF1E4
	DBF	D7,$1AF1DE
	MOVEM.L	D1-D3/A0-A2,-(A7)
	MOVE.W	#$FF,-(A7)
	MOVE.W	#6,-(A7)
	TRAP	#1
	ADDQ.L	#4,A7
	MOVEM.L	(A7)+,D1-D3/A0-A2
	TST.L	D0
	BNE	$1AF2A4
	ADD.W	D6,$1B2574
	TST.W	D6
	BMI.B	$1AF252
	MOVE.W	$1B2576,D0
	SUBQ.W	#1,D0
	CMP.W	$1B2574,D0
	BGE.B	$1AF266
	MOVEQ	#-1,D6
	MOVE.W	$1B2576,$1B2574
	SUBQ.W	#1,$1B2574
	BRA.B	$1AF266
	CMPI.W	#1,$1B2574
	BGE.B	$1AF266
	MOVE.W	#1,$1B2574
	MOVEQ	#1,D6
	MOVE.W	$1B2572,-(A7)
	MOVE.W	$1B2574,-(A7)
	JSR	$1B0564
	ADDQ.W	#4,A7
	MOVE.W	D0,-(A7)
	JSR	$1B04EC
	ADDQ.W	#2,A7
	MOVEA.L	$1B289C,A1
	LEA	($C,A0),A0
	JSR	$1AF78A
	JSR	$1AF38A
	SF	$1B2980
	BRA	$1AF1B0
	SWAP	D0
	CMPI.B	#$4D,D0
	BNE.B	$1AF2C2
	MOVE.W	$1B28A6,D0
	SUBQ.W	#1,D0
	BEQ	$1AF1B0
	MOVE.W	D0,$1B28A6
	BRA	$1AF20A
	CMPI.W	#$4B,D0
	BNE.B	$1AF2D2
	ADDQ.W	#1,$1B28A6
	BRA	$1AF20A
	TST.W	D6
	BPL.B	$1AF2DC
	SUBQ.W	#1,$1B2574
	JSR	$1AF3C2
	MOVE.W	$1B2576,D0
	CMP.W	$1B2574,D0
	BNE.B	$1AF30A
	CLR.W	$1B2574
	MOVE.W	$1B2572,-(A7)
	MOVE.W	$1B2574,-(A7)
	JSR	$1B0564
	ADDQ.W	#4,A7
	JSR	$1AF34E
	MOVEM.L	(A7)+,D0/D6-A1
	RTS
	MOVEM.L	D0-D1/A0-A1,-(A7)
	MOVE	SR,-(A7)
	ORI	#$2BC,SR
	ST	$1B2848
	MOVEA.L	$456.W,A0
	MOVEQ	#7,D0
	MOVE.L	(A0)+,D1
	BEQ.B	$1AF336
	DBF	D0,$1AF32C
	BRA.B	$1AF346
	SUBQ.L	#4,A0
	LEA	$1AF376,A1
	MOVE.L	A1,(A0)
	MOVE.L	A0,$1B2932
	MOVE	(A7)+,SR
	MOVEM.L	(A7)+,D0-D1/A0-A1
	RTS
	MOVEM.L	D0/A0-A1,-(A7)
	MOVE	SR,-(A7)
	ORI	#$2BC,SR
	TST.B	$1B2848
	BEQ.B	$1AF36E
	MOVEA.L	$1B2932,A0
	CLR.L	(A0)
	SF	$1B2848
	MOVE	(A7)+,SR
	MOVEM.L	(A7)+,D0/A0-A1
	RTS
	ST	$1B2980
	RTS
	MOVE.L	$1B2A28,$1B28AC
	RTS
	MOVEM.L	D0-D2/A0-A2,-(A7)
	MOVE.L	$1B289C,D0
	MOVE.L	$1B2A28,$1B289C
	MOVE.L	D0,$1B2A28
	MOVE.L	D0,D1
	MOVE.L	D0,$44E.W
	LSR.L	#8,D0
	MOVEA.L	#-$7DFF,A0
	LEA	(2,A0),A1
	SWAP	D1
	MOVE.B	D1,(A0)
	MOVE.B	D0,(A1)
	MOVEM.L	(A7)+,D0-D2/A0-A2
	RTS
	MOVE.L	D0,-(A7)
	MOVE.L	$1B2A28,D0
	CMP.L	$1B28AC,D0
	BEQ.B	$1AF3D8
	JSR	$1AF38A
	MOVE.L	(A7)+,D0
	RTS
	MOVEM.L	D1-D3/D5-A3,-(A7)
	MOVE.W	D0,$1B257C
	MOVE.W	$1B2572,-(A7)
	JSR	$1B0518
	ADDQ.L	#2,A7
	TST.W	D0
	BPL.B	$1AF412
	MOVE.W	$1B2572,-(A7)
	MOVE.W	#1,-(A7)
	MOVE.L	$1B28DE,-(A7)
	JSR	$1B07E4
	ADDQ.W	#8,A7
	NOP
	MOVEA.L	$1B291C,A0
	MOVE.L	A0,-(A7)
	MOVE.L	#$20,-(A7)
	MOVE.W	$1B257C,-(A7)
	MOVE.W	#$3F,-(A7)
	TRAP	#1
	ADDA.W	#$C,A7
	MOVEA.L	$1B291C,A0
	MOVE.W	(8,A0),$1B28A6
	MOVE.W	($A,A0),D5
	MOVE.W	($C,A0),D0
	CMPI.W	#2,D0
	BNE.B	$1AF44E
	MOVEQ	#-1,D0
	MOVE.B	D0,$1B2876
	SF	$1B2A2C
	SF	$1B29A6
	MOVEM.L	D5,-(A7)
	JSR	$1AF978
	MOVEM.L	(A7)+,D5
	TST.W	D0
	BNE	$1AF568
	MOVEQ	#7,D1
	LEA	$1B28B0,A0
	LEA	$1B28FC,A1
	MOVE.L	(A0)+,(A1)+
	DBF	D1,$1AF482
	MOVEM.L	D5,-(A7)
	JSR	$1B007A
	MOVEM.L	(A7)+,D5
	MOVE.W	$1B2572,-(A7)
	CLR.W	-(A7)
	MOVEA.L	$1B291C,A1
	MOVE.L	(4,A1),-(A7)
	ADDQ.L	#8,(A7)
	JSR	$1B0598
	ADDQ.W	#8,A7
	MOVE.L	(4,A1),D7
	ADDQ.L	#8,D7
	LSR.L	#1,D7
	SUBQ.L	#1,D7
	MOVE.W	(A1)+,(A0)+
	DBF	D7,$1AF4BC
	MOVEQ	#1,D6
	JSR	$1AF56E
	CMP.W	$1B2576,D6
	BLT.B	$1AF4E4
	MOVE.W	$1B2572,-(A7)
	MOVE.W	D6,-(A7)
	JSR	$1B0842
	LEA	(4,A7),A7
	MOVE.W	$1B2572,-(A7)
	MOVE.W	D6,-(A7)
	MOVEA.L	$1B291C,A1
	MOVE.L	(4,A1),-(A7)
	ADDQ.L	#8,(A7)
	JSR	$1B0598
	ADDQ.W	#8,A7
	MOVE.L	(4,A1),D7
	ADDQ.L	#8,D7
	LSR.L	#1,D7
	SUBQ.L	#1,D7
	MOVE.W	(A1)+,(A0)+
	DBF	D7,$1AF50A
	ADDQ.W	#1,D6
	CMP.W	D6,D5
	BGE.B	$1AF4C4
	CMP.W	$1B2576,D5
	BLE.B	$1AF524
	MOVE.W	D5,$1B2576
	CLR.W	$1B2574
	MOVE.W	$1B2572,-(A7)
	MOVE.W	$1B2574,-(A7)
	JSR	$1B0564
	ADDQ.W	#4,A7
	MOVE.W	D0,-(A7)
	JSR	$1B04EC
	ADDQ.W	#2,A7
	JSR	$1AF872
	MOVE.L	$1B289C,-(A7)
	MOVE.L	$1B2A28,-(A7)
	MOVE.W	#$C8,-(A7)
	JSR	$1B0AAC
	LEA	($A,A7),A7
	MOVEM.L	(A7)+,D1-D3/D5-A3
	RTS
	MOVEM.L	D0-D3/A0-A2,-(A7)
	MOVEA.L	$1B291C,A0
	MOVE.L	A0,-(A7)
	MOVE.L	#8,-(A7)
	MOVE.W	$1B257C,-(A7)
	MOVE.W	#$3F,-(A7)
	TRAP	#1
	ADDA.W	#$C,A7
	MOVEA.L	$1B291C,A0
	ADDQ.W	#8,A0
	MOVE.L	A0,-(A7)
	MOVE.L	(-4,A0),-(A7)
	MOVE.W	$1B257C,-(A7)
	MOVE.W	#$3F,-(A7)
	TRAP	#1
	ADDA.W	#$C,A7
	MOVEM.L	(A7)+,D0-D3/A0-A2
	RTS
	MOVEM.L	D0/D5-A1,-(A7)
	CMPI.W	#1,$1B2576
	BEQ	$1AF6B2
	MOVE.L	$1B289C,-(A7)
	MOVE.L	$1B2A28,-(A7)
	MOVE.W	#$C8,-(A7)
	JSR	$1B0AAC
	LEA	($A,A7),A7
	JSR	$1AF316
	JSR	$1AF37E
	JSR	$1AF38A
	SF	$1B2980
	MOVE.W	D0,D6
	BPL.B	$1AF600
	NEG.W	D6
	BRA	$1AF6B8
	TST.B	$1B2980
	BEQ.B	$1AF600
	MOVE.L	$1B2A28,-(A7)
	MOVE.L	$1B289C,-(A7)
	MOVE.W	#$C8,-(A7)
	JSR	$1B0AAC
	LEA	($A,A7),A7
	DBF	D6,$1AF628
	BRA.B	$1AF692
	MOVE.W	#2,-(A7)
	MOVE.W	#1,-(A7)
	TRAP	#$D
	ADDQ.L	#4,A7
	TST.W	D0
	BNE.B	$1AF692
	ADDQ.W	#1,$1B2574
	MOVE.W	$1B2576,D0
	CMP.W	$1B2574,D0
	BGE.B	$1AF654
	MOVE.W	#1,$1B2574
	MOVE.W	$1B2572,-(A7)
	MOVE.W	$1B2574,-(A7)
	JSR	$1B0564
	ADDQ.W	#4,A7
	MOVE.W	D0,-(A7)
	JSR	$1B04EC
	ADDQ.W	#2,A7
	MOVEA.L	$1B289C,A1
	LEA	($C,A0),A0
	JSR	$1AF78A
	JSR	$1AF38A
	SF	$1B2980
	BRA	$1AF600
	JSR	$1AF3C2
	MOVE.W	$1B2576,D0
	CMP.W	$1B2574,D0
	BNE.B	$1AF6AC
	CLR.W	$1B2574
	JSR	$1AF34E
	MOVEM.L	(A7)+,D0/D5-A1
	RTS
	TST.B	$1B2980
	BEQ.B	$1AF6B8
	MOVE.L	$1B2A28,-(A7)
	MOVE.L	$1B289C,-(A7)
	MOVE.W	#$C8,-(A7)
	JSR	$1B0AAC
	LEA	($A,A7),A7
	MOVE.W	#2,-(A7)
	MOVE.W	#1,-(A7)
	TRAP	#$D
	ADDQ.L	#4,A7
	TST.W	D0
	BNE.B	$1AF746
	DBF	D6,$1AF6F0
	BRA.B	$1AF746
	TST.W	$1B2574
	BNE.B	$1AF702
	MOVE.W	$1B2576,$1B2574
	MOVE.W	$1B2572,-(A7)
	MOVE.W	$1B2574,-(A7)
	JSR	$1B0564
	ADDQ.W	#4,A7
	MOVE.W	D0,-(A7)
	JSR	$1B04EC
	ADDQ.W	#2,A7
	MOVEA.L	$1B289C,A1
	LEA	($C,A0),A0
	JSR	$1AF78A
	JSR	$1AF38A
	SF	$1B2980
	SUBQ.W	#1,$1B2574
	BRA	$1AF6B8
	JSR	$1AF3C2
	MOVE.W	$1B2576,D0
	CMP.W	$1B2574,D0
	BNE.B	$1AF760
	CLR.W	$1B2574
	BRA	$1AF6AC
	MOVEM.L	D0-A6,-(A7)
	MOVE.W	$1B2572,-(A7)
	JSR	$1B096A
	ADDQ.W	#2,A7
	CLR.W	$1B2574
	MOVE.W	#1,$1B2576
	MOVEM.L	(A7)+,D0-A6
	RTS
	MOVEM.L	D0-D1/D7-A4,-(A7)
	MOVEQ	#3,D7
	MOVEA.L	A1,A2
	ADDQ.W	#8,A0
	MOVE.L	(-4,A0),D0
	BEQ.B	$1AF7E4
	ADD.L	A0,D0
	MOVEA.L	D0,A4
	MOVEA.L	A0,A3
	ADDA.W	(A0)+,A3
	CMPA.L	A3,A4
	BLE.B	$1AF7E2
	MOVEQ	#0,D0
	MOVE.B	(A0)+,D0
	BEQ.B	$1AF7DA
	BMI.B	$1AF7C2
	SUBQ.W	#1,D0
	BNE.B	$1AF7B4
	MOVE.W	(A3)+,D0
	MOVE.W	(A3)+,D1
	EOR.W	D1,(A2)
	LEA	($A0,A2),A2
	DBF	D0,$1AF7B6
	BRA.B	$1AF7A2
	NEG.B	D0
	SUBQ.W	#1,D0
	BNE.B	$1AF7CA
	MOVE.W	(A3)+,D0
	SUBQ.W	#1,D0
	MOVE.W	(A3)+,D1
	EOR.W	D1,(A2)
	LEA	($A0,A2),A2
	DBF	D0,$1AF7CC
	BRA.B	$1AF7A2
	MOVE.W	(A3)+,D0
	LSL.W	#2,D0
	ADDA.W	D0,A2
	BRA.B	$1AF7A2
	MOVEA.L	A3,A0
	ADDQ.W	#2,A1
	DBF	D7,$1AF790
	MOVEM.L	(A7)+,D0-D1/D7-A4
	RTS
	MOVEM.L	D1-D6/A0-A3,-(A7)
	MOVEA.L	($2C,A7),A3
	MOVE.W	($30,A7),D6
	CLR.W	-(A7)
	MOVE.L	A3,-(A7)
	MOVE.W	#$4E,-(A7)
	TRAP	#1
	ADDQ.L	#8,A7
	TST.W	D0
	BMI.B	$1AF86E
	MOVEA.L	$1B2948,A0
	MOVE.L	($1A,A0),D5
	TST.W	D6
	BPL.B	$1AF828
	MOVE.L	D5,-(A7)
	JSR	$1B037E
	ADDQ.L	#4,A7
	MOVE.W	D0,D6
	BMI.B	$1AF86A
	CLR.W	-(A7)
	MOVE.L	A3,-(A7)
	MOVE.W	#$3D,-(A7)
	TRAP	#1
	ADDQ.W	#8,A7
	MOVE.W	D0,D4
	BMI.B	$1AF86E
	MOVE.W	D6,-(A7)
	JSR	$1B04EC
	ADDQ.L	#2,A7
	MOVE.L	A0,-(A7)
	MOVE.L	D5,-(A7)
	MOVE.W	D4,-(A7)
	MOVE.W	#$3F,-(A7)
	TRAP	#1
	ADDA.W	#$C,A7
	TST.L	D0
	BMI.B	$1AF86E
	MOVE.W	D4,-(A7)
	MOVE.W	#$3E,-(A7)
	TRAP	#1
	ADDQ.L	#4,A7
	MOVEQ	#0,D0
	MOVE.W	D6,D0
	MOVEM.L	(A7)+,D1-D6/A0-A3
	RTS
	MOVEQ	#-1,D0
	BRA.B	$1AF864
	MOVEQ	#-2,D0
	BRA.B	$1AF864
	MOVEM.L	D1/A0-A1,-(A7)
	MOVE.W	#-1,$1B2870
	SF	$1B29A6
	ST	$1B2A2C
	ST	$1B257A
	MOVE.L	A0,$1B2A2E
	JSR	$1AF978
	TST.W	D0
	BNE.B	$1AF8B4
	MOVEQ	#7,D1
	LEA	$1B28B0,A0
	LEA	$1B28FC,A1
	MOVE.L	(A0)+,(A1)+
	DBF	D1,$1AF8AE
	MOVEM.L	(A7)+,D1/A0-A1
	RTS
	MOVEM.L	D1-D3/A0-A2,-(A7)
	MOVE.W	#-1,$1B2870
	SF	$1B257A
	SF	$1B29A6
	SF	$1B2A2C
	CLR.W	-(A7)
	MOVE.L	A0,-(A7)
	MOVE.W	#$3D,-(A7)
	TRAP	#1
	ADDQ.W	#8,A7
	TST.W	D0
	BPL.B	$1AF8EC
	MOVEQ	#1,D0
	BRA.B	$1AF932
	MOVE.W	D0,$1B257C
	MOVEQ	#7,D1
	LEA	$1B28B0,A1
	LEA	$1B28FC,A0
	MOVE.L	(A0)+,(A1)+
	DBF	D1,$1AF900
	LEA	$1B28DE,A0
	MOVE.L	A0,-(A7)
	JSR	$1AFFA0
	ADDQ.L	#4,A7
	TST.W	D0
	BNE.B	$1AF930
	MOVE.L	$1B291C,D0
	MOVE.L	$1B289C,D1
	CMP.L	D0,D1
	JSR	$1AF978
	BRA.B	$1AF932
	MOVEQ	#3,D0
	CMPI.W	#$FFFF,$1B257C
	BEQ.B	$1AF95A
	MOVEM.L	D0-D3/A0-A2,-(A7)
	MOVE.W	$1B257C,-(A7)
	MOVE.W	#$3E,-(A7)
	TRAP	#1
	ADDQ.W	#4,A7
	MOVEM.L	(A7)+,D0-D3/A0-A2
	MOVE.W	#-1,$1B257C
	TST.W	D0
	BNE.B	$1AF972
	MOVEQ	#7,D1
	LEA	$1B28B0,A0
	LEA	$1B28FC,A1
	MOVE.L	(A0)+,(A1)+
	DBF	D1,$1AF96C
	MOVEM.L	(A7)+,D1-D3/A0-A2
	RTS
	CLR.W	$1B28F2
	SF	$1B257E
	SF	$1B2578
	MOVEQ	#0,D0
	MOVE.W	D0,$1B28F4
	MOVEQ	#8,D0
	MOVE.L	D0,$1B28A2
	MOVEA.L	$1B291C,A0
	JSR	$1AFA2C
	JSR	$1AFA00
	CMPI.B	#7,D0
	BEQ	$1AFCAC
	MOVEQ	#3,D0
	BRA.B	$1AF9BA
	MOVEQ	#0,D0
	TST.W	D0
	BNE.B	$1AF9DA
	JSR	$1AFF9E
	TST.B	$1B257E
	BEQ.B	$1AF9D4
	JSR	$1B1606
	BRA.B	$1AF9DA
	JSR	$1B165E
	RTS
	MOVEQ	#8,D0
	MOVE.L	D0,$1B28A2
	MOVEA.L	$1B291C,A0
	JSR	$1AFA2C
	JSR	$1AFA00
	TST.W	D0
	BNE	$1AFA80
	BRA	$1AFD44
	MOVEM.L	D1-D2/A0-A1,-(A7)
	MOVE.L	(A0)+,D2
	MOVE.L	D2,$1B28E2
	LEA	$1B0022,A1
	MOVEQ	#8,D0
	MOVE.L	(A1)+,D1
	CMP.L	D2,D1
	BEQ.B	$1AFA1E
	DBF	D0,$1AFA14
	ADDQ.W	#1,D0
	MOVE.L	(A0)+,$1B28A2
	MOVEM.L	(A7)+,D1-D2/A0-A1
	RTS
	MOVEM.L	A1-A3,-(A7)
	TST.B	$1B2A2C
	BNE.B	$1AFA64
	MOVEA.L	A0,A3
	MOVE.L	A0,-(A7)
	MOVE.L	$1B28A2,-(A7)
	MOVE.W	$1B257C,-(A7)
	MOVE.W	#$3F,-(A7)
	TRAP	#1
	ADDA.W	#$C,A7
	TST.L	D0
	BPL.B	$1AFA60
	MOVEQ	#4,D0
	MOVEM.L	(A7)+,A1-A3
	BRA	$1AF9BA
	MOVEA.L	A3,A0
	BRA.B	$1AFA7A
	MOVEA.L	$1B2A2E,A1
	MOVE.L	$1B28A2,D0
	MOVEA.L	A1,A0
	ADDA.L	D0,A1
	MOVE.L	A1,$1B2A2E
	MOVEM.L	(A7)+,A1-A3
	RTS
	SUBQ.W	#1,D0
	BEQ.B	$1AFAB4
	SUBQ.W	#1,D0
	BEQ	$1AFB1E
	SUBQ.W	#1,D0
	BEQ	$1AFD44
	SUBQ.W	#1,D0
	BEQ	$1AFBDA
	SUBQ.W	#1,D0
	BEQ	$1AFC5A
	SUBQ.W	#1,D0
	BEQ	$1AFD44
	SUBQ.W	#1,D0
	BEQ	$1AFCAC
	SUBQ.W	#1,D0
	BEQ	$1AFD44
	SUBQ.W	#1,D0
	BRA	$1AFD44
	MOVE.W	$1B28F4,D0
	EORI.W	#3,D0
	BNE	$1AFD44
	MOVEA.L	$1B291C,A0
	JSR	$1AFA2C
	MOVEQ	#0,D0
	MOVE.B	$1B0070,D0
	MOVE.W	D0,$1B2ADA
	TST.B	$1B257A
	BEQ.B	$1AFAEE
	JSR	$1AFEFC
	BRA	$1AF9BA
	TST.B	D0
	BNE.B	$1AFAFC
	JSR	$1AFE7A
	BRA	$1AF9BA
	SUBQ.W	#1,D0
	BNE.B	$1AFB0A
	JSR	$1AFD54
	BRA	$1AF9BA
	SUBQ.W	#1,D0
	BNE.B	$1AFB18
	JSR	$1AFEFC
	BRA	$1AF9BA
	MOVEQ	#5,D0
	BRA	$1AF9BA
	MOVEM.L	D0-D1/D7-A1,-(A7)
	MOVEA.L	$1B291C,A0
	JSR	$1AFA2C
	CMPI.W	#4,$1B28F2
	BGE	$1AFBD2
	TST.B	$1B29A6
	BEQ.B	$1AFB4A
	LEA	$1B2982,A1
	BRA.B	$1AFB50
	LEA	$1B2596,A1
	MOVE.W	$1B28F2,D0
	LSL.W	#3,D0
	ADDA.W	D0,A1
	ADDQ.W	#2,A0
	MOVE.W	(A0)+,D0
	BEQ.B	$1AFB6A
	MOVE.L	#$4000,D1
	DIVU.W	D0,D1
	MOVE.W	D1,D0
	MOVE.W	D0,(4,A1)
	MOVE.W	(A0)+,D0
	TST.B	$1B29A6
	BNE.B	$1AFB8C
	BTST	#0,D0
	BEQ.B	$1AFB86
	ST	$1B257E
	BRA.B	$1AFB8C
	SF	$1B257E
	MOVEQ	#0,D7
	BTST	#1,D0
	BEQ.B	$1AFB96
	ST	D7
	MOVEQ	#0,D0
	MOVEQ	#0,D1
	MOVE.B	(A0)+,D0
	MOVE.B	(A0)+,D1
	CMP.W	D0,D1
	BNE.B	$1AFBAE
	ADDQ.W	#1,D1
	CMPI.W	#$F,D1
	BLE.B	$1AFBAE
	SUBQ.W	#1,D1
	SUBQ.W	#1,D0
	MOVE.W	#2,(6,A1)
	TST.B	D7
	BEQ.B	$1AFBBE
	MOVE.W	#-2,(6,A1)
	ANDI.W	#$F,D0
	ANDI.W	#$F,D1
	MOVE.W	D0,(A1)
	MOVE.W	D1,(2,A1)
	ADDQ.W	#1,$1B28F2
	MOVEM.L	(A7)+,D0-D1/D7-A1
	BRA	$1AF9DC
	MOVEM.L	D1-D2/A0-A1,-(A7)
	MOVE.W	$1B28F4,D0
	EORI.W	#3,D0
	BEQ.B	$1AFBF4
	MOVEQ	#4,D0
	MOVEM.L	(A7)+,D1-D2/A0-A1
	BRA	$1AF9BA
	ST	$1B2578
	MOVEA.L	$1B291C,A0
	JSR	$1AFA2C
	MOVEA.L	A0,A1
	TST.B	$1B29A6
	BEQ.B	$1AFC18
	LEA	$1B0046,A0
	BRA.B	$1AFC1E
	LEA	$1B28B0,A0
	MOVE.B	$1B006E,D0
	MOVEQ	#1,D1
	LSL.B	D0,D1
	CMPI.B	#$10,D1
	BLE.B	$1AFC30
	MOVEQ	#$10,D1
	SUBQ.W	#1,D1
	MOVEQ	#0,D0
	MOVE.B	(A1)+,D0
	LSL.W	#4,D0
	ANDI.W	#$F00,D0
	MOVEQ	#0,D2
	MOVE.B	(A1)+,D2
	ANDI.W	#$F0,D2
	OR.W	D2,D0
	MOVE.B	(A1)+,D2
	LSR.W	#4,D2
	OR.W	D2,D0
	MOVE.W	D0,(A0)+
	DBF	D1,$1AFC32
	MOVEM.L	(A7)+,D1-D2/A0-A1
	BRA	$1AF9DC
	MOVEM.L	D1/A0-A1,-(A7)
	MOVE.W	$1B28F4,D0
	EORI.B	#1,D0
	BNE	$1AFD44
	LEA	$1B0066,A0
	JSR	$1AFA2C
	MOVEQ	#4,D0
	LEA	$1B0066,A1
	MOVE.L	(A0)+,(A1)+
	DBF	D0,$1AFC80
	ORI.W	#2,$1B28F4
	MOVEQ	#0,D0
	MOVE.B	$1B006E,D0
	CMPI.W	#4,D0
	BLE.B	$1AFC9E
	MOVEQ	#4,D0
	MOVE.W	D0,$1B2940
	MOVEM.L	(A7)+,D1/A0-A1
	BRA	$1AF9DC
	MOVEM.L	D1/A0,-(A7)
	MOVE.L	$1B28A2,D1
	SUBQ.L	#4,D1
	MOVEQ	#4,D0
	MOVE.L	D0,$1B28A2
	MOVEA.L	$1B291C,A0
	JSR	$1AFA2C
	JSR	$1AFA00
	CMPI.B	#6,D0
	BEQ.B	$1AFCFC
	CMPI.B	#8,D0
	BEQ.B	$1AFCE8
	MOVEQ	#8,D0
	MOVEM.L	(A7)+,D1/A0
	BRA	$1AF9BA
	MOVE.W	$1B257C,D0
	JSR	$1AF3DC
	MOVEM.L	(A7)+,D1/A0
	BRA	$1AF9BA
	ORI.W	#1,$1B28F4
	TST.B	$1B2A2C
	BNE.B	$1AFD3C
	CMPI.L	#$9F90,D1
	BLT.B	$1AFD1E
	MOVEQ	#9,D0
	MOVEM.L	(A7)+,D1/A0
	BRA	$1AF9BA
	MOVE.L	D1,$1B28A2
	MOVEA.L	$1B291C,A0
	MOVE.L	A0,$1B2A2E
	JSR	$1AFA2C
	ST	$1B2A2C
	MOVEM.L	(A7)+,D1/A0
	BRA	$1AF9DC
	MOVEA.L	$1B291C,A0
	JSR	$1AFA2C
	BRA	$1AF9DC
	MOVEM.L	D1-D7/A1-A6,-(A7)
	MOVEQ	#0,D0
	MOVE.W	$1B0066,D0
	ADD.W	#$F,D0
	LSR.L	#3,D0
	ANDI.L	#$FFFFFFFE,D0
	MOVE.W	D0,D7
	MOVE.W	$1B0068,D6
	SUBQ.W	#1,D6
	MOVEA.L	A0,A3
	CMPI.B	#1,$1B006F
	BNE.B	$1AFD8A
	MOVEA.L	#-1,A5
	BRA.B	$1AFD90
	MOVEA.L	#0,A5
	MOVEA.L	A3,A0
	MOVEA.L	$1B289C,A1
	MOVEA.L	A1,A2
	MOVEQ	#0,D3
	MOVE.B	$1B006E,D3
	NEG.W	D3
	ADDQ.W	#4,D3
	MOVEQ	#3,D5
	MOVEA.L	A2,A1
	MOVE.W	D7,D0
	CMP.W	D3,D5
	BLT.B	$1AFDB4
	BSR.B	$1AFE06
	BLT.B	$1AFE02
	ADDQ.W	#2,A2
	DBF	D5,$1AFDA8
	ADDA.W	#$98,A2
	TST.W	D3
	BPL.B	$1AFDD4
	MOVE.W	D3,D5
	NEG.W	D5
	SUBQ.W	#1,D5
	MOVE.W	D7,D0
	BSR	$1AFE4E
	BLT.B	$1AFE02
	DBF	D5,$1AFDC8
	MOVE.L	A5,D0
	BEQ.B	$1AFDDC
	MOVE.L	D7,D0
	BSR.B	$1AFE4E
	DBF	D6,$1AFDA6
	MOVEQ	#4,D7
	SUB.B	$1B006E,D7
	BLE.B	$1AFDFA
	SUBQ.W	#1,D7
	MOVEQ	#3,D0
	JSR	$1AFF5A
	SUBQ.W	#1,D0
	DBF	D7,$1AFDEE
	MOVEQ	#0,D0
	MOVEM.L	(A7)+,D1-D7/A1-A6
	RTS
	MOVEQ	#4,D0
	BRA.B	$1AFDFC
	MOVEM.L	D2-D3,-(A7)
	MOVEQ	#0,D3
	TST.B	$1B29A6
	BNE.B	$1AFE16
	MOVEQ	#6,D3
	SWAP	D3
	MOVEQ	#0,D2
	MOVE.B	(A0)+,D2
	BLT.B	$1AFE2C
	MOVE.B	(A0)+,(A1)+
	ADDA.W	D3,A1
	SWAP	D3
	SUBQ.W	#1,D0
	DBF	D2,$1AFE1E
	BRA.B	$1AFE42
	CMPI.B	#$80,D2
	BEQ.B	$1AFE42
	NEG.B	D2
	MOVE.B	(A0)+,D1
	MOVE.B	D1,(A1)+
	ADDA.W	D3,A1
	SWAP	D3
	SUBQ.W	#1,D0
	DBF	D2,$1AFE36
	TST.W	D0
	BLT.B	$1AFE48
	BNE.B	$1AFE18
	MOVEM.L	(A7)+,D2-D3
	RTS
	MOVEM.L	D2,-(A7)
	MOVEQ	#0,D2
	MOVE.B	(A0)+,D2
	BLT.B	$1AFE62
	ADDQ.W	#1,D2
	ADDA.W	D2,A0
	SUB.W	D2,D0
	BLE.B	$1AFE74
	BRA.B	$1AFE52
	CMPI.B	#$80,D2
	BEQ.B	$1AFE52
	NEG.B	D2
	ADDQ.W	#1,D2
	ADDQ.L	#1,A0
	SUB.W	D2,D0
	BLE.B	$1AFE74
	BRA.B	$1AFE52
	MOVEM.L	(A7)+,D2
	RTS
	MOVEM.L	D1-D5/A1-A4,-(A7)
	MOVEA.L	A0,A3
	CMPI.B	#1,$1B006F
	BNE.B	$1AFE8E
	MOVEQ	#-1,D5
	BRA.B	$1AFE90
	MOVEQ	#0,D5
	MOVEA.L	A3,A0
	MOVEA.L	$1B289C,A2
	MOVE.W	#$C7,D2
	MOVEA.L	A2,A3
	MOVEA.L	A3,A2
	MOVEQ	#0,D1
	MOVE.B	$1B006E,D1
	SUBQ.W	#1,D1
	MOVEA.L	A2,A1
	MOVE.W	#$13,D0
	MOVE.W	(A0)+,(A1)
	ADDQ.W	#8,A1
	DBF	D0,$1AFEB0
	ADDQ.W	#2,A2
	DBF	D1,$1AFEAA
	LEA	($A0,A3),A3
	TST.L	D5
	BEQ.B	$1AFED6
	MOVEA.L	D5,A1
	MOVE.W	#$13,D0
	MOVE.W	(A0)+,D1
	NOT.W	D1
	DBF	D0,$1AFECC
	MOVE.L	A1,D5
	DBF	D2,$1AFE9E
	MOVEQ	#4,D7
	SUB.B	$1B006E,D7
	BEQ.B	$1AFEF4
	SUBQ.W	#1,D7
	MOVEQ	#3,D0
	JSR	$1AFF5A
	SUBQ.W	#1,D0
	DBF	D7,$1AFEE8
	MOVEQ	#0,D0
	MOVEM.L	(A7)+,D1-D5/A1-A4
	RTS
	MOVEM.L	D6-A1,-(A7)
	MOVEA.L	A0,A1
	MOVEA.L	$1B289C,A0
	MOVE.W	$1B0068,D0
	MULU.W	#$A0,D0
	MOVE.L	D0,$1B28DA
	MOVEQ	#0,D7
	MOVE.B	$1B006E,D7
	SUBQ.W	#1,D7
	ADDQ.W	#8,A1
	MOVE.L	(-4,A1),D0
	JSR	$1B0C62
	ADDQ.W	#2,A0
	ADDA.L	(-4,A1),A1
	DBF	D7,$1AFF22
	MOVEQ	#4,D7
	SUB.B	$1B006E,D7
	BEQ.B	$1AFF52
	SUBQ.W	#1,D7
	MOVEQ	#3,D0
	JSR	$1AFF5A
	SUBQ.W	#1,D0
	DBF	D7,$1AFF46
	MOVEQ	#0,D0
	MOVEM.L	(A7)+,D6-A1
	RTS
	MOVEM.L	D0/A0,-(A7)
	MOVEA.L	$1B289C,A0
	LSL.W	#1,D0
	ADDA.W	D0,A0
	MOVE.W	#$18F,D0
	CLR.W	(A0)
	ADDQ.W	#8,A0
	CLR.W	(A0)
	ADDQ.W	#8,A0
	CLR.W	(A0)
	ADDQ.W	#8,A0
	CLR.W	(A0)
	ADDQ.W	#8,A0
	CLR.W	(A0)
	ADDQ.W	#8,A0
	CLR.W	(A0)
	ADDQ.W	#8,A0
	CLR.W	(A0)
	ADDQ.W	#8,A0
	CLR.W	(A0)
	ADDQ.W	#8,A0
	CLR.W	(A0)
	ADDQ.W	#8,A0
	CLR.W	(A0)
	ADDQ.W	#8,A0
	DBF	D0,$1AFF6C
	MOVEM.L	(A7)+,D0/A0
	RTS
	RTS
	MOVEM.L	A0,-(A7)
	MOVEA.L	(8,A7),A0
	JSR	$1B17D6
	CMPI.W	#4,D0
	BLE.B	$1B001E
	ADDA.W	D0,A0
	SUBQ.L	#4,A0
	MOVE.B	(A0)+,D0
	CMPI.B	#$2E,D0
	BNE.B	$1B001E
	MOVE.B	(A0)+,D0
	CMPI.B	#$4E,D0
	BEQ.B	$1B0006
	CMPI.B	#$50,D0
	BNE.B	$1B001E
	MOVE.B	(A0)+,D0
	CMPI.B	#$43,D0
	BEQ.B	$1AFFDC
	CMPI.B	#$49,D0
	BNE.B	$1B001E
	MOVE.B	(A0),D0
	CMPI.B	#$31,D0
	BNE.B	$1AFFF6
	MOVE.B	(-1,A0),D0
	CMPI.B	#$43,D0
	BEQ.B	$1AFFF2
	MOVEQ	#2,D0
	BRA.B	$1B0018
	MOVEQ	#3,D0
	BRA.B	$1B0018
	CMPI.B	#$32,D0
	BEQ.B	$1B0002
	CMPI.B	#$33,D0
	BNE.B	$1B001E
	MOVEQ	#4,D0
	BRA.B	$1B0018
	MOVE.B	(A0)+,D0
	CMPI.B	#$45,D0
	BNE.B	$1B001E
	MOVE.B	(A0)+,D0
	CMPI.B	#$4F,D0
	BNE.B	$1B001E
	MOVEQ	#1,D0
	MOVEM.L	(A7)+,A0
	RTS
	MOVEQ	#0,D0
	BRA.B	$1B0018
	NEG.W	(A6)
	DC.W	$4944
	NEG.W	(A0)
	SUBQ.W	#1,(A4)
	DC.W	$464F
	ADDQ.W	#1,A5
	DC.W	$494C
	DC.W	$424D
	DC.W	$424D
	SWAP	D4
	DC.W	$434D
	DC.W	$4150
	DC.W	$4752
	DC.W	$4142
	DC.W	$4352
	TRAP	#7
	DC.W	$424F
	NEG.W	(A1)+
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#1,D0
	ORI.B	#3,D2
	SUBI.B	#7,D5
	DC.W	8
	MOVEP.W	($B,A2),D4
	DC.W	$C
	ST	$1B2A2C
	SF	$1B29A6
	JSR	$1B008E
	RTS
	MOVEA.L	$1B291C,A0
	BSR.B	$1B009E
	MOVEQ	#0,D0
	RTS
	MOVEQ	#$A,D0
	RTS
	MOVE.L	$1B002A,(A0)+
	ADDQ.L	#4,A0
	MOVE.L	$1B002E,(A0)+
	MOVE.L	#4,$1B28A2
	JSR	$1B00D6
	JSR	$1B014C
	JSR	$1B01E2
	JSR	$1B01E4
	JSR	$1B0258
	RTS
	MOVEM.L	A1-A2,-(A7)
	MOVE.L	$1B0032,(A0)+
	MOVE.L	#$14,(A0)+
	MOVE.W	#$140,$1B0066
	MOVE.W	#$C8,$1B0068
	MOVE.W	#4,D0
	LEA	$1B006E,A1
	MOVE.B	D0,(A1)
	CLR.B	(1,A1)
	MOVE.W	$1B2ADA,D0
	MOVE.B	D0,$1B0070
	CLR.W	$1B006A
	CLR.W	$1B006C
	MOVE.W	#$140,$1B0076
	MOVE.W	#$C8,$1B0078
	LEA	$1B0066,A1
	MOVEQ	#4,D0
	MOVE.L	(A1)+,(A0)+
	DBF	D0,$1B0136
	ADDI.L	#$1C,$1B28A2
	MOVEM.L	(A7)+,A1-A2
	RTS
	MOVEM.L	D1-D2/A1-A2,-(A7)
	MOVE.L	$1B0036,(A0)+
	MOVEQ	#0,D0
	MOVE.W	#4,D0
	MOVEQ	#1,D1
	LSL.W	D0,D1
	MOVE.W	D1,D0
	MULU.W	#3,D1
	MOVE.L	D1,(A0)+
	ADDQ.L	#8,D1
	ADD.L	D1,$1B28A2
	TST.B	$1B2580
	BNE.B	$1B0180
	LEA	$1B02EA,A2
	BRA.B	$1B0186
	LEA	$1B02F2,A2
	LEA	$1B28FC,A1
	SUBQ.W	#1,D0
	MOVE.W	(A1)+,D1
	MOVEQ	#0,D2
	MOVE.W	D1,D2
	ANDI.W	#$F00,D2
	LSR.W	#8,D2
	TST.B	$1B2580
	BNE.B	$1B01A4
	LSR.W	#1,D2
	MOVE.B	(0.B,A2,D2.W),D2
	MOVE.B	D2,(A0)+
	MOVE.W	D1,D2
	ANDI.W	#$F0,D2
	LSR.W	#4,D2
	TST.B	$1B2580
	BNE.B	$1B01BC
	LSR.W	#1,D2
	MOVE.B	(0.B,A2,D2.W),D2
	MOVE.B	D2,(A0)+
	MOVE.W	D1,D2
	ANDI.W	#$F,D2
	TST.B	$1B2580
	BNE.B	$1B01D2
	LSR.W	#1,D2
	MOVE.B	(0.B,A2,D2.W),D2
	MOVE.B	D2,(A0)+
	DBF	D0,$1B018E
	MOVEM.L	(A7)+,D1-D2/A1-A2
	RTS
	RTS
	MOVEM.L	D0-D1/D7/A1,-(A7)
	MOVEQ	#3,D7
	LEA	$1B2596,A1
	MOVE.L	$1B003E,(A0)+
	MOVE.L	#8,(A0)+
	ADDI.L	#$10,$1B28A2
	CLR.W	(A0)
	MOVE.L	#$4000,D0
	TST.W	(4,A1)
	BNE.B	$1B0218
	MOVEQ	#0,D0
	BRA.B	$1B021C
	DIVU.W	(4,A1),D0
	MOVE.W	D0,(2,A0)
	TST.B	$1B25B8
	BEQ.B	$1B022C
	MOVEQ	#1,D0
	BRA.B	$1B022E
	MOVEQ	#0,D0
	TST.W	(6,A1)
	BPL.B	$1B0238
	ORI.W	#2,D0
	MOVE.W	D0,(4,A0)
	MOVE.W	(A1),D0
	MOVE.W	(2,A1),D1
	MOVE.B	D0,(6,A0)
	MOVE.B	D1,(7,A0)
	ADDQ.W	#8,A0
	ADDQ.W	#8,A1
	DBF	D7,$1B01F0
	MOVEM.L	(A7)+,D0-D1/D7/A1
	RTS
	TST.B	$1B2A2C
	BEQ.B	$1B0280
	MOVEM.L	D0,-(A7)
	MOVE.L	$1B0022,(A0)+
	MOVE.L	#2,(A0)+
	ADDI.L	#$A,$1B28A2
	MOVE.W	D0,(A0)+
	MOVEM.L	(A7)+,D0
	NOP
	MOVEM.L	D7-A1,-(A7)
	JSR	$1B02A4
	MOVEA.L	$1B291C,A0
	LEA	(8,A0),A0
	MOVE.L	A1,D7
	SUB.L	A0,D7
	MOVE.L	D7,(-4,A0)
	MOVEM.L	(A7)+,D7-A1
	RTS
	MOVEM.L	D6-A0/A2-A3,-(A7)
	MOVE.L	#$424F4459,(A0)+
	ADDQ.W	#4,A0
	MOVEA.L	A0,A3
	MOVEA.L	A0,A1
	MOVEA.L	$1B289C,A0
	MOVEA.L	$1B2AD6,A2
	MOVEQ	#0,D7
	MOVE.B	$1B006E,D7
	SUBQ.W	#1,D7
	JSR	$1B0B32
	LEA	(4,A1),A1
	ADDA.L	(A1)+,A1
	ADDQ.W	#2,A0
	DBF	D7,$1B02CA
	MOVE.L	A1,D7
	SUB.L	A3,D7
	MOVE.L	D7,(-4,A3)
	MOVEM.L	(A7)+,D6-A0/A2-A3
	RTS
	ORI.B	#$6E,-(A5)
	DC.W	$92B7
	DC.W	$DBFF
	ORI.B	#$33,(A1)
	NEG.W	(A5)
	BNE.B	$1B0371
	OR.L	(A1)+,D4
	DC.W	$AABB
	MULU.W	(A5)+,D6
	DC.W	$EEFF
	MOVEM.L	D1-D2/A0-A2,-(A7)
	MOVE.L	#-1,-(A7)
	MOVE.W	#$48,-(A7)
	TRAP	#1
	ADDQ.L	#6,A7
	SUBI.L	#$4000,D0
	BMI.B	$1B035A
	BCLR	#0,D0
	MOVE.L	D0,$1B258C
	MOVE.L	D0,-(A7)
	MOVE.W	#$48,-(A7)
	TRAP	#1
	ADDQ.L	#6,A7
	TST.L	D0
	BMI.B	$1B035A
	MOVE.L	D0,$1B2592
	CLR.W	$1B2590
	MOVE.L	D0,$1B2586
	ADD.L	$1B258C,D0
	MOVE.L	D0,$1B2582
	MOVEQ	#1,D0
	MOVEM.L	(A7)+,D1-D2/A0-A2
	RTS
	MOVEQ	#-1,D0
	BRA.B	$1B0354
	MOVEM.L	D0-D2/A0-A2,-(A7)
	TST.L	$1B2592
	BEQ.B	$1B0378
	MOVE.L	$1B2592,-(A7)
	MOVE.W	#$49,-(A7)
	TRAP	#1
	ADDQ.L	#6,A7
	MOVEM.L	(A7)+,D0-D2/A0-A2
	RTS
	MOVEM.L	D1-D2/A1,-(A7)
	MOVE.L	($10,A7),D0
	BMI.B	$1B03F6
	BTST	#0,D0
	BEQ.B	$1B0390
	ADDQ.L	#1,D0
	MOVEQ	#0,D1
	MOVEA.L	$1B2582,A1
	MOVE.W	$1B2590,D2
	CMP.W	D2,D1
	BEQ.B	$1B03AC
	TST.L	-(A1)
	BEQ.B	$1B03CC
	SUBQ.W	#4,A1
	ADDQ.W	#1,D1
	BRA.B	$1B039E
	CMPI.W	#$7FFE,D1
	BGE.B	$1B03F6
	ADDQ.L	#8,D0
	CMP.L	$1B258C,D0
	BGT.B	$1B03F6
	ADDQ.W	#1,$1B2590
	SUB.L	D0,$1B258C
	SUBQ.L	#8,D0
	BRA.B	$1B03DC
	CMP.L	$1B258C,D0
	BGT.B	$1B03F6
	ADDQ.L	#4,A1
	SUB.L	D0,$1B258C
	MOVEA.L	$1B2586,A0
	ADD.L	D0,$1B2586
	MOVE.L	A0,-(A1)
	MOVE.L	D0,-(A1)
	MOVEQ	#0,D0
	MOVE.W	D1,D0
	MOVEM.L	(A7)+,D1-D2/A1
	RTS
	MOVEQ	#-1,D0
	BRA.B	$1B03F0
	MOVEM.L	D0-D4/A0-A1,-(A7)
	MOVEQ	#0,D0
	MOVE.W	($20,A7),D0
	BMI	$1B04E6
	ADDQ.L	#1,D0
	CMP.W	$1B2590,D0
	BGT	$1B04E6
	BNE.B	$1B044E
	SUBQ.W	#1,$1B2590
	ADDQ.L	#8,$1B258C
	SUBQ.L	#1,D0
	LSL.L	#3,D0
	MOVEA.L	$1B2582,A0
	SUBA.L	D0,A0
	ADDQ.L	#8,A0
	TST.W	$1B2590
	BEQ.B	$1B0452
	TST.L	-(A0)
	BNE.B	$1B0452
	ADDA.W	#$C,A0
	SUBQ.W	#1,$1B2590
	ADDQ.L	#8,$1B258C
	BRA.B	$1B0430
	SUBQ.L	#1,D0
	LSL.L	#3,D0
	MOVEA.L	$1B2582,A0
	SUBA.L	D0,A0
	MOVE.L	-(A0),D1
	BEQ	$1B04E6
	MOVE.L	-(A0),D2
	CLR.L	(4,A0)
	ADD.L	D2,$1B258C
	MOVE.L	D1,D3
	ADD.L	D2,D3
	CMP.L	$1B2586,D3
	BNE.B	$1B0480
	SUB.L	D2,$1B2586
	BRA.B	$1B04E6
	MOVE.L	$1B2586,D3
	SUB.L	D1,D3
	SUB.L	D2,D3
	MOVEA.L	D1,A0
	MOVE.L	D1,D0
	MOVEA.L	D1,A1
	ADDA.L	D2,A1
	MOVE.L	D3,D4
	DIVU.W	#$A0,D3
	BEQ.B	$1B04B8
	MOVE.L	A1,-(A7)
	MOVE.L	A0,-(A7)
	MOVE.W	D3,-(A7)
	JSR	$1B0AAC
	LEA	($A,A7),A7
	SWAP	D3
	EXT.L	D3
	BEQ.B	$1B04C6
	SUB.L	D3,D4
	ADDA.L	D4,A0
	ADDA.L	D4,A1
	BRA.B	$1B04BA
	SWAP	D3
	ADDQ.W	#2,D3
	LSR.W	#2,D3
	SUBQ.W	#1,D3
	MOVE.L	(A1)+,(A0)+
	DBF	D3,$1B04C0
	MOVEA.L	$1B2582,A0
	MOVE.W	$1B2590,D3
	SUBQ.W	#1,D3
	CMP.L	-(A0),D0
	BGT.B	$1B04DA
	SUB.L	D2,(A0)
	SUBQ.L	#4,A0
	DBF	D3,$1B04D4
	SUB.L	D2,$1B2586
	MOVEM.L	(A7)+,D0-D4/A0-A1
	RTS
	MOVEM.L	D0,-(A7)
	MOVEQ	#0,D0
	MOVE.W	(8,A7),D0
	BMI.B	$1B0512
	CMP.W	$1B2590,D0
	BGE.B	$1B0512
	MOVEA.L	$1B2582,A0
	LSL.L	#3,D0
	SUBA.L	D0,A0
	MOVEA.L	-(A0),A0
	MOVEM.L	(A7)+,D0
	RTS
	MOVEQ	#0,D0
	MOVEA.L	D0,A0
	BRA.B	$1B050C
	MOVEM.L	D1,-(A7)
	MOVE.W	(8,A7),D1
	MOVE.W	$1B258A,-(A7)
	JSR	$1B04EC
	ADDQ.L	#2,A7
	MOVE.W	(A0),D0
	ADDQ.L	#4,A0
	SUBQ.W	#1,D0
	TST.W	(2,A0)
	BMI.B	$1B053E
	CMP.W	(A0),D1
	BEQ.B	$1B054A
	ADDA.W	#$10,A0
	DBF	D0,$1B0534
	MOVEQ	#-1,D0
	BRA.B	$1B055E
	MOVEA.L	A0,A1
	ADDQ.L	#4,A1
	ADDQ.L	#2,A0
	MOVEQ	#0,D0
	MOVE.W	(A0),D0
	MOVE.W	D0,-(A7)
	JSR	$1B04EC
	ADDQ.L	#2,A7
	MOVEM.L	(A7)+,D1
	RTS
	MOVEM.L	D1/A0-A1,-(A7)
	MOVE.W	($12,A7),-(A7)
	JSR	$1B0518
	ADDQ.L	#2,A7
	TST.W	D0
	BMI.B	$1B0594
	MOVE.W	($10,A7),D1
	MOVE.W	(A0),D0
	CMP.W	D0,D1
	BGE.B	$1B0594
	LSL.W	#1,D1
	ADDQ.W	#2,D1
	MOVEQ	#0,D0
	MOVE.W	(0.B,A0,D1.W),D0
	BMI.B	$1B0594
	MOVEM.L	(A7)+,D1/A0-A1
	RTS
	MOVEQ	#-1,D0
	BRA.B	$1B058E
	MOVEM.L	D1-D2/A1-A2,-(A7)
	MOVE.L	($14,A7),-(A7)
	JSR	$1B037E
	ADDQ.L	#4,A7
	MOVE.W	D0,D2
	BMI.B	$1B0604
	MOVEA.L	A0,A2
	MOVE.W	($1A,A7),-(A7)
	JSR	$1B0518
	ADDQ.L	#2,A7
	TST.W	D0
	BMI.B	$1B0608
	MOVE.W	($18,A7),D1
	MOVE.W	(A0),D0
	CMP.W	D0,D1
	BGE.B	$1B0608
	LSL.W	#1,D1
	ADDQ.W	#2,D1
	MOVE.W	(0.B,A0,D1.W),D0
	BMI.B	$1B05F4
	MOVE.W	D0,-(A7)
	JSR	$1B03FA
	ADDQ.L	#2,A7
	MOVE.W	D2,-(A7)
	JSR	$1B04EC
	ADDQ.L	#2,A7
	MOVEA.L	A0,A2
	MOVE.W	($1A,A7),-(A7)
	JSR	$1B0518
	ADDQ.L	#2,A7
	MOVE.W	D2,(0.B,A0,D1.W)
	MOVEA.L	A2,A0
	MOVEQ	#0,D0
	MOVE.W	D2,D0
	MOVEM.L	(A7)+,D1-D2/A1-A2
	RTS
	MOVEQ	#-1,D0
	BRA.B	$1B05FE
	MOVE.W	D2,-(A7)
	JSR	$1B03FA
	ADDQ.L	#2,A7
	MOVEQ	#-2,D0
	BRA.B	$1B05FE
	MOVEM.L	D0-D1/A0-A1,-(A7)
	MOVE.W	($16,A7),-(A7)
	JSR	$1B0518
	ADDQ.L	#2,A7
	TST.W	D0
	BMI.B	$1B064E
	MOVE.W	($14,A7),D1
	MOVE.W	(A0),D0
	CMP.W	D0,D1
	BGE.B	$1B064E
	LSL.W	#1,D1
	ADDQ.W	#2,D1
	MOVE.W	(0.B,A0,D1.W),D0
	BMI.B	$1B064E
	MOVE.W	#-1,(0.B,A0,D1.W)
	MOVE.W	D0,-(A7)
	JSR	$1B03FA
	ADDQ.L	#2,A7
	MOVEM.L	(A7)+,D0-D1/A0-A1
	RTS
	MOVEM.L	D0-D4/A0-A2,-(A7)
	MOVE.W	($26,A7),D4
	MOVE.W	($24,A7),D1
	MOVE.W	D4,-(A7)
	MOVE.W	D1,-(A7)
	JSR	$1B0616
	ADDQ.L	#4,A7
	MOVE.W	D4,-(A7)
	JSR	$1B0518
	ADDQ.L	#2,A7
	TST.W	D0
	BMI.B	$1B06CE
	MOVEA.L	A0,A2
	MOVE.W	(A2)+,D2
	SUBQ.W	#1,D2
	BMI.B	$1B06CE
	MOVE.W	D2,D3
	LSL.W	#1,D3
	ADDQ.W	#2,D3
	EXT.L	D3
	MOVE.L	D3,-(A7)
	JSR	$1B037E
	ADDQ.L	#4,A7
	MOVE.W	D0,D4
	BMI.B	$1B06CE
	MOVE.W	D2,(A0)+
	MOVE.W	D1,D3
	BEQ.B	$1B06A6
	SUBQ.W	#1,D3
	MOVE.W	(A2)+,(A0)+
	DBF	D3,$1B06A0
	ADDQ.W	#2,A2
	SUB.W	D1,D2
	BLE.B	$1B06B4
	SUBQ.W	#1,D2
	MOVE.W	(A2)+,(A0)+
	DBF	D2,$1B06AE
	MOVE.W	($26,A7),D0
	MOVE.W	D4,-(A7)
	MOVE.W	D0,-(A7)
	MOVE.L	A1,-(A7)
	JSR	$1B06DE
	ADDQ.L	#8,A7
	TST.W	D0
	MOVEM.L	(A7)+,D0-D4/A0-A2
	RTS
	MOVEQ	#-1,D0
	BRA.B	$1B06C8
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	MOVEM.L	D1-D3/A0-A1,-(A7)
	MOVEA.L	($18,A7),A0
	LEA	$1B06D2,A1
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.W	($1C,A7),D1
	MOVE.W	$1B258A,-(A7)
	JSR	$1B04EC
	ADDQ.L	#2,A7
	MOVEA.L	A0,A1
	MOVE.W	(A0),D0
	ADDQ.L	#4,A0
	SUBQ.W	#1,D0
	TST.W	(2,A0)
	BMI.B	$1B0740
	CMP.W	(A0),D1
	BNE.B	$1B0740
	MOVE.W	(2,A0),D0
	MOVE.W	#-1,(2,A0)
	SUBQ.W	#1,(2,A1)
	MOVE.W	D0,-(A7)
	JSR	$1B03FA
	ADDQ.L	#2,A7
	MOVE.W	$1B258A,-(A7)
	JSR	$1B04EC
	ADDQ.L	#2,A7
	MOVEA.L	A0,A1
	BRA.B	$1B0748
	ADDA.W	#$10,A0
	DBF	D0,$1B070C
	MOVEA.L	A1,A0
	MOVE.W	(A0),D0
	CMP.W	(2,A0),D0
	BGT.B	$1B07B4
	ADDI.W	#$14,D0
	LSL.W	#4,D0
	ADDQ.W	#4,D0
	EXT.L	D0
	MOVE.L	D0,-(A7)
	JSR	$1B037E
	ADDQ.L	#4,A7
	MOVE.W	D0,D2
	BMI.B	$1B07E0
	MOVE.W	(A1),D0
	MOVE.W	D0,(A0)
	ADDI.W	#$14,(A0)+
	MOVE.W	D0,(A0)+
	ADDQ.L	#4,A1
	SUBQ.W	#1,D0
	MOVE.L	(A1)+,(A0)+
	MOVE.L	(A1)+,(A0)+
	MOVE.L	(A1)+,(A0)+
	MOVE.L	(A1)+,(A0)+
	DBF	D0,$1B0778
	ADDQ.L	#2,A0
	MOVEQ	#$13,D0
	MOVE.W	#-1,(A0)
	ADDA.W	#$10,A0
	DBF	D0,$1B0788
	MOVE.W	$1B258A,-(A7)
	JSR	$1B03FA
	ADDQ.L	#2,A7
	MOVE.W	D2,$1B258A
	MOVE.W	D2,-(A7)
	JSR	$1B04EC
	ADDQ.L	#2,A7
	MOVEA.L	A0,A1
	ADDQ.L	#6,A1
	TST.W	(A1)
	BMI.B	$1B07C0
	ADDA.W	#$10,A1
	BRA.B	$1B07B6
	ADDQ.W	#1,(2,A0)
	MOVE.W	($1E,A7),(A1)+
	MOVE.W	D1,(-4,A1)
	LEA	$1B06D2,A0
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVEQ	#1,D0
	MOVEM.L	(A7)+,D1-D3/A0-A1
	RTS
	MOVEQ	#-1,D0
	BRA.B	$1B07DA
	MOVEM.L	D1-D2/A1,-(A7)
	MOVE.W	($14,A7),D1
	MOVE.W	D1,D2
	LSL.W	#1,D1
	ADDQ.W	#2,D1
	EXT.L	D1
	MOVE.L	D1,-(A7)
	JSR	$1B037E
	ADDQ.L	#4,A7
	TST.W	D0
	BMI.B	$1B083E
	MOVEA.L	A0,A1
	MOVE.W	D2,(A1)+
	MOVEQ	#-1,D1
	SUBQ.W	#1,D2
	MOVE.W	D1,(A1)+
	DBF	D2,$1B080A
	MOVE.W	D0,D1
	MOVE.W	($16,A7),D0
	MOVEA.L	($10,A7),A1
	MOVE.W	D1,-(A7)
	MOVE.W	D0,-(A7)
	MOVE.L	A1,-(A7)
	JSR	$1B06DE
	ADDQ.L	#8,A7
	TST.W	D0
	BMI.B	$1B0834
	MOVE.W	D1,D0
	MOVEM.L	(A7)+,D1-D2/A1
	RTS
	MOVE.W	D1,-(A7)
	JSR	$1B03FA
	ADDQ.L	#2,A7
	MOVEQ	#-1,D0
	BRA.B	$1B082E
	MOVEM.L	D0-D4/A0-A2,-(A7)
	MOVE.W	($26,A7),-(A7)
	JSR	$1B0518
	ADDQ.L	#2,A7
	TST.W	D0
	BMI.B	$1B08B2
	MOVEA.L	A0,A2
	MOVE.W	($24,A7),D1
	MOVE.W	(A2)+,D2
	ADDQ.W	#1,D2
	CMP.W	D2,D1
	BGE.B	$1B08B2
	MOVE.W	D2,D3
	LSL.W	#1,D3
	ADDQ.W	#2,D3
	EXT.L	D3
	MOVE.L	D3,-(A7)
	JSR	$1B037E
	ADDQ.L	#4,A7
	MOVE.W	D0,D4
	BMI.B	$1B08B2
	MOVE.W	D2,(A0)+
	MOVE.W	D1,D3
	BEQ.B	$1B0888
	SUBQ.W	#1,D3
	MOVE.W	(A2)+,(A0)+
	DBF	D3,$1B0882
	MOVE.W	#-1,(A0)+
	SUB.W	D1,D2
	SUBQ.W	#2,D2
	BMI.B	$1B0898
	MOVE.W	(A2)+,(A0)+
	DBF	D2,$1B0892
	MOVE.W	($26,A7),D0
	MOVE.W	D4,-(A7)
	MOVE.W	D0,-(A7)
	MOVE.L	A1,-(A7)
	JSR	$1B06DE
	ADDQ.L	#8,A7
	TST.W	D0
	MOVEM.L	(A7)+,D0-D4/A0-A2
	RTS
	MOVEQ	#-1,D0
	BRA.B	$1B08AC
	MOVEM.L	D2-D5/A0,-(A7)
	MOVE.W	($1A,A7),D2
	MOVE.W	D2,D1
	LSR.W	#4,D1
	ADDQ.W	#1,D1
	MOVE.W	D2,D3
	ANDI.W	#$F,D3
	CMPI.W	#2,D3
	BLT.B	$1B08D2
	ADDQ.W	#1,D1
	MOVE.W	($18,A7),D3
	MOVE.W	D1,D4
	LSL.W	#1,D4
	MULU.W	D3,D4
	MOVE.L	D4,-(A7)
	JSR	$1B037E
	ADDQ.L	#4,A7
	MOVE.W	D0,D5
	BMI.B	$1B0928
	MOVE.L	D4,D0
	LSR.L	#1,D0
	SUBQ.W	#1,D0
	MOVE.W	#-1,(A0)+
	DBF	D0,$1B08F0
	ADDQ.L	#3,D4
	LSL.L	#2,D4
	MOVE.L	D4,-(A7)
	JSR	$1B037E
	ADDQ.L	#4,A7
	TST.W	D0
	BMI.B	$1B091E
	CLR.W	(A0)+
	MOVE.W	D1,(A0)+
	MOVE.W	D3,(A0)+
	MOVE.W	D2,(A0)+
	CLR.L	(A0)+
	MOVEQ	#0,D1
	MOVE.W	D5,D1
	MOVEM.L	(A7)+,D2-D5/A0
	RTS
	MOVE.W	D5,-(A7)
	JSR	$1B03FA
	ADDQ.L	#2,A7
	MOVEQ	#-1,D0
	MOVEQ	#-1,D1
	BRA.B	$1B0918
	MOVEM.L	A0,-(A7)
	MOVE.L	#$144,-(A7)
	JSR	$1B037E
	ADDQ.L	#4,A7
	MOVE.W	D0,$1B258A
	BMI.B	$1B0966
	MOVE.W	#$14,(A0)+
	CLR.W	(A0)
	ADDQ.L	#4,A0
	MOVEQ	#$13,D0
	MOVE.W	#-1,(A0)
	ADDA.W	#$10,A0
	DBF	D0,$1B0952
	MOVEQ	#1,D0
	MOVEM.L	(A7)+,A0
	RTS
	MOVEQ	#-1,D0
	BRA.B	$1B0960
	MOVEM.L	D0-D3/A0-A1,-(A7)
	MOVE.W	($1C,A7),D2
	MOVE.W	D2,-(A7)
	JSR	$1B0518
	ADDQ.L	#2,A7
	TST.W	D0
	BMI.B	$1B09B8
	MOVE.W	(A0)+,D1
	SUBQ.W	#1,D1
	MOVE.W	D2,-(A7)
	JSR	$1B0518
	ADDQ.L	#2,A7
	MOVE.W	D1,D0
	LSL.W	#1,D0
	MOVE.W	D0,D3
	MOVE.W	(2.B,A0,D3.W),D0
	BMI.B	$1B09AA
	MOVE.W	#-1,(2.B,A0,D3.W)
	MOVE.W	D0,-(A7)
	JSR	$1B03FA
	ADDQ.W	#2,A7
	DBF	D1,$1B0984
	MOVE.W	D2,-(A7)
	JSR	$1B09BE
	ADDQ.W	#2,A7
	MOVEM.L	(A7)+,D0-D3/A0-A1
	RTS
	MOVEM.L	D0-D2/A0-A1,-(A7)
	MOVE.W	($18,A7),D0
	BMI	$1B0AA6
	CMPI.W	#$3E8,D0
	BGE.B	$1B09DC
	MOVE.W	D0,-(A7)
	CLR.W	-(A7)
	JSR	$1B0616
	ADDQ.L	#4,A7
	MOVE.W	$1B258A,-(A7)
	JSR	$1B04EC
	ADDQ.L	#2,A7
	MOVE.W	(A0),D1
	ADDQ.L	#4,A0
	SUBQ.W	#1,D1
	TST.W	(2,A0)
	BMI.B	$1B09FA
	CMP.W	(A0),D0
	BEQ.B	$1B0A06
	ADDA.W	#$10,A0
	DBF	D1,$1B09F0
	BRA	$1B0AA6
	ADDQ.L	#2,A0
	MOVE.W	(A0),D0
	MOVE.W	#-1,(A0)
	MOVE.W	D0,-(A7)
	JSR	$1B03FA
	ADDQ.L	#2,A7
	MOVE.W	$1B258A,-(A7)
	JSR	$1B04EC
	ADDQ.L	#2,A7
	SUBQ.W	#1,(2,A0)
	MOVE.W	(A0),D0
	SUB.W	(2,A0),D0
	CMPI.W	#$28,D0
	BLT.B	$1B0AA6
	MOVEA.L	A0,A1
	MOVE.W	(2,A1),D0
	ADDI.W	#$14,D0
	LSL.W	#4,D0
	ADDQ.W	#4,D0
	EXT.L	D0
	MOVE.L	D0,-(A7)
	JSR	$1B037E
	ADDQ.L	#4,A7
	TST.W	D0
	BMI.B	$1B0AA6
	MOVE.W	(A1),D2
	MOVE.W	(2,A1),D1
	MOVE.W	D1,(2,A0)
	ADDI.W	#$14,D1
	MOVE.W	D1,(A0)
	ADDQ.L	#4,A1
	ADDQ.L	#4,A0
	SUBQ.W	#1,D2
	TST.W	(2,A1)
	BMI.B	$1B0A7A
	MOVE.L	(A1)+,(A0)+
	MOVE.L	(A1)+,(A0)+
	MOVE.L	(A1)+,(A0)+
	MOVE.L	(A1)+,(A0)+
	BRA.B	$1B0A7E
	ADDA.W	#$10,A1
	DBF	D2,$1B0A6A
	MOVEQ	#$13,D2
	ADDQ.L	#2,A0
	MOVE.W	#-1,(A0)
	ADDA.W	#$10,A0
	DBF	D2,$1B0A86
	MOVE.W	$1B258A,-(A7)
	JSR	$1B03FA
	ADDQ.L	#2,A7
	MOVE.W	D0,$1B258A
	MOVEM.L	(A7)+,D0-D2/A0-A1
	RTS
	MOVEM.L	D0/A0-A1,-(A7)
	MOVE.W	($10,A7),D0
	MOVEA.L	($12,A7),A1
	MOVEA.L	($16,A7),A0
	SUBQ.W	#1,D0
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	MOVE.L	(A0)+,(A1)+
	DBF	D0,$1B0ABE
	MOVEM.L	(A7)+,D0/A0-A1
	RTS
	MOVEM.L	D0/A0,-(A7)
	MOVE.W	($C,A7),D0
	SUBQ.W	#1,D0
	MOVEA.L	($E,A7),A0
	CLR.W	(A0)+
	DBF	D0,$1B0B26
	MOVEM.L	(A7)+,D0/A0
	RTS
	MOVE.W	#$14,$1B28D4
	MOVE.W	#$A0,$1B289A
	MOVE.W	#$C8,$1B286E
	MOVE.L	#$7CF8,$1B286A
	JMP	$1B0B78
	MOVE.L	D0,-(A7)
	MOVE.W	$1B289A,D0
	MULU.W	$1B286E,D0
	SUBQ.L	#2,D0
	MOVE.L	D0,$1B286A
	MOVE.L	(A7)+,D0
	JMP	$1B0B78
	MOVEM.L	D0-A6,-(A7)
	MOVE.L	#$56444154,(A1)
	LEA	($A,A1),A3
	MOVEA.L	A2,A4
	SF	D4
	MOVE.W	(A0),D0
	ADDA.W	$1B289A,A0
	MOVEA.L	A2,A5
	MOVEQ	#0,D3
	MOVE.W	$1B28D4,D7
	SUBQ.W	#1,D7
	MOVE.W	$1B286E,D6
	SUBQ.W	#1,D6
	BRA.B	$1B0BC4
	MOVE.W	(A0),D0
	ADDA.W	$1B289A,A0
	TST.B	D4
	BEQ.B	$1B0BBC
	CMP.W	D0,D1
	BEQ.B	$1B0BC6
	BSR.B	$1B0C18
	BRA.B	$1B0BC6
	CMP.W	D0,D1
	BNE.B	$1B0BC4
	BSR.B	$1B0C34
	BRA.B	$1B0BC6
	MOVE.W	D0,(A2)+
	ADDQ.W	#1,D3
	MOVE.W	D0,D1
	DBF	D6,$1B0BA8
	MOVE.W	$1B286E,D6
	SUBQ.W	#1,D6
	SUBA.L	$1B286A,A0
	DBF	D7,$1B0BA8
	TST.B	D4
	BEQ.B	$1B0BE8
	BSR.B	$1B0C18
	BRA.B	$1B0BEC
	BSR.B	$1B0C38
	ADDQ.W	#2,A2
	ADDQ.W	#1,A3
	MOVE.L	A3,D2
	ANDI.L	#$FFFFFFFE,D2
	MOVEA.L	D2,A3
	MOVE.W	(A4)+,(A3)+
	CMPA.L	A4,A2
	BNE.B	$1B0BF8
	MOVE.L	A1,D0
	ADDQ.L	#8,D0
	MOVE.L	A3,D1
	SUBQ.L	#2,D1
	SUB.L	D0,D1
	MOVE.L	D1,(4,A1)
	SUB.L	D0,D2
	MOVE.W	D2,(8,A1)
	MOVEM.L	(A7)+,D0-A6
	RTS
	CMPI.W	#$7F,D3
	BGT.B	$1B0C22
	MOVE.B	D3,(A3)+
	BRA.B	$1B0C2A
	MOVE.B	#1,(A3)+
	MOVE.W	(A5),(A2)+
	MOVE.W	D3,(A5)
	MOVEA.L	A2,A5
	MOVE.W	D0,(A2)+
	SF	D4
	MOVEQ	#0,D3
	RTS
	SUBQ.W	#1,D3
	BEQ.B	$1B0C5C
	CMPI.W	#$80,D3
	BGT.B	$1B0C44
	NEG.W	D3
	MOVE.B	D3,(A3)+
	BRA.B	$1B0C58
	CLR.B	(A3)+
	LEA	(2,A2),A6
	MOVE.W	(-2,A2),(A2)
	SUBQ.W	#2,A2
	CMPA.L	A2,A5
	BNE.B	$1B0C4A
	MOVEA.L	A6,A2
	MOVE.W	D3,(A5)
	LEA	(-2,A2),A5
	ST	D4
	MOVEQ	#1,D3
	RTS
	MOVE.W	#$A0,$1B289A
	MOVE.L	$1B28DA,$1B286A
	SUBQ.L	#8,$1B286A
	JMP	$1B0CA4
	MOVE.L	D0,-(A7)
	MOVE.W	$1B289A,D0
	MULU.W	$1B286E,D0
	MOVE.L	D0,$1B28DA
	SUBQ.L	#2,D0
	MOVE.L	D0,$1B286A
	MOVE.L	(A7)+,D0
	JMP	$1B0CA4
	MOVEM.L	D0-D1/D4-A2,-(A7)
	MOVE.W	$1B289A,D6
	MOVE.L	$1B28DA,D4
	ADD.L	A0,D4
	MOVE.L	$1B286A,D5
	MOVEA.L	A1,A2
	MOVE.L	A1,D7
	ADDA.W	(A1)+,A2
	ADD.L	D0,D7
	CMP.L	A2,D7
	BLE.B	$1B0D06
	MOVEQ	#0,D0
	MOVE.B	(A1)+,D0
	BEQ.B	$1B0CE4
	BPL.B	$1B0CEA
	NEG.B	D0
	SUBQ.W	#1,D0
	MOVE.W	(A2)+,(A0)
	ADDA.W	D6,A0
	CMP.L	A0,D4
	BGT.B	$1B0CDE
	SUBA.L	D5,A0
	DBF	D0,$1B0CD4
	BRA.B	$1B0CC4
	MOVE.W	(A2)+,D0
	SUBQ.W	#1,D0
	BRA.B	$1B0CD4
	SUBQ.W	#1,D0
	BEQ.B	$1B0D00
	MOVE.W	(A2)+,D1
	MOVE.W	D1,(A0)
	ADDA.W	D6,A0
	CMP.L	A0,D4
	BGT.B	$1B0CFA
	SUBA.L	D5,A0
	DBF	D0,$1B0CF0
	BRA.B	$1B0CC4
	MOVE.W	(A2)+,D0
	SUBQ.W	#1,D0
	BRA.B	$1B0CEE
	MOVEM.L	(A7)+,D0-D1/D4-A2
	RTS
	LINK	A6,#0
	JSR	$1B0E70
	BNE.B	$1B0D1E
	JSR	$1B0F90
	BRA	$1B0E5A
	MOVE.W	#7,-(A7)
	JSR	$1B1924
	ADDQ.L	#2,A7
	MOVE.L	D0,$1B28A8
	MOVE.L	$1B28A8,D0
	EXT.W	D0
	MOVE.W	D0,-(A7)
	JSR	$1B2122
	ADDQ.L	#2,A7
	BRA	$1B0DCA
	CLR.B	$1B2876
	SF	D0
	JSR	$1AEEFC
	BRA	$1B0DFA
	MOVE.B	#1,$1B2876
	SF	D0
	JSR	$1AEEFC
	BRA	$1B0DFA
	JSR	$1AF142
	BRA	$1B0DFA
	MOVE.B	$1B2876,D0
	EXT.W	D0
	CMP.W	#0,D0
	BLT.B	$1B0D92
	SF	D0
	JSR	$1AEEFC
	BRA.B	$1B0D98
	JSR	$1AF142
	BRA	$1B0DFA
	JSR	$1AEDDC
	BRA	$1B0DFA
	JSR	$1AED68
	BRA	$1B0DFA
	MOVE.B	$1B25B8,D0
	BEQ.B	$1B0DC0
	JSR	$1B165E
	BRA.B	$1B0DC6
	JSR	$1B1606
	BRA.B	$1B0DFA
	BRA.B	$1B0DFA
	CMP.W	#9,D0
	BEQ.B	$1B0DB0
	CMP.W	#$2A,D0
	BEQ.B	$1B0D7A
	CMP.W	#$2B,D0
	BEQ.B	$1B0D9C
	CMP.W	#$2D,D0
	BEQ.B	$1B0DA6
	CMP.W	#$34,D0
	BEQ	$1B0D5C
	CMP.W	#$35,D0
	BEQ	$1B0D4A
	CMP.W	#$36,D0
	BEQ	$1B0D70
	CMPI.L	#$610000,$1B28A8
	BEQ.B	$1B0E3C
	MOVE.L	$1B28A8,D0
	EXT.W	D0
	CMP.W	#$20,D0
	BEQ.B	$1B0E3C
	MOVE.L	$1B28A8,D0
	EXT.W	D0
	CMP.W	#$1B,D0
	BEQ.B	$1B0E3C
	CMPI.L	#$740000,$1B28A8
	BEQ.B	$1B0E3C
	CMPI.L	#$750000,$1B28A8
	BNE	$1B0D22
	MOVEM.L	D0-D2/A1-A2,-(A7)
	LEA	$1B1600,A0
	PEA	$1B1600
	MOVEA.L	$1B293C,A1
	JSR	(A1)
	ADDQ.W	#4,A7
	MOVEM.L	(A7)+,D0-D2/A1-A2
	JSR	$1B1020
	BNE	$1B0D22
	JSR	$1B0F90
	UNLK	A6
	RTS
	RTS
	LINK	A6,#0
	MOVEM.L	D6-D7,-(A7)
	MOVE.W	#2,-(A7)
	JSR	$1B18E6
	ADDQ.L	#2,A7
	MOVE.L	D0,$1B2936
	MOVE.W	#4,-(A7)
	JSR	$1B18E6
	ADDQ.L	#2,A7
	MOVE.W	D0,$1B2946
	CMPI.W	#1,$1B2946
	BLE.B	$1B0EB2
	MOVE.W	#-1,-(A7)
	JSR	$1B199A
	ADDQ.L	#2,A7
	JSR	$1B17FC
	CLR.L	-(A7)
	MOVE.W	#$20,-(A7)
	JSR	$1B1924
	ADDQ.L	#6,A7
	MOVE.L	D0,$1B28E6
	JSR	$1B0302
	TST.W	D0
	BMI.B	$1B0F36
	MOVE.L	#$19E10,-(A7)
	JSR	$1B037E
	ADDQ.L	#4,A7
	TST.W	D0
	BMI.B	$1B0F36
	MOVE.L	A0,D0
	CLR.B	D0
	ADDI.L	#$100,D0
	MOVE.L	D0,$1B2A28
	MOVEA.L	D0,A0
	ADDA.L	#$7D00,A0
	MOVE.L	A0,$1B289C
	ADDA.L	#$8000,A0
	MOVE.L	A0,$1B291C
	ADDA.L	#$8000,A0
	MOVE.L	A0,$1B2AD6
	ADDA.L	#$1F90,A0
	MOVE.L	A0,$1B28DE
	CLR.L	(A0)
	JSR	$1B092E
	MOVEQ	#1,D0
	BRA.B	$1B0F38
	MOVEQ	#0,D0
	MOVE.W	D0,D6
	CLR.W	D7
	BRA.B	$1B0F60
	MOVE.W	#-1,-(A7)
	MOVE.W	D7,-(A7)
	MOVE.W	#7,-(A7)
	JSR	$1B18E6
	ADDQ.L	#6,A7
	MOVE.W	D7,D1
	ASL.W	#1,D1
	LEA	$1B284A,A0
	MOVE.W	D0,(0.B,A0,D1.W)
	ADDQ.W	#1,D7
	CMPI.W	#$10,D7
	BLT.B	$1B0F3E
	MOVE.W	#$22,-(A7)
	JSR	$1B18E6
	ADDQ.L	#2,A7
	MOVE.L	D0,$1B28D6
	MOVEA.L	$1B28D6,A0
	MOVE.L	($10,A0),$1B293C
	MOVE.W	D6,D0
	MOVEM.L	(A7)+,D6-D7
	UNLK	A6
	RTS
	LINK	A6,#-2
	MOVE.W	#$80,-(A7)
	MOVE.W	#4,-(A7)
	MOVE.W	#3,-(A7)
	JSR	$1B18A8
	ADDQ.L	#6,A7
	MOVE.W	#1,-(A7)
	MOVE.W	#4,-(A7)
	MOVE.W	#3,-(A7)
	JSR	$1B18A8
	ADDQ.L	#6,A7
	JSR	$1B165E
	JSR	$1B035E
	PEA	$1B284A
	MOVE.W	#6,-(A7)
	JSR	$1B18E6
	ADDQ.L	#6,A7
	MOVE.L	$1B28E6,-(A7)
	MOVE.W	#$20,-(A7)
	JSR	$1B1924
	ADDQ.L	#6,A7
	MOVE.W	$1B2946,-(A7)
	MOVE.L	$1B2936,-(A7)
	MOVE.L	$1B2936,-(A7)
	MOVE.W	#5,-(A7)
	JSR	$1B18E6
	LEA	($C,A7),A7
	JSR	$1B17E4
	CLR.W	-(A7)
	JSR	$1B199A
	ADDQ.L	#2,A7
	UNLK	A6
	RTS
	LINK	A6,#-4
	JSR	$1AF764
	JSR	$1B165E
	MOVEM.L	D0-D2/A1-A2,-(A7)
	LEA	$1B1600,A0
	PEA	$1B1600
	MOVEA.L	$1B293C,A1
	JSR	(A1)
	ADDQ.W	#4,A7
	MOVEM.L	(A7)+,D0-D2/A1-A2
	MOVE.L	$1B28E6,-(A7)
	MOVE.W	#$20,-(A7)
	JSR	$1B1924
	ADDQ.L	#6,A7
	MOVE.W	$1B2946,-(A7)
	MOVE.L	$1B2A28,-(A7)
	MOVE.L	$1B2A28,-(A7)
	MOVE.W	#5,-(A7)
	JSR	$1B18E6
	LEA	($C,A7),A7
	PEA	$1B284A
	MOVE.W	#6,-(A7)
	JSR	$1B18E6
	ADDQ.L	#6,A7
	MOVE.W	#$1B,-(A7)
	MOVE.W	#2,-(A7)
	JSR	$1B1924
	ADDQ.L	#4,A7
	MOVE.W	#$45,-(A7)
	MOVE.W	#2,-(A7)
	JSR	$1B1924
	ADDQ.L	#4,A7
	MOVE.W	#$1B,-(A7)
	MOVE.W	#2,-(A7)
	JSR	$1B1924
	ADDQ.L	#4,A7
	MOVE.W	#$59,-(A7)
	MOVE.W	#2,-(A7)
	JSR	$1B1924
	ADDQ.L	#4,A7
	MOVE.W	#$20,-(A7)
	MOVE.W	#2,-(A7)
	JSR	$1B1924
	ADDQ.L	#4,A7
	MOVE.W	$1B2946,D0
	BEQ.B	$1B10FC
	MOVE.W	#$38,-(A7)
	MOVE.W	#2,-(A7)
	JSR	$1B1924
	ADDQ.L	#4,A7
	BRA.B	$1B110C
	MOVE.W	#$24,-(A7)
	MOVE.W	#2,-(A7)
	JSR	$1B1924
	ADDQ.L	#4,A7
	PEA	$1B25BA
	MOVE.W	#9,-(A7)
	JSR	$1B1924
	ADDQ.L	#6,A7
	MOVE.W	#$1B,-(A7)
	MOVE.W	#2,-(A7)
	JSR	$1B1924
	ADDQ.L	#4,A7
	MOVE.W	#$59,-(A7)
	MOVE.W	#2,-(A7)
	JSR	$1B1924
	ADDQ.L	#4,A7
	MOVE.W	#$21,-(A7)
	MOVE.W	#2,-(A7)
	JSR	$1B1924
	ADDQ.L	#4,A7
	MOVE.W	$1B2946,D0
	BEQ.B	$1B1168
	MOVE.W	#$36,-(A7)
	MOVE.W	#2,-(A7)
	JSR	$1B1924
	ADDQ.L	#4,A7
	BRA.B	$1B1178
	MOVE.W	#$22,-(A7)
	MOVE.W	#2,-(A7)
	JSR	$1B1924
	ADDQ.L	#4,A7
	PEA	$1B25DC
	MOVE.W	#9,-(A7)
	JSR	$1B1924
	ADDQ.L	#6,A7
	MOVE.W	#$1B,-(A7)
	MOVE.W	#2,-(A7)
	JSR	$1B1924
	ADDQ.L	#4,A7
	MOVE.W	#$59,-(A7)
	MOVE.W	#2,-(A7)
	JSR	$1B1924
	ADDQ.L	#4,A7
	MOVE.W	#$22,-(A7)
	MOVE.W	#2,-(A7)
	JSR	$1B1924
	ADDQ.L	#4,A7
	MOVE.W	$1B2946,D0
	BEQ.B	$1B11D4
	MOVE.W	#$40,-(A7)
	MOVE.W	#2,-(A7)
	JSR	$1B1924
	ADDQ.L	#4,A7
	BRA.B	$1B11E4
	MOVE.W	#$2C,-(A7)
	MOVE.W	#2,-(A7)
	JSR	$1B1924
	ADDQ.L	#4,A7
	PEA	$1B2602
	MOVE.W	#9,-(A7)
	JSR	$1B1924
	ADDQ.L	#6,A7
	MOVE.W	#$1B,-(A7)
	MOVE.W	#2,-(A7)
	JSR	$1B1924
	ADDQ.L	#4,A7
	MOVE.W	#$59,-(A7)
	MOVE.W	#2,-(A7)
	JSR	$1B1924
	ADDQ.L	#4,A7
	MOVE.W	#$37,-(A7)
	MOVE.W	#2,-(A7)
	JSR	$1B1924
	ADDQ.L	#4,A7
	MOVE.W	$1B2946,D0
	BEQ.B	$1B1240
	MOVE.W	#$3A,-(A7)
	MOVE.W	#2,-(A7)
	JSR	$1B1924
	ADDQ.L	#4,A7
	BRA.B	$1B1250
	MOVE.W	#$26,-(A7)
	MOVE.W	#2,-(A7)
	JSR	$1B1924
	ADDQ.L	#4,A7
	MOVE.W	#$BD,-(A7)
	MOVE.W	#2,-(A7)
	JSR	$1B1924
	ADDQ.L	#4,A7
	PEA	$1B2614
	MOVE.W	#9,-(A7)
	JSR	$1B1924
	ADDQ.L	#6,A7
	MOVE.W	#$1B,-(A7)
	MOVE.W	#2,-(A7)
	JSR	$1B1924
	ADDQ.L	#4,A7
	MOVE.W	#$59,-(A7)
	MOVE.W	#2,-(A7)
	JSR	$1B1924
	ADDQ.L	#4,A7
	MOVE.W	#$38,-(A7)
	MOVE.W	#2,-(A7)
	JSR	$1B1924
	ADDQ.L	#4,A7
	MOVE.W	$1B2946,D0
	BEQ.B	$1B12BC
	MOVE.W	#$3C,-(A7)
	MOVE.W	#2,-(A7)
	JSR	$1B1924
	ADDQ.L	#4,A7
	BRA.B	$1B12CC
	MOVE.W	#$28,-(A7)
	MOVE.W	#2,-(A7)
	JSR	$1B1924
	ADDQ.L	#4,A7
	PEA	$1B2632
	MOVE.W	#9,-(A7)
	JSR	$1B1924
	ADDQ.L	#6,A7
	PEA	$1B264C
	PEA	$1B29A8
	JSR	$1B20F6
	ADDQ.L	#8,A7
	MOVE.W	#$19,-(A7)
	JSR	$1B1924
	ADDQ.L	#2,A7
	ADD.B	D0,$1B29A8
	CLR.W	-(A7)
	LEA	$1B29A8,A0
	MOVE.L	A0,D0
	ADDQ.L	#2,D0
	MOVE.L	D0,-(A7)
	MOVE.W	#$47,-(A7)
	JSR	$1B1924
	ADDQ.L	#8,A7
	PEA	$1B2650
	PEA	$1B29A8
	JSR	$1B20AC
	ADDQ.L	#8,A7
	MOVE.W	#$80,-(A7)
	MOVE.W	#4,-(A7)
	MOVE.W	#3,-(A7)
	JSR	$1B18A8
	ADDQ.L	#6,A7
	MOVE.W	#1,-(A7)
	MOVE.W	#4,-(A7)
	MOVE.W	#3,-(A7)
	JSR	$1B18A8
	ADDQ.L	#6,A7
	PEA	$1B293A
	MOVE.L	$1B28DE,-(A7)
	PEA	$1B29A8
	JSR	$1B1874
	LEA	($C,A7),A7
	MOVE.W	#7,-(A7)
	MOVE.W	#4,-(A7)
	MOVE.W	#3,-(A7)
	JSR	$1B18A8
	ADDQ.L	#6,A7
	MOVE.W	#4,-(A7)
	MOVE.W	#4,-(A7)
	MOVE.W	#3,-(A7)
	JSR	$1B18A8
	ADDQ.L	#6,A7
	MOVE.W	#9,-(A7)
	MOVE.W	#4,-(A7)
	MOVE.W	#3,-(A7)
	JSR	$1B18A8
	ADDQ.L	#6,A7
	CLR.W	-(A7)
	MOVE.W	#4,-(A7)
	MOVE.W	#3,-(A7)
	JSR	$1B18A8
	ADDQ.L	#6,A7
	CLR.W	-(A7)
	MOVE.W	#4,-(A7)
	MOVE.W	#3,-(A7)
	JSR	$1B18A8
	ADDQ.L	#6,A7
	CLR.W	-(A7)
	MOVE.W	#4,-(A7)
	MOVE.W	#3,-(A7)
	JSR	$1B18A8
	ADDQ.L	#6,A7
	CLR.W	-(A7)
	MOVE.W	#4,-(A7)
	MOVE.W	#3,-(A7)
	JSR	$1B18A8
	ADDQ.L	#6,A7
	MOVE.W	$1B293A,D0
	BEQ.B	$1B145A
	PEA	$1B29A8
	JSR	$1B210A
	ADDQ.L	#4,A7
	MOVE.W	D0,(-2,A6)
	BRA.B	$1B141A
	SUBQ.W	#1,(-2,A6)
	MOVE.W	(-2,A6),D0
	LEA	$1B29A8,A0
	MOVE.B	(0.B,A0,D0.W),D0
	EXT.W	D0
	CMP.W	#$5C,D0
	BNE.B	$1B1416
	MOVE.W	(-2,A6),D0
	LEA	$1B29A9,A0
	CLR.B	(0.B,A0,D0.W)
	MOVE.B	$1B29A8,D0
	EXT.W	D0
	SUB.W	#$41,D0
	MOVE.W	D0,-(A7)
	MOVE.W	#$E,-(A7)
	JSR	$1B1924
	ADDQ.L	#4,A7
	BRA.B	$1B145C
	BRA.B	$1B14A4
	PEA	$1B29A8
	MOVE.W	#$3B,-(A7)
	JSR	$1B1924
	ADDQ.L	#6,A7
	TST.W	D0
	BNE	$1B1060
	CLR.W	-(A7)
	MOVE.L	$1B28DE,-(A7)
	MOVE.W	#$3D,-(A7)
	JSR	$1B1924
	ADDQ.L	#8,A7
	MOVE.W	D0,(-4,A6)
	TST.W	(-4,A6)
	BLT	$1B1060
	MOVE.W	(-4,A6),-(A7)
	MOVE.W	#$3E,-(A7)
	JSR	$1B1924
	ADDQ.L	#4,A7
	CLR.L	-(A7)
	MOVE.W	#$20,-(A7)
	JSR	$1B1924
	ADDQ.L	#6,A7
	MOVE.L	D0,$1B28E6
	MOVE.W	$1B293A,D0
	BNE.B	$1B14C8
	MOVE.W	#0,D0
	BRA	$1B15FC
	CLR.W	-(A7)
	MOVE.L	$1B2A28,-(A7)
	MOVE.L	$1B2A28,-(A7)
	MOVE.W	#5,-(A7)
	JSR	$1B18E6
	LEA	($C,A7),A7
	MOVE.W	#7,-(A7)
	MOVE.W	#4,-(A7)
	MOVE.W	#3,-(A7)
	JSR	$1B18A8
	ADDQ.L	#6,A7
	MOVE.W	#4,-(A7)
	MOVE.W	#4,-(A7)
	MOVE.W	#3,-(A7)
	JSR	$1B18A8
	ADDQ.L	#6,A7
	MOVE.W	#9,-(A7)
	MOVE.W	#4,-(A7)
	MOVE.W	#3,-(A7)
	JSR	$1B18A8
	ADDQ.L	#6,A7
	CLR.W	-(A7)
	MOVE.W	#4,-(A7)
	MOVE.W	#3,-(A7)
	JSR	$1B18A8
	ADDQ.L	#6,A7
	CLR.W	-(A7)
	MOVE.W	#4,-(A7)
	MOVE.W	#3,-(A7)
	JSR	$1B18A8
	ADDQ.L	#6,A7
	CLR.W	-(A7)
	MOVE.W	#4,-(A7)
	MOVE.W	#3,-(A7)
	JSR	$1B18A8
	ADDQ.L	#6,A7
	CLR.W	-(A7)
	MOVE.W	#4,-(A7)
	MOVE.W	#3,-(A7)
	JSR	$1B18A8
	ADDQ.L	#6,A7
	MOVE.W	#$1B,-(A7)
	MOVE.W	#2,-(A7)
	JSR	$1B1924
	ADDQ.L	#4,A7
	MOVE.W	#$45,-(A7)
	MOVE.W	#2,-(A7)
	JSR	$1B1924
	ADDQ.L	#4,A7
	MOVEM.L	D0-D2/A1-A2,-(A7)
	LEA	$1B1600,A0
	PEA	$1B1600
	MOVEA.L	$1B293C,A1
	JSR	(A1)
	ADDQ.W	#4,A7
	MOVEM.L	(A7)+,D0-D2/A1-A2
	MOVEA.L	$1B28DE,A0
	JSR	$1AF8BA
	MOVE.W	D0,$1B25B6
	JSR	$1B17A6
	MOVE.L	$1B289C,-(A7)
	MOVE.L	$1B2A28,-(A7)
	MOVE.W	#$C8,-(A7)
	JSR	$1B0AAC
	LEA	($A,A7),A7
	MOVE.W	$1B25B6,D0
	BNE	$1B1024
	NOP
	MOVE.W	#$FF,-(A7)
	MOVE.W	#6,-(A7)
	JSR	$1B1924
	ADDQ.L	#4,A7
	TST.L	D0
	BNE.B	$1B15E4
	MOVE.W	#1,D0
	UNLK	A6
	RTS
	TBLU.B	D0:D0,D0
	ORI.B	#0,D0
	MOVEM.L	D0-D1/A0-A1,-(A7)
	MOVE	SR,-(A7)
	TST.B	$1B25B8
	BNE.B	$1B1650
	ORI	#$700,SR
	MOVEA.L	$456.W,A0
	MOVEQ	#7,D0
	TST.L	(A0)+
	BEQ.B	$1B1628
	DBF	D0,$1B161E
	BRA.B	$1B1650
	SUBQ.L	#4,A0
	LEA	$1B168C,A1
	MOVE.L	A1,(A0)
	MOVE.L	A0,$1B29A2
	CLR.W	$1B2952
	CLR.W	$1B2950
	CLR.W	$1B294E
	CLR.W	$1B294C
	ST	$1B25B8
	MOVE	(A7)+,SR
	MOVEM.L	(A7)+,D0-D1/A0-A1
	RTS
	MOVEM.L	D0/A0-A1,-(A7)
	MOVE	SR,-(A7)
	ORI	#$700,SR
	TST.B	$1B25B8
	BEQ.B	$1B1678
	MOVEA.L	$1B29A2,A0
	CLR.L	(A0)
	MOVE	(A7)+,SR
	SF	$1B25B8
	JSR	$1B17A6
	MOVEM.L	(A7)+,D0/A0-A1
	RTS
	MOVE	SR,-(A7)
	ORI	#$700,SR
	LEA	$FFFF8240,A3
	LEA	$1B2596,A0
	MOVE.W	(A0)+,D0
	MOVE.W	(A0)+,D1
	MOVE.W	(A0)+,D2
	MOVE.W	(A0)+,D3
	TST.W	D2
	BEQ.B	$1B16E0
	TST.W	D3
	BPL.B	$1B16B0
	EXG	D0,D1
	ADDQ.W	#1,$1B2952
	CMP.W	$1B2952,D2
	BNE.B	$1B16E0
	CLR.W	$1B2952
	LSL.L	#1,D0
	LSL.L	#1,D1
	MOVEA.L	A3,A1
	MOVEA.L	A1,A2
	ADDA.W	D1,A1
	ADDA.W	D0,A2
	MOVE.W	(A1),D7
	NEG.W	D3
	MOVE.W	(0.B,A1,D3.W),(A1)
	ADDA.W	D3,A1
	CMPA.L	A1,A2
	BNE.B	$1B16D4
	MOVE.W	D7,(A1)
	MOVE.W	(A0)+,D0
	MOVE.W	(A0)+,D1
	MOVE.W	(A0)+,D2
	MOVE.W	(A0)+,D3
	TST.W	D2
	BEQ.B	$1B1722
	TST.W	D3
	BPL.B	$1B16F2
	EXG	D0,D1
	ADDQ.W	#1,$1B2950
	CMP.W	$1B2950,D2
	BNE.B	$1B1722
	CLR.W	$1B2950
	LSL.L	#1,D0
	LSL.L	#1,D1
	MOVEA.L	A3,A1
	MOVEA.L	A1,A2
	ADDA.W	D1,A1
	ADDA.W	D0,A2
	MOVE.W	(A1),D7
	NEG.W	D3
	MOVE.W	(0.B,A1,D3.W),(A1)
	ADDA.W	D3,A1
	CMPA.L	A1,A2
	BNE.B	$1B1716
	MOVE.W	D7,(A1)
	MOVE.W	(A0)+,D0
	MOVE.W	(A0)+,D1
	MOVE.W	(A0)+,D2
	MOVE.W	(A0)+,D3
	TST.W	D2
	BEQ.B	$1B1764
	TST.W	D3
	BPL.B	$1B1734
	EXG	D0,D1
	ADDQ.W	#1,$1B294E
	CMP.W	$1B294E,D2
	BNE.B	$1B1764
	CLR.W	$1B294E
	LSL.L	#1,D0
	LSL.L	#1,D1
	MOVEA.L	A3,A1
	MOVEA.L	A1,A2
	ADDA.W	D1,A1
	ADDA.W	D0,A2
	MOVE.W	(A1),D7
	NEG.W	D3
	MOVE.W	(0.B,A1,D3.W),(A1)
	ADDA.W	D3,A1
	CMPA.L	A1,A2
	BNE.B	$1B1758
	MOVE.W	D7,(A1)
	MOVE.W	(A0)+,D0
	MOVE.W	(A0)+,D1
	MOVE.W	(A0)+,D2
	BEQ.B	$1B17A2
	MOVE.W	(A0)+,D3
	BPL.B	$1B1772
	EXG	D0,D1
	ADDQ.W	#1,$1B294C
	CMP.W	$1B294C,D2
	BNE.B	$1B17A2
	CLR.W	$1B294C
	LSL.L	#1,D0
	LSL.L	#1,D1
	MOVEA.L	A3,A1
	MOVEA.L	A1,A2
	ADDA.W	D1,A1
	ADDA.W	D0,A2
	MOVE.W	(A1),D7
	NEG.W	D3
	MOVE.W	(0.B,A1,D3.W),(A1)
	ADDA.W	D3,A1
	CMPA.L	A1,A2
	BNE.B	$1B1796
	MOVE.W	D7,(A1)
	MOVE	(A7)+,SR
	RTS
	MOVEM.L	D0-D2/A0-A1,-(A7)
	LEA	$1B28FC,A0
	MOVEA.L	#$FF8240,A1
	MOVEQ	#$F,D0
	MOVE.W	(A0)+,D1
	MOVE.W	D1,D2
	ANDI.W	#$111,D2
	ANDI.W	#$EEE,D1
	LSR.W	#1,D1
	LSL.W	#3,D2
	OR.W	D2,D1
	MOVE.W	D1,(A1)+
	DBF	D0,$1B17B8
	MOVEM.L	(A7)+,D0-D2/A0-A1
	RTS
	CLR.W	D0
	TST.B	(0.B,A0,D0.W)
	BEQ.B	$1B17E2
	ADDQ.W	#1,D0
	BRA.B	$1B17D8
	RTS
	LINK	A6,#0
	MOVE.W	#$13,-(A7)
	JSR	$1B2276
	ADDQ.L	#2,A7
	MOVE.W	#1,D0
	UNLK	A6
	RTS
	LINK	A6,#-2
	LEA	$1B2976,A0
	MOVE.L	A0,$1B2A32
	LEA	$1B2956,A0
	MOVE.L	A0,$1B2A36
	LEA	$1B2878,A0
	MOVE.L	A0,$1B2A3A
	LEA	$1B2AE8,A0
	MOVE.L	A0,$1B2A3E
	LEA	$1B2ADC,A0
	MOVE.L	A0,$1B2A42
	LEA	$1B292A,A0
	MOVE.L	A0,$1B2A46
	LEA	$1B2A32,A0
	MOVE.L	A0,$1B28EC
	MOVE.W	#$A,-(A7)
	JSR	$1B2276
	ADDQ.L	#2,A7
	MOVE.W	$1B2AE8,$1B28EA
	MOVE.W	$1B28EA,D0
	UNLK	A6
	RTS
	LINK	A6,#0
	MOVE.L	(8,A6),$1B2ADC
	MOVE.L	($C,A6),$1B2AE0
	MOVE.W	#$5A,-(A7)
	JSR	$1B2276
	ADDQ.L	#2,A7
	MOVEA.L	($10,A6),A0
	MOVE.W	$1B2AEA,(A0)
	MOVE.W	$1B2AE8,D0
	UNLK	A6
	RTS
	LEA	$1B2AA6,A0
	ADDA.W	$1B28F6,A0
	ADDQ.W	#4,$1B28F6
	MOVE.L	A1,(A0)
	MOVE.L	A2,($10,A0)
	MOVE.L	(A7)+,($20,A0)
	TRAP	#$D
	SUBQ.W	#4,$1B28F6
	LEA	$1B2AA6,A0
	ADDA.W	$1B28F6,A0
	MOVEA.L	(A0),A1
	MOVEA.L	($10,A0),A2
	MOVE.L	($20,A0),-(A7)
	TST.W	D0
	RTS
	LEA	$1B2AA6,A0
	ADDA.W	$1B28F6,A0
	ADDQ.W	#4,$1B28F6
	MOVE.L	A1,(A0)
	MOVE.L	A2,($10,A0)
	MOVE.L	(A7)+,($20,A0)
	TRAP	#$E
	SUBQ.W	#4,$1B28F6
	LEA	$1B2AA6,A0
	ADDA.W	$1B28F6,A0
	MOVEA.L	(A0),A1
	MOVEA.L	($10,A0),A2
	MOVE.L	($20,A0),-(A7)
	TST.W	D0
	RTS
	LEA	$1B2AA6,A0
	ADDA.W	$1B28F6,A0
	ADDQ.W	#4,$1B28F6
	MOVE.L	A1,(A0)
	MOVE.L	A2,($10,A0)
	MOVE.L	(A7)+,($20,A0)
	TRAP	#1
	SUBQ.W	#4,$1B28F6
	LEA	$1B2AA6,A0
	ADDA.W	$1B28F6,A0
	MOVEA.L	(A0),A1
	MOVEA.L	($10,A0),A2
	MOVE.L	($20,A0),-(A7)
	TST.W	D0
	RTS
	LINK	A6,#0
	MOVE.L	$1B265A,D0
	LEA	$1B281C,A0
	SUB.L	A0,D0
	ASR.L	#2,D0
	CMP.W	#8,D0
	BGE.B	$1B1992
	MOVEA.L	$1B265A,A0
	ADDQ.L	#4,$1B265A
	MOVE.L	(8,A6),(A0)
	MOVE.W	#1,D0
	BRA.B	$1B1996
	MOVE.W	#0,D0
	UNLK	A6
	RTS
	LINK	A6,#-2
	MOVEM.L	A5,-(A7)
	BRA.B	$1B19B4
	SUBQ.L	#4,$1B265A
	MOVEA.L	$1B265A,A0
	MOVEA.L	(A0),A0
	JSR	(A0)
	MOVE.L	$1B265A,D0
	LEA	$1B281C,A0
	SUB.L	A0,D0
	ASR.L	#2,D0
	BNE.B	$1B19A4
	LEA	$1B265E,A0
	MOVEA.L	A0,A5
	BRA.B	$1B19E8
	MOVE.W	($A,A5),D0
	AND.W	#$403,D0
	BEQ.B	$1B19E4
	MOVE.L	A5,-(A7)
	JSR	$1B1A10
	ADDQ.L	#4,A7
	ADDA.W	#$10,A5
	MOVE.L	A5,D0
	LEA	$1B265E,A0
	MOVE.L	A0,D1
	ADD.L	#$140,D1
	CMP.L	D1,D0
	BLT.B	$1B19D0
	MOVE.W	(8,A6),-(A7)
	JSR	$1B250C
	ADDQ.L	#2,A7
	MOVEM.L	(A7)+,A5
	UNLK	A6
	RTS
	LINK	A6,#0
	MOVEM.L	A5,-(A7)
	MOVEA.L	(8,A6),A5
	MOVE.W	($A,A5),D0
	AND.W	#2,D0
	BEQ.B	$1B1A38
	MOVE.L	A5,-(A7)
	JSR	$1B1A72
	ADDQ.L	#4,A7
	BEQ.B	$1B1A38
	MOVE.W	#-1,D0
	BRA.B	$1B1A6A
	MOVE.W	($A,A5),D0
	AND.W	#$10,D0
	BEQ.B	$1B1A4E
	MOVE.L	(6,A5),-(A7)
	JSR	$1B1DC0
	ADDQ.L	#4,A7
	CLR.W	($A,A5)
	MOVE.W	($C,A5),-(A7)
	JSR	$1B2524
	ADDQ.L	#2,A7
	BEQ.B	$1B1A66
	MOVE.W	#-1,D0
	BRA.B	$1B1A6A
	MOVE.W	#0,D0
	MOVEM.L	(A7)+,A5
	UNLK	A6
	RTS
	LINK	A6,#0
	MOVEM.L	D7/A5,-(A7)
	MOVEA.L	(8,A6),A5
	MOVE.W	($A,A5),D0
	AND.W	#$403,D0
	BNE.B	$1B1A8E
	MOVE.W	#-1,D0
	BRA.B	$1B1B00
	MOVE.L	(A5),D7
	SUB.L	(6,A5),D7
	MOVE.W	($A,A5),D0
	AND.W	#$80,D0
	BEQ.B	$1B1AF4
	MOVE.W	($A,A5),D0
	AND.W	#2,D0
	BNE.B	$1B1AAE
	MOVE.W	#-1,D0
	BRA.B	$1B1B00
	MOVE.W	($A,A5),D0
	AND.W	#4,D0
	BEQ.B	$1B1ACA
	MOVE.W	#2,-(A7)
	CLR.L	-(A7)
	MOVE.W	($C,A5),-(A7)
	JSR	$1B1B08
	ADDQ.L	#8,A7
	MOVE.W	D7,-(A7)
	MOVE.L	(6,A5),-(A7)
	MOVE.W	($C,A5),-(A7)
	JSR	$1B2150
	ADDQ.L	#8,A7
	CMPI.W	#$FFFF,D0
	BNE.B	$1B1AEE
	ORI.W	#$40,($A,A5)
	MOVE.W	#-1,D0
	BRA.B	$1B1B00
	ANDI.W	#$FF7F,($A,A5)
	MOVE.L	(6,A5),(A5)
	CLR.W	(4,A5)
	MOVE.W	#0,D0
	MOVEM.L	(A7)+,D7/A5
	UNLK	A6
	RTS
	LINK	A6,#-$E
	TST.W	(8,A6)
	BGE.B	$1B1B24
	MOVE.W	#-$25,$1B28A0
	MOVE.L	#-1,D0
	BRA	$1B1C6A
	MOVE.W	($E,A6),-(A7)
	MOVE.W	(8,A6),-(A7)
	MOVE.L	($A,A6),-(A7)
	MOVE.W	#$42,-(A7)
	JSR	$1B1924
	LEA	($A,A7),A7
	MOVE.L	D0,(-4,A6)
	TST.L	D0
	BLT.B	$1B1B4E
	MOVE.L	(-4,A6),D0
	BRA	$1B1C6A
	MOVE.W	#1,-(A7)
	MOVE.W	(8,A6),-(A7)
	CLR.L	-(A7)
	MOVE.W	#$42,-(A7)
	JSR	$1B1924
	LEA	($A,A7),A7
	MOVE.L	D0,(-8,A6)
	TST.L	D0
	BGE.B	$1B1B82
	MOVE.L	(-8,A6),D0
	MOVE.W	D0,$1B28A0
	MOVE.L	#-1,D0
	BRA	$1B1C6A
	MOVE.W	#2,-(A7)
	MOVE.W	(8,A6),-(A7)
	CLR.L	-(A7)
	MOVE.W	#$42,-(A7)
	JSR	$1B1924
	LEA	($A,A7),A7
	MOVE.L	D0,(-$C,A6)
	CMPI.W	#1,($E,A6)
	BNE.B	$1B1BB4
	MOVE.L	(-8,A6),D0
	ADD.L	($A,A6),D0
	MOVE.L	D0,($A,A6)
	BRA.B	$1B1BDA
	CMPI.W	#2,($E,A6)
	BNE.B	$1B1BCA
	MOVE.L	(-$C,A6),D0
	ADD.L	($A,A6),D0
	MOVE.L	D0,($A,A6)
	BRA.B	$1B1BDA
	MOVE.W	($E,A6),D0
	BEQ.B	$1B1BDA
	MOVE.L	#-1,D0
	BRA	$1B1C6A
	MOVE.L	($A,A6),D0
	CMP.L	(-$C,A6),D0
	BLE.B	$1B1C2C
	MOVE.W	(8,A6),-(A7)
	JSR	$1B1EDE
	ADDQ.L	#2,A7
	AND.W	#-$2001,D0
	TST.W	D0
	BNE.B	$1B1C0C
	MOVE.L	(-4,A6),D0
	MOVE.W	D0,$1B28A0
	MOVE.L	#-1,D0
	BRA.B	$1B1C6A
	BRA.B	$1B1C2C
	PEA	(-$E,A6)
	MOVE.L	($A,A6),D0
	SUB.L	(-$C,A6),D0
	MOVE.L	D0,-(A7)
	MOVE.W	(8,A6),-(A7)
	MOVE.W	#$40,-(A7)
	JSR	$1B1924
	LEA	($C,A7),A7
	CLR.W	-(A7)
	MOVE.W	(8,A6),-(A7)
	MOVE.L	($A,A6),-(A7)
	MOVE.W	#$42,-(A7)
	JSR	$1B1924
	LEA	($A,A7),A7
	TST.L	D0
	SLT	D0
	AND.W	#1,D0
	MOVE.W	D0,(-$E,A6)
	BEQ.B	$1B1C64
	MOVE.W	(-$E,A6),$1B28A0
	MOVE.L	#-1,D0
	BRA.B	$1B1C6A
	BRA.B	$1B1C6A
	MOVE.L	($A,A6),D0
	NOP
	UNLK	A6
	RTS
	LINK	A6,#0
	MOVEM.L	D7/A4-A5,-(A7)
	MOVE.L	#$418,D7
	MOVE.L	(8,A6),D1
	ADD.L	#$418,D1
	SUBQ.L	#1,D1
	MOVE.L	D1,-(A7)
	MOVE.L	#$418,D1
	MOVE.L	D1,-(A7)
	JSR	$1B247C
	MOVE.L	(A7)+,D1
	ADDQ.L	#4,A7
	MOVE.L	D7,-(A7)
	MOVE.L	D1,D7
	MOVE.L	D7,-(A7)
	JSR	$1B24CA
	MOVE.L	(A7)+,D7
	MOVE.L	D7,D0
	ASL.L	#3,D0
	MOVE.L	D0,-(A7)
	JSR	$1B205A
	ADDQ.L	#4,A7
	MOVEA.L	D0,A5
	CMPA.L	#-1,A5
	BNE.B	$1B1CCA
	MOVE.L	#0,D0
	BRA.B	$1B1CE4
	MOVEA.L	A5,A4
	MOVE.L	D7,(4,A4)
	MOVE.L	A4,D0
	ADDQ.L	#8,D0
	MOVE.L	D0,-(A7)
	JSR	$1B1DC0
	ADDQ.L	#4,A7
	MOVE.L	$1B27A0,D0
	MOVEM.L	(A7)+,D7/A4-A5
	UNLK	A6
	RTS
	LINK	A6,#0
	MOVEM.L	D7/A4-A5,-(A7)
	MOVE.L	#1,D7
	MOVE.L	(8,A6),D1
	ADDQ.L	#8,D1
	SUBQ.L	#1,D1
	MOVE.L	D1,-(A7)
	MOVE.L	#8,D1
	MOVE.L	D1,-(A7)
	JSR	$1B247C
	MOVE.L	(A7)+,D1
	ADDQ.L	#4,A7
	ADD.L	D1,D7
	MOVE.L	$1B27A0,D0
	MOVEA.L	D0,A4
	TST.L	D0
	BNE.B	$1B1D40
	LEA	$1B283C,A0
	MOVE.L	A0,D0
	MOVEA.L	D0,A4
	MOVE.L	D0,$1B27A0
	MOVE.L	D0,$1B283C
	CLR.L	$1B2840
	MOVEA.L	(A4),A5
	MOVE.L	(4,A5),D0
	CMP.L	D7,D0
	BCS.B	$1B1D74
	MOVE.L	(4,A5),D0
	CMP.L	D7,D0
	BNE.B	$1B1D56
	MOVE.L	(A5),(A4)
	BRA.B	$1B1D68
	MOVE.L	D7,D0
	SUB.L	D0,(4,A5)
	MOVE.L	(4,A5),D0
	ASL.L	#3,D0
	ADDA.L	D0,A5
	MOVE.L	D7,(4,A5)
	MOVE.L	A4,$1B27A0
	MOVE.L	A5,D0
	ADDQ.L	#8,D0
	BRA.B	$1B1D9C
	MOVE.L	A5,D0
	CMP.L	$1B27A0,D0
	BNE.B	$1B1D96
	MOVE.L	D7,-(A7)
	JSR	$1B1C6E
	ADDQ.L	#4,A7
	MOVEA.L	D0,A5
	TST.L	D0
	BNE.B	$1B1D96
	MOVE.L	#0,D0
	BRA.B	$1B1D9C
	MOVEA.L	A5,A4
	MOVEA.L	(A5),A5
	BRA.B	$1B1D42
	MOVEM.L	(A7)+,D7/A4-A5
	UNLK	A6
	RTS
	LINK	A6,#0
	MOVE.W	(8,A6),D0
	AND.L	#$FFFF,D0
	MOVE.L	D0,-(A7)
	JSR	$1B1CEC
	ADDQ.L	#4,A7
	UNLK	A6
	RTS
	LINK	A6,#0
	MOVEM.L	A4-A5,-(A7)
	MOVE.L	(8,A6),D0
	BNE.B	$1B1DD0
	BRA.B	$1B1E44
	MOVE.L	(8,A6),D0
	SUBQ.L	#8,D0
	MOVEA.L	D0,A5
	MOVEA.L	$1B27A0,A4
	BRA.B	$1B1DF6
	MOVE.L	A4,D0
	CMP.L	(A4),D0
	BLT.B	$1B1DF4
	MOVE.L	A5,D0
	CMP.L	A4,D0
	BGT.B	$1B1DF2
	MOVE.L	A5,D0
	CMP.L	(A4),D0
	BGE.B	$1B1DF4
	BRA.B	$1B1E02
	MOVEA.L	(A4),A4
	MOVE.L	A5,D0
	CMP.L	A4,D0
	BLE.B	$1B1DE0
	MOVE.L	A5,D0
	CMP.L	(A4),D0
	BGE.B	$1B1DE0
	MOVE.L	A5,D0
	MOVE.L	(4,A5),D1
	ASL.L	#3,D1
	ADD.L	D1,D0
	CMP.L	(A4),D0
	BNE.B	$1B1E20
	MOVEA.L	(A4),A0
	MOVE.L	(4,A0),D0
	ADD.L	D0,(4,A5)
	MOVEA.L	(A4),A0
	MOVE.L	(A0),(A5)
	BRA.B	$1B1E22
	MOVE.L	(A4),(A5)
	MOVE.L	A4,D0
	MOVE.L	(4,A4),D1
	ASL.L	#3,D1
	ADD.L	D1,D0
	CMP.L	A5,D0
	BNE.B	$1B1E3C
	MOVE.L	(4,A5),D0
	ADD.L	D0,(4,A4)
	MOVE.L	(A5),(A4)
	BRA.B	$1B1E3E
	MOVE.L	A5,(A4)
	MOVE.L	A4,$1B27A0
	MOVEM.L	(A7)+,A4-A5
	UNLK	A6
	RTS
	LINK	A6,#-2
	CLR.W	(-2,A6)
	BRA.B	$1B1E92
	MOVE.W	(-2,A6),D0
	ASL.W	#2,D0
	LEA	$1B2A4A,A0
	MOVE.W	(0.B,A0,D0.W),D0
	BNE.B	$1B1E8E
	MOVE.W	(-2,A6),D0
	ASL.W	#2,D0
	LEA	$1B2A4A,A0
	MOVE.W	(8,A6),(0.B,A0,D0.W)
	MOVE.W	(-2,A6),D0
	ASL.W	#2,D0
	LEA	$1B2A4A,A0
	MOVE.W	($A,A6),(2.B,A0,D0.W)
	BRA.B	$1B1E9A
	ADDQ.W	#1,(-2,A6)
	CMPI.W	#$17,(-2,A6)
	BLT.B	$1B1E56
	UNLK	A6
	RTS
	LINK	A6,#-2
	CLR.W	(-2,A6)
	BRA.B	$1B1ED2
	MOVE.W	(-2,A6),D0
	ASL.W	#2,D0
	LEA	$1B2A4A,A0
	MOVE.W	(0.B,A0,D0.W),D0
	CMP.W	(8,A6),D0
	BNE.B	$1B1ECE
	MOVE.W	(-2,A6),D0
	ASL.W	#2,D0
	LEA	$1B2A4A,A0
	CLR.W	(0.B,A0,D0.W)
	ADDQ.W	#1,(-2,A6)
	CMPI.W	#$17,(-2,A6)
	BLT.B	$1B1EA8
	UNLK	A6
	RTS
	LINK	A6,#-2
	MOVEM.L	D7,-(A7)
	MOVE.W	(8,A6),D7
	MOVE.W	#$5C,(-2,A6)
	LEA	$1B2A4A,A0
	MOVEA.L	A0,A1
	ADDA.W	(-2,A6),A1
	CMP.W	(A0),D7
	BEQ.B	$1B1F06
	ADDQ.W	#4,A0
	CMPA.L	A0,A1
	BNE.B	$1B1EFC
	MOVE.W	(2,A0),D0
	MOVEM.L	(A7)+,D7
	UNLK	A6
	RTS
	LINK	A6,#0
	MOVEM.L	D7,-(A7)
	PEA	$1B27A4
	MOVE.L	(8,A6),-(A7)
	JSR	$1B20D2
	ADDQ.L	#8,A7
	BNE.B	$1B1F34
	CLR.W	D7
	BRA	$1B2032
	PEA	$1B27AA
	MOVE.L	(8,A6),-(A7)
	JSR	$1B20D2
	ADDQ.L	#8,A7
	BNE.B	$1B1F50
	MOVE.W	#2,D7
	BRA	$1B2032
	PEA	$1B27B0
	MOVE.L	(8,A6),-(A7)
	JSR	$1B20D2
	ADDQ.L	#8,A7
	BNE.B	$1B1F6C
	MOVE.W	#3,D7
	BRA	$1B2032
	MOVE.W	($C,A6),D0
	AND.W	#4,D0
	BEQ.B	$1B1FC8
	MOVE.W	($C,A6),D0
	AND.W	#3,D0
	MOVE.W	D0,-(A7)
	MOVE.L	(8,A6),-(A7)
	MOVE.W	#$3D,-(A7)
	JSR	$1B1924
	ADDQ.L	#8,A7
	MOVE.W	D0,D7
	TST.W	D0
	BLT.B	$1B1FA0
	MOVE.W	($C,A6),D0
	AND.W	#$10,D0
	BEQ.B	$1B1FC6
	TST.W	D7
	BLT.B	$1B1FB2
	MOVE.W	D7,-(A7)
	MOVE.W	#$3E,-(A7)
	JSR	$1B1924
	ADDQ.L	#4,A7
	CLR.W	-(A7)
	MOVE.L	(8,A6),-(A7)
	MOVE.W	#$3C,-(A7)
	JSR	$1B1924
	ADDQ.L	#8,A7
	MOVE.W	D0,D7
	BRA.B	$1B2032
	MOVE.W	($C,A6),D0
	AND.W	#$10,D0
	BEQ.B	$1B2016
	MOVE.W	($C,A6),D0
	AND.W	#3,D0
	MOVE.W	D0,-(A7)
	MOVE.L	(8,A6),-(A7)
	MOVE.W	#$3D,-(A7)
	JSR	$1B1924
	ADDQ.L	#8,A7
	MOVE.W	D0,D7
	TST.W	D0
	BLT.B	$1B2014
	MOVE.W	D7,-(A7)
	MOVE.W	#$3E,-(A7)
	JSR	$1B1924
	ADDQ.L	#4,A7
	CLR.W	-(A7)
	MOVE.L	(8,A6),-(A7)
	MOVE.W	#$3C,-(A7)
	JSR	$1B1924
	ADDQ.L	#8,A7
	MOVE.W	D0,D7
	BRA.B	$1B2032
	MOVE.W	($C,A6),D0
	AND.W	#3,D0
	MOVE.W	D0,-(A7)
	MOVE.L	(8,A6),-(A7)
	MOVE.W	#$3D,-(A7)
	JSR	$1B1924
	ADDQ.L	#8,A7
	MOVE.W	D0,D7
	TST.W	D7
	BGE.B	$1B2042
	MOVE.W	D7,$1B28A0
	MOVE.W	#-1,D0
	BRA.B	$1B2052
	MOVE.W	($C,A6),-(A7)
	MOVE.W	D7,-(A7)
	JSR	$1B1E4C
	ADDQ.L	#4,A7
	MOVE.W	D7,D0
	MOVEM.L	(A7)+,D7
	UNLK	A6
	RTS
	LINK	A6,#-4
	MOVE.L	(8,A6),-(A7)
	MOVE.W	#$48,-(A7)
	JSR	$1B1924
	ADDQ.L	#6,A7
	MOVE.L	D0,(-4,A6)
	MOVE.L	(-4,A6),D0
	BNE.B	$1B2088
	MOVE.L	#-1,(-4,A6)
	MOVE.W	#-$27,$1B28A0
	MOVE.L	(-4,A6),D0
	UNLK	A6
	RTS
	LINK	A6,#0
	MOVE.W	(8,A6),D0
	AND.L	#$FFFF,D0
	MOVE.L	D0,-(A7)
	JSR	$1B205A
	ADDQ.L	#4,A7
	UNLK	A6
	RTS
	LINK	A6,#0
	MOVE.L	(8,A6),D0
	MOVEA.L	D0,A0
	MOVEA.L	($C,A6),A1
	MOVEQ	#-1,D1
	TST.B	(A0)+
	DBEQ	D1,$1B20BC
	BNE.B	$1B20BC
	SUBQ.L	#1,A0
	MOVE.B	(A1)+,(A0)+
	DBEQ	D1,$1B20C6
	BNE.B	$1B20C6
	UNLK	A6
	RTS
	MOVEM.L	(4,A7),A0-A1
	CLR.W	D0
	MOVE.B	(A0)+,D0
	BEQ.B	$1B20E4
	CMP.B	(A1)+,D0
	BEQ.B	$1B20DA
	SUBQ.L	#1,A1
	CLR.W	D1
	MOVE.B	(A1),D1
	BEQ.B	$1B20EC
	EXT.W	D0
	TST.W	D0
	BEQ.B	$1B20F2
	EXT.W	D1
	SUB.W	D1,D0
	RTS
	MOVEM.L	(4,A7),A0-A1
	MOVE.L	A0,D0
	MOVEQ	#-1,D1
	MOVE.B	(A1)+,(A0)+
	DBEQ	D1,$1B2100
	BNE.B	$1B2100
	RTS
	MOVEA.L	(4,A7),A0
	MOVEQ	#-1,D0
	BRA.B	$1B2116
	ADDQ.W	#1,D0
	SUBQ.L	#1,D0
	TST.B	(A0)+
	DBEQ	D0,$1B2116
	BNE.B	$1B2112
	NOT.L	D0
	RTS
	LINK	A6,#0
	CMPI.W	#$61,(8,A6)
	BLT.B	$1B2146
	CMPI.W	#$7A,(8,A6)
	BGT.B	$1B2146
	MOVE.W	(8,A6),D0
	SUB.W	#$61,D0
	ADD.W	#$41,D0
	BRA.B	$1B214C
	BRA.B	$1B214C
	MOVE.W	(8,A6),D0
	NOP
	UNLK	A6
	RTS
	LINK	A6,#-$206
	MOVEM.L	D6-D7/A3-A5,-(A7)
	MOVEA.L	($A,A6),A5
	MOVEA.L	A5,A4
	CLR.W	(-2,A6)
	CMPI.W	#1,(8,A6)
	BEQ.B	$1B217E
	MOVE.W	(8,A6),-(A7)
	JSR	$1B1EDE
	ADDQ.L	#2,A7
	AND.W	#$2000,D0
	BNE	$1B2220
	LEA	(-$206,A6),A0
	MOVEA.L	A0,A3
	MOVE.L	A4,D7
	SUB.L	A5,D7
	CMP.W	($E,A6),D7
	SCS	D7
	AND.W	#1,D7
	BRA.B	$1B2210
	MOVE.B	(A4)+,D0
	MOVE.B	D0,(A3)+
	EXT.W	D0
	CMP.W	#$A,D0
	BNE.B	$1B21AE
	MOVE.L	A3,D0
	SUBQ.L	#1,D0
	MOVEA.L	D0,A0
	MOVE.B	#$D,(A0)
	MOVE.B	#$A,(A3)+
	MOVE.L	A4,D7
	SUB.L	A5,D7
	CMP.W	($E,A6),D7
	SCS	D7
	AND.W	#1,D7
	MOVE.L	A3,D0
	LEA	(-$206,A6),A0
	SUB.L	A0,D0
	CMP.W	#$1FE,D0
	BGE.B	$1B21CE
	MOVE.W	D7,D0
	BNE.B	$1B2210
	MOVE.L	A3,D0
	LEA	(-$206,A6),A0
	SUB.L	A0,D0
	EXT.L	D0
	MOVE.L	D0,(-6,A6)
	PEA	(-$206,A6)
	MOVE.L	(-6,A6),-(A7)
	MOVE.W	(8,A6),-(A7)
	MOVE.W	#$40,-(A7)
	JSR	$1B1924
	LEA	($C,A7),A7
	MOVE.W	D0,D6
	CMP.L	(-6,A6),D0
	BEQ.B	$1B220A
	MOVE.W	D6,$1B28A0
	MOVE.W	#-1,D0
	BRA.B	$1B226E
	LEA	(-$206,A6),A0
	MOVEA.L	A0,A3
	MOVE.W	D7,D0
	BNE	$1B2194
	MOVE.L	A4,D0
	SUB.L	A5,D0
	MOVE.W	D0,(-2,A6)
	BRA.B	$1B226A
	MOVE.L	A5,-(A7)
	MOVE.W	($E,A6),D0
	AND.L	#$FFFF,D0
	MOVE.L	D0,-(A7)
	MOVE.W	(8,A6),-(A7)
	MOVE.W	#$40,-(A7)
	JSR	$1B1924
	LEA	($C,A7),A7
	MOVE.L	D0,(-6,A6)
	MOVE.W	($E,A6),D1
	AND.L	#$FFFF,D1
	CMP.L	D1,D0
	BEQ.B	$1B2262
	MOVE.L	(-6,A6),D0
	MOVE.W	D0,$1B28A0
	MOVE.W	#-1,D0
	BRA.B	$1B226E
	MOVE.L	(-6,A6),D0
	ADD.W	D0,(-2,A6)
	MOVE.W	(-2,A6),D0
	MOVEM.L	(A7)+,D6-D7/A3-A5
	UNLK	A6
	RTS
	LINK	A6,#-6
	MOVE.W	(8,A6),$1B2976
	MOVE.W	(8,A6),D0
	SUB.W	#$A,D0
	MULS.W	#3,D0
	LEA	$1B2320,A0
	EXT.L	D0
	ADD.L	A0,D0
	MOVE.L	D0,(-6,A6)
	MOVE.W	#1,(-2,A6)
	BRA.B	$1B22C4
	MOVEA.L	(-6,A6),A0
	ADDQ.L	#1,(-6,A6)
	MOVE.B	(A0),D0
	MOVE.W	(-2,A6),D1
	ASL.W	#1,D1
	LEA	$1B2976,A0
	EXT.W	D0
	MOVE.W	D0,(0.B,A0,D1.W)
	ADDQ.W	#1,(-2,A6)
	CMPI.W	#4,(-2,A6)
	BLT.B	$1B22A4
	MOVE.L	$1B28EC,-(A7)
	JSR	$1B22E4
	ADDQ.L	#4,A7
	MOVE.W	$1B2AE8,D0
	UNLK	A6
	RTS
	LEA	$1B2AA6,A0
	ADDA.W	$1B28F6,A0
	ADDQ.W	#4,$1B28F6
	MOVE.L	A1,(A0)
	MOVE.L	A2,($10,A0)
	MOVE.L	(4,A7),D1
	MOVE.W	#$C8,D0
	TRAP	#2
	SUBQ.W	#4,$1B28F6
	LEA	$1B2AA6,A0
	ADDA.W	$1B28F6,A0
	MOVEA.L	(A0),A1
	MOVEA.L	($10,A0),A2
	RTS
	ORI.B	#2,D1
	BTST	D0,D1
	ANDI.B	#0,D1
	BTST	D0,D1
	ANDI.B	#1,D1
	BTST	D0,D1
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#3,D1
	BTST	D2,D0
	BTST	D2,D5
	ORI.B	#1,D0
	ANDI.B	#$10,D1
	BTST	D3,D1
	ANDI.B	#0,D1
	ORI.B	#0,D0
	ORI.B	#0,D0
	BTST	D0,D1
	BTST	D0,D2
	BTST	D0,D1
	ANDI.B	#2,D1
	BTST	D0,D1
	BTST	D0,D1
	ANDI.B	#1,D1
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ANDI.B	#1,D1
	BTST	D0,D1
	ADDI.B	#4,D1
	BTST	D0,D1
	BTST	D0,D3
	BTST	D0,D2
	BTST	D0,D1
	SUBI.B	#8,D2
	BTST	D0,D1
	ORI.B	#0,D0
	ORI.B	#1,D0
	MOVEP.W	($101,A1),D0
	BTST	D0,D1
	BTST	D0,D1
	BTST	D0,D0
	ORI.B	#3,D5
	BTST	D1,D1
	ANDI.B	#0,D2
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#3,D0
	DC.W	8
	BTST	D1,D0
	ADDI.B	#8,D1
	BTST	D0,D0
	BTST	#4,D1
	BTST	D0,D1
	BTST	D1,D1
	BTST	D0,D0
	BTST	D2,D0
	BTST	D0,D1
	BTST	D0,D0
	BTST	D2,D0
	ORI.B	#0,D1
	BTST	D0,D1
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D2
	ANDI.B	#0,D3
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#1,D0
	ORI.B	#0,D5
	BTST	D0,D1
	ORI.B	#0,D1
	ANDI.B	#6,D5
	BTST	D0,D0
	ANDI.B	#1,D1
	BTST	D0,D0
	ADDI.B	#0,D5
	ORI.B	#1,D0
	BTST	D0,D0
	BTST	D0,D0
	ANDI.B	#2,D1
	BTST	D0,D1
	BTST	D0,D1
	BTST	D0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#1,D0
	ANDI.B	#2,D3
	BTST	D0,D1
	BTST	D0,D1
	BTST	D0,D1
	ORI.B	#0,D1
	BTST	D0,D2
	LINK	A6,#0
	MOVEM.L	D0-D3,-(A7)
	MOVE.L	(8,A6),D2
	BNE.B	$1B2494
	DIVU.W	#0,D0
	CLR.L	D0
	CLR.L	D1
	BRA.B	$1B24BA
	MOVE.L	($C,A6),D1
	CLR.L	D0
	MOVEQ	#1,D3
	CMP.L	D1,D2
	BCC.B	$1B24AC
	ASL.L	#1,D2
	BCC.B	$1B24A8
	ROXR.L	#1,D2
	BRA.B	$1B24AC
	ASL.L	#1,D3
	BRA.B	$1B249C
	CMP.L	D1,D2
	BHI.B	$1B24B4
	OR.L	D3,D0
	SUB.L	D2,D1
	LSR.L	#1,D2
	LSR.L	#1,D3
	BCC.B	$1B24AC
	MOVE.L	D0,(8,A6)
	MOVE.L	D1,($C,A6)
	MOVEM.L	(A7)+,D0-D3
	UNLK	A6
	RTS
	LINK	A6,#0
	MOVEM.L	D0-D3,-(A7)
	MOVEM.L	(8,A6),D1-D2
	MOVE.L	D1,D3
	ANDI.L	#$FFFF0000,D3
	BEQ.B	$1B24E6
	SWAP	D3
	MULU.W	D2,D3
	MOVE.L	D2,D0
	SWAP	D0
	TST.W	D0
	BEQ.B	$1B24F2
	MULU.W	D1,D0
	ADD.W	D0,D3
	SWAP	D3
	CLR.W	D3
	MULU.W	D1,D2
	ADD.L	D2,D3
	MOVE.L	D3,($C,A6)
	MOVEM.L	(A7)+,D0-D3
	UNLK	A6
	MOVE.L	(A7)+,(A7)
	TST.L	(4,A7)
	RTS
	LINK	A6,#0
	MOVE.W	(8,A6),-(A7)
	MOVE.W	#$4C,-(A7)
	JSR	$1B1924
	ADDQ.L	#4,A7
	UNLK	A6
	RTS
	LINK	A6,#-2
	MOVE.W	(8,A6),-(A7)
	JSR	$1B1E9E
	ADDQ.L	#2,A7
	TST.W	(8,A6)
	BGT.B	$1B2540
	MOVE.W	#0,D0
	BRA.B	$1B256C
	MOVE.W	(8,A6),-(A7)
	MOVE.W	#$3E,-(A7)
	JSR	$1B1924
	ADDQ.L	#4,A7
	MOVE.W	D0,(-2,A6)
	BEQ.B	$1B2566
	MOVE.W	(-2,A6),$1B28A0
	MOVE.W	#-1,D0
	BRA.B	$1B256C
	BRA.B	$1B256C
	MOVE.W	#0,D0
	NOP
	UNLK	A6
	RTS
	ORI.B	#0,D1
	ORI.B	#1,D0
	ORI.B	#0,D0
	DC.W	$FFFF
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	DC.W	$FFFF
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	DC.W	$F
	ORI.B	#2,D5
	ORI.B	#4,D0
	ORI.B	#2,D0
	ORI.B	#7,D5
	ORI.B	#2,D0
	DC.W	8
	DC.W	$F
	ORI.B	#2,D0
	ORI.B	#0,D0
	NEG.W	-(A5)
	BGE.B	$1B2633
	MOVEQ	#$65,D4
	MOVEA.L	(A0),A0
	BSR.B	$1B262D
	BGT.B	$1B263A
	MOVEA.L	(A3),A0
	ADDQ.B	#2,-(A0)
	ADDQ.W	#3,($6577,A1)
	BCS.B	$1B2642
	MOVEA.L	([$2E20312E.L,A6],$300A.W),A0
	ORI.B	#$65,D0
	BGE.B	$1B2645
	BLS.B	$1B2656
	MOVEA.L	([$7475.W,A0],$7265206F.L),A0
	MOVEQ	#$20,D1
	BSR.B	$1B265E
	BVS.B	$1B265F
	BSR.B	$1B2668
	BVS.B	$1B2665
	BGT.B	$1B2618
	MOVEQ	#$6F,D2
	MOVEA.L	($6F61,A4),A0
	BCC.B	$1B262E
	EORI.B	#$61,D0
	BGT.B	$1B2669
	BCS.B	$1B2674
	MOVEA.L	($5175.W,A4,D6.L*8),A0
	BVS.B	$1B2684
	MOVE.L	A2,D7
	ORI.B	#$31,D0
	MOVE.W	$30204172,-(A4)
	MOVEQ	#$69,D2
	DC.W	$7354
	BCS.B	$1B2685
	BVC.B	$1B2644
	NEG.W	-(A5)
	MOVEQ	#$65,D3
	BGE.B	$1B2699
	MOVEQ	#$6D,D0
	BCS.B	$1B269C
	MOVEQ	#$A,D2
	ORI.B	#$6F,D0
	MOVEQ	#$20,D1
	DC.W	$456C
	BCS.B	$1B269D
	MOVEQ	#$72,D2
	BLE.B	$1B26AC
	BVS.B	$1B26A3
	MOVEA.L	D1,A0
	MOVEQ	#$74,D1
	DC.W	$7320
	DC.W	$4C74
	BCC.B	$1B2678
	ORI.B	#$3A,D0
	ORI.B	#$2A,D0
	MOVE.L	(0,A2),D7
	ORI.B	#0,D0
	ORI.B	#$1C,(A3)+
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#9,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#2,D0
	ORI.B	#0,D1
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#2,D0
	ORI.B	#0,D1
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ANDI.B	#0,D0
	ORI.B	#$4F,D0
	DC.W	$4E3A
	ORI.B	#$55,D0
	DC.W	$583A
	ORI.B	#$52,D0
	DC.W	$543A
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ORI.B	#0,D0
	ANDI.B	#0,D0
