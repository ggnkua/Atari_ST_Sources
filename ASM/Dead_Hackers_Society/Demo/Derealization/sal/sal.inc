 dc.w 9  ; NUMCAM    
 dc.w 374  ; NUMVERTS  
 dc.w 1728  ; TNUMVERTS 
 dc.w 576  ; NUMFACES  
 dc.s 0.927295  ; camera_fov 
 dc.l camera_sal  ; camera     
 dc.l coords_sal  ; coords     
 dc.l faces_sal   ; faces      
 dc.l tcoords_sal ; tcoords    
 dc.l tex_sal+20 ; palette    
 dc.l textures_sal ; textures    
textures_sal: 
 dc.l tex_sal+20+768+256*256*5 
 dc.l tex_sal+20+768+256*256*4 
 dc.l tex_sal+20+768+256*256*3 
 dc.l tex_sal+20+768+256*256*2 
 dc.l tex_sal+20+768+256*256*1 
 dc.l tex_sal+20+768+256*256*0 
tex_sal: incbin "sal\saltxt3.apx"
camera_sal:				;x,y,z , rx,ry,rz,rw , time
	dc.s -1.012200,0.545000,-0.064600,-0.100400,-0.992900,-0.064200,1.144500,0.000000
	dc.s -1.012200,0.545000,-0.064600,-0.100400,-0.992900,-0.064200,1.144500,0.000000
	dc.s 0.110000,0.545000,-0.451300,-0.043600,-0.996000,-0.078400,2.129200,0.166700
	dc.s 1.076300,0.545000,-0.098000,-0.055300,-0.992400,0.109600,4.071000,0.333300
	dc.s -0.260400,0.265000,0.720300,0.125500,-0.990100,-0.062300,5.353700,0.500000
	dc.s -0.511900,0.055000,0.138200,-0.472400,0.862100,-0.183200,5.437600,0.666700
	dc.s 0.783100,0.055000,-0.182500,-0.859800,0.482600,-0.167100,5.517400,0.833300
	dc.s 0.783100,0.425000,-0.182500,-0.645400,0.759200,-0.083800,5.944400,1.000000
	dc.s 0.783100,0.425000,-0.182500,-0.645400,0.759200,-0.083800,5.944400,1.000000
coords_sal:				;x,y,z
	dc.s	-1.297522,0.020982,0.748504
	dc.s	1.347522,0.020982,0.748504
	dc.s	1.347522,0.020982,-0.848504
	dc.s	-1.297522,0.020982,-0.848504
	dc.s	0.025000,0.020982,-0.050000
	dc.s	1.347522,0.020982,-0.050000
	dc.s	0.025000,0.020982,0.748504
	dc.s	-1.297522,0.020982,-0.050000
	dc.s	0.025000,0.020982,-0.848504
	dc.s	-0.636261,0.020982,0.349252
	dc.s	0.025000,0.020982,0.349252
	dc.s	-0.636261,0.020982,0.748504
	dc.s	1.347522,0.020982,-0.449252
	dc.s	0.686261,0.020982,-0.050000
	dc.s	0.686261,0.020982,-0.449252
	dc.s	0.686261,0.020982,0.349252
	dc.s	1.347522,0.020982,0.349252
	dc.s	0.686261,0.020982,0.748504
	dc.s	-0.636261,0.020982,-0.050000
	dc.s	-1.297522,0.020982,0.349252
	dc.s	-0.636261,0.020982,-0.848504
	dc.s	-0.636261,0.020982,-0.449252
	dc.s	-1.297522,0.020982,-0.449252
	dc.s	0.686261,0.020982,-0.848504
	dc.s	0.025000,0.020982,-0.449252
	dc.s	-0.966892,0.020982,0.548878
	dc.s	-0.636261,0.020982,0.548878
	dc.s	-0.966892,0.020982,0.748504
	dc.s	-0.305631,0.020982,0.349252
	dc.s	-0.305631,0.020982,0.149626
	dc.s	0.025000,0.020982,0.149626
	dc.s	-0.305630,0.020982,0.748504
	dc.s	-0.305631,0.020982,0.548878
	dc.s	0.025000,0.020982,0.548878
	dc.s	1.347522,0.020982,-0.648878
	dc.s	1.016892,0.020982,-0.449252
	dc.s	1.016892,0.020982,-0.648878
	dc.s	1.016892,0.020982,-0.249626
	dc.s	1.347522,0.020982,-0.249626
	dc.s	1.016892,0.020982,-0.050000
	dc.s	0.355631,0.020982,-0.249626
	dc.s	0.686261,0.020982,-0.249626
	dc.s	0.355631,0.020982,-0.050000
	dc.s	0.355631,0.020982,0.548878
	dc.s	0.686261,0.020982,0.548878
	dc.s	0.355631,0.020982,0.748504
	dc.s	1.016892,0.020982,0.149626
	dc.s	1.347522,0.020982,0.149626
	dc.s	1.016892,0.020982,0.349252
	dc.s	1.016892,0.020982,0.548878
	dc.s	1.347522,0.020982,0.548878
	dc.s	1.016892,0.020982,0.748504
	dc.s	0.355631,0.020982,0.349252
	dc.s	0.355631,0.020982,0.149626
	dc.s	0.686261,0.020982,0.149626
	dc.s	-0.966892,0.020982,-0.050000
	dc.s	-0.966892,0.020982,0.149626
	dc.s	-1.297522,0.020982,0.149626
	dc.s	-0.636261,0.020982,0.149626
	dc.s	-0.305631,0.020982,-0.050000
	dc.s	-1.297522,0.020982,0.548878
	dc.s	-0.966892,0.020982,0.349252
	dc.s	-1.297522,0.020982,-0.648878
	dc.s	-0.966892,0.020982,-0.848504
	dc.s	-0.966892,0.020982,-0.648878
	dc.s	-0.636261,0.020982,-0.648878
	dc.s	-0.305631,0.020982,-0.848504
	dc.s	-0.305631,0.020982,-0.648878
	dc.s	-0.966892,0.020982,-0.449252
	dc.s	-0.966892,0.020982,-0.249626
	dc.s	-1.297522,0.020982,-0.249626
	dc.s	0.355631,0.020982,-0.848504
	dc.s	0.355631,0.020982,-0.648878
	dc.s	0.025000,0.020982,-0.648878
	dc.s	1.016892,0.020982,-0.848504
	dc.s	0.686261,0.020982,-0.648878
	dc.s	0.355631,0.020982,-0.449252
	dc.s	0.025000,0.020982,-0.249626
	dc.s	-0.305631,0.020982,-0.449252
	dc.s	-0.305631,0.020982,-0.249626
	dc.s	-0.636261,0.020982,-0.249626
	dc.s	-1.297522,1.069018,0.748504
	dc.s	1.347522,1.069018,0.748504
	dc.s	1.347522,1.069018,-0.848504
	dc.s	-1.297522,1.069018,-0.848504
	dc.s	0.025000,1.069018,-0.050000
	dc.s	0.025000,1.069018,-0.848504
	dc.s	-1.297522,1.069018,-0.050000
	dc.s	0.025000,1.069018,0.748504
	dc.s	1.347522,1.069018,-0.050000
	dc.s	-0.636261,1.069018,0.349252
	dc.s	-0.636261,1.069018,-0.050000
	dc.s	-1.297522,1.069018,0.349252
	dc.s	0.686261,1.069018,-0.449252
	dc.s	0.686261,1.069018,-0.848504
	dc.s	0.025000,1.069018,-0.449252
	dc.s	-0.636261,1.069018,-0.449252
	dc.s	-0.636261,1.069018,-0.848504
	dc.s	-1.297522,1.069018,-0.449252
	dc.s	0.025000,1.069018,0.349252
	dc.s	-0.636261,1.069018,0.748504
	dc.s	0.686261,1.069018,0.748504
	dc.s	1.347522,1.069018,0.349252
	dc.s	-0.305631,1.069018,-0.848504
	dc.s	-0.636261,1.069018,-0.648878
	dc.s	-0.966892,1.069018,-0.648878
	dc.s	-0.966892,1.069018,-0.848504
	dc.s	-1.297522,1.069018,-0.648878
	dc.s	-0.636261,1.069018,-0.249626
	dc.s	-0.305631,1.069018,-0.249626
	dc.s	-0.305631,1.069018,-0.449252
	dc.s	0.025000,1.069018,0.548878
	dc.s	-0.305631,1.069018,0.548878
	dc.s	-0.305631,1.069018,0.748504
	dc.s	0.025000,1.069018,0.149626
	dc.s	-0.305631,1.069018,0.349252
	dc.s	-0.636261,1.069018,0.548878
	dc.s	-0.966892,1.069018,0.748504
	dc.s	0.355631,1.069018,0.748504
	dc.s	0.686261,1.069018,0.548878
	dc.s	0.355631,1.069018,0.548878
	dc.s	1.016892,1.069018,0.748504
	dc.s	1.347522,1.069018,0.548878
	dc.s	1.016892,1.069018,0.548878
	dc.s	1.016892,1.069018,0.349252
	dc.s	1.347522,1.069018,0.149626
	dc.s	1.016892,1.069018,0.149626
	dc.s	0.355631,1.069018,-0.050000
	dc.s	0.686261,1.069018,-0.249626
	dc.s	1.016892,1.069018,-0.050000
	dc.s	1.347522,1.069018,-0.249626
	dc.s	1.016892,1.069018,-0.249626
	dc.s	1.016892,1.069018,-0.449252
	dc.s	1.347522,1.069018,-0.648878
	dc.s	0.355631,1.069018,0.349252
	dc.s	0.686261,1.069018,0.149626
	dc.s	0.355631,1.069018,0.149626
	dc.s	0.686261,1.069018,0.349252
	dc.s	0.686261,1.069018,-0.050000
	dc.s	1.347522,1.069018,-0.449252
	dc.s	-0.966892,1.069018,0.548878
	dc.s	-0.966892,1.069018,0.349252
	dc.s	-1.297522,1.069018,0.548878
	dc.s	-0.305631,1.069018,0.149626
	dc.s	-0.305631,1.069018,-0.050000
	dc.s	-0.636261,1.069018,0.149626
	dc.s	-0.966892,1.069018,0.149626
	dc.s	-0.966892,1.069018,-0.050000
	dc.s	-1.297522,1.069018,0.149626
	dc.s	0.355631,1.069018,-0.249626
	dc.s	0.355631,1.069018,-0.449252
	dc.s	0.025000,1.069018,-0.249626
	dc.s	1.016892,1.069018,-0.648878
	dc.s	1.016892,1.069018,-0.848504
	dc.s	0.686261,1.069018,-0.648878
	dc.s	0.355631,1.069018,-0.648878
	dc.s	0.355631,1.069018,-0.848504
	dc.s	0.025000,1.069018,-0.648878
	dc.s	-0.966892,1.069018,-0.249626
	dc.s	-0.966892,1.069018,-0.449252
	dc.s	-1.297522,1.069018,-0.249626
	dc.s	-0.305631,1.069018,-0.648878
	dc.s	-0.305631,0.413995,0.748504
	dc.s	-0.305631,0.545000,0.748504
	dc.s	-0.636261,0.413995,0.748504
	dc.s	-0.966892,0.413995,0.748504
	dc.s	-0.966892,0.545000,0.748504
	dc.s	-1.297522,0.413995,0.748504
	dc.s	0.355631,0.676005,0.748504
	dc.s	0.355631,0.807009,0.748504
	dc.s	0.025000,0.676005,0.748504
	dc.s	1.016892,0.938014,0.748504
	dc.s	1.016892,1.069018,0.748504
	dc.s	0.686261,0.938014,0.748504
	dc.s	0.355631,0.938014,0.748504
	dc.s	0.355631,1.069018,0.748504
	dc.s	0.025000,0.938014,0.748504
	dc.s	-0.966892,0.676005,0.748504
	dc.s	-0.966892,0.807009,0.748504
	dc.s	-1.297522,0.676005,0.748504
	dc.s	-0.305631,0.938014,0.748504
	dc.s	-0.305631,1.069018,0.748504
	dc.s	-0.636261,0.938014,0.748504
	dc.s	-0.966892,0.938014,0.748504
	dc.s	-0.966892,1.069018,0.748504
	dc.s	-1.297522,0.938014,0.748504
	dc.s	-0.305631,0.676005,0.748504
	dc.s	0.025000,0.545000,0.748504
	dc.s	0.025000,1.069018,0.748504
	dc.s	-1.297522,0.545000,0.748504
	dc.s	0.025000,0.020982,0.748504
	dc.s	1.347522,0.545000,0.748504
	dc.s	-0.636261,0.282991,0.748504
	dc.s	-0.636261,0.545000,0.748504
	dc.s	-1.297522,0.282991,0.748504
	dc.s	0.686261,0.807009,0.748504
	dc.s	0.686261,1.069018,0.748504
	dc.s	0.025000,0.807009,0.748504
	dc.s	-0.636261,0.807009,0.748504
	dc.s	-0.636261,1.069018,0.748504
	dc.s	-1.297522,0.807009,0.748504
	dc.s	-0.636261,0.020982,0.748504
	dc.s	0.025000,0.282991,0.748504
	dc.s	0.686261,0.020982,0.748504
	dc.s	1.347522,0.282991,0.748504
	dc.s	0.686261,0.282991,0.748504
	dc.s	0.686261,0.545000,0.748504
	dc.s	1.347522,0.807009,0.748504
	dc.s	-0.966892,0.151986,0.748504
	dc.s	-0.966892,0.282991,0.748504
	dc.s	-1.297522,0.151986,0.748504
	dc.s	-0.305631,0.807009,0.748504
	dc.s	-0.636261,0.676005,0.748504
	dc.s	-0.966892,0.020982,0.748504
	dc.s	-0.636261,0.151986,0.748504
	dc.s	0.025000,0.151986,0.748504
	dc.s	-0.305631,0.151986,0.748504
	dc.s	-0.305630,0.020982,0.748504
	dc.s	0.025000,0.413995,0.748504
	dc.s	-0.305631,0.282991,0.748504
	dc.s	0.355631,0.020982,0.748504
	dc.s	0.686261,0.151986,0.748504
	dc.s	0.355631,0.151986,0.748504
	dc.s	1.016892,0.020982,0.748504
	dc.s	1.347522,0.151986,0.748504
	dc.s	1.016892,0.151986,0.748504
	dc.s	1.016892,0.282991,0.748504
	dc.s	1.347522,0.413995,0.748504
	dc.s	1.016892,0.413995,0.748504
	dc.s	0.355631,0.545000,0.748504
	dc.s	0.686261,0.676005,0.748504
	dc.s	1.016892,0.545000,0.748504
	dc.s	1.347522,0.676005,0.748504
	dc.s	1.016892,0.676005,0.748504
	dc.s	1.016892,0.807009,0.748504
	dc.s	1.347522,0.938014,0.748504
	dc.s	0.355631,0.282991,0.748504
	dc.s	0.686261,0.413995,0.748504
	dc.s	0.355631,0.413995,0.748504
	dc.s	-1.297522,0.020982,0.748504
	dc.s	1.347522,0.020982,0.748504
	dc.s	-1.297522,1.069018,0.748504
	dc.s	1.347522,1.069018,0.748504
	dc.s	0.025000,0.545000,-0.848504
	dc.s	1.347522,0.545000,-0.848504
	dc.s	0.025000,0.020982,-0.848504
	dc.s	-1.297522,0.545000,-0.848504
	dc.s	0.025000,1.069018,-0.848504
	dc.s	-0.636261,0.282991,-0.848504
	dc.s	0.025000,0.282991,-0.848504
	dc.s	-0.636261,0.020982,-0.848504
	dc.s	0.686261,0.807009,-0.848504
	dc.s	-0.305631,0.413995,-0.848504
	dc.s	0.025000,0.413995,-0.848504
	dc.s	-0.305631,0.020982,-0.848504
	dc.s	-0.305631,0.151986,-0.848504
	dc.s	0.025000,0.151986,-0.848504
	dc.s	0.355631,0.676005,-0.848504
	dc.s	0.686261,0.676005,-0.848504
	dc.s	0.355631,0.545000,-0.848504
	dc.s	1.016892,0.938014,-0.848504
	dc.s	1.347522,0.938014,-0.848504
	dc.s	1.016892,0.807009,-0.848504
	dc.s	1.016892,0.676005,-0.848504
	dc.s	1.347522,0.676005,-0.848504
	dc.s	1.016892,0.545000,-0.848504
	dc.s	0.355631,0.151986,-0.848504
	dc.s	0.686261,0.151986,-0.848504
	dc.s	0.355631,0.020982,-0.848504
	dc.s	1.016892,0.413995,-0.848504
	dc.s	1.347522,0.020982,-0.848504
	dc.s	-1.297522,0.020982,-0.848504
	dc.s	1.347522,1.069018,-0.848504
	dc.s	-1.297522,1.069018,-0.848504
	dc.s	1.347522,0.413995,-0.848504
	dc.s	1.016892,0.282991,-0.848504
	dc.s	1.016892,0.151986,-0.848504
	dc.s	1.347522,0.151986,-0.848504
	dc.s	1.016892,0.020982,-0.848504
	dc.s	0.355631,0.282991,-0.848504
	dc.s	0.355631,0.413995,-0.848504
	dc.s	0.686261,0.413995,-0.848504
	dc.s	-1.297522,0.151986,-0.848504
	dc.s	-0.966892,0.282991,-0.848504
	dc.s	-1.297522,0.413995,-0.848504
	dc.s	-0.966892,0.545000,-0.848504
	dc.s	-0.966892,0.413995,-0.848504
	dc.s	-0.636261,0.413995,-0.848504
	dc.s	-0.305631,0.545000,-0.848504
	dc.s	-1.297522,0.676005,-0.848504
	dc.s	-0.966892,0.807009,-0.848504
	dc.s	-0.966892,0.676005,-0.848504
	dc.s	-1.297522,0.938014,-0.848504
	dc.s	-0.966892,1.069018,-0.848504
	dc.s	-0.966892,0.938014,-0.848504
	dc.s	-0.636261,0.938014,-0.848504
	dc.s	-0.305631,1.069018,-0.848504
	dc.s	-0.305631,0.938014,-0.848504
	dc.s	0.025000,0.676005,-0.848504
	dc.s	0.355631,0.807009,-0.848504
	dc.s	0.025000,0.938014,-0.848504
	dc.s	0.355631,1.069018,-0.848504
	dc.s	0.355631,0.938014,-0.848504
	dc.s	0.686261,0.938014,-0.848504
	dc.s	1.016892,1.069018,-0.848504
	dc.s	-0.305631,0.676005,-0.848504
	dc.s	-0.636261,0.676005,-0.848504
	dc.s	-0.305631,0.807009,-0.848504
	dc.s	1.347522,0.807009,-0.848504
	dc.s	0.686261,0.545000,-0.848504
	dc.s	0.686261,0.282991,-0.848504
	dc.s	1.347522,0.282991,-0.848504
	dc.s	0.686261,0.020982,-0.848504
	dc.s	-1.297522,0.282991,-0.848504
	dc.s	-0.636261,0.545000,-0.848504
	dc.s	-1.297522,0.807009,-0.848504
	dc.s	-0.636261,1.069018,-0.848504
	dc.s	-0.636261,0.807009,-0.848504
	dc.s	0.025000,0.807009,-0.848504
	dc.s	0.686261,1.069018,-0.848504
	dc.s	-0.966892,0.151986,-0.848504
	dc.s	-0.636261,0.151986,-0.848504
	dc.s	-0.966892,0.020982,-0.848504
	dc.s	-0.305631,0.282991,-0.848504
	dc.s	-1.297522,0.020982,0.748504
	dc.s	-1.297522,0.020982,-0.848504
	dc.s	-1.297522,1.069018,0.748504
	dc.s	-1.297522,1.069018,-0.848504
	dc.s	-1.297522,0.545000,-0.050000
	dc.s	-1.297522,0.545000,-0.848504
	dc.s	-1.297522,0.020982,-0.050000
	dc.s	-1.297522,0.545000,0.748504
	dc.s	-1.297522,1.069018,-0.050000
	dc.s	-1.297522,0.020982,0.349252
	dc.s	-1.297522,0.282991,0.349252
	dc.s	-1.297522,0.282991,-0.050000
	dc.s	-1.297522,0.807009,-0.449252
	dc.s	-1.297522,0.807009,-0.848504
	dc.s	-1.297522,0.545000,-0.449252
	dc.s	-1.297522,0.020982,-0.449252
	dc.s	-1.297522,0.282991,-0.449252
	dc.s	-1.297522,0.282991,-0.848504
	dc.s	-1.297522,0.282991,0.748504
	dc.s	-1.297522,0.545000,0.349252
	dc.s	-1.297522,0.807009,0.748504
	dc.s	-1.297522,1.069018,0.349252
	dc.s	-1.297522,0.807009,0.349252
	dc.s	-1.297522,0.807009,-0.050000
	dc.s	-1.297522,1.069018,-0.449252
	dc.s	1.347522,0.282991,0.349252
	dc.s	1.347522,0.545000,0.349252
	dc.s	1.347522,0.282991,0.748504
	dc.s	1.347522,0.807009,-0.449252
	dc.s	1.347522,1.069018,-0.449252
	dc.s	1.347522,0.807009,-0.050000
	dc.s	1.347522,0.807009,0.349252
	dc.s	1.347522,1.069018,0.349252
	dc.s	1.347522,0.807009,0.748504
	dc.s	1.347522,0.282991,-0.050000
	dc.s	1.347522,0.020982,0.349252
	dc.s	1.347522,0.282991,-0.848504
	dc.s	1.347522,0.282991,-0.449252
	dc.s	1.347522,0.020982,-0.449252
	dc.s	1.347522,0.545000,-0.449252
	dc.s	1.347522,0.807009,-0.848504
	dc.s	1.347522,0.020982,0.748504
	dc.s	1.347522,0.020982,-0.848504
	dc.s	1.347522,1.069018,0.748504
	dc.s	1.347522,1.069018,-0.848504
	dc.s	1.347522,0.545000,-0.050000
	dc.s	1.347522,1.069018,-0.050000
	dc.s	1.347522,0.545000,0.748504
	dc.s	1.347522,0.020982,-0.050000
	dc.s	1.347522,0.545000,-0.848504
faces_sal:				;f1,f2,f3 , tf1,tf2,tf3 , texnum , flag
	dc.w 0,25,27,  0,1,2,  0,0
	dc.w 26,25,9,  3,4,5,  0,0
	dc.w 11,27,26,  6,7,8,  0,0
	dc.w 27,25,26,  9,10,11,  0,0
	dc.w 10,28,30,  12,13,14,  0,0
	dc.w 28,9,29,  15,16,17,  0,0
	dc.w 30,29,4,  18,19,20,  0,0
	dc.w 28,29,30,  21,22,23,  0,0
	dc.w 6,31,33,  24,25,26,  0,0
	dc.w 31,11,32,  27,28,29,  0,0
	dc.w 33,32,10,  30,31,32,  0,0
	dc.w 31,32,33,  33,34,35,  0,0
	dc.w 11,26,32,  36,37,38,  0,0
	dc.w 26,9,28,  39,40,41,  0,0
	dc.w 32,28,10,  42,43,44,  0,0
	dc.w 32,26,28,  45,46,47,  0,0
	dc.w 2,34,36,  48,49,50,  0,0
	dc.w 35,34,12,  51,52,53,  0,0
	dc.w 14,36,35,  54,55,56,  0,0
	dc.w 35,36,34,  57,58,59,  0,0
	dc.w 13,37,39,  60,61,62,  0,0
	dc.w 37,12,38,  63,64,65,  0,0
	dc.w 39,38,5,  66,67,68,  0,0
	dc.w 39,37,38,  69,70,71,  0,0
	dc.w 4,40,42,  72,73,74,  0,0
	dc.w 40,14,41,  75,76,77,  0,0
	dc.w 42,41,13,  78,79,80,  0,0
	dc.w 42,40,41,  81,82,83,  0,0
	dc.w 13,41,37,  84,85,86,  0,0
	dc.w 41,14,35,  87,88,89,  0,0
	dc.w 37,35,12,  90,91,92,  0,0
	dc.w 41,35,37,  93,94,95,  0,0
	dc.w 6,43,45,  96,97,98,  0,0
	dc.w 43,15,44,  99,100,101,  0,0
	dc.w 45,44,17,  102,103,104,  0,0
	dc.w 45,43,44,  105,106,107,  0,0
	dc.w 15,46,48,  108,109,110,  0,0
	dc.w 46,5,47,  111,112,113,  0,0
	dc.w 48,47,16,  114,115,116,  0,0
	dc.w 48,46,47,  117,118,119,  0,0
	dc.w 17,49,51,  120,121,122,  0,0
	dc.w 49,16,50,  123,124,125,  0,0
	dc.w 51,50,1,  126,127,128,  0,0
	dc.w 51,49,50,  129,130,131,  0,0
	dc.w 17,44,49,  132,133,134,  0,0
	dc.w 44,15,48,  135,136,137,  0,0
	dc.w 49,48,16,  138,139,140,  0,0
	dc.w 44,48,49,  141,142,143,  0,0
	dc.w 6,33,43,  144,145,146,  0,0
	dc.w 33,10,52,  147,148,149,  0,0
	dc.w 43,52,15,  150,151,152,  0,0
	dc.w 33,52,43,  153,154,155,  0,0
	dc.w 10,30,53,  156,157,158,  0,0
	dc.w 30,4,42,  159,160,161,  0,0
	dc.w 53,42,13,  162,163,164,  0,0
	dc.w 30,42,53,  165,166,167,  0,0
	dc.w 15,54,46,  168,169,170,  0,0
	dc.w 54,13,39,  171,172,173,  0,0
	dc.w 46,39,5,  174,175,176,  0,0
	dc.w 54,39,46,  177,178,179,  0,0
	dc.w 10,53,52,  180,181,182,  0,0
	dc.w 53,13,54,  183,184,185,  0,0
	dc.w 52,54,15,  186,187,188,  0,0
	dc.w 52,53,54,  189,190,191,  0,0
	dc.w 7,55,57,  192,193,194,  0,0
	dc.w 56,55,18,  195,196,197,  0,0
	dc.w 19,57,56,  198,199,200,  0,0
	dc.w 57,55,56,  201,202,203,  0,0
	dc.w 9,58,29,  204,205,206,  0,0
	dc.w 58,18,59,  207,208,209,  0,0
	dc.w 29,59,4,  210,211,212,  0,0
	dc.w 58,59,29,  213,214,215,  0,0
	dc.w 0,60,25,  216,217,218,  0,0
	dc.w 60,19,61,  219,220,221,  0,0
	dc.w 25,61,9,  222,223,224,  0,0
	dc.w 25,60,61,  225,226,227,  0,0
	dc.w 19,56,61,  228,229,230,  0,0
	dc.w 58,56,18,  231,232,233,  0,0
	dc.w 9,61,58,  234,235,236,  0,0
	dc.w 61,56,58,  237,238,239,  0,0
	dc.w 22,62,64,  240,241,242,  0,0
	dc.w 62,3,63,  243,244,245,  0,0
	dc.w 64,63,20,  246,247,248,  0,0
	dc.w 62,63,64,  249,250,251,  0,0
	dc.w 21,65,67,  252,253,254,  0,0
	dc.w 65,20,66,  255,256,257,  0,0
	dc.w 67,66,8,  258,259,260,  0,0
	dc.w 67,65,66,  261,262,263,  0,0
	dc.w 70,22,68,  264,265,266,  0,0
	dc.w 69,68,21,  267,268,269,  0,0
	dc.w 70,69,7,  270,271,272,  0,0
	dc.w 70,68,69,  273,274,275,  0,0
	dc.w 22,64,68,  276,277,278,  0,0
	dc.w 65,64,20,  279,280,281,  0,0
	dc.w 21,68,65,  282,283,284,  0,0
	dc.w 68,64,65,  285,286,287,  0,0
	dc.w 73,8,71,  288,289,290,  0,0
	dc.w 72,71,23,  291,292,293,  0,0
	dc.w 73,72,24,  294,295,296,  0,0
	dc.w 73,71,72,  297,298,299,  0,0
	dc.w 23,74,75,  300,301,302,  0,0
	dc.w 74,2,36,  303,304,305,  0,0
	dc.w 75,36,14,  306,307,308,  0,0
	dc.w 74,36,75,  309,310,311,  0,0
	dc.w 24,76,77,  312,313,314,  0,0
	dc.w 40,76,14,  315,316,317,  0,0
	dc.w 4,77,40,  318,319,320,  0,0
	dc.w 77,76,40,  321,322,323,  0,0
	dc.w 72,23,75,  324,325,326,  0,0
	dc.w 75,14,76,  327,328,329,  0,0
	dc.w 72,76,24,  330,331,332,  0,0
	dc.w 72,75,76,  333,334,335,  0,0
	dc.w 78,21,67,  336,337,338,  0,0
	dc.w 73,67,8,  339,340,341,  0,0
	dc.w 78,73,24,  342,343,344,  0,0
	dc.w 78,67,73,  345,346,347,  0,0
	dc.w 24,77,79,  348,349,350,  0,0
	dc.w 59,77,4,  351,352,353,  0,0
	dc.w 18,79,59,  354,355,356,  0,0
	dc.w 59,79,77,  357,358,359,  0,0
	dc.w 69,21,80,  360,361,362,  0,0
	dc.w 80,18,55,  363,364,365,  0,0
	dc.w 69,55,7,  366,367,368,  0,0
	dc.w 69,80,55,  369,370,371,  0,0
	dc.w 78,80,21,  372,373,374,  0,0
	dc.w 78,24,79,  375,376,377,  0,0
	dc.w 80,79,18,  378,379,380,  0,0
	dc.w 78,79,80,  381,382,383,  0,0
	dc.w 81,140,142,  384,385,386,  1,0
	dc.w 140,90,141,  387,388,389,  1,0
	dc.w 142,141,92,  390,391,392,  1,0
	dc.w 142,140,141,  393,394,395,  1,0
	dc.w 90,143,145,  396,397,398,  1,0
	dc.w 143,85,144,  399,400,401,  1,0
	dc.w 145,144,91,  402,403,404,  1,0
	dc.w 145,143,144,  405,406,407,  1,0
	dc.w 92,146,148,  408,409,410,  1,0
	dc.w 146,91,147,  411,412,413,  1,0
	dc.w 148,147,87,  414,415,416,  1,0
	dc.w 148,146,147,  417,418,419,  1,0
	dc.w 92,141,146,  420,421,422,  1,0
	dc.w 141,90,145,  423,424,425,  1,0
	dc.w 146,145,91,  426,427,428,  1,0
	dc.w 141,145,146,  429,430,431,  1,0
	dc.w 85,149,151,  432,433,434,  1,0
	dc.w 149,93,150,  435,436,437,  1,0
	dc.w 151,150,95,  438,439,440,  1,0
	dc.w 151,149,150,  441,442,443,  1,0
	dc.w 93,152,154,  444,445,446,  1,0
	dc.w 152,83,153,  447,448,449,  1,0
	dc.w 154,153,94,  450,451,452,  1,0
	dc.w 154,152,153,  453,454,455,  1,0
	dc.w 95,155,157,  456,457,458,  1,0
	dc.w 155,94,156,  459,460,461,  1,0
	dc.w 157,156,86,  462,463,464,  1,0
	dc.w 157,155,156,  465,466,467,  1,0
	dc.w 95,150,155,  468,469,470,  1,0
	dc.w 150,93,154,  471,472,473,  1,0
	dc.w 155,154,94,  474,475,476,  1,0
	dc.w 150,154,155,  477,478,479,  1,0
	dc.w 87,158,160,  480,481,482,  1,0
	dc.w 158,96,159,  483,484,485,  1,0
	dc.w 160,159,98,  486,487,488,  1,0
	dc.w 158,159,160,  489,490,491,  1,0
	dc.w 96,161,104,  492,493,494,  1,0
	dc.w 161,86,103,  495,496,497,  1,0
	dc.w 104,103,97,  498,499,500,  1,0
	dc.w 161,103,104,  501,502,503,  1,0
	dc.w 98,105,107,  504,505,506,  1,0
	dc.w 105,97,106,  507,508,509,  1,0
	dc.w 107,106,84,  510,511,512,  1,0
	dc.w 107,105,106,  513,514,515,  1,0
	dc.w 96,104,159,  516,517,518,  1,0
	dc.w 104,97,105,  519,520,521,  1,0
	dc.w 159,105,98,  522,523,524,  1,0
	dc.w 159,104,105,  525,526,527,  1,0
	dc.w 87,147,158,  528,529,530,  1,0
	dc.w 147,91,108,  531,532,533,  1,0
	dc.w 158,108,96,  534,535,536,  1,0
	dc.w 147,108,158,  537,538,539,  1,0
	dc.w 91,144,109,  540,541,542,  1,0
	dc.w 144,85,151,  543,544,545,  1,0
	dc.w 109,151,95,  546,547,548,  1,0
	dc.w 144,151,109,  549,550,551,  1,0
	dc.w 96,110,161,  552,553,554,  1,0
	dc.w 110,95,157,  555,556,557,  1,0
	dc.w 161,157,86,  558,559,560,  1,0
	dc.w 110,157,161,  561,562,563,  1,0
	dc.w 91,109,108,  564,565,566,  1,0
	dc.w 109,95,110,  567,568,569,  1,0
	dc.w 108,110,96,  570,571,572,  1,0
	dc.w 108,109,110,  573,574,575,  1,0
	dc.w 88,111,113,  576,577,578,  1,0
	dc.w 111,99,112,  579,580,581,  1,0
	dc.w 113,112,100,  582,583,584,  1,0
	dc.w 113,111,112,  585,586,587,  1,0
	dc.w 99,114,115,  588,589,590,  1,0
	dc.w 114,85,143,  591,592,593,  1,0
	dc.w 115,143,90,  594,595,596,  1,0
	dc.w 115,114,143,  597,598,599,  1,0
	dc.w 100,116,117,  600,601,602,  1,0
	dc.w 116,90,140,  603,604,605,  1,0
	dc.w 117,140,81,  606,607,608,  1,0
	dc.w 117,116,140,  609,610,611,  1,0
	dc.w 100,112,116,  612,613,614,  1,0
	dc.w 112,99,115,  615,616,617,  1,0
	dc.w 116,115,90,  618,619,620,  1,0
	dc.w 112,115,116,  621,622,623,  1,0
	dc.w 88,118,120,  624,625,626,  1,0
	dc.w 118,101,119,  627,628,629,  1,0
	dc.w 120,119,137,  630,631,632,  1,0
	dc.w 118,119,120,  633,634,635,  1,0
	dc.w 101,121,123,  636,637,638,  1,0
	dc.w 121,82,122,  639,640,641,  1,0
	dc.w 123,122,102,  642,643,644,  1,0
	dc.w 121,122,123,  645,646,647,  1,0
	dc.w 137,124,126,  648,649,650,  1,0
	dc.w 124,102,125,  651,652,653,  1,0
	dc.w 126,125,89,  654,655,656,  1,0
	dc.w 124,125,126,  657,658,659,  1,0
	dc.w 101,123,119,  660,661,662,  1,0
	dc.w 123,102,124,  663,664,665,  1,0
	dc.w 119,124,137,  666,667,668,  1,0
	dc.w 119,123,124,  669,670,671,  1,0
	dc.w 85,127,149,  672,673,674,  1,0
	dc.w 127,138,128,  675,676,677,  1,0
	dc.w 149,128,93,  678,679,680,  1,0
	dc.w 127,128,149,  681,682,683,  1,0
	dc.w 138,129,131,  684,685,686,  1,0
	dc.w 129,89,130,  687,688,689,  1,0
	dc.w 131,130,139,  690,691,692,  1,0
	dc.w 129,130,131,  693,694,695,  1,0
	dc.w 93,132,152,  696,697,698,  1,0
	dc.w 132,139,133,  699,700,701,  1,0
	dc.w 152,133,83,  702,703,704,  1,0
	dc.w 132,133,152,  705,706,707,  1,0
	dc.w 138,131,128,  708,709,710,  1,0
	dc.w 131,139,132,  711,712,713,  1,0
	dc.w 128,132,93,  714,715,716,  1,0
	dc.w 128,131,132,  717,718,719,  1,0
	dc.w 88,120,111,  720,721,722,  1,0
	dc.w 120,137,134,  723,724,725,  1,0
	dc.w 111,134,99,  726,727,728,  1,0
	dc.w 111,120,134,  729,730,731,  1,0
	dc.w 137,126,135,  732,733,734,  1,0
	dc.w 126,89,129,  735,736,737,  1,0
	dc.w 135,129,138,  738,739,740,  1,0
	dc.w 135,126,129,  741,742,743,  1,0
	dc.w 99,136,114,  744,745,746,  1,0
	dc.w 136,138,127,  747,748,749,  1,0
	dc.w 114,127,85,  750,751,752,  1,0
	dc.w 114,136,127,  753,754,755,  1,0
	dc.w 99,134,136,  756,757,758,  1,0
	dc.w 134,137,135,  759,760,761,  1,0
	dc.w 136,135,138,  762,763,764,  1,0
	dc.w 134,135,136,  765,766,767,  1,0
	dc.w 239,208,210,  768,769,770,  2,0
	dc.w 208,192,209,  771,772,773,  2,0
	dc.w 210,209,194,  774,775,776,  2,0
	dc.w 208,209,210,  777,778,779,  2,0
	dc.w 192,162,164,  780,781,782,  2,0
	dc.w 162,187,163,  783,784,785,  2,0
	dc.w 164,163,193,  786,787,788,  2,0
	dc.w 162,163,164,  789,790,791,  2,0
	dc.w 194,165,167,  792,793,794,  2,0
	dc.w 165,193,166,  795,796,797,  2,0
	dc.w 167,166,189,  798,799,800,  2,0
	dc.w 165,166,167,  801,802,803,  2,0
	dc.w 192,164,209,  804,805,806,  2,0
	dc.w 164,193,165,  807,808,809,  2,0
	dc.w 209,165,194,  810,811,812,  2,0
	dc.w 209,164,165,  813,814,815,  2,0
	dc.w 187,168,170,  816,817,818,  2,0
	dc.w 168,195,169,  819,820,821,  2,0
	dc.w 170,169,197,  822,823,824,  2,0
	dc.w 170,168,169,  825,826,827,  2,0
	dc.w 195,171,173,  828,829,830,  2,0
	dc.w 171,242,172,  831,832,833,  2,0
	dc.w 173,172,196,  834,835,836,  2,0
	dc.w 173,171,172,  837,838,839,  2,0
	dc.w 197,174,176,  840,841,842,  2,0
	dc.w 174,196,175,  843,844,845,  2,0
	dc.w 176,175,188,  846,847,848,  2,0
	dc.w 176,174,175,  849,850,851,  2,0
	dc.w 197,169,174,  852,853,854,  2,0
	dc.w 169,195,173,  855,856,857,  2,0
	dc.w 174,173,196,  858,859,860,  2,0
	dc.w 169,173,174,  861,862,863,  2,0
	dc.w 189,177,179,  864,865,866,  2,0
	dc.w 177,198,178,  867,868,869,  2,0
	dc.w 179,178,200,  870,871,872,  2,0
	dc.w 177,178,179,  873,874,875,  2,0
	dc.w 198,180,182,  876,877,878,  2,0
	dc.w 180,188,181,  879,880,881,  2,0
	dc.w 182,181,199,  882,883,884,  2,0
	dc.w 180,181,182,  885,886,887,  2,0
	dc.w 200,183,185,  888,889,890,  2,0
	dc.w 183,199,184,  891,892,893,  2,0
	dc.w 185,184,241,  894,895,896,  2,0
	dc.w 183,184,185,  897,898,899,  2,0
	dc.w 198,182,178,  900,901,902,  2,0
	dc.w 182,199,183,  903,904,905,  2,0
	dc.w 178,183,200,  906,907,908,  2,0
	dc.w 178,182,183,  909,910,911,  2,0
	dc.w 187,170,163,  912,913,914,  2,0
	dc.w 170,197,186,  915,916,917,  2,0
	dc.w 163,186,193,  918,919,920,  2,0
	dc.w 163,170,186,  921,922,923,  2,0
	dc.w 197,176,211,  924,925,926,  2,0
	dc.w 176,188,180,  927,928,929,  2,0
	dc.w 211,180,198,  930,931,932,  2,0
	dc.w 211,176,180,  933,934,935,  2,0
	dc.w 193,212,166,  936,937,938,  2,0
	dc.w 212,198,177,  939,940,941,  2,0
	dc.w 166,177,189,  942,943,944,  2,0
	dc.w 166,212,177,  945,946,947,  2,0
	dc.w 193,186,212,  948,949,950,  2,0
	dc.w 186,197,211,  951,952,953,  2,0
	dc.w 212,211,198,  954,955,956,  2,0
	dc.w 186,211,212,  957,958,959,  2,0
	dc.w 239,213,208,  960,961,962,  2,0
	dc.w 201,214,213,  963,964,965,  2,0
	dc.w 214,192,208,  966,967,968,  2,0
	dc.w 213,214,208,  969,970,971,  2,0
	dc.w 190,215,217,  972,973,974,  2,0
	dc.w 215,202,216,  975,976,977,  2,0
	dc.w 217,216,201,  978,979,980,  2,0
	dc.w 217,215,216,  981,982,983,  2,0
	dc.w 202,218,219,  984,985,986,  2,0
	dc.w 218,187,162,  987,988,989,  2,0
	dc.w 219,162,192,  990,991,992,  2,0
	dc.w 219,218,162,  993,994,995,  2,0
	dc.w 201,216,214,  996,997,998,  2,0
	dc.w 216,202,219,  999,1000,1001,  2,0
	dc.w 214,219,192,  1002,1003,1004,  2,0
	dc.w 216,219,214,  1005,1006,1007,  2,0
	dc.w 190,220,222,  1008,1009,1010,  2,0
	dc.w 220,203,221,  1011,1012,1013,  2,0
	dc.w 222,221,205,  1014,1015,1016,  2,0
	dc.w 220,221,222,  1017,1018,1019,  2,0
	dc.w 203,223,225,  1020,1021,1022,  2,0
	dc.w 223,240,224,  1023,1024,1025,  2,0
	dc.w 225,224,204,  1026,1027,1028,  2,0
	dc.w 223,224,225,  1029,1030,1031,  2,0
	dc.w 205,226,228,  1032,1033,1034,  2,0
	dc.w 226,204,227,  1035,1036,1037,  2,0
	dc.w 228,227,191,  1038,1039,1040,  2,0
	dc.w 226,227,228,  1041,1042,1043,  2,0
	dc.w 203,225,221,  1044,1045,1046,  2,0
	dc.w 225,204,226,  1047,1048,1049,  2,0
	dc.w 221,226,205,  1050,1051,1052,  2,0
	dc.w 221,225,226,  1053,1054,1055,  2,0
	dc.w 187,229,168,  1056,1057,1058,  2,0
	dc.w 229,206,230,  1059,1060,1061,  2,0
	dc.w 168,230,195,  1062,1063,1064,  2,0
	dc.w 229,230,168,  1065,1066,1067,  2,0
	dc.w 206,231,233,  1068,1069,1070,  2,0
	dc.w 231,191,232,  1071,1072,1073,  2,0
	dc.w 233,232,207,  1074,1075,1076,  2,0
	dc.w 231,232,233,  1077,1078,1079,  2,0
	dc.w 195,234,171,  1080,1081,1082,  2,0
	dc.w 234,207,235,  1083,1084,1085,  2,0
	dc.w 171,235,242,  1086,1087,1088,  2,0
	dc.w 234,235,171,  1089,1090,1091,  2,0
	dc.w 206,233,230,  1092,1093,1094,  2,0
	dc.w 233,207,234,  1095,1096,1097,  2,0
	dc.w 230,234,195,  1098,1099,1100,  2,0
	dc.w 230,233,234,  1101,1102,1103,  2,0
	dc.w 190,222,215,  1104,1105,1106,  2,0
	dc.w 222,205,236,  1107,1108,1109,  2,0
	dc.w 215,236,202,  1110,1111,1112,  2,0
	dc.w 215,222,236,  1113,1114,1115,  2,0
	dc.w 205,228,237,  1116,1117,1118,  2,0
	dc.w 228,191,231,  1119,1120,1121,  2,0
	dc.w 237,231,206,  1122,1123,1124,  2,0
	dc.w 237,228,231,  1125,1126,1127,  2,0
	dc.w 202,238,218,  1128,1129,1130,  2,0
	dc.w 238,206,229,  1131,1132,1133,  2,0
	dc.w 218,229,187,  1134,1135,1136,  2,0
	dc.w 218,238,229,  1137,1138,1139,  2,0
	dc.w 202,236,238,  1140,1141,1142,  2,0
	dc.w 236,205,237,  1143,1144,1145,  2,0
	dc.w 238,237,206,  1146,1147,1148,  2,0
	dc.w 236,237,238,  1149,1150,1151,  2,0
	dc.w 271,320,322,  1152,1153,1154,  3,0
	dc.w 321,320,248,  1155,1156,1157,  3,0
	dc.w 250,322,321,  1158,1159,1160,  3,0
	dc.w 322,320,321,  1161,1162,1163,  3,0
	dc.w 249,323,253,  1164,1165,1166,  3,0
	dc.w 323,248,252,  1167,1168,1169,  3,0
	dc.w 253,252,243,  1170,1171,1172,  3,0
	dc.w 323,252,253,  1173,1174,1175,  3,0
	dc.w 245,254,256,  1176,1177,1178,  3,0
	dc.w 254,250,255,  1179,1180,1181,  3,0
	dc.w 256,255,249,  1182,1183,1184,  3,0
	dc.w 254,255,256,  1185,1186,1187,  3,0
	dc.w 250,321,255,  1188,1189,1190,  3,0
	dc.w 321,248,323,  1191,1192,1193,  3,0
	dc.w 255,323,249,  1194,1195,1196,  3,0
	dc.w 255,321,323,  1197,1198,1199,  3,0
	dc.w 243,257,259,  1200,1201,1202,  3,0
	dc.w 257,251,258,  1203,1204,1205,  3,0
	dc.w 259,258,309,  1206,1207,1208,  3,0
	dc.w 259,257,258,  1209,1210,1211,  3,0
	dc.w 251,260,262,  1212,1213,1214,  3,0
	dc.w 260,272,261,  1215,1216,1217,  3,0
	dc.w 262,261,308,  1218,1219,1220,  3,0
	dc.w 262,260,261,  1221,1222,1223,  3,0
	dc.w 309,263,265,  1224,1225,1226,  3,0
	dc.w 263,308,264,  1227,1228,1229,  3,0
	dc.w 265,264,244,  1230,1231,1232,  3,0
	dc.w 265,263,264,  1233,1234,1235,  3,0
	dc.w 309,258,263,  1236,1237,1238,  3,0
	dc.w 258,251,262,  1239,1240,1241,  3,0
	dc.w 263,262,308,  1242,1243,1244,  3,0
	dc.w 258,262,263,  1245,1246,1247,  3,0
	dc.w 245,266,268,  1248,1249,1250,  3,0
	dc.w 266,310,267,  1251,1252,1253,  3,0
	dc.w 268,267,312,  1254,1255,1256,  3,0
	dc.w 268,266,267,  1257,1258,1259,  3,0
	dc.w 310,269,275,  1260,1261,1262,  3,0
	dc.w 269,244,274,  1263,1264,1265,  3,0
	dc.w 275,274,311,  1266,1267,1268,  3,0
	dc.w 275,269,274,  1269,1270,1271,  3,0
	dc.w 312,276,278,  1272,1273,1274,  3,0
	dc.w 276,311,277,  1275,1276,1277,  3,0
	dc.w 278,277,270,  1278,1279,1280,  3,0
	dc.w 278,276,277,  1281,1282,1283,  3,0
	dc.w 312,267,276,  1284,1285,1286,  3,0
	dc.w 267,310,275,  1287,1288,1289,  3,0
	dc.w 276,275,311,  1290,1291,1292,  3,0
	dc.w 267,275,276,  1293,1294,1295,  3,0
	dc.w 245,256,266,  1296,1297,1298,  3,0
	dc.w 256,249,279,  1299,1300,1301,  3,0
	dc.w 266,279,310,  1302,1303,1304,  3,0
	dc.w 256,279,266,  1305,1306,1307,  3,0
	dc.w 249,253,280,  1308,1309,1310,  3,0
	dc.w 253,243,259,  1311,1312,1313,  3,0
	dc.w 280,259,309,  1314,1315,1316,  3,0
	dc.w 253,259,280,  1317,1318,1319,  3,0
	dc.w 310,281,269,  1320,1321,1322,  3,0
	dc.w 281,309,265,  1323,1324,1325,  3,0
	dc.w 269,265,244,  1326,1327,1328,  3,0
	dc.w 281,265,269,  1329,1330,1331,  3,0
	dc.w 249,280,279,  1332,1333,1334,  3,0
	dc.w 280,309,281,  1335,1336,1337,  3,0
	dc.w 279,281,310,  1338,1339,1340,  3,0
	dc.w 279,280,281,  1341,1342,1343,  3,0
	dc.w 271,282,320,  1344,1345,1346,  3,0
	dc.w 282,313,283,  1347,1348,1349,  3,0
	dc.w 320,283,248,  1350,1351,1352,  3,0
	dc.w 320,282,283,  1353,1354,1355,  3,0
	dc.w 313,284,286,  1356,1357,1358,  3,0
	dc.w 284,246,285,  1359,1360,1361,  3,0
	dc.w 286,285,314,  1362,1363,1364,  3,0
	dc.w 284,285,286,  1365,1366,1367,  3,0
	dc.w 248,287,252,  1368,1369,1370,  3,0
	dc.w 287,314,288,  1371,1372,1373,  3,0
	dc.w 252,288,243,  1374,1375,1376,  3,0
	dc.w 252,287,288,  1377,1378,1379,  3,0
	dc.w 248,283,287,  1380,1381,1382,  3,0
	dc.w 283,313,286,  1383,1384,1385,  3,0
	dc.w 287,286,314,  1386,1387,1388,  3,0
	dc.w 283,286,287,  1389,1390,1391,  3,0
	dc.w 246,289,291,  1392,1393,1394,  3,0
	dc.w 289,315,290,  1395,1396,1397,  3,0
	dc.w 291,290,317,  1398,1399,1400,  3,0
	dc.w 289,290,291,  1401,1402,1403,  3,0
	dc.w 315,292,294,  1404,1405,1406,  3,0
	dc.w 292,273,293,  1407,1408,1409,  3,0
	dc.w 294,293,316,  1410,1411,1412,  3,0
	dc.w 294,292,293,  1413,1414,1415,  3,0
	dc.w 317,295,297,  1416,1417,1418,  3,0
	dc.w 295,316,296,  1419,1420,1421,  3,0
	dc.w 297,296,247,  1422,1423,1424,  3,0
	dc.w 297,295,296,  1425,1426,1427,  3,0
	dc.w 315,294,290,  1428,1429,1430,  3,0
	dc.w 295,294,316,  1431,1432,1433,  3,0
	dc.w 317,290,295,  1434,1435,1436,  3,0
	dc.w 290,294,295,  1437,1438,1439,  3,0
	dc.w 243,298,257,  1440,1441,1442,  3,0
	dc.w 298,318,299,  1443,1444,1445,  3,0
	dc.w 257,299,251,  1446,1447,1448,  3,0
	dc.w 298,299,257,  1449,1450,1451,  3,0
	dc.w 318,300,302,  1452,1453,1454,  3,0
	dc.w 300,247,301,  1455,1456,1457,  3,0
	dc.w 302,301,319,  1458,1459,1460,  3,0
	dc.w 300,301,302,  1461,1462,1463,  3,0
	dc.w 251,303,260,  1464,1465,1466,  3,0
	dc.w 303,319,304,  1467,1468,1469,  3,0
	dc.w 260,304,272,  1470,1471,1472,  3,0
	dc.w 303,304,260,  1473,1474,1475,  3,0
	dc.w 318,302,299,  1476,1477,1478,  3,0
	dc.w 302,319,303,  1479,1480,1481,  3,0
	dc.w 299,303,251,  1482,1483,1484,  3,0
	dc.w 299,302,303,  1485,1486,1487,  3,0
	dc.w 243,288,298,  1488,1489,1490,  3,0
	dc.w 288,314,305,  1491,1492,1493,  3,0
	dc.w 298,305,318,  1494,1495,1496,  3,0
	dc.w 288,305,298,  1497,1498,1499,  3,0
	dc.w 314,285,306,  1500,1501,1502,  3,0
	dc.w 285,246,291,  1503,1504,1505,  3,0
	dc.w 306,291,317,  1506,1507,1508,  3,0
	dc.w 285,291,306,  1509,1510,1511,  3,0
	dc.w 318,307,300,  1512,1513,1514,  3,0
	dc.w 307,317,297,  1515,1516,1517,  3,0
	dc.w 300,297,247,  1518,1519,1520,  3,0
	dc.w 307,297,300,  1521,1522,1523,  3,0
	dc.w 314,306,305,  1524,1525,1526,  3,0
	dc.w 306,317,307,  1527,1528,1529,  3,0
	dc.w 305,307,318,  1530,1531,1532,  3,0
	dc.w 305,306,307,  1533,1534,1535,  3,0
	dc.w 330,333,335,  1536,1537,1538,  4,0
	dc.w 324,334,333,  1539,1540,1541,  4,0
	dc.w 334,328,335,  1542,1543,1544,  4,0
	dc.w 333,334,335,  1545,1546,1547,  4,0
	dc.w 328,336,338,  1548,1549,1550,  4,0
	dc.w 336,327,337,  1551,1552,1553,  4,0
	dc.w 338,337,329,  1554,1555,1556,  4,0
	dc.w 338,336,337,  1557,1558,1559,  4,0
	dc.w 339,341,325,  1560,1561,1562,  4,0
	dc.w 339,330,340,  1563,1564,1565,  4,0
	dc.w 340,329,341,  1566,1567,1568,  4,0
	dc.w 339,340,341,  1569,1570,1571,  4,0
	dc.w 330,335,340,  1572,1573,1574,  4,0
	dc.w 335,328,338,  1575,1576,1577,  4,0
	dc.w 340,338,329,  1578,1579,1580,  4,0
	dc.w 335,338,340,  1581,1582,1583,  4,0
	dc.w 324,342,334,  1584,1585,1586,  4,0
	dc.w 342,331,343,  1587,1588,1589,  4,0
	dc.w 334,343,328,  1590,1591,1592,  4,0
	dc.w 342,343,334,  1593,1594,1595,  4,0
	dc.w 331,344,346,  1596,1597,1598,  4,0
	dc.w 344,326,345,  1599,1600,1601,  4,0
	dc.w 346,345,332,  1602,1603,1604,  4,0
	dc.w 344,345,346,  1605,1606,1607,  4,0
	dc.w 328,347,336,  1608,1609,1610,  4,0
	dc.w 347,332,348,  1611,1612,1613,  4,0
	dc.w 336,348,327,  1614,1615,1616,  4,0
	dc.w 347,348,336,  1617,1618,1619,  4,0
	dc.w 331,346,343,  1620,1621,1622,  4,0
	dc.w 346,332,347,  1623,1624,1625,  4,0
	dc.w 343,347,328,  1626,1627,1628,  4,0
	dc.w 343,346,347,  1629,1630,1631,  4,0
	dc.w 365,349,351,  1632,1633,1634,  5,0
	dc.w 349,369,350,  1635,1636,1637,  5,0
	dc.w 351,350,371,  1638,1639,1640,  5,0
	dc.w 351,349,350,  1641,1642,1643,  5,0
	dc.w 369,352,354,  1644,1645,1646,  5,0
	dc.w 352,368,353,  1647,1648,1649,  5,0
	dc.w 354,353,370,  1650,1651,1652,  5,0
	dc.w 354,352,353,  1653,1654,1655,  5,0
	dc.w 371,355,357,  1656,1657,1658,  5,0
	dc.w 355,370,356,  1659,1660,1661,  5,0
	dc.w 357,356,367,  1662,1663,1664,  5,0
	dc.w 357,355,356,  1665,1666,1667,  5,0
	dc.w 371,350,355,  1668,1669,1670,  5,0
	dc.w 350,369,354,  1671,1672,1673,  5,0
	dc.w 355,354,370,  1674,1675,1676,  5,0
	dc.w 350,354,355,  1677,1678,1679,  5,0
	dc.w 359,372,358,  1680,1681,1682,  5,0
	dc.w 349,358,369,  1683,1684,1685,  5,0
	dc.w 359,349,365,  1686,1687,1688,  5,0
	dc.w 359,358,349,  1689,1690,1691,  5,0
	dc.w 366,360,362,  1692,1693,1694,  5,0
	dc.w 361,360,373,  1695,1696,1697,  5,0
	dc.w 372,362,361,  1698,1699,1700,  5,0
	dc.w 362,360,361,  1701,1702,1703,  5,0
	dc.w 369,363,352,  1704,1705,1706,  5,0
	dc.w 363,373,364,  1707,1708,1709,  5,0
	dc.w 352,364,368,  1710,1711,1712,  5,0
	dc.w 363,364,352,  1713,1714,1715,  5,0
	dc.w 372,361,358,  1716,1717,1718,  5,0
	dc.w 361,373,363,  1719,1720,1721,  5,0
	dc.w 358,363,369,  1722,1723,1724,  5,0
	dc.w 358,361,363,  1725,1726,1727,  5,0
tcoords_sal:				;u,v
	dc.s	0.975193,-0.040327
	dc.s	0.856179,0.089912
	dc.s	0.980897,0.087776
	dc.s	0.861884,0.218014
	dc.s	0.856179,0.089912
	dc.s	0.737165,0.220150
	dc.s	0.986602,0.215878
	dc.s	0.980897,0.087776
	dc.s	0.861884,0.218014
	dc.s	0.980897,0.087776
	dc.s	0.856179,0.089912
	dc.s	0.861884,0.218014
	dc.s	0.748575,0.476355
	dc.s	0.742870,0.348253
	dc.s	0.623856,0.478491
	dc.s	0.742870,0.348253
	dc.s	0.737165,0.220150
	dc.s	0.618151,0.350389
	dc.s	0.623856,0.478491
	dc.s	0.618151,0.350389
	dc.s	0.499137,0.480628
	dc.s	0.742870,0.348253
	dc.s	0.618151,0.350389
	dc.s	0.623856,0.478491
	dc.s	0.998012,0.472083
	dc.s	0.992307,0.343981
	dc.s	0.873293,0.474219
	dc.s	0.992307,0.343981
	dc.s	0.986602,0.215878
	dc.s	0.867589,0.346117
	dc.s	0.873293,0.474219
	dc.s	0.867589,0.346117
	dc.s	0.748575,0.476355
	dc.s	0.992307,0.343981
	dc.s	0.867589,0.346117
	dc.s	0.873293,0.474219
	dc.s	0.986602,0.215878
	dc.s	0.861884,0.218014
	dc.s	0.867589,0.346117
	dc.s	0.861884,0.218014
	dc.s	0.737165,0.220150
	dc.s	0.742870,0.348253
	dc.s	0.867589,0.346117
	dc.s	0.742870,0.348253
	dc.s	0.748575,0.476355
	dc.s	0.867589,0.346117
	dc.s	0.861884,0.218014
	dc.s	0.742870,0.348253
	dc.s	0.023082,1.001582
	dc.s	0.147801,0.999446
	dc.s	0.142096,0.871343
	dc.s	0.266815,0.869207
	dc.s	0.147801,0.999446
	dc.s	0.272519,0.997310
	dc.s	0.261110,0.741105
	dc.s	0.142096,0.871343
	dc.s	0.266815,0.869207
	dc.s	0.266815,0.869207
	dc.s	0.142096,0.871343
	dc.s	0.147801,0.999446
	dc.s	0.510547,0.736833
	dc.s	0.391533,0.867071
	dc.s	0.516252,0.864935
	dc.s	0.391533,0.867071
	dc.s	0.272519,0.997310
	dc.s	0.397238,0.995174
	dc.s	0.516252,0.864935
	dc.s	0.397238,0.995174
	dc.s	0.521957,0.993038
	dc.s	0.516252,0.864935
	dc.s	0.391533,0.867071
	dc.s	0.397238,0.995174
	dc.s	0.499137,0.480628
	dc.s	0.380123,0.610866
	dc.s	0.504842,0.608730
	dc.s	0.380123,0.610866
	dc.s	0.261110,0.741105
	dc.s	0.385828,0.738969
	dc.s	0.504842,0.608730
	dc.s	0.385828,0.738969
	dc.s	0.510547,0.736833
	dc.s	0.504842,0.608730
	dc.s	0.380123,0.610866
	dc.s	0.385828,0.738969
	dc.s	0.510547,0.736833
	dc.s	0.385828,0.738969
	dc.s	0.391533,0.867071
	dc.s	0.385828,0.738969
	dc.s	0.261110,0.741105
	dc.s	0.266815,0.869207
	dc.s	0.391533,0.867071
	dc.s	0.266815,0.869207
	dc.s	0.272519,0.997310
	dc.s	0.385828,0.738969
	dc.s	0.266815,0.869207
	dc.s	0.391533,0.867071
	dc.s	0.998012,0.472083
	dc.s	0.878998,0.602322
	dc.s	1.003717,0.600186
	dc.s	0.878998,0.602322
	dc.s	0.759984,0.732560
	dc.s	0.884703,0.730424
	dc.s	1.003717,0.600186
	dc.s	0.884703,0.730424
	dc.s	1.009422,0.728288
	dc.s	1.003717,0.600186
	dc.s	0.878998,0.602322
	dc.s	0.884703,0.730424
	dc.s	0.759984,0.732560
	dc.s	0.640971,0.862799
	dc.s	0.765689,0.860663
	dc.s	0.640971,0.862799
	dc.s	0.521957,0.993038
	dc.s	0.646675,0.990902
	dc.s	0.765689,0.860663
	dc.s	0.646675,0.990902
	dc.s	0.771394,0.988765
	dc.s	0.765689,0.860663
	dc.s	0.640971,0.862799
	dc.s	0.646675,0.990902
	dc.s	1.009422,0.728288
	dc.s	0.890408,0.858527
	dc.s	1.015127,0.856391
	dc.s	0.890408,0.858527
	dc.s	0.771394,0.988765
	dc.s	0.896113,0.986629
	dc.s	1.015127,0.856391
	dc.s	0.896113,0.986629
	dc.s	1.020832,0.984493
	dc.s	1.015127,0.856391
	dc.s	0.890408,0.858527
	dc.s	0.896113,0.986629
	dc.s	1.009422,0.728288
	dc.s	0.884703,0.730424
	dc.s	0.890408,0.858527
	dc.s	0.884703,0.730424
	dc.s	0.759984,0.732560
	dc.s	0.765689,0.860663
	dc.s	0.890408,0.858527
	dc.s	0.765689,0.860663
	dc.s	0.771394,0.988765
	dc.s	0.884703,0.730424
	dc.s	0.765689,0.860663
	dc.s	0.890408,0.858527
	dc.s	0.998012,0.472083
	dc.s	0.873293,0.474219
	dc.s	0.878998,0.602322
	dc.s	0.873293,0.474219
	dc.s	0.748575,0.476355
	dc.s	0.754280,0.604458
	dc.s	0.878998,0.602322
	dc.s	0.754280,0.604458
	dc.s	0.759984,0.732560
	dc.s	0.873293,0.474219
	dc.s	0.754280,0.604458
	dc.s	0.878998,0.602322
	dc.s	0.748575,0.476355
	dc.s	0.623856,0.478491
	dc.s	0.629561,0.606594
	dc.s	0.623856,0.478491
	dc.s	0.499137,0.480628
	dc.s	0.504842,0.608730
	dc.s	0.629561,0.606594
	dc.s	0.504842,0.608730
	dc.s	0.510547,0.736833
	dc.s	0.623856,0.478491
	dc.s	0.504842,0.608730
	dc.s	0.629561,0.606594
	dc.s	0.759984,0.732560
	dc.s	0.635266,0.734697
	dc.s	0.640971,0.862799
	dc.s	0.635266,0.734697
	dc.s	0.510547,0.736833
	dc.s	0.516252,0.864935
	dc.s	0.640971,0.862799
	dc.s	0.516252,0.864935
	dc.s	0.521957,0.993038
	dc.s	0.635266,0.734697
	dc.s	0.516252,0.864935
	dc.s	0.640971,0.862799
	dc.s	0.748575,0.476355
	dc.s	0.629561,0.606594
	dc.s	0.754280,0.604458
	dc.s	0.629561,0.606594
	dc.s	0.510547,0.736833
	dc.s	0.635266,0.734697
	dc.s	0.754280,0.604458
	dc.s	0.635266,0.734697
	dc.s	0.759984,0.732560
	dc.s	0.754280,0.604458
	dc.s	0.629561,0.606594
	dc.s	0.635266,0.734697
	dc.s	0.476318,-0.031783
	dc.s	0.482023,0.096320
	dc.s	0.601036,-0.033919
	dc.s	0.606741,0.094184
	dc.s	0.482023,0.096320
	dc.s	0.487728,0.224422
	dc.s	0.725755,-0.036055
	dc.s	0.601036,-0.033919
	dc.s	0.606741,0.094184
	dc.s	0.601036,-0.033919
	dc.s	0.482023,0.096320
	dc.s	0.606741,0.094184
	dc.s	0.737165,0.220150
	dc.s	0.612446,0.222286
	dc.s	0.618151,0.350389
	dc.s	0.612446,0.222286
	dc.s	0.487728,0.224422
	dc.s	0.493432,0.352525
	dc.s	0.618151,0.350389
	dc.s	0.493432,0.352525
	dc.s	0.499137,0.480628
	dc.s	0.612446,0.222286
	dc.s	0.493432,0.352525
	dc.s	0.618151,0.350389
	dc.s	0.975193,-0.040327
	dc.s	0.850474,-0.038191
	dc.s	0.856179,0.089912
	dc.s	0.850474,-0.038191
	dc.s	0.725755,-0.036055
	dc.s	0.731460,0.092048
	dc.s	0.856179,0.089912
	dc.s	0.731460,0.092048
	dc.s	0.737165,0.220150
	dc.s	0.856179,0.089912
	dc.s	0.850474,-0.038191
	dc.s	0.731460,0.092048
	dc.s	0.725755,-0.036055
	dc.s	0.606741,0.094184
	dc.s	0.731460,0.092048
	dc.s	0.612446,0.222286
	dc.s	0.606741,0.094184
	dc.s	0.487728,0.224422
	dc.s	0.737165,0.220150
	dc.s	0.731460,0.092048
	dc.s	0.612446,0.222286
	dc.s	0.731460,0.092048
	dc.s	0.606741,0.094184
	dc.s	0.612446,0.222286
	dc.s	0.226880,-0.027510
	dc.s	0.102162,-0.025374
	dc.s	0.107867,0.102728
	dc.s	0.102162,-0.025374
	dc.s	-0.022557,-0.023238
	dc.s	-0.016852,0.104864
	dc.s	0.107867,0.102728
	dc.s	-0.016852,0.104864
	dc.s	-0.011147,0.232967
	dc.s	0.102162,-0.025374
	dc.s	-0.016852,0.104864
	dc.s	0.107867,0.102728
	dc.s	0.238290,0.228695
	dc.s	0.113571,0.230831
	dc.s	0.119276,0.358933
	dc.s	0.113571,0.230831
	dc.s	-0.011147,0.232967
	dc.s	-0.005442,0.361069
	dc.s	0.119276,0.358933
	dc.s	-0.005442,0.361069
	dc.s	0.000262,0.489172
	dc.s	0.119276,0.358933
	dc.s	0.113571,0.230831
	dc.s	-0.005442,0.361069
	dc.s	0.351599,-0.029647
	dc.s	0.226880,-0.027510
	dc.s	0.232585,0.100592
	dc.s	0.357304,0.098456
	dc.s	0.232585,0.100592
	dc.s	0.238290,0.228695
	dc.s	0.351599,-0.029647
	dc.s	0.357304,0.098456
	dc.s	0.476318,-0.031783
	dc.s	0.351599,-0.029647
	dc.s	0.232585,0.100592
	dc.s	0.357304,0.098456
	dc.s	0.226880,-0.027510
	dc.s	0.107867,0.102728
	dc.s	0.232585,0.100592
	dc.s	0.113571,0.230831
	dc.s	0.107867,0.102728
	dc.s	-0.011147,0.232967
	dc.s	0.238290,0.228695
	dc.s	0.232585,0.100592
	dc.s	0.113571,0.230831
	dc.s	0.232585,0.100592
	dc.s	0.107867,0.102728
	dc.s	0.113571,0.230831
	dc.s	0.124981,0.487036
	dc.s	0.000262,0.489172
	dc.s	0.005967,0.617274
	dc.s	0.130686,0.615138
	dc.s	0.005967,0.617274
	dc.s	0.011672,0.745377
	dc.s	0.124981,0.487036
	dc.s	0.130686,0.615138
	dc.s	0.249700,0.484900
	dc.s	0.124981,0.487036
	dc.s	0.005967,0.617274
	dc.s	0.130686,0.615138
	dc.s	0.011672,0.745377
	dc.s	0.017377,0.873480
	dc.s	0.136391,0.743241
	dc.s	0.017377,0.873480
	dc.s	0.023082,1.001582
	dc.s	0.142096,0.871343
	dc.s	0.136391,0.743241
	dc.s	0.142096,0.871343
	dc.s	0.261110,0.741105
	dc.s	0.017377,0.873480
	dc.s	0.142096,0.871343
	dc.s	0.136391,0.743241
	dc.s	0.249700,0.484900
	dc.s	0.255405,0.613002
	dc.s	0.374419,0.482764
	dc.s	0.380123,0.610866
	dc.s	0.255405,0.613002
	dc.s	0.261110,0.741105
	dc.s	0.499137,0.480628
	dc.s	0.374419,0.482764
	dc.s	0.380123,0.610866
	dc.s	0.374419,0.482764
	dc.s	0.255405,0.613002
	dc.s	0.380123,0.610866
	dc.s	0.130686,0.615138
	dc.s	0.011672,0.745377
	dc.s	0.136391,0.743241
	dc.s	0.136391,0.743241
	dc.s	0.261110,0.741105
	dc.s	0.255405,0.613002
	dc.s	0.130686,0.615138
	dc.s	0.255405,0.613002
	dc.s	0.249700,0.484900
	dc.s	0.130686,0.615138
	dc.s	0.136391,0.743241
	dc.s	0.255405,0.613002
	dc.s	0.243995,0.356797
	dc.s	0.238290,0.228695
	dc.s	0.119276,0.358933
	dc.s	0.124981,0.487036
	dc.s	0.119276,0.358933
	dc.s	0.000262,0.489172
	dc.s	0.243995,0.356797
	dc.s	0.124981,0.487036
	dc.s	0.249700,0.484900
	dc.s	0.243995,0.356797
	dc.s	0.119276,0.358933
	dc.s	0.124981,0.487036
	dc.s	0.249700,0.484900
	dc.s	0.374419,0.482764
	dc.s	0.368714,0.354661
	dc.s	0.493432,0.352525
	dc.s	0.374419,0.482764
	dc.s	0.499137,0.480628
	dc.s	0.487728,0.224422
	dc.s	0.368714,0.354661
	dc.s	0.493432,0.352525
	dc.s	0.493432,0.352525
	dc.s	0.368714,0.354661
	dc.s	0.374419,0.482764
	dc.s	0.357304,0.098456
	dc.s	0.238290,0.228695
	dc.s	0.363009,0.226559
	dc.s	0.363009,0.226559
	dc.s	0.487728,0.224422
	dc.s	0.482023,0.096320
	dc.s	0.357304,0.098456
	dc.s	0.482023,0.096320
	dc.s	0.476318,-0.031783
	dc.s	0.357304,0.098456
	dc.s	0.363009,0.226559
	dc.s	0.482023,0.096320
	dc.s	0.243995,0.356797
	dc.s	0.363009,0.226559
	dc.s	0.238290,0.228695
	dc.s	0.243995,0.356797
	dc.s	0.249700,0.484900
	dc.s	0.368714,0.354661
	dc.s	0.363009,0.226559
	dc.s	0.368714,0.354661
	dc.s	0.487728,0.224422
	dc.s	0.243995,0.356797
	dc.s	0.368714,0.354661
	dc.s	0.363009,0.226559
	dc.s	-0.797522,-0.248504
	dc.s	-0.466892,-0.048878
	dc.s	-0.797522,-0.048878
	dc.s	-0.466892,-0.048878
	dc.s	-0.136261,0.150748
	dc.s	-0.466892,0.150748
	dc.s	-0.797522,-0.048878
	dc.s	-0.466892,0.150748
	dc.s	-0.797522,0.150748
	dc.s	-0.797522,-0.048878
	dc.s	-0.466892,-0.048878
	dc.s	-0.466892,0.150748
	dc.s	-0.136261,0.150748
	dc.s	0.194369,0.350374
	dc.s	-0.136261,0.350374
	dc.s	0.194369,0.350374
	dc.s	0.525000,0.550000
	dc.s	0.194369,0.550000
	dc.s	-0.136261,0.350374
	dc.s	0.194369,0.550000
	dc.s	-0.136261,0.550000
	dc.s	-0.136261,0.350374
	dc.s	0.194369,0.350374
	dc.s	0.194369,0.550000
	dc.s	-0.797522,0.150748
	dc.s	-0.466892,0.350374
	dc.s	-0.797522,0.350374
	dc.s	-0.466892,0.350374
	dc.s	-0.136261,0.550000
	dc.s	-0.466892,0.550000
	dc.s	-0.797522,0.350374
	dc.s	-0.466892,0.550000
	dc.s	-0.797522,0.550000
	dc.s	-0.797522,0.350374
	dc.s	-0.466892,0.350374
	dc.s	-0.466892,0.550000
	dc.s	-0.797522,0.150748
	dc.s	-0.466892,0.150748
	dc.s	-0.466892,0.350374
	dc.s	-0.466892,0.150748
	dc.s	-0.136261,0.150748
	dc.s	-0.136261,0.350374
	dc.s	-0.466892,0.350374
	dc.s	-0.136261,0.350374
	dc.s	-0.136261,0.550000
	dc.s	-0.466892,0.150748
	dc.s	-0.136261,0.350374
	dc.s	-0.466892,0.350374
	dc.s	0.525000,0.550000
	dc.s	0.855631,0.749626
	dc.s	0.525000,0.749626
	dc.s	0.855631,0.749626
	dc.s	1.186261,0.949252
	dc.s	0.855631,0.949252
	dc.s	0.525000,0.749626
	dc.s	0.855631,0.949252
	dc.s	0.525000,0.949252
	dc.s	0.525000,0.749626
	dc.s	0.855631,0.749626
	dc.s	0.855631,0.949252
	dc.s	1.186261,0.949252
	dc.s	1.516892,1.148878
	dc.s	1.186261,1.148878
	dc.s	1.516892,1.148878
	dc.s	1.847522,1.348504
	dc.s	1.516892,1.348504
	dc.s	1.186261,1.148878
	dc.s	1.516892,1.348504
	dc.s	1.186261,1.348504
	dc.s	1.186261,1.148878
	dc.s	1.516892,1.148878
	dc.s	1.516892,1.348504
	dc.s	0.525000,0.949252
	dc.s	0.855631,1.148878
	dc.s	0.525000,1.148878
	dc.s	0.855631,1.148878
	dc.s	1.186261,1.348504
	dc.s	0.855631,1.348504
	dc.s	0.525000,1.148878
	dc.s	0.855631,1.348504
	dc.s	0.525000,1.348504
	dc.s	0.525000,1.148878
	dc.s	0.855631,1.148878
	dc.s	0.855631,1.348504
	dc.s	0.525000,0.949252
	dc.s	0.855631,0.949252
	dc.s	0.855631,1.148878
	dc.s	0.855631,0.949252
	dc.s	1.186261,0.949252
	dc.s	1.186261,1.148878
	dc.s	0.855631,1.148878
	dc.s	1.186261,1.148878
	dc.s	1.186261,1.348504
	dc.s	0.855631,0.949252
	dc.s	1.186261,1.148878
	dc.s	0.855631,1.148878
	dc.s	-0.797522,0.550000
	dc.s	-0.466892,0.749626
	dc.s	-0.797522,0.749626
	dc.s	-0.466892,0.749626
	dc.s	-0.136261,0.949252
	dc.s	-0.466892,0.949252
	dc.s	-0.797522,0.749626
	dc.s	-0.466892,0.949252
	dc.s	-0.797522,0.949252
	dc.s	-0.466892,0.749626
	dc.s	-0.466892,0.949252
	dc.s	-0.797522,0.749626
	dc.s	-0.136261,0.949252
	dc.s	0.194369,1.148878
	dc.s	-0.136261,1.148878
	dc.s	0.194369,1.148878
	dc.s	0.525000,1.348504
	dc.s	0.194369,1.348504
	dc.s	-0.136261,1.148878
	dc.s	0.194369,1.348504
	dc.s	-0.136261,1.348504
	dc.s	0.194369,1.148878
	dc.s	0.194369,1.348504
	dc.s	-0.136261,1.148878
	dc.s	-0.797522,0.949252
	dc.s	-0.466892,1.148878
	dc.s	-0.797522,1.148878
	dc.s	-0.466892,1.148878
	dc.s	-0.136261,1.348504
	dc.s	-0.466892,1.348504
	dc.s	-0.797522,1.148878
	dc.s	-0.466892,1.348504
	dc.s	-0.797522,1.348504
	dc.s	-0.797522,1.148878
	dc.s	-0.466892,1.148878
	dc.s	-0.466892,1.348504
	dc.s	-0.136261,0.949252
	dc.s	-0.136261,1.148878
	dc.s	-0.466892,0.949252
	dc.s	-0.136261,1.148878
	dc.s	-0.136261,1.348504
	dc.s	-0.466892,1.148878
	dc.s	-0.466892,0.949252
	dc.s	-0.466892,1.148878
	dc.s	-0.797522,0.949252
	dc.s	-0.466892,0.949252
	dc.s	-0.136261,1.148878
	dc.s	-0.466892,1.148878
	dc.s	-0.797522,0.550000
	dc.s	-0.466892,0.550000
	dc.s	-0.466892,0.749626
	dc.s	-0.466892,0.550000
	dc.s	-0.136261,0.550000
	dc.s	-0.136261,0.749626
	dc.s	-0.466892,0.749626
	dc.s	-0.136261,0.749626
	dc.s	-0.136261,0.949252
	dc.s	-0.466892,0.550000
	dc.s	-0.136261,0.749626
	dc.s	-0.466892,0.749626
	dc.s	-0.136261,0.550000
	dc.s	0.194369,0.550000
	dc.s	0.194369,0.749626
	dc.s	0.194369,0.550000
	dc.s	0.525000,0.550000
	dc.s	0.525000,0.749626
	dc.s	0.194369,0.749626
	dc.s	0.525000,0.749626
	dc.s	0.525000,0.949252
	dc.s	0.194369,0.550000
	dc.s	0.525000,0.749626
	dc.s	0.194369,0.749626
	dc.s	-0.136261,0.949252
	dc.s	0.194369,0.949252
	dc.s	0.194369,1.148878
	dc.s	0.194369,0.949252
	dc.s	0.525000,0.949252
	dc.s	0.525000,1.148878
	dc.s	0.194369,1.148878
	dc.s	0.525000,1.148878
	dc.s	0.525000,1.348504
	dc.s	0.194369,0.949252
	dc.s	0.525000,1.148878
	dc.s	0.194369,1.148878
	dc.s	-0.136261,0.550000
	dc.s	0.194369,0.749626
	dc.s	-0.136261,0.749626
	dc.s	0.194369,0.749626
	dc.s	0.525000,0.949252
	dc.s	0.194369,0.949252
	dc.s	-0.136261,0.749626
	dc.s	0.194369,0.949252
	dc.s	-0.136261,0.949252
	dc.s	-0.136261,0.749626
	dc.s	0.194369,0.749626
	dc.s	0.194369,0.949252
	dc.s	0.525000,-0.248504
	dc.s	0.525000,-0.048878
	dc.s	0.194369,-0.248504
	dc.s	0.525000,-0.048878
	dc.s	0.525000,0.150748
	dc.s	0.194369,-0.048878
	dc.s	0.194369,-0.248504
	dc.s	0.194369,-0.048878
	dc.s	-0.136261,-0.248504
	dc.s	0.194369,-0.248504
	dc.s	0.525000,-0.048878
	dc.s	0.194369,-0.048878
	dc.s	0.525000,0.150748
	dc.s	0.525000,0.350374
	dc.s	0.194369,0.150748
	dc.s	0.525000,0.350374
	dc.s	0.525000,0.550000
	dc.s	0.194369,0.350374
	dc.s	0.194369,0.150748
	dc.s	0.194369,0.350374
	dc.s	-0.136261,0.150748
	dc.s	0.194369,0.150748
	dc.s	0.525000,0.350374
	dc.s	0.194369,0.350374
	dc.s	-0.136261,-0.248504
	dc.s	-0.136261,-0.048878
	dc.s	-0.466892,-0.248504
	dc.s	-0.136261,-0.048878
	dc.s	-0.136261,0.150748
	dc.s	-0.466892,-0.048878
	dc.s	-0.466892,-0.248504
	dc.s	-0.466892,-0.048878
	dc.s	-0.797522,-0.248504
	dc.s	-0.466892,-0.248504
	dc.s	-0.136261,-0.048878
	dc.s	-0.466892,-0.048878
	dc.s	-0.136261,-0.248504
	dc.s	0.194369,-0.048878
	dc.s	-0.136261,-0.048878
	dc.s	0.194369,-0.048878
	dc.s	0.525000,0.150748
	dc.s	0.194369,0.150748
	dc.s	-0.136261,-0.048878
	dc.s	0.194369,0.150748
	dc.s	-0.136261,0.150748
	dc.s	0.194369,-0.048878
	dc.s	0.194369,0.150748
	dc.s	-0.136261,-0.048878
	dc.s	0.525000,-0.248504
	dc.s	0.855631,-0.248504
	dc.s	0.855631,-0.048878
	dc.s	0.855631,-0.248504
	dc.s	1.186261,-0.248504
	dc.s	1.186261,-0.048878
	dc.s	0.855631,-0.048878
	dc.s	1.186261,-0.048878
	dc.s	1.186261,0.150748
	dc.s	0.855631,-0.248504
	dc.s	1.186261,-0.048878
	dc.s	0.855631,-0.048878
	dc.s	1.186261,-0.248504
	dc.s	1.516892,-0.248504
	dc.s	1.516892,-0.048878
	dc.s	1.516892,-0.248504
	dc.s	1.847522,-0.248504
	dc.s	1.847522,-0.048878
	dc.s	1.516892,-0.048878
	dc.s	1.847522,-0.048878
	dc.s	1.847522,0.150748
	dc.s	1.516892,-0.248504
	dc.s	1.847522,-0.048878
	dc.s	1.516892,-0.048878
	dc.s	1.186261,0.150748
	dc.s	1.516892,0.150748
	dc.s	1.516892,0.350374
	dc.s	1.516892,0.150748
	dc.s	1.847522,0.150748
	dc.s	1.847522,0.350374
	dc.s	1.516892,0.350374
	dc.s	1.847522,0.350374
	dc.s	1.847522,0.550000
	dc.s	1.516892,0.150748
	dc.s	1.847522,0.350374
	dc.s	1.516892,0.350374
	dc.s	1.186261,-0.248504
	dc.s	1.516892,-0.048878
	dc.s	1.186261,-0.048878
	dc.s	1.516892,-0.048878
	dc.s	1.847522,0.150748
	dc.s	1.516892,0.150748
	dc.s	1.186261,-0.048878
	dc.s	1.516892,0.150748
	dc.s	1.186261,0.150748
	dc.s	1.186261,-0.048878
	dc.s	1.516892,-0.048878
	dc.s	1.516892,0.150748
	dc.s	0.525000,0.550000
	dc.s	0.855631,0.550000
	dc.s	0.855631,0.749626
	dc.s	0.855631,0.550000
	dc.s	1.186261,0.550000
	dc.s	1.186261,0.749626
	dc.s	0.855631,0.749626
	dc.s	1.186261,0.749626
	dc.s	1.186261,0.949252
	dc.s	0.855631,0.550000
	dc.s	1.186261,0.749626
	dc.s	0.855631,0.749626
	dc.s	1.186261,0.550000
	dc.s	1.516892,0.550000
	dc.s	1.516892,0.749626
	dc.s	1.516892,0.550000
	dc.s	1.847522,0.550000
	dc.s	1.847522,0.749626
	dc.s	1.516892,0.749626
	dc.s	1.847522,0.749626
	dc.s	1.847522,0.949252
	dc.s	1.516892,0.550000
	dc.s	1.847522,0.749626
	dc.s	1.516892,0.749626
	dc.s	1.186261,0.949252
	dc.s	1.516892,0.949252
	dc.s	1.516892,1.148878
	dc.s	1.516892,0.949252
	dc.s	1.847522,0.949252
	dc.s	1.847522,1.148878
	dc.s	1.516892,1.148878
	dc.s	1.847522,1.148878
	dc.s	1.847522,1.348504
	dc.s	1.516892,0.949252
	dc.s	1.847522,1.148878
	dc.s	1.516892,1.148878
	dc.s	1.186261,0.550000
	dc.s	1.516892,0.749626
	dc.s	1.186261,0.749626
	dc.s	1.516892,0.749626
	dc.s	1.847522,0.949252
	dc.s	1.516892,0.949252
	dc.s	1.186261,0.749626
	dc.s	1.516892,0.949252
	dc.s	1.186261,0.949252
	dc.s	1.186261,0.749626
	dc.s	1.516892,0.749626
	dc.s	1.516892,0.949252
	dc.s	0.525000,-0.248504
	dc.s	0.855631,-0.048878
	dc.s	0.525000,-0.048878
	dc.s	0.855631,-0.048878
	dc.s	1.186261,0.150748
	dc.s	0.855631,0.150748
	dc.s	0.525000,-0.048878
	dc.s	0.855631,0.150748
	dc.s	0.525000,0.150748
	dc.s	0.525000,-0.048878
	dc.s	0.855631,-0.048878
	dc.s	0.855631,0.150748
	dc.s	1.186261,0.150748
	dc.s	1.516892,0.350374
	dc.s	1.186261,0.350374
	dc.s	1.516892,0.350374
	dc.s	1.847522,0.550000
	dc.s	1.516892,0.550000
	dc.s	1.186261,0.350374
	dc.s	1.516892,0.550000
	dc.s	1.186261,0.550000
	dc.s	1.186261,0.350374
	dc.s	1.516892,0.350374
	dc.s	1.516892,0.550000
	dc.s	0.525000,0.150748
	dc.s	0.855631,0.350374
	dc.s	0.525000,0.350374
	dc.s	0.855631,0.350374
	dc.s	1.186261,0.550000
	dc.s	0.855631,0.550000
	dc.s	0.525000,0.350374
	dc.s	0.855631,0.550000
	dc.s	0.525000,0.550000
	dc.s	0.525000,0.350374
	dc.s	0.855631,0.350374
	dc.s	0.855631,0.550000
	dc.s	0.525000,0.150748
	dc.s	0.855631,0.150748
	dc.s	0.855631,0.350374
	dc.s	0.855631,0.150748
	dc.s	1.186261,0.150748
	dc.s	1.186261,0.350374
	dc.s	0.855631,0.350374
	dc.s	1.186261,0.350374
	dc.s	1.186261,0.550000
	dc.s	0.855631,0.150748
	dc.s	1.186261,0.350374
	dc.s	0.855631,0.350374
	dc.s	0.980044,0.062538
	dc.s	0.860033,0.174031
	dc.s	0.980044,0.174031
	dc.s	0.860033,0.174031
	dc.s	0.740022,0.285524
	dc.s	0.860033,0.285524
	dc.s	0.980044,0.174031
	dc.s	0.860033,0.285524
	dc.s	0.980044,0.285524
	dc.s	0.860033,0.174031
	dc.s	0.860033,0.285524
	dc.s	0.980044,0.174031
	dc.s	0.740022,0.285524
	dc.s	0.620011,0.397017
	dc.s	0.740022,0.397017
	dc.s	0.620011,0.397017
	dc.s	0.500000,0.508511
	dc.s	0.620011,0.508511
	dc.s	0.740022,0.397017
	dc.s	0.620011,0.508511
	dc.s	0.740022,0.508511
	dc.s	0.620011,0.397017
	dc.s	0.620011,0.508511
	dc.s	0.740022,0.397017
	dc.s	0.980044,0.285524
	dc.s	0.860033,0.397017
	dc.s	0.980044,0.397017
	dc.s	0.860033,0.397017
	dc.s	0.740022,0.508511
	dc.s	0.860033,0.508511
	dc.s	0.980044,0.397017
	dc.s	0.860033,0.508511
	dc.s	0.980044,0.508511
	dc.s	0.860033,0.397017
	dc.s	0.860033,0.508511
	dc.s	0.980044,0.397017
	dc.s	0.740022,0.285524
	dc.s	0.740022,0.397017
	dc.s	0.860033,0.285524
	dc.s	0.740022,0.397017
	dc.s	0.740022,0.508511
	dc.s	0.860033,0.397017
	dc.s	0.860033,0.285524
	dc.s	0.860033,0.397017
	dc.s	0.980044,0.285524
	dc.s	0.860033,0.285524
	dc.s	0.740022,0.397017
	dc.s	0.860033,0.397017
	dc.s	0.500000,0.508511
	dc.s	0.379989,0.620004
	dc.s	0.500000,0.620004
	dc.s	0.379989,0.620004
	dc.s	0.259978,0.731497
	dc.s	0.379989,0.731497
	dc.s	0.500000,0.620004
	dc.s	0.379989,0.731497
	dc.s	0.500000,0.731497
	dc.s	0.500000,0.620004
	dc.s	0.379989,0.620004
	dc.s	0.379989,0.731497
	dc.s	0.259978,0.731497
	dc.s	0.139967,0.842990
	dc.s	0.259978,0.842990
	dc.s	0.139967,0.842990
	dc.s	0.019956,0.954484
	dc.s	0.139967,0.954484
	dc.s	0.259978,0.842990
	dc.s	0.139967,0.954484
	dc.s	0.259978,0.954484
	dc.s	0.259978,0.842990
	dc.s	0.139967,0.842990
	dc.s	0.139967,0.954484
	dc.s	0.500000,0.731497
	dc.s	0.379989,0.842990
	dc.s	0.500000,0.842990
	dc.s	0.379989,0.842990
	dc.s	0.259978,0.954484
	dc.s	0.379989,0.954484
	dc.s	0.500000,0.842990
	dc.s	0.379989,0.954484
	dc.s	0.500000,0.954484
	dc.s	0.500000,0.842990
	dc.s	0.379989,0.842990
	dc.s	0.379989,0.954484
	dc.s	0.500000,0.731497
	dc.s	0.379989,0.731497
	dc.s	0.379989,0.842990
	dc.s	0.379989,0.731497
	dc.s	0.259978,0.731497
	dc.s	0.259978,0.842990
	dc.s	0.379989,0.842990
	dc.s	0.259978,0.842990
	dc.s	0.259978,0.954484
	dc.s	0.379989,0.731497
	dc.s	0.259978,0.842990
	dc.s	0.379989,0.842990
	dc.s	0.980044,0.508511
	dc.s	0.860033,0.620004
	dc.s	0.980044,0.620004
	dc.s	0.860033,0.620004
	dc.s	0.740022,0.731497
	dc.s	0.860033,0.731497
	dc.s	0.980044,0.620004
	dc.s	0.860033,0.731497
	dc.s	0.980044,0.731497
	dc.s	0.860033,0.620004
	dc.s	0.860033,0.731497
	dc.s	0.980044,0.620004
	dc.s	0.740022,0.731497
	dc.s	0.620011,0.842990
	dc.s	0.740022,0.842990
	dc.s	0.620011,0.842990
	dc.s	0.500000,0.954484
	dc.s	0.620011,0.954484
	dc.s	0.740022,0.842990
	dc.s	0.620011,0.954484
	dc.s	0.740022,0.954484
	dc.s	0.620011,0.842990
	dc.s	0.620011,0.954484
	dc.s	0.740022,0.842990
	dc.s	0.980044,0.731497
	dc.s	0.860033,0.842990
	dc.s	0.980044,0.842990
	dc.s	0.860033,0.842990
	dc.s	0.740022,0.954484
	dc.s	0.860033,0.954484
	dc.s	0.980044,0.842990
	dc.s	0.860033,0.954484
	dc.s	0.980044,0.954484
	dc.s	0.860033,0.842990
	dc.s	0.860033,0.954484
	dc.s	0.980044,0.842990
	dc.s	0.740022,0.731497
	dc.s	0.740022,0.842990
	dc.s	0.860033,0.731497
	dc.s	0.740022,0.842990
	dc.s	0.740022,0.954484
	dc.s	0.860033,0.842990
	dc.s	0.860033,0.731497
	dc.s	0.860033,0.842990
	dc.s	0.980044,0.731497
	dc.s	0.860033,0.731497
	dc.s	0.740022,0.842990
	dc.s	0.860033,0.842990
	dc.s	0.500000,0.508511
	dc.s	0.500000,0.620004
	dc.s	0.620011,0.508511
	dc.s	0.500000,0.620004
	dc.s	0.500000,0.731497
	dc.s	0.620011,0.620004
	dc.s	0.620011,0.508511
	dc.s	0.620011,0.620004
	dc.s	0.740022,0.508511
	dc.s	0.620011,0.508511
	dc.s	0.500000,0.620004
	dc.s	0.620011,0.620004
	dc.s	0.500000,0.731497
	dc.s	0.500000,0.842990
	dc.s	0.620011,0.731497
	dc.s	0.500000,0.842990
	dc.s	0.500000,0.954484
	dc.s	0.620011,0.842990
	dc.s	0.620011,0.731497
	dc.s	0.620011,0.842990
	dc.s	0.740022,0.731497
	dc.s	0.620011,0.731497
	dc.s	0.500000,0.842990
	dc.s	0.620011,0.842990
	dc.s	0.740022,0.508511
	dc.s	0.740022,0.620004
	dc.s	0.860033,0.508511
	dc.s	0.740022,0.620004
	dc.s	0.740022,0.731497
	dc.s	0.860033,0.620004
	dc.s	0.860033,0.508511
	dc.s	0.860033,0.620004
	dc.s	0.980044,0.508511
	dc.s	0.860033,0.508511
	dc.s	0.740022,0.620004
	dc.s	0.860033,0.620004
	dc.s	0.740022,0.508511
	dc.s	0.620011,0.620004
	dc.s	0.740022,0.620004
	dc.s	0.620011,0.620004
	dc.s	0.500000,0.731497
	dc.s	0.620011,0.731497
	dc.s	0.740022,0.620004
	dc.s	0.620011,0.731497
	dc.s	0.740022,0.731497
	dc.s	0.620011,0.620004
	dc.s	0.620011,0.731497
	dc.s	0.740022,0.620004
	dc.s	0.980044,0.062538
	dc.s	0.860033,0.062538
	dc.s	0.860033,0.174031
	dc.s	0.740022,0.062538
	dc.s	0.740022,0.174031
	dc.s	0.860033,0.062538
	dc.s	0.740022,0.174031
	dc.s	0.740022,0.285524
	dc.s	0.860033,0.174031
	dc.s	0.860033,0.062538
	dc.s	0.740022,0.174031
	dc.s	0.860033,0.174031
	dc.s	0.500000,0.062538
	dc.s	0.500000,0.174031
	dc.s	0.620011,0.062538
	dc.s	0.500000,0.174031
	dc.s	0.500000,0.285524
	dc.s	0.620011,0.174031
	dc.s	0.620011,0.062538
	dc.s	0.620011,0.174031
	dc.s	0.740022,0.062538
	dc.s	0.620011,0.062538
	dc.s	0.500000,0.174031
	dc.s	0.620011,0.174031
	dc.s	0.500000,0.285524
	dc.s	0.500000,0.397017
	dc.s	0.620011,0.285524
	dc.s	0.500000,0.397017
	dc.s	0.500000,0.508511
	dc.s	0.620011,0.397017
	dc.s	0.620011,0.285524
	dc.s	0.620011,0.397017
	dc.s	0.740022,0.285524
	dc.s	0.620011,0.285524
	dc.s	0.500000,0.397017
	dc.s	0.620011,0.397017
	dc.s	0.740022,0.062538
	dc.s	0.620011,0.174031
	dc.s	0.740022,0.174031
	dc.s	0.620011,0.174031
	dc.s	0.500000,0.285524
	dc.s	0.620011,0.285524
	dc.s	0.740022,0.174031
	dc.s	0.620011,0.285524
	dc.s	0.740022,0.285524
	dc.s	0.620011,0.174031
	dc.s	0.620011,0.285524
	dc.s	0.740022,0.174031
	dc.s	0.500000,0.062538
	dc.s	0.379989,0.062538
	dc.s	0.379989,0.174031
	dc.s	0.379989,0.062538
	dc.s	0.259978,0.062538
	dc.s	0.259978,0.174031
	dc.s	0.379989,0.174031
	dc.s	0.259978,0.174031
	dc.s	0.259978,0.285524
	dc.s	0.379989,0.062538
	dc.s	0.259978,0.174031
	dc.s	0.379989,0.174031
	dc.s	0.259978,0.062538
	dc.s	0.139967,0.062538
	dc.s	0.139967,0.174031
	dc.s	0.139967,0.062538
	dc.s	0.019956,0.062538
	dc.s	0.019956,0.174031
	dc.s	0.139967,0.174031
	dc.s	0.019956,0.174031
	dc.s	0.019956,0.285524
	dc.s	0.139967,0.062538
	dc.s	0.019956,0.174031
	dc.s	0.139967,0.174031
	dc.s	0.259978,0.285524
	dc.s	0.139967,0.285524
	dc.s	0.139967,0.397017
	dc.s	0.139967,0.285524
	dc.s	0.019956,0.285524
	dc.s	0.019956,0.397017
	dc.s	0.139967,0.397017
	dc.s	0.019956,0.397017
	dc.s	0.019956,0.508511
	dc.s	0.139967,0.285524
	dc.s	0.019956,0.397017
	dc.s	0.139967,0.397017
	dc.s	0.259978,0.062538
	dc.s	0.139967,0.174031
	dc.s	0.259978,0.174031
	dc.s	0.139967,0.174031
	dc.s	0.019956,0.285524
	dc.s	0.139967,0.285524
	dc.s	0.259978,0.174031
	dc.s	0.139967,0.285524
	dc.s	0.259978,0.285524
	dc.s	0.259978,0.174031
	dc.s	0.139967,0.174031
	dc.s	0.139967,0.285524
	dc.s	0.500000,0.508511
	dc.s	0.379989,0.508511
	dc.s	0.379989,0.620004
	dc.s	0.379989,0.508511
	dc.s	0.259978,0.508511
	dc.s	0.259978,0.620004
	dc.s	0.379989,0.620004
	dc.s	0.259978,0.620004
	dc.s	0.259978,0.731497
	dc.s	0.379989,0.508511
	dc.s	0.259978,0.620004
	dc.s	0.379989,0.620004
	dc.s	0.259978,0.508511
	dc.s	0.139967,0.508511
	dc.s	0.139967,0.620004
	dc.s	0.139967,0.508511
	dc.s	0.019956,0.508511
	dc.s	0.019956,0.620004
	dc.s	0.139967,0.620004
	dc.s	0.019956,0.620004
	dc.s	0.019956,0.731497
	dc.s	0.139967,0.508511
	dc.s	0.019956,0.620004
	dc.s	0.139967,0.620004
	dc.s	0.259978,0.731497
	dc.s	0.139967,0.731497
	dc.s	0.139967,0.842990
	dc.s	0.139967,0.731497
	dc.s	0.019956,0.731497
	dc.s	0.019956,0.842990
	dc.s	0.139967,0.842990
	dc.s	0.019956,0.842990
	dc.s	0.019956,0.954484
	dc.s	0.139967,0.731497
	dc.s	0.019956,0.842990
	dc.s	0.139967,0.842990
	dc.s	0.259978,0.508511
	dc.s	0.139967,0.620004
	dc.s	0.259978,0.620004
	dc.s	0.139967,0.620004
	dc.s	0.019956,0.731497
	dc.s	0.139967,0.731497
	dc.s	0.259978,0.620004
	dc.s	0.139967,0.731497
	dc.s	0.259978,0.731497
	dc.s	0.259978,0.620004
	dc.s	0.139967,0.620004
	dc.s	0.139967,0.731497
	dc.s	0.500000,0.062538
	dc.s	0.379989,0.174031
	dc.s	0.500000,0.174031
	dc.s	0.379989,0.174031
	dc.s	0.259978,0.285524
	dc.s	0.379989,0.285524
	dc.s	0.500000,0.174031
	dc.s	0.379989,0.285524
	dc.s	0.500000,0.285524
	dc.s	0.500000,0.174031
	dc.s	0.379989,0.174031
	dc.s	0.379989,0.285524
	dc.s	0.259978,0.285524
	dc.s	0.139967,0.397017
	dc.s	0.259978,0.397017
	dc.s	0.139967,0.397017
	dc.s	0.019956,0.508511
	dc.s	0.139967,0.508511
	dc.s	0.259978,0.397017
	dc.s	0.139967,0.508511
	dc.s	0.259978,0.508511
	dc.s	0.259978,0.397017
	dc.s	0.139967,0.397017
	dc.s	0.139967,0.508511
	dc.s	0.500000,0.285524
	dc.s	0.379989,0.397017
	dc.s	0.500000,0.397017
	dc.s	0.379989,0.397017
	dc.s	0.259978,0.508511
	dc.s	0.379989,0.508511
	dc.s	0.500000,0.397017
	dc.s	0.379989,0.508511
	dc.s	0.500000,0.508511
	dc.s	0.500000,0.397017
	dc.s	0.379989,0.397017
	dc.s	0.379989,0.508511
	dc.s	0.500000,0.285524
	dc.s	0.379989,0.285524
	dc.s	0.379989,0.397017
	dc.s	0.379989,0.285524
	dc.s	0.259978,0.285524
	dc.s	0.259978,0.397017
	dc.s	0.379989,0.397017
	dc.s	0.259978,0.397017
	dc.s	0.259978,0.508511
	dc.s	0.379989,0.285524
	dc.s	0.259978,0.397017
	dc.s	0.379989,0.397017
	dc.s	0.017328,0.021445
	dc.s	0.137996,0.141083
	dc.s	0.137996,0.021445
	dc.s	0.258664,0.141083
	dc.s	0.137996,0.141083
	dc.s	0.258664,0.260722
	dc.s	0.258664,0.021445
	dc.s	0.137996,0.021445
	dc.s	0.258664,0.141083
	dc.s	0.137996,0.021445
	dc.s	0.137996,0.141083
	dc.s	0.258664,0.141083
	dc.s	0.500000,0.260722
	dc.s	0.379332,0.260722
	dc.s	0.500000,0.380361
	dc.s	0.379332,0.260722
	dc.s	0.258664,0.260722
	dc.s	0.379332,0.380361
	dc.s	0.500000,0.380361
	dc.s	0.379332,0.380361
	dc.s	0.500000,0.500000
	dc.s	0.379332,0.260722
	dc.s	0.379332,0.380361
	dc.s	0.500000,0.380361
	dc.s	0.500000,0.021445
	dc.s	0.379332,0.021445
	dc.s	0.500000,0.141083
	dc.s	0.379332,0.021445
	dc.s	0.258664,0.021445
	dc.s	0.379332,0.141083
	dc.s	0.500000,0.141083
	dc.s	0.379332,0.141083
	dc.s	0.500000,0.260722
	dc.s	0.379332,0.021445
	dc.s	0.379332,0.141083
	dc.s	0.500000,0.141083
	dc.s	0.258664,0.021445
	dc.s	0.258664,0.141083
	dc.s	0.379332,0.141083
	dc.s	0.258664,0.141083
	dc.s	0.258664,0.260722
	dc.s	0.379332,0.260722
	dc.s	0.379332,0.141083
	dc.s	0.379332,0.260722
	dc.s	0.500000,0.260722
	dc.s	0.379332,0.141083
	dc.s	0.258664,0.141083
	dc.s	0.379332,0.260722
	dc.s	0.500000,0.500000
	dc.s	0.620668,0.619639
	dc.s	0.620668,0.500000
	dc.s	0.620668,0.619639
	dc.s	0.741336,0.739278
	dc.s	0.741336,0.619639
	dc.s	0.620668,0.500000
	dc.s	0.741336,0.619639
	dc.s	0.741336,0.500000
	dc.s	0.620668,0.500000
	dc.s	0.620668,0.619639
	dc.s	0.741336,0.619639
	dc.s	0.741336,0.739278
	dc.s	0.862004,0.858917
	dc.s	0.862004,0.739278
	dc.s	0.862004,0.858917
	dc.s	0.982672,0.978555
	dc.s	0.982672,0.858917
	dc.s	0.862004,0.739278
	dc.s	0.982672,0.858917
	dc.s	0.982672,0.739278
	dc.s	0.862004,0.739278
	dc.s	0.862004,0.858917
	dc.s	0.982672,0.858917
	dc.s	0.741336,0.500000
	dc.s	0.862004,0.619639
	dc.s	0.862004,0.500000
	dc.s	0.862004,0.619639
	dc.s	0.982672,0.739278
	dc.s	0.982672,0.619639
	dc.s	0.862004,0.500000
	dc.s	0.982672,0.619639
	dc.s	0.982672,0.500000
	dc.s	0.862004,0.500000
	dc.s	0.862004,0.619639
	dc.s	0.982672,0.619639
	dc.s	0.741336,0.500000
	dc.s	0.741336,0.619639
	dc.s	0.862004,0.619639
	dc.s	0.741336,0.619639
	dc.s	0.741336,0.739278
	dc.s	0.862004,0.739278
	dc.s	0.862004,0.619639
	dc.s	0.862004,0.739278
	dc.s	0.982672,0.739278
	dc.s	0.741336,0.619639
	dc.s	0.862004,0.739278
	dc.s	0.862004,0.619639
	dc.s	0.500000,0.021445
	dc.s	0.620668,0.141083
	dc.s	0.620668,0.021445
	dc.s	0.620668,0.141083
	dc.s	0.741336,0.260722
	dc.s	0.741336,0.141083
	dc.s	0.620668,0.021445
	dc.s	0.741336,0.141083
	dc.s	0.741336,0.021445
	dc.s	0.620668,0.021445
	dc.s	0.620668,0.141083
	dc.s	0.741336,0.141083
	dc.s	0.741336,0.260722
	dc.s	0.862004,0.380361
	dc.s	0.862004,0.260722
	dc.s	0.862004,0.380361
	dc.s	0.982672,0.500000
	dc.s	0.982672,0.380361
	dc.s	0.862004,0.260722
	dc.s	0.982672,0.380361
	dc.s	0.982672,0.260722
	dc.s	0.862004,0.260722
	dc.s	0.862004,0.380361
	dc.s	0.982672,0.380361
	dc.s	0.741336,0.021445
	dc.s	0.862004,0.141083
	dc.s	0.862004,0.021445
	dc.s	0.862004,0.141083
	dc.s	0.982672,0.260722
	dc.s	0.982672,0.141083
	dc.s	0.862004,0.021445
	dc.s	0.982672,0.141083
	dc.s	0.982672,0.021445
	dc.s	0.862004,0.021445
	dc.s	0.862004,0.141083
	dc.s	0.982672,0.141083
	dc.s	0.741336,0.021445
	dc.s	0.741336,0.141083
	dc.s	0.862004,0.141083
	dc.s	0.741336,0.141083
	dc.s	0.741336,0.260722
	dc.s	0.862004,0.260722
	dc.s	0.862004,0.141083
	dc.s	0.862004,0.260722
	dc.s	0.982672,0.260722
	dc.s	0.741336,0.141083
	dc.s	0.862004,0.260722
	dc.s	0.862004,0.141083
	dc.s	0.500000,0.021445
	dc.s	0.500000,0.141083
	dc.s	0.620668,0.141083
	dc.s	0.500000,0.141083
	dc.s	0.500000,0.260722
	dc.s	0.620668,0.260722
	dc.s	0.620668,0.141083
	dc.s	0.620668,0.260722
	dc.s	0.741336,0.260722
	dc.s	0.500000,0.141083
	dc.s	0.620668,0.260722
	dc.s	0.620668,0.141083
	dc.s	0.500000,0.260722
	dc.s	0.500000,0.380361
	dc.s	0.620668,0.380361
	dc.s	0.500000,0.380361
	dc.s	0.500000,0.500000
	dc.s	0.620668,0.500000
	dc.s	0.620668,0.380361
	dc.s	0.620668,0.500000
	dc.s	0.741336,0.500000
	dc.s	0.500000,0.380361
	dc.s	0.620668,0.500000
	dc.s	0.620668,0.380361
	dc.s	0.741336,0.260722
	dc.s	0.741336,0.380361
	dc.s	0.862004,0.380361
	dc.s	0.741336,0.380361
	dc.s	0.741336,0.500000
	dc.s	0.862004,0.500000
	dc.s	0.862004,0.380361
	dc.s	0.862004,0.500000
	dc.s	0.982672,0.500000
	dc.s	0.741336,0.380361
	dc.s	0.862004,0.500000
	dc.s	0.862004,0.380361
	dc.s	0.500000,0.260722
	dc.s	0.620668,0.380361
	dc.s	0.620668,0.260722
	dc.s	0.620668,0.380361
	dc.s	0.741336,0.500000
	dc.s	0.741336,0.380361
	dc.s	0.620668,0.260722
	dc.s	0.741336,0.380361
	dc.s	0.741336,0.260722
	dc.s	0.620668,0.260722
	dc.s	0.620668,0.380361
	dc.s	0.741336,0.380361
	dc.s	0.017328,0.021445
	dc.s	0.017328,0.141083
	dc.s	0.137996,0.141083
	dc.s	0.017328,0.141083
	dc.s	0.017328,0.260722
	dc.s	0.137996,0.260722
	dc.s	0.137996,0.141083
	dc.s	0.137996,0.260722
	dc.s	0.258664,0.260722
	dc.s	0.137996,0.141083
	dc.s	0.017328,0.141083
	dc.s	0.137996,0.260722
	dc.s	0.017328,0.260722
	dc.s	0.017328,0.380361
	dc.s	0.137996,0.380361
	dc.s	0.017328,0.380361
	dc.s	0.017328,0.500000
	dc.s	0.137996,0.500000
	dc.s	0.137996,0.380361
	dc.s	0.137996,0.500000
	dc.s	0.258664,0.500000
	dc.s	0.017328,0.380361
	dc.s	0.137996,0.500000
	dc.s	0.137996,0.380361
	dc.s	0.258664,0.260722
	dc.s	0.258664,0.380361
	dc.s	0.379332,0.380361
	dc.s	0.258664,0.380361
	dc.s	0.258664,0.500000
	dc.s	0.379332,0.500000
	dc.s	0.379332,0.380361
	dc.s	0.379332,0.500000
	dc.s	0.500000,0.500000
	dc.s	0.379332,0.380361
	dc.s	0.258664,0.380361
	dc.s	0.379332,0.500000
	dc.s	0.258664,0.260722
	dc.s	0.137996,0.260722
	dc.s	0.258664,0.380361
	dc.s	0.137996,0.260722
	dc.s	0.017328,0.260722
	dc.s	0.137996,0.380361
	dc.s	0.258664,0.380361
	dc.s	0.137996,0.380361
	dc.s	0.258664,0.500000
	dc.s	0.137996,0.260722
	dc.s	0.137996,0.380361
	dc.s	0.258664,0.380361
	dc.s	0.017328,0.500000
	dc.s	0.017328,0.619639
	dc.s	0.137996,0.619639
	dc.s	0.017328,0.619639
	dc.s	0.017328,0.739278
	dc.s	0.137996,0.739278
	dc.s	0.137996,0.619639
	dc.s	0.137996,0.739278
	dc.s	0.258664,0.739278
	dc.s	0.017328,0.619639
	dc.s	0.137996,0.739278
	dc.s	0.137996,0.619639
	dc.s	0.017328,0.739278
	dc.s	0.017328,0.858917
	dc.s	0.137996,0.858917
	dc.s	0.017328,0.858917
	dc.s	0.017328,0.978556
	dc.s	0.137996,0.978555
	dc.s	0.137996,0.858917
	dc.s	0.137996,0.978555
	dc.s	0.258664,0.978555
	dc.s	0.137996,0.858917
	dc.s	0.017328,0.858917
	dc.s	0.137996,0.978555
	dc.s	0.258664,0.739278
	dc.s	0.258664,0.858917
	dc.s	0.379332,0.858917
	dc.s	0.258664,0.858917
	dc.s	0.258664,0.978555
	dc.s	0.379332,0.978555
	dc.s	0.379332,0.858917
	dc.s	0.379332,0.978555
	dc.s	0.500000,0.978555
	dc.s	0.379332,0.858917
	dc.s	0.258664,0.858917
	dc.s	0.379332,0.978555
	dc.s	0.017328,0.739278
	dc.s	0.137996,0.858917
	dc.s	0.137996,0.739278
	dc.s	0.258664,0.858917
	dc.s	0.137996,0.858917
	dc.s	0.258664,0.978555
	dc.s	0.258664,0.739278
	dc.s	0.137996,0.739278
	dc.s	0.258664,0.858917
	dc.s	0.137996,0.739278
	dc.s	0.137996,0.858917
	dc.s	0.258664,0.858917
	dc.s	0.500000,0.500000
	dc.s	0.500000,0.619639
	dc.s	0.620668,0.619639
	dc.s	0.500000,0.619639
	dc.s	0.500000,0.739278
	dc.s	0.620668,0.739278
	dc.s	0.620668,0.619639
	dc.s	0.620668,0.739278
	dc.s	0.741336,0.739278
	dc.s	0.500000,0.619639
	dc.s	0.620668,0.739278
	dc.s	0.620668,0.619639
	dc.s	0.500000,0.739278
	dc.s	0.500000,0.858917
	dc.s	0.620668,0.858917
	dc.s	0.500000,0.858917
	dc.s	0.500000,0.978555
	dc.s	0.620668,0.978555
	dc.s	0.620668,0.858917
	dc.s	0.620668,0.978555
	dc.s	0.741336,0.978555
	dc.s	0.500000,0.858917
	dc.s	0.620668,0.978555
	dc.s	0.620668,0.858917
	dc.s	0.741336,0.739278
	dc.s	0.741336,0.858917
	dc.s	0.862004,0.858917
	dc.s	0.741336,0.858917
	dc.s	0.741336,0.978555
	dc.s	0.862004,0.978555
	dc.s	0.862004,0.858917
	dc.s	0.862004,0.978555
	dc.s	0.982672,0.978555
	dc.s	0.741336,0.858917
	dc.s	0.862004,0.978555
	dc.s	0.862004,0.858917
	dc.s	0.500000,0.739278
	dc.s	0.620668,0.858917
	dc.s	0.620668,0.739278
	dc.s	0.620668,0.858917
	dc.s	0.741336,0.978555
	dc.s	0.741336,0.858917
	dc.s	0.620668,0.739278
	dc.s	0.741336,0.858917
	dc.s	0.741336,0.739278
	dc.s	0.620668,0.739278
	dc.s	0.620668,0.858917
	dc.s	0.741336,0.858917
	dc.s	0.500000,0.500000
	dc.s	0.379332,0.500000
	dc.s	0.500000,0.619639
	dc.s	0.379332,0.500000
	dc.s	0.258664,0.500000
	dc.s	0.379332,0.619639
	dc.s	0.500000,0.619639
	dc.s	0.379332,0.619639
	dc.s	0.500000,0.739278
	dc.s	0.379332,0.500000
	dc.s	0.379332,0.619639
	dc.s	0.500000,0.619639
	dc.s	0.258664,0.500000
	dc.s	0.137996,0.500000
	dc.s	0.258664,0.619639
	dc.s	0.137996,0.500000
	dc.s	0.017328,0.500000
	dc.s	0.137996,0.619639
	dc.s	0.258664,0.619639
	dc.s	0.137996,0.619639
	dc.s	0.258664,0.739278
	dc.s	0.137996,0.500000
	dc.s	0.137996,0.619639
	dc.s	0.258664,0.619639
	dc.s	0.500000,0.739278
	dc.s	0.379332,0.739278
	dc.s	0.500000,0.858917
	dc.s	0.379332,0.739278
	dc.s	0.258664,0.739278
	dc.s	0.379332,0.858917
	dc.s	0.500000,0.858917
	dc.s	0.379332,0.858917
	dc.s	0.500000,0.978555
	dc.s	0.379332,0.739278
	dc.s	0.379332,0.858917
	dc.s	0.500000,0.858917
	dc.s	0.258664,0.500000
	dc.s	0.258664,0.619639
	dc.s	0.379332,0.619639
	dc.s	0.258664,0.619639
	dc.s	0.258664,0.739278
	dc.s	0.379332,0.739278
	dc.s	0.379332,0.619639
	dc.s	0.379332,0.739278
	dc.s	0.500000,0.739278
	dc.s	0.379332,0.619639
	dc.s	0.258664,0.619639
	dc.s	0.379332,0.739278
	dc.s	0.485423,0.036591
	dc.s	0.252623,0.036591
	dc.s	0.485423,0.270528
	dc.s	0.019823,0.036591
	dc.s	0.252623,0.270528
	dc.s	0.252623,0.036591
	dc.s	0.252623,0.270528
	dc.s	0.485423,0.504464
	dc.s	0.485423,0.270528
	dc.s	0.252623,0.036591
	dc.s	0.252623,0.270528
	dc.s	0.485423,0.270528
	dc.s	0.485423,0.504464
	dc.s	0.718223,0.738401
	dc.s	0.718223,0.504464
	dc.s	0.718223,0.738401
	dc.s	0.951023,0.972338
	dc.s	0.951023,0.738401
	dc.s	0.718223,0.504464
	dc.s	0.951023,0.738401
	dc.s	0.951023,0.504464
	dc.s	0.718223,0.504464
	dc.s	0.718223,0.738401
	dc.s	0.951023,0.738401
	dc.s	0.718223,0.036591
	dc.s	0.951023,0.270528
	dc.s	0.951023,0.036591
	dc.s	0.718223,0.036591
	dc.s	0.485423,0.036591
	dc.s	0.718223,0.270528
	dc.s	0.718223,0.270528
	dc.s	0.951023,0.504464
	dc.s	0.951023,0.270528
	dc.s	0.718223,0.036591
	dc.s	0.718223,0.270528
	dc.s	0.951023,0.270528
	dc.s	0.485423,0.036591
	dc.s	0.485423,0.270528
	dc.s	0.718223,0.270528
	dc.s	0.485423,0.270528
	dc.s	0.485423,0.504464
	dc.s	0.718223,0.504464
	dc.s	0.718223,0.270528
	dc.s	0.718223,0.504464
	dc.s	0.951023,0.504464
	dc.s	0.485423,0.270528
	dc.s	0.718223,0.504464
	dc.s	0.718223,0.270528
	dc.s	0.019823,0.036591
	dc.s	0.019823,0.270528
	dc.s	0.252623,0.270528
	dc.s	0.019823,0.270528
	dc.s	0.019823,0.504464
	dc.s	0.252623,0.504464
	dc.s	0.252623,0.270528
	dc.s	0.252623,0.504464
	dc.s	0.485423,0.504464
	dc.s	0.019823,0.270528
	dc.s	0.252623,0.504464
	dc.s	0.252623,0.270528
	dc.s	0.019823,0.504464
	dc.s	0.019823,0.738401
	dc.s	0.252623,0.738401
	dc.s	0.019823,0.738401
	dc.s	0.019823,0.972338
	dc.s	0.252623,0.972338
	dc.s	0.252623,0.738401
	dc.s	0.252623,0.972338
	dc.s	0.485423,0.972338
	dc.s	0.019823,0.738401
	dc.s	0.252623,0.972338
	dc.s	0.252623,0.738401
	dc.s	0.485423,0.504464
	dc.s	0.485423,0.738401
	dc.s	0.718223,0.738401
	dc.s	0.485423,0.738401
	dc.s	0.485423,0.972338
	dc.s	0.718223,0.972338
	dc.s	0.718223,0.738401
	dc.s	0.718223,0.972338
	dc.s	0.951023,0.972338
	dc.s	0.485423,0.738401
	dc.s	0.718223,0.972338
	dc.s	0.718223,0.738401
	dc.s	0.019823,0.504464
	dc.s	0.252623,0.738401
	dc.s	0.252623,0.504464
	dc.s	0.252623,0.738401
	dc.s	0.485423,0.972338
	dc.s	0.485423,0.738401
	dc.s	0.252623,0.504464
	dc.s	0.485423,0.738401
	dc.s	0.485423,0.504464
	dc.s	0.252623,0.504464
	dc.s	0.252623,0.738401
	dc.s	0.485423,0.738401
	dc.s	0.999065,0.019983
	dc.s	0.749532,0.269515
	dc.s	0.999065,0.269515
	dc.s	0.749532,0.269515
	dc.s	0.500000,0.519048
	dc.s	0.749532,0.519048
	dc.s	0.999065,0.269515
	dc.s	0.749532,0.519048
	dc.s	0.999065,0.519048
	dc.s	0.999065,0.269515
	dc.s	0.749532,0.269515
	dc.s	0.749532,0.519048
	dc.s	0.500000,0.519048
	dc.s	0.250467,0.768580
	dc.s	0.500000,0.768580
	dc.s	0.250467,0.768580
	dc.s	0.000935,1.018113
	dc.s	0.250467,1.018113
	dc.s	0.500000,0.768580
	dc.s	0.250467,1.018113
	dc.s	0.500000,1.018113
	dc.s	0.500000,0.768580
	dc.s	0.250467,0.768580
	dc.s	0.250467,1.018113
	dc.s	0.999065,0.519048
	dc.s	0.749532,0.768580
	dc.s	0.999065,0.768580
	dc.s	0.749532,0.768580
	dc.s	0.500000,1.018113
	dc.s	0.749532,1.018113
	dc.s	0.999065,0.768580
	dc.s	0.749532,1.018113
	dc.s	0.999065,1.018113
	dc.s	0.999065,0.768580
	dc.s	0.749532,0.768580
	dc.s	0.749532,1.018113
	dc.s	0.999065,0.519048
	dc.s	0.749532,0.519048
	dc.s	0.749532,0.768580
	dc.s	0.749532,0.519048
	dc.s	0.500000,0.519048
	dc.s	0.500000,0.768580
	dc.s	0.749532,0.768580
	dc.s	0.500000,0.768580
	dc.s	0.500000,1.018113
	dc.s	0.749532,0.519048
	dc.s	0.500000,0.768580
	dc.s	0.749532,0.768580
	dc.s	0.749532,0.019983
	dc.s	0.500000,0.019983
	dc.s	0.500000,0.269515
	dc.s	0.749532,0.269515
	dc.s	0.500000,0.269515
	dc.s	0.500000,0.519048
	dc.s	0.749532,0.019983
	dc.s	0.749532,0.269515
	dc.s	0.999065,0.019983
	dc.s	0.749532,0.019983
	dc.s	0.500000,0.269515
	dc.s	0.749532,0.269515
	dc.s	0.000935,0.019983
	dc.s	0.000935,0.269515
	dc.s	0.250467,0.019983
	dc.s	0.250467,0.269515
	dc.s	0.000935,0.269515
	dc.s	0.000935,0.519048
	dc.s	0.500000,0.019983
	dc.s	0.250467,0.019983
	dc.s	0.250467,0.269515
	dc.s	0.250467,0.019983
	dc.s	0.000935,0.269515
	dc.s	0.250467,0.269515
	dc.s	0.500000,0.519048
	dc.s	0.250467,0.519048
	dc.s	0.250467,0.768580
	dc.s	0.250467,0.519048
	dc.s	0.000935,0.519048
	dc.s	0.000935,0.768580
	dc.s	0.250467,0.768580
	dc.s	0.000935,0.768580
	dc.s	0.000935,1.018113
	dc.s	0.250467,0.519048
	dc.s	0.000935,0.768580
	dc.s	0.250467,0.768580
	dc.s	0.500000,0.019983
	dc.s	0.250467,0.269515
	dc.s	0.500000,0.269515
	dc.s	0.250467,0.269515
	dc.s	0.000935,0.519048
	dc.s	0.250467,0.519048
	dc.s	0.500000,0.269515
	dc.s	0.250467,0.519048
	dc.s	0.500000,0.519048
	dc.s	0.500000,0.269515
	dc.s	0.250467,0.269515
	dc.s	0.250467,0.519048
