 dc.w 13  ; NUMCAM    
 dc.w 969  ; NUMVERTS  
 dc.w 4314  ; TNUMVERTS 
 dc.w 1438  ; NUMFACES  
 dc.s 0.789582  ; camera_fov 
 dc.l camera_neuron_bak  ; camera     
 dc.l coords_neuron_bak  ; coords     
 dc.l faces_neuron_bak   ; faces      
 dc.l tcoords_neuron_bak ; tcoords    
 dc.l tex_neuron_bak+20 ; palette    
 dc.l textures_neuron_bak ; textures    
textures_neuron_bak: 
 dc.l tex_neuron_bak+20+768+256*256*0 
tex_neuron_bak: incbin "neuron\neubak2c.apx"
camera_neuron_bak:				;x,y,z , rx,ry,rz,rw , time
	dc.s -69.512703,-3.129400,-2.183900,0.031300,-0.999000,0.032600,1.613800,0.000000
	dc.s -12.147200,-3.129400,2.226000,0.250300,-0.931300,0.264700,1.697600,0.083300
	dc.s -2.763700,-5.629400,14.786400,0.897800,-0.424300,0.118200,0.601800,0.166700
	dc.s 7.034200,-12.629400,4.773800,0.539800,0.744800,-0.392200,1.545900,0.250000
	dc.s 4.775500,0.370600,-1.217700,0.346500,0.840100,-0.417400,1.908400,0.333300
	dc.s 3.560900,9.370600,-4.344100,-0.061500,0.998000,0.013200,0.835400,0.416700
	dc.s 8.557000,9.370600,-19.016800,-0.022900,0.994100,0.105900,2.814200,0.500000
	dc.s 9.130400,9.370600,-9.842400,-0.038800,0.994100,0.101600,2.515600,0.583300
	dc.s 8.068000,9.370600,-0.725300,-0.125700,0.978100,0.166000,1.924900,0.666700
	dc.s 7.658800,9.370600,4.182100,-0.441800,0.851400,0.282700,1.317800,0.750000
	dc.s 7.823600,9.370600,14.029600,-0.661700,0.727700,0.180600,0.765000,0.833300
	dc.s -7.979100,9.370600,13.505600,-0.806900,-0.536200,-0.247800,1.011300,0.916700
	dc.s -7.979100,-15.129400,13.505600,-0.806900,-0.536200,-0.247800,1.011300,1.000000
coords_neuron_bak:				;x,y,z
	dc.s	-3.563236,5.705143,5.556922
	dc.s	-13.695899,10.723286,12.138312
	dc.s	-3.061859,5.498973,4.720366
	dc.s	-2.936605,5.076344,5.297184
	dc.s	-3.410048,4.884383,4.029706
	dc.s	-4.368979,6.176301,5.850188
	dc.s	-4.246522,5.814872,6.288411
	dc.s	-6.750826,7.548513,9.457342
	dc.s	-8.886406,8.681892,10.638167
	dc.s	-10.108206,9.754093,11.579738
	dc.s	-11.341851,10.117143,11.946272
	dc.s	-2.873564,5.376620,5.109509
	dc.s	-4.387595,6.157941,6.373760
	dc.s	-4.840117,6.286239,6.008479
	dc.s	-4.658478,5.675404,6.449128
	dc.s	-10.092745,9.553435,11.350487
	dc.s	-10.883854,9.729085,11.892658
	dc.s	-14.791938,11.189284,12.089013
	dc.s	-14.908388,11.303007,12.352689
	dc.s	-15.002182,11.256600,12.214526
	dc.s	-3.550121,4.626358,4.061181
	dc.s	-5.166870,5.769973,5.913033
	dc.s	-3.668495,5.249650,5.695638
	dc.s	-7.074224,7.876682,9.183247
	dc.s	-4.860527,5.970138,5.679430
	dc.s	-7.346583,7.440454,9.053608
	dc.s	-5.013235,6.151934,7.092970
	dc.s	-7.964809,8.452392,10.099236
	dc.s	-7.135170,7.613774,8.912946
	dc.s	-8.074250,8.170057,9.930904
	dc.s	-7.840900,8.421131,10.540495
	dc.s	-9.364338,9.396416,11.455917
	dc.s	-9.219667,9.200178,11.019419
	dc.s	-8.715927,8.788649,11.165101
	dc.s	-10.042738,9.626773,11.763416
	dc.s	-11.885781,10.256335,11.680528
	dc.s	-13.699261,10.909528,12.097281
	dc.s	-13.131897,10.440868,11.782949
	dc.s	-14.925550,11.355030,12.265512
	dc.s	-15.017159,11.244010,12.297009
	dc.s	-3.578116,5.507299,5.683019
	dc.s	-3.317398,5.329412,4.349568
	dc.s	2.745381,3.960794,1.035927
	dc.s	2.981174,4.139567,1.282359
	dc.s	2.537220,2.187239,1.221804
	dc.s	3.104749,4.031489,1.630020
	dc.s	3.181179,2.855794,2.302265
	dc.s	2.681590,3.406215,4.712123
	dc.s	2.607444,2.567118,4.628830
	dc.s	2.385966,1.741316,1.311405
	dc.s	3.104440,2.134506,2.481619
	dc.s	2.432233,1.406809,1.704509
	dc.s	2.605926,1.298396,2.239933
	dc.s	2.937708,1.716879,2.690425
	dc.s	2.904527,1.760682,3.447652
	dc.s	2.625229,1.284281,3.092745
	dc.s	2.429292,1.399576,4.029115
	dc.s	2.397888,1.859748,4.486579
	dc.s	0.810266,-0.092969,3.666001
	dc.s	-0.611061,-1.021773,4.204637
	dc.s	-0.950686,-0.093847,3.662329
	dc.s	0.814743,-0.097567,2.122534
	dc.s	1.250516,-1.045859,3.461893
	dc.s	-1.358395,-1.037954,2.340354
	dc.s	-0.950915,-0.100386,2.112332
	dc.s	0.503343,-1.027225,1.597862
	dc.s	0.797297,-1.814017,3.744895
	dc.s	-0.885430,-1.820977,3.745078
	dc.s	-0.885167,-1.827020,2.064667
	dc.s	0.796480,-1.822323,2.064564
	dc.s	-0.588898,-5.531266,3.614352
	dc.s	0.015397,-8.548712,3.308339
	dc.s	0.346594,-8.172960,2.591890
	dc.s	-0.932412,-8.741842,3.124009
	dc.s	-0.335292,-11.827123,3.544690
	dc.s	-0.822555,-8.320729,2.199910
	dc.s	-0.640600,-11.258014,2.856215
	dc.s	0.166724,-9.693310,2.987256
	dc.s	-0.813898,-11.090022,3.058836
	dc.s	-0.797991,-11.253559,3.294661
	dc.s	-0.880960,-13.525212,3.353892
	dc.s	-0.257765,-18.889908,4.701813
	dc.s	-0.624368,-17.733797,4.129121
	dc.s	0.347368,-21.813972,4.516494
	dc.s	0.048457,-20.018154,4.438018
	dc.s	0.308870,-21.262884,4.421396
	dc.s	1.512621,6.269391,6.074203
	dc.s	0.456176,6.504720,4.687870
	dc.s	-0.285752,6.301068,4.673676
	dc.s	1.566195,6.765376,5.333447
	dc.s	2.522587,5.676752,1.242936
	dc.s	2.473282,5.343895,0.832047
	dc.s	2.658684,4.854906,0.674486
	dc.s	2.808462,4.686643,0.774132
	dc.s	3.361261,4.893720,1.458634
	dc.s	-0.359260,4.009148,-0.147738
	dc.s	-1.126678,3.676784,-0.475683
	dc.s	0.588859,3.825780,-0.048854
	dc.s	0.085524,2.338058,-0.266167
	dc.s	-2.540221,5.394722,4.615748
	dc.s	-2.434032,5.349047,4.874091
	dc.s	-2.882882,5.277525,4.098745
	dc.s	-2.647867,4.562043,5.178547
	dc.s	-2.878621,4.283226,5.029984
	dc.s	-1.338590,6.040604,-6.943877
	dc.s	-1.338590,6.040604,-6.943877
	dc.s	-1.931513,6.192255,-7.130032
	dc.s	-1.338590,6.040604,-6.943877
	dc.s	-1.338590,6.040604,-6.943877
	dc.s	-1.338590,6.040604,-6.943877
	dc.s	-1.931513,6.192255,-7.130032
	dc.s	-1.931513,6.192255,-7.130032
	dc.s	-1.338590,6.040604,-6.943877
	dc.s	-1.931513,6.192255,-7.130032
	dc.s	-1.931513,6.192255,-7.130032
	dc.s	-1.931513,6.192255,-7.130032
	dc.s	-1.931513,6.192255,-7.130032
	dc.s	-6.966690,12.536518,-0.453510
	dc.s	-6.966690,12.536518,-0.453510
	dc.s	-6.929918,12.362439,-0.409324
	dc.s	-6.929918,12.362439,-0.409324
	dc.s	-6.966690,12.536518,-0.453510
	dc.s	-6.929918,12.362439,-0.409324
	dc.s	-6.929918,12.362439,-0.409324
	dc.s	-6.966690,12.536518,-0.453510
	dc.s	-6.929918,12.362439,-0.409324
	dc.s	-6.929918,12.362439,-0.409324
	dc.s	-6.966690,12.536518,-0.453510
	dc.s	-6.966690,12.536518,-0.453510
	dc.s	1.678091,9.513812,7.968416
	dc.s	1.997484,10.838470,8.103562
	dc.s	2.839324,15.464708,9.352167
	dc.s	2.663230,13.703114,8.740589
	dc.s	2.405571,13.164230,8.660020
	dc.s	2.779330,14.299721,9.113751
	dc.s	2.614746,15.168337,9.291478
	dc.s	2.613334,16.685673,9.818981
	dc.s	6.031977,9.794992,-1.245329
	dc.s	7.529498,11.070304,-2.277579
	dc.s	1.100227,7.945862,6.892265
	dc.s	0.780560,6.893294,5.386284
	dc.s	0.173734,6.567327,5.896770
	dc.s	1.661601,7.627914,7.163795
	dc.s	1.630337,8.655966,7.346503
	dc.s	1.218559,8.207626,7.317859
	dc.s	1.739412,8.755767,7.779963
	dc.s	3.539562,5.826171,1.342781
	dc.s	3.448613,5.361619,0.768019
	dc.s	4.915752,7.882915,-0.084952
	dc.s	5.203281,8.739010,-0.819201
	dc.s	1.966890,8.598199,7.369851
	dc.s	1.384040,8.224693,7.478353
	dc.s	2.826375,5.707071,1.774227
	dc.s	3.028149,5.981890,0.691615
	dc.s	3.839749,6.836491,0.808959
	dc.s	1.810084,6.572678,5.492970
	dc.s	0.434579,6.012014,6.018083
	dc.s	1.983152,7.567658,6.849962
	dc.s	2.039554,8.363586,7.332769
	dc.s	3.486376,6.584860,0.886152
	dc.s	3.122428,5.872141,0.517781
	dc.s	3.116015,5.535304,0.509315
	dc.s	3.335864,6.013182,1.410273
	dc.s	3.118496,6.200958,0.858187
	dc.s	4.323456,7.119277,-0.121998
	dc.s	5.358357,9.061405,-0.640450
	dc.s	0.049316,6.129929,5.847791
	dc.s	1.512621,6.269391,6.074203
	dc.s	1.566195,6.765376,5.333447
	dc.s	1.859081,8.019671,6.884233
	dc.s	2.110694,8.799439,7.696790
	dc.s	1.344651,7.953596,6.787444
	dc.s	1.475260,8.834273,7.509418
	dc.s	2.808462,4.686643,0.774132
	dc.s	3.647391,5.600137,1.104445
	dc.s	0.241110,6.754086,5.499237
	dc.s	1.100227,7.945862,6.892265
	dc.s	0.780560,6.893294,5.386284
	dc.s	0.173734,6.567327,5.896770
	dc.s	0.864716,6.134075,6.152852
	dc.s	1.661601,7.627914,7.163795
	dc.s	3.539562,5.826171,1.342781
	dc.s	3.448613,5.361619,0.768019
	dc.s	2.826375,5.707071,1.774227
	dc.s	3.028149,5.981890,0.691615
	dc.s	1.791964,6.426307,5.802099
	dc.s	1.810084,6.572678,5.492970
	dc.s	0.434579,6.012014,6.018083
	dc.s	1.192317,6.049025,6.069200
	dc.s	1.983152,7.567658,6.849962
	dc.s	2.674438,5.750113,1.584974
	dc.s	3.486376,6.584860,0.886152
	dc.s	2.996420,5.600881,1.852449
	dc.s	3.269676,5.265597,1.774915
	dc.s	3.335864,6.013182,1.410273
	dc.s	3.118496,6.200958,0.858187
	dc.s	1.512621,6.269391,6.074203
	dc.s	1.344651,7.953596,6.787444
	dc.s	2.522587,5.676752,1.242936
	dc.s	3.361261,4.893720,1.458634
	dc.s	3.647391,5.600137,1.104445
	dc.s	3.028149,5.981890,0.691615
	dc.s	3.122428,5.872141,0.517781
	dc.s	3.116015,5.535304,0.509315
	dc.s	2.522587,5.676752,1.242936
	dc.s	2.473282,5.343895,0.832047
	dc.s	2.658684,4.854906,0.674486
	dc.s	2.808462,4.686643,0.774132
	dc.s	3.448613,5.361619,0.768019
	dc.s	2.995847,4.630616,0.906475
	dc.s	2.981174,4.139567,1.282359
	dc.s	2.808462,4.686643,0.774132
	dc.s	3.361261,4.893720,1.458634
	dc.s	0.091927,3.830653,-0.588681
	dc.s	0.610366,3.348173,-0.313322
	dc.s	0.429969,2.701718,-0.406335
	dc.s	0.186343,3.607643,-0.939518
	dc.s	0.266256,3.332511,-0.909152
	dc.s	2.413832,5.214733,5.100750
	dc.s	-0.387097,5.639803,5.654822
	dc.s	-2.054888,5.183638,5.034789
	dc.s	1.572969,6.436448,4.675770
	dc.s	-2.562229,5.282504,3.826282
	dc.s	2.500493,5.548132,2.179483
	dc.s	-1.523667,6.143269,1.868030
	dc.s	-3.046945,5.508018,1.805067
	dc.s	2.113597,5.202102,1.013880
	dc.s	-1.574146,5.418986,0.477222
	dc.s	-2.930593,5.379502,0.634758
	dc.s	-0.254940,1.004712,4.856860
	dc.s	-2.140470,1.371078,4.491210
	dc.s	0.923339,0.286636,3.712786
	dc.s	-1.078623,0.284853,3.705771
	dc.s	2.295378,1.083376,2.025796
	dc.s	0.933005,0.279397,2.069521
	dc.s	-1.080599,0.278567,2.049256
	dc.s	1.973055,1.359472,1.256949
	dc.s	1.061351,1.067690,0.986768
	dc.s	-2.188761,1.326687,1.151952
	dc.s	2.462467,3.810425,5.012739
	dc.s	-3.465346,3.971450,3.680388
	dc.s	-1.362969,3.820285,-0.050350
	dc.s	2.470321,4.144045,0.792712
	dc.s	2.221644,2.013227,4.754082
	dc.s	1.009835,2.759950,5.567618
	dc.s	-1.108629,2.325343,-0.054711
	dc.s	0.716254,2.168312,0.130320
	dc.s	2.330305,2.444740,0.942299
	dc.s	0.972808,-1.026642,3.935384
	dc.s	-1.080504,-1.020488,3.934500
	dc.s	0.972724,-1.028940,1.868107
	dc.s	-1.081347,-1.021531,1.866565
	dc.s	0.212713,-6.623052,3.363595
	dc.s	-0.833665,-4.994359,2.250879
	dc.s	-0.505018,-14.582228,3.694745
	dc.s	-0.925151,-17.282034,4.466448
	dc.s	-0.494571,-16.110619,4.027639
	dc.s	-0.342182,-17.714195,4.246074
	dc.s	0.419182,-23.169931,4.189763
	dc.s	0.241110,6.754086,5.499237
	dc.s	-1.181862,5.768060,4.680666
	dc.s	-0.385987,0.433284,4.121822
	dc.s	-2.270186,1.247645,4.296568
	dc.s	1.292017,-25.732594,3.333067
	dc.s	-2.535400,1.002605,2.998221
	dc.s	-2.299920,1.218968,1.369548
	dc.s	0.698282,5.726817,5.986879
	dc.s	1.427144,1.421032,4.874650
	dc.s	-3.564968,3.248175,2.480996
	dc.s	-3.157193,3.216208,1.039178
	dc.s	-2.944779,1.726811,3.883192
	dc.s	0.348344,1.249923,0.692025
	dc.s	2.953698,4.264151,4.288704
	dc.s	2.891694,2.422701,1.613288
	dc.s	3.209209,2.710334,3.379375
	dc.s	2.714650,1.826547,1.676296
	dc.s	-0.070561,-0.102535,3.946020
	dc.s	1.120074,-0.110995,2.895409
	dc.s	-1.257524,-0.113191,2.886418
	dc.s	-0.068620,-0.109526,1.835865
	dc.s	-0.054034,-1.015254,4.305346
	dc.s	-1.459210,-1.031712,2.900352
	dc.s	-0.054250,-1.017790,1.496900
	dc.s	1.351480,-1.040977,2.902362
	dc.s	-0.044875,-1.817273,4.050673
	dc.s	-1.191395,-1.822151,2.904064
	dc.s	-0.043921,-1.824299,1.759077
	dc.s	1.103222,-1.812269,2.904277
	dc.s	-0.054681,-2.929555,1.566623
	dc.s	-0.063722,-2.943346,4.277593
	dc.s	-1.422901,-2.967536,2.911715
	dc.s	1.301204,-2.958026,2.916953
	dc.s	-1.085853,-4.928013,2.898286
	dc.s	0.035865,-4.781389,1.987639
	dc.s	-0.089414,-6.309891,2.091505
	dc.s	0.454689,-6.306462,3.011154
	dc.s	-0.535152,-8.621529,3.382687
	dc.s	-2.235835,1.526210,4.561033
	dc.s	-2.954813,4.892232,2.834691
	dc.s	-2.958036,5.001785,3.646571
	dc.s	-3.104862,4.917039,1.944768
	dc.s	-3.498893,3.717848,1.994299
	dc.s	-3.211070,5.496411,1.391844
	dc.s	-2.742060,4.769592,0.732567
	dc.s	-3.186008,5.444272,1.016669
	dc.s	-2.697574,4.218718,0.735847
	dc.s	-2.907332,3.822766,4.726733
	dc.s	-2.807321,2.599535,4.575848
	dc.s	-3.254565,3.754013,4.268611
	dc.s	-3.446153,2.773539,3.328424
	dc.s	-2.721312,2.171347,4.507388
	dc.s	-3.442443,2.837950,1.729317
	dc.s	-2.784178,3.554028,0.664488
	dc.s	-3.100734,2.407740,1.213802
	dc.s	-2.748872,2.843780,0.693665
	dc.s	-2.560120,1.737852,4.423434
	dc.s	-2.609962,1.394077,4.007823
	dc.s	-2.821733,1.247770,2.970946
	dc.s	-3.134082,1.717601,2.190647
	dc.s	-2.422009,4.335776,0.566328
	dc.s	-1.364344,4.838428,0.394613
	dc.s	-2.055978,5.430051,0.371310
	dc.s	-1.271707,4.385832,0.253766
	dc.s	-2.494008,3.580162,0.454415
	dc.s	-0.431993,4.764867,0.451128
	dc.s	0.558490,4.735257,0.581575
	dc.s	1.413693,4.787930,0.760216
	dc.s	2.141248,4.999333,0.854753
	dc.s	2.252162,4.657487,0.733823
	dc.s	-2.412326,2.536567,0.517060
	dc.s	-1.596105,2.828435,0.001436
	dc.s	1.121321,3.279832,0.114709
	dc.s	-1.648359,1.369072,0.793709
	dc.s	0.978512,1.308470,0.774848
	dc.s	2.064074,1.516650,1.182693
	dc.s	2.757243,5.228951,2.947036
	dc.s	2.993346,4.652467,3.734257
	dc.s	2.781316,5.162436,4.126395
	dc.s	2.670604,4.520158,4.812893
	dc.s	-1.028353,-8.319097,2.555185
	dc.s	-0.309060,-12.552814,3.464161
	dc.s	-0.720099,-15.090815,3.691514
	dc.s	-0.462292,-13.973643,3.875030
	dc.s	-1.077620,-15.186973,3.950225
	dc.s	-0.689611,-17.957935,4.667493
	dc.s	-0.628378,-16.829706,4.037118
	dc.s	-0.408815,-16.757936,4.387094
	dc.s	-0.235185,-20.170652,4.697223
	dc.s	-0.365275,-20.407137,4.318340
	dc.s	-0.031095,-21.465172,4.562473
	dc.s	0.670046,-23.421148,4.237250
	dc.s	0.908320,-23.455683,4.136110
	dc.s	1.173730,-25.672541,3.364634
	dc.s	1.330018,-25.101320,3.653422
	dc.s	0.780560,6.893294,5.386284
	dc.s	0.173734,6.567327,5.896770
	dc.s	0.864716,6.134075,6.152852
	dc.s	-1.332177,3.073782,-0.391603
	dc.s	-0.237428,2.101258,-0.013943
	dc.s	-2.178687,5.403060,4.576027
	dc.s	-1.536030,5.250127,5.149267
	dc.s	2.246337,5.545062,1.579849
	dc.s	1.554750,5.021879,1.005389
	dc.s	1.945007,1.361859,4.531600
	dc.s	-0.302594,0.204448,3.963096
	dc.s	-1.382939,0.240129,2.876354
	dc.s	2.115220,1.234647,1.465627
	dc.s	0.152260,0.195523,1.810864
	dc.s	-0.097209,0.983101,0.889096
	dc.s	1.429407,5.386113,5.839880
	dc.s	-2.203889,4.703434,5.197792
	dc.s	2.393982,2.964425,4.914159
	dc.s	0.407482,1.708647,5.295218
	dc.s	-3.246894,4.438730,1.951274
	dc.s	-3.304389,4.535205,3.492936
	dc.s	-2.701278,5.389275,0.479814
	dc.s	2.217203,1.889161,1.052516
	dc.s	3.016935,5.125677,2.197424
	dc.s	3.197696,3.619634,3.597466
	dc.s	0.943125,-2.955945,3.908599
	dc.s	-1.068056,-2.957597,3.909481
	dc.s	-1.054574,-2.940510,1.927439
	dc.s	0.941405,-2.933401,1.930076
	dc.s	0.507978,-4.838069,2.248246
	dc.s	-0.849752,-5.192030,3.506290
	dc.s	0.282012,-6.374059,2.300863
	dc.s	-1.012713,-15.341231,4.202701
	dc.s	-0.555511,-16.428358,4.528428
	dc.s	-0.457076,-19.889685,4.590743
	dc.s	0.481403,-22.068314,4.150945
	dc.s	1.222708,-25.434444,3.286187
	dc.s	1.268559,-24.839336,3.498698
	dc.s	2.826375,5.707071,1.774227
	dc.s	-0.978107,5.616308,5.191422
	dc.s	1.407986,5.764523,2.286711
	dc.s	2.179954,5.670399,2.758053
	dc.s	-0.115832,5.853715,2.216592
	dc.s	-0.540914,5.995868,2.678361
	dc.s	0.062554,6.194848,3.718712
	dc.s	-1.550691,5.768507,3.210119
	dc.s	-2.347621,5.649887,2.477518
	dc.s	1.693260,5.334008,1.413801
	dc.s	-0.881290,5.520190,0.970637
	dc.s	-0.846781,5.831331,1.620811
	dc.s	1.002238,1.101422,4.769280
	dc.s	-2.450379,1.081112,3.714025
	dc.s	1.183039,0.283115,3.309288
	dc.s	2.358207,1.030360,2.522587
	dc.s	1.297914,-25.700455,3.476819
	dc.s	-1.335203,0.277851,2.453010
	dc.s	0.218501,0.415715,1.647503
	dc.s	1.764460,5.296400,5.687639
	dc.s	1.024976,5.411657,5.923879
	dc.s	0.106564,5.383311,5.886488
	dc.s	-0.375844,5.327710,5.750446
	dc.s	-1.632306,5.018760,5.277606
	dc.s	-0.851687,4.605190,5.725386
	dc.s	0.437658,3.904885,5.860150
	dc.s	-0.701548,3.863456,5.785560
	dc.s	-0.652281,2.440660,5.551660
	dc.s	-1.740324,3.526087,5.438004
	dc.s	-2.534614,2.532722,4.829380
	dc.s	1.782660,1.505191,4.729953
	dc.s	-1.604477,1.814828,5.108289
	dc.s	-2.410943,1.908540,4.699032
	dc.s	-2.000575,1.496558,4.711318
	dc.s	-2.914085,4.928889,3.253605
	dc.s	-3.119653,4.889957,1.532421
	dc.s	-3.010652,4.827524,1.040283
	dc.s	-3.112037,4.403101,1.339614
	dc.s	-3.235947,2.313612,3.737943
	dc.s	-3.442683,2.403174,2.204630
	dc.s	-3.276416,3.551505,1.215257
	dc.s	-2.413415,1.492736,4.367120
	dc.s	-3.318005,2.049105,2.988811
	dc.s	-2.785179,1.274004,2.269696
	dc.s	-2.968547,1.785044,1.558732
	dc.s	-2.568373,2.046299,0.836800
	dc.s	-2.456388,1.460863,1.264975
	dc.s	-2.629494,1.376465,1.589803
	dc.s	-2.498862,4.787464,0.547858
	dc.s	-1.803806,4.832771,0.399152
	dc.s	-1.924569,4.253899,0.356002
	dc.s	-2.437333,3.994118,0.524368
	dc.s	0.140867,3.968986,-0.100687
	dc.s	-0.587344,4.327262,0.156560
	dc.s	1.782005,4.848485,0.843284
	dc.s	1.811826,4.417760,0.652534
	dc.s	1.461355,4.115156,0.457155
	dc.s	-1.604092,3.409985,-0.025788
	dc.s	2.410185,3.623144,0.831043
	dc.s	1.876759,2.334402,0.638109
	dc.s	0.895872,2.685480,0.020850
	dc.s	-2.052500,1.444119,0.914337
	dc.s	-0.680182,2.134208,-0.002769
	dc.s	-0.559948,1.253970,0.675874
	dc.s	1.808118,1.467498,1.009046
	dc.s	2.751981,5.290489,2.456207
	dc.s	3.124929,4.690900,2.257114
	dc.s	2.565486,5.035403,4.865587
	dc.s	3.200860,4.317035,2.013568
	dc.s	2.969326,3.060749,4.234959
	dc.s	2.245584,1.489139,1.374680
	dc.s	2.755931,1.937058,4.090533
	dc.s	2.204647,1.504892,4.398319
	dc.s	0.406911,-0.097349,3.871450
	dc.s	-0.548525,-0.097900,3.869634
	dc.s	1.037901,-0.120206,2.473244
	dc.s	1.034951,-0.117332,3.318144
	dc.s	-1.173857,-0.118666,3.311095
	dc.s	-1.174103,-0.122448,2.462729
	dc.s	-0.547181,-0.105493,1.908361
	dc.s	0.411333,-0.103546,1.914360
	dc.s	0.503462,-1.024872,4.205004
	dc.s	-1.357796,-1.037591,3.460512
	dc.s	-0.611555,-1.023092,1.596718
	dc.s	1.250560,-1.047082,2.342060
	dc.s	-0.498578,-1.811772,3.964403
	dc.s	-1.103608,-1.820001,2.449261
	dc.s	0.410746,-1.817431,1.844992
	dc.s	1.017832,-1.805485,3.359043
	dc.s	0.411603,-1.808539,3.964520
	dc.s	-0.611093,-3.028087,4.182696
	dc.s	-1.104531,-1.814683,3.358808
	dc.s	-1.326077,-2.939388,2.396489
	dc.s	-0.498227,-1.819930,1.844993
	dc.s	0.481099,-2.925292,1.666073
	dc.s	1.016531,-1.813049,2.449559
	dc.s	1.194856,-2.968928,3.465519
	dc.s	0.468547,-3.020740,4.185461
	dc.s	-1.323698,-2.970127,3.462055
	dc.s	-1.005495,-5.006423,2.549222
	dc.s	-0.597494,-2.929159,1.665798
	dc.s	1.209204,-2.930847,2.403737
	dc.s	0.534788,-5.045975,3.458869
	dc.s	-0.039991,-5.095346,3.777167
	dc.s	-1.020590,-4.969458,3.256625
	dc.s	-0.538090,-4.533105,2.001294
	dc.s	0.706681,-4.969384,2.736392
	dc.s	-0.180721,-6.809058,3.522440
	dc.s	-0.548924,-5.996561,2.125334
	dc.s	0.130419,-8.147434,2.158726
	dc.s	0.433537,-6.177364,2.560477
	dc.s	-0.449595,-8.269119,2.037844
	dc.s	-0.040086,-9.698559,2.453440
	dc.s	-0.684355,-10.978594,3.434528
	dc.s	-0.482858,-9.652994,2.361467
	dc.s	-0.286282,-11.922516,3.086100
	dc.s	0.146549,-9.645401,2.692843
	dc.s	-0.803478,-12.789250,3.696127
	dc.s	-0.607168,-12.650134,3.714309
	dc.s	-0.858142,-15.991147,4.440692
	dc.s	-0.976848,-15.964357,3.945555
	dc.s	-0.774767,-18.034107,4.250173
	dc.s	-0.246063,-20.116270,4.226920
	dc.s	-0.039057,-20.095804,4.270141
	dc.s	0.227158,-21.819345,4.093754
	dc.s	0.499350,-23.165894,3.916621
	dc.s	1.791964,6.426307,5.802099
	dc.s	1.810084,6.572678,5.492970
	dc.s	-0.369391,6.220881,5.142907
	dc.s	0.434579,6.012014,6.018083
	dc.s	1.192317,6.049025,6.069200
	dc.s	2.674438,5.750113,1.584974
	dc.s	2.996420,5.600881,1.852449
	dc.s	3.269676,5.265597,1.774915
	dc.s	2.995847,4.630616,0.906475
	dc.s	-0.836165,3.923285,-0.207529
	dc.s	0.091927,3.830653,-0.588681
	dc.s	-0.664354,3.923171,-0.637907
	dc.s	-1.273125,3.409420,-0.463978
	dc.s	0.610366,3.348173,-0.313322
	dc.s	0.429969,2.701718,-0.406335
	dc.s	-1.249310,2.681905,-0.307764
	dc.s	-2.687472,5.379082,4.341175
	dc.s	-2.450610,5.009275,5.150745
	dc.s	-3.121363,5.080026,3.956646
	dc.s	-3.109194,4.167929,4.821693
	dc.s	2.539342,5.354247,4.767510
	dc.s	1.904202,6.250697,4.953705
	dc.s	1.596614,5.757326,5.804246
	dc.s	1.899245,6.076532,5.398815
	dc.s	0.049316,6.129929,5.847791
	dc.s	-2.332163,5.398350,4.250067
	dc.s	-1.892930,5.535348,4.212213
	dc.s	-2.079202,5.312127,4.827573
	dc.s	2.612117,5.455317,4.207343
	dc.s	2.494127,5.476224,2.764000
	dc.s	1.952548,5.538731,1.949454
	dc.s	-1.618779,5.934581,2.520027
	dc.s	-0.807164,6.002367,3.204386
	dc.s	-2.053280,6.211116,1.943678
	dc.s	-2.795115,5.246970,2.377447
	dc.s	-2.653929,5.185553,2.882736
	dc.s	-2.633883,6.040819,1.945150
	dc.s	-2.577020,5.222620,3.375995
	dc.s	2.141107,5.376051,1.227828
	dc.s	0.791480,5.007687,0.846224
	dc.s	-0.230439,5.535360,1.413214
	dc.s	-0.362345,5.034980,0.680247
	dc.s	-1.523866,5.802453,0.705092
	dc.s	-0.894007,5.129562,0.612651
	dc.s	-1.519353,6.126657,1.149621
	dc.s	2.070948,1.257165,4.321206
	dc.s	2.272183,1.091240,3.744853
	dc.s	-1.401523,1.133245,4.730032
	dc.s	0.418100,0.291302,3.935979
	dc.s	2.367420,1.018544,3.057154
	dc.s	1.235898,0.242998,2.893279
	dc.s	1.188067,0.278813,2.475989
	dc.s	1.386370,-25.642504,3.372546
	dc.s	1.145193,-25.503323,3.570475
	dc.s	-1.334645,0.281739,3.296853
	dc.s	-2.495828,1.038022,2.091839
	dc.s	-0.572500,0.281375,1.828357
	dc.s	-1.437329,1.106794,0.968870
	dc.s	2.251987,5.081310,5.316851
	dc.s	2.459485,5.020613,5.116847
	dc.s	1.487061,4.452924,5.756116
	dc.s	2.105146,4.388100,5.437649
	dc.s	1.126292,5.747808,5.971007
	dc.s	0.257103,5.714269,5.925484
	dc.s	-2.099144,4.971647,5.154393
	dc.s	-2.331650,4.431650,5.162476
	dc.s	1.714295,2.372877,5.221661
	dc.s	-2.559250,4.010172,5.023125
	dc.s	-1.683787,2.528977,5.315245
	dc.s	0.149264,1.272605,5.063858
	dc.s	2.020720,1.536841,4.586064
	dc.s	-0.842497,1.742968,5.271126
	dc.s	-1.594484,1.406407,4.877438
	dc.s	-4.999451,7.761616,-8.912186
	dc.s	2.276848,10.354945,-12.852189
	dc.s	2.387201,10.305835,-12.771242
	dc.s	-0.163177,4.447200,-2.215992
	dc.s	-0.669243,4.569874,-2.361296
	dc.s	-0.120143,5.661609,-4.279624
	dc.s	0.082123,4.029120,-2.062830
	dc.s	-0.559078,5.709517,-4.290303
	dc.s	0.084620,5.555883,-4.695897
	dc.s	0.014029,6.773588,-7.594314
	dc.s	0.078917,7.288209,-8.838703
	dc.s	0.465333,7.101878,-8.717422
	dc.s	1.518478,9.565797,-11.430591
	dc.s	1.651176,9.240377,-10.960475
	dc.s	2.200016,10.309691,-12.581688
	dc.s	2.184533,10.050533,-12.132042
	dc.s	1.883173,10.090104,-12.325959
	dc.s	-1.083066,6.461281,-6.550499
	dc.s	-0.897318,6.568441,-7.137139
	dc.s	-1.140600,6.431163,-7.287159
	dc.s	-1.604753,6.414345,-7.466246
	dc.s	-2.375975,6.521644,-7.416589
	dc.s	-2.042524,6.558662,-7.390786
	dc.s	-3.328463,7.097474,-8.258096
	dc.s	-4.535587,7.662398,-8.795318
	dc.s	2.350422,10.014668,-12.413616
	dc.s	-0.981856,4.290970,-2.153731
	dc.s	-0.800498,6.311165,-5.912791
	dc.s	-1.017282,6.161370,-6.041115
	dc.s	-0.029285,6.155423,-5.499201
	dc.s	-0.367074,6.850124,-7.919235
	dc.s	0.352983,7.257790,-8.753942
	dc.s	-0.013897,7.294392,-9.006315
	dc.s	-0.843776,6.478855,-7.440917
	dc.s	-0.044272,7.236489,-9.188478
	dc.s	2.004426,9.466951,-11.484192
	dc.s	-1.687618,6.503573,-7.427283
	dc.s	-2.676477,6.770476,-8.282294
	dc.s	-5.143122,7.742840,-8.867020
	dc.s	-4.086207,7.368174,-8.770854
	dc.s	-0.864822,5.848441,-6.032379
	dc.s	1.011986,8.767914,-10.832393
	dc.s	-3.633577,4.491741,4.218013
	dc.s	-6.907056,7.896900,9.525901
	dc.s	-9.596088,9.050251,11.111414
	dc.s	-9.689854,9.250428,11.647179
	dc.s	-3.465346,3.971450,3.680388
	dc.s	-3.563236,5.705143,5.556922
	dc.s	-13.695899,10.723286,12.138312
	dc.s	-2.936605,5.076344,5.297184
	dc.s	-4.246522,5.814872,6.288411
	dc.s	-6.750826,7.548513,9.457342
	dc.s	-8.886406,8.681892,10.638167
	dc.s	-2.873564,5.376620,5.109509
	dc.s	-4.658478,5.675404,6.449128
	dc.s	-6.861426,7.292141,9.375414
	dc.s	-8.481522,8.256035,10.363205
	dc.s	-10.092745,9.553435,11.350487
	dc.s	-10.883854,9.729085,11.892658
	dc.s	-14.791938,11.189284,12.089013
	dc.s	-15.002182,11.256600,12.214526
	dc.s	-3.139874,4.772902,5.278209
	dc.s	-3.501149,4.253613,4.451514
	dc.s	-3.109194,4.167929,4.821693
	dc.s	-3.351912,4.557854,5.120302
	dc.s	-5.166870,5.769973,5.913033
	dc.s	-3.951440,4.744752,4.926135
	dc.s	-3.668495,5.249650,5.695638
	dc.s	-7.346583,7.440454,9.053608
	dc.s	-5.063087,5.598040,6.092022
	dc.s	-5.013235,6.151934,7.092970
	dc.s	-8.074250,8.170057,9.930904
	dc.s	-6.962962,7.062602,8.915860
	dc.s	-8.020022,7.934745,10.281671
	dc.s	-7.840900,8.421131,10.540495
	dc.s	-8.026486,8.128569,10.580237
	dc.s	-8.715927,8.788649,11.165101
	dc.s	-9.982296,9.194038,11.500519
	dc.s	-11.885781,10.256335,11.680528
	dc.s	-13.131897,10.440868,11.782949
	dc.s	-15.017159,11.244010,12.297009
	dc.s	-3.254565,3.754013,4.268611
	dc.s	-2.647867,4.562043,5.178547
	dc.s	-2.878621,4.283226,5.029984
	dc.s	-4.239338,5.223196,5.780451
	dc.s	-3.633577,4.491741,4.218013
	dc.s	-9.596088,9.050251,11.111414
	dc.s	-10.198530,9.351463,11.391797
	dc.s	-9.689854,9.250428,11.647179
	dc.s	-11.708648,9.911788,11.701163
	dc.s	-14.506718,10.931414,12.052569
	dc.s	-3.061859,5.498973,4.720366
	dc.s	-2.936605,5.076344,5.297184
	dc.s	-3.410048,4.884383,4.029706
	dc.s	-2.873564,5.376620,5.109509
	dc.s	-2.687472,5.379082,4.341175
	dc.s	-2.450610,5.009275,5.150745
	dc.s	-3.121363,5.080026,3.956646
	dc.s	-2.540221,5.394722,4.615748
	dc.s	-2.434032,5.349047,4.874091
	dc.s	-2.882882,5.277525,4.098745
	dc.s	-3.317398,5.329412,4.349568
	dc.s	-3.465346,3.971450,3.680388
	dc.s	-2.936605,5.076344,5.297184
	dc.s	-3.410048,4.884383,4.029706
	dc.s	-3.304389,4.535205,3.492936
	dc.s	-2.450610,5.009275,5.150745
	dc.s	-3.139874,4.772902,5.278209
	dc.s	-3.121363,5.080026,3.956646
	dc.s	-3.550121,4.626358,4.061181
	dc.s	-2.647867,4.562043,5.178547
	dc.s	-3.633577,4.491741,4.218013
	dc.s	1.011986,8.767914,-10.832393
	dc.s	-1.346469,6.300635,-6.525618
	dc.s	-1.076541,4.248297,-2.600320
	dc.s	-0.317352,6.331920,-5.681818
	dc.s	-0.890794,5.823833,-5.210157
	dc.s	0.056479,6.178926,-6.349594
	dc.s	0.230877,6.567575,-7.816159
	dc.s	-0.628665,6.586032,-7.796556
	dc.s	0.767432,7.900850,-9.547013
	dc.s	1.993514,10.107673,-12.567019
	dc.s	-4.496270,7.544746,-8.738184
	dc.s	-0.842938,5.462505,-4.100498
	dc.s	0.171892,6.793746,-7.849535
	dc.s	-3.499330,7.186951,-8.673724
	dc.s	2.239419,10.146643,-12.735203
	dc.s	-1.346469,6.300635,-6.525618
	dc.s	-0.505728,4.932405,-4.371586
	dc.s	-1.076541,4.248297,-2.600320
	dc.s	-0.890794,5.823833,-5.210157
	dc.s	0.056479,6.178926,-6.349594
	dc.s	0.230877,6.567575,-7.816159
	dc.s	-0.154519,6.451568,-8.248422
	dc.s	-0.628665,6.586032,-7.796556
	dc.s	0.767432,7.900850,-9.547013
	dc.s	0.255753,7.014700,-9.164972
	dc.s	1.993514,10.107673,-12.567019
	dc.s	-4.496270,7.544746,-8.738184
	dc.s	0.351147,6.802711,-8.755927
	dc.s	0.022912,7.088596,-9.202420
	dc.s	-3.499330,7.186951,-8.673724
	dc.s	2.276848,10.354945,-12.852189
	dc.s	2.387201,10.305835,-12.771242
	dc.s	-1.249310,2.681905,-0.307764
	dc.s	0.082123,4.029120,-2.062830
	dc.s	-0.318017,3.469948,-2.285493
	dc.s	0.084620,5.555883,-4.695897
	dc.s	-0.512003,5.692964,-5.759948
	dc.s	-0.105176,5.801153,-5.858979
	dc.s	0.523763,7.061691,-8.894657
	dc.s	0.465333,7.101878,-8.717422
	dc.s	-0.095992,6.240447,-7.630612
	dc.s	-0.780886,6.201890,-7.324359
	dc.s	-0.348478,6.576919,-8.355483
	dc.s	1.651176,9.240377,-10.960475
	dc.s	1.506636,8.682240,-10.803521
	dc.s	-1.140600,6.431163,-7.287159
	dc.s	-1.043824,6.302181,-7.309097
	dc.s	-1.281506,6.198603,-7.245825
	dc.s	-1.604753,6.414345,-7.466246
	dc.s	-2.375975,6.521644,-7.416589
	dc.s	-3.560441,7.136018,-8.358051
	dc.s	-3.328463,7.097474,-8.258096
	dc.s	2.350422,10.014668,-12.413616
	dc.s	0.122724,3.228768,-1.298452
	dc.s	-0.658903,3.035425,-1.654568
	dc.s	0.046546,2.838854,-0.987896
	dc.s	-0.966660,3.121275,-1.571410
	dc.s	-0.102492,4.917641,-4.217179
	dc.s	-0.847111,5.071555,-4.364293
	dc.s	-0.813338,5.614437,-5.364600
	dc.s	-1.017282,6.161370,-6.041115
	dc.s	-0.940219,5.927302,-5.787677
	dc.s	-0.843776,6.478855,-7.440917
	dc.s	-0.044272,7.236489,-9.188478
	dc.s	1.269929,8.654403,-10.857701
	dc.s	2.004426,9.466951,-11.484192
	dc.s	-1.149368,6.045542,-6.250005
	dc.s	-2.228738,6.425881,-7.800580
	dc.s	-2.676477,6.770476,-8.282294
	dc.s	-4.086207,7.368174,-8.770854
	dc.s	-0.890794,5.823833,-5.210157
	dc.s	0.022912,7.088596,-9.202420
	dc.s	-0.348478,6.576919,-8.355483
	dc.s	-1.140600,6.431163,-7.287159
	dc.s	-1.281506,6.198603,-7.245825
	dc.s	-1.604753,6.414345,-7.466246
	dc.s	-0.813338,5.614437,-5.364600
	dc.s	-1.017282,6.161370,-6.041115
	dc.s	-0.940219,5.927302,-5.787677
	dc.s	-0.044272,7.236489,-9.188478
	dc.s	-1.149368,6.045542,-6.250005
	dc.s	-1.338590,6.040604,-6.943877
	dc.s	-2.228738,6.425881,-7.800580
	dc.s	-2.676477,6.770476,-8.282294
	dc.s	-1.332177,3.073782,-0.391603
	dc.s	-1.076541,4.248297,-2.600320
	dc.s	0.091927,3.830653,-0.588681
	dc.s	-0.664354,3.923171,-0.637907
	dc.s	-1.273125,3.409420,-0.463978
	dc.s	-0.711684,4.101092,-1.302873
	dc.s	-0.163177,4.447200,-2.215992
	dc.s	0.186343,3.607643,-0.939518
	dc.s	-0.669243,4.569874,-2.361296
	dc.s	0.082123,4.029120,-2.062830
	dc.s	-1.126678,3.676784,-0.475683
	dc.s	-0.097484,3.997750,-1.197359
	dc.s	0.122724,3.228768,-1.298452
	dc.s	0.266256,3.332511,-0.909152
	dc.s	-0.981856,4.290970,-2.153731
	dc.s	-1.108629,2.325343,-0.054711
	dc.s	-1.332177,3.073782,-0.391603
	dc.s	-0.237428,2.101258,-0.013943
	dc.s	-1.076541,4.248297,-2.600320
	dc.s	-0.680182,2.134208,-0.002769
	dc.s	0.429969,2.701718,-0.406335
	dc.s	-1.249310,2.681905,-0.307764
	dc.s	-0.318017,3.469948,-2.285493
	dc.s	0.122724,3.228768,-1.298452
	dc.s	0.085524,2.338058,-0.266167
	dc.s	-0.658903,3.035425,-1.654568
	dc.s	0.046546,2.838854,-0.987896
	dc.s	-0.966660,3.121275,-1.571410
	dc.s	0.429969,2.701718,-0.406335
	dc.s	0.122724,3.228768,-1.298452
	dc.s	0.266256,3.332511,-0.909152
	dc.s	0.085524,2.338058,-0.266167
	dc.s	0.046546,2.838854,-0.987896
	dc.s	-3.298739,7.981811,0.539692
	dc.s	-6.511416,11.791731,-0.650178
	dc.s	-6.857457,11.692575,-0.588878
	dc.s	-7.443886,12.779129,-0.850402
	dc.s	-8.374037,14.156628,-1.448110
	dc.s	-8.841167,18.117809,-4.896127
	dc.s	-7.428818,15.064020,0.920959
	dc.s	-6.638489,16.449200,1.654763
	dc.s	-8.896813,18.333782,-4.973179
	dc.s	-3.704798,8.042068,0.693261
	dc.s	-5.596881,10.451414,-1.009143
	dc.s	-5.555149,10.511148,-0.367118
	dc.s	-7.703195,12.857122,-1.275319
	dc.s	-8.119223,12.834946,-1.360492
	dc.s	-8.251103,12.956703,-1.106037
	dc.s	-8.475677,14.203444,-1.980609
	dc.s	-8.608375,14.404274,-1.376073
	dc.s	-9.040172,17.277637,-3.796374
	dc.s	-8.891227,15.671007,-2.257999
	dc.s	-7.450652,13.854649,0.315342
	dc.s	-5.143425,10.081719,-0.868033
	dc.s	-5.937136,10.566133,-0.387781
	dc.s	-6.217819,10.853127,-0.973691
	dc.s	-8.124271,13.463421,-1.584922
	dc.s	-8.742983,14.062384,-1.632106
	dc.s	-8.692360,15.244265,-2.681256
	dc.s	-8.911128,18.083965,-4.934610
	dc.s	-9.002722,18.167700,-4.798644
	dc.s	-4.089619,8.037354,0.635730
	dc.s	-4.341132,7.920647,0.421072
	dc.s	-4.365454,8.082575,-0.143936
	dc.s	-4.951340,10.030068,-0.689490
	dc.s	-5.346697,9.554053,-0.452927
	dc.s	-6.594746,11.630546,-0.539082
	dc.s	-6.425521,11.570039,-1.167062
	dc.s	-6.634583,11.230201,-0.771461
	dc.s	-7.870875,12.710894,-0.753475
	dc.s	-7.939433,12.979109,-0.828696
	dc.s	-7.753219,12.992508,-0.971786
	dc.s	-8.239003,13.377745,-1.628657
	dc.s	-8.970127,15.437899,-2.615994
	dc.s	-8.816351,14.518679,-1.497930
	dc.s	-8.606245,15.329378,-2.413601
	dc.s	-8.995201,15.541039,-2.263718
	dc.s	-7.534878,12.798288,-0.328054
	dc.s	-7.698073,13.063847,-0.406652
	dc.s	-7.467553,13.074396,-0.417118
	dc.s	-7.204233,13.493271,0.220457
	dc.s	-7.465866,13.865173,0.409752
	dc.s	-9.006076,17.404085,-4.305118
	dc.s	-5.205842,9.607617,-0.061430
	dc.s	-5.490573,9.764716,-0.292672
	dc.s	-5.829150,11.084446,-0.689417
	dc.s	-7.722943,12.704109,-1.406205
	dc.s	-8.539716,13.639162,-1.109872
	dc.s	-7.790135,12.935808,-0.695713
	dc.s	-8.826797,16.385918,-2.916544
	dc.s	-7.050282,12.307402,-0.380778
	dc.s	-7.216274,13.611433,0.358534
	dc.s	-7.553315,13.954264,0.360144
	dc.s	-7.178914,14.915613,0.842820
	dc.s	-6.965579,15.702221,1.185274
	dc.s	-7.246259,15.740553,1.154755
	dc.s	-3.298739,7.981811,0.539692
	dc.s	-3.704798,8.042068,0.693261
	dc.s	-2.394271,6.824492,0.477739
	dc.s	-2.857320,6.252497,0.201791
	dc.s	-3.535846,6.307811,0.815040
	dc.s	-5.596881,10.451414,-1.009143
	dc.s	-2.476553,6.535615,0.227031
	dc.s	-3.190656,6.220726,0.320180
	dc.s	-5.143425,10.081719,-0.868033
	dc.s	-3.200256,6.740381,1.370940
	dc.s	-2.654706,6.864241,1.369676
	dc.s	-4.089619,8.037354,0.635730
	dc.s	-2.583303,6.285073,0.194732
	dc.s	-3.468071,6.251752,0.598745
	dc.s	-3.547183,6.355736,1.065008
	dc.s	-4.341132,7.920647,0.421072
	dc.s	-4.365454,8.082575,-0.143936
	dc.s	-4.951340,10.030068,-0.689490
	dc.s	-5.346697,9.554053,-0.452927
	dc.s	-3.604692,6.783336,1.101440
	dc.s	-2.358961,6.922212,1.117580
	dc.s	-5.205842,9.607617,-0.061430
	dc.s	-1.523667,6.143269,1.868030
	dc.s	-3.046945,5.508018,1.805067
	dc.s	-3.535846,6.307811,0.815040
	dc.s	-3.200256,6.740381,1.370940
	dc.s	-2.654706,6.864241,1.369676
	dc.s	-3.468071,6.251752,0.598745
	dc.s	-3.547183,6.355736,1.065008
	dc.s	-2.053280,6.211116,1.943678
	dc.s	-2.633883,6.040819,1.945150
	dc.s	-3.211070,5.496411,1.391844
	dc.s	-3.604692,6.783336,1.101440
	dc.s	-2.358961,6.922212,1.117580
	dc.s	-1.523667,6.143269,1.868030
	dc.s	-1.574146,5.418986,0.477222
	dc.s	-2.930593,5.379502,0.634758
	dc.s	-2.394271,6.824492,0.477739
	dc.s	-2.857320,6.252497,0.201791
	dc.s	-2.701278,5.389275,0.479814
	dc.s	-2.476553,6.535615,0.227031
	dc.s	-3.190656,6.220726,0.320180
	dc.s	-2.583303,6.285073,0.194732
	dc.s	-3.468071,6.251752,0.598745
	dc.s	-1.523866,5.802453,0.705092
	dc.s	-1.519353,6.126657,1.149621
	dc.s	-3.211070,5.496411,1.391844
	dc.s	-3.186008,5.444272,1.016669
	dc.s	-2.055978,5.430051,0.371310
	dc.s	-2.358961,6.922212,1.117580
	dc.s	1.630337,8.655966,7.346503
	dc.s	1.218559,8.207626,7.317859
	dc.s	1.739412,8.755767,7.779963
	dc.s	2.427734,10.483777,8.201851
	dc.s	1.815794,10.272695,8.042258
	dc.s	2.466595,16.239960,9.614017
	dc.s	4.915752,7.882915,-0.084952
	dc.s	5.773280,9.166049,-0.769735
	dc.s	5.258868,8.502078,-0.732064
	dc.s	5.203281,8.739010,-0.819201
	dc.s	6.587361,10.220352,-1.725973
	dc.s	7.138446,10.609501,-2.005269
	dc.s	1.966890,8.598199,7.369851
	dc.s	1.384040,8.224693,7.478353
	dc.s	2.802263,13.597809,8.796767
	dc.s	2.522742,13.520988,8.874126
	dc.s	3.839749,6.836491,0.808959
	dc.s	6.067200,9.783663,-1.062863
	dc.s	2.039554,8.363586,7.332769
	dc.s	2.180371,9.516530,7.794413
	dc.s	2.721892,12.642206,8.716337
	dc.s	2.659238,15.245035,9.148859
	dc.s	2.552246,14.944283,9.133278
	dc.s	2.508284,16.621456,9.656255
	dc.s	4.323456,7.119277,-0.121998
	dc.s	5.358357,9.061405,-0.640450
	dc.s	6.940780,10.428179,-1.657464
	dc.s	6.078292,9.507311,-1.266929
	dc.s	8.485836,11.684461,-2.770030
	dc.s	7.506454,11.088594,-2.064659
	dc.s	8.514912,11.646969,-2.847443
	dc.s	2.307829,17.358004,10.069467
	dc.s	1.859081,8.019671,6.884233
	dc.s	2.110694,8.799439,7.696790
	dc.s	2.099537,9.602629,8.079200
	dc.s	1.475260,8.834273,7.509418
faces_neuron_bak:				;f1,f2,f3 , tf1,tf2,tf3 , texnum , flag
	dc.w 39,38,18,  0,1,2,  0,0
	dc.w 39,19,38,  3,4,5,  0,0
	dc.w 11,0,2,  6,7,8,  0,0
	dc.w 3,40,0,  9,10,11,  0,0
	dc.w 3,22,40,  12,13,14,  0,0
	dc.w 633,20,21,  15,16,17,  0,0
	dc.w 20,4,24,  18,19,20,  0,0
	dc.w 20,24,21,  21,22,23,  0,0
	dc.w 4,41,24,  24,25,26,  0,0
	dc.w 2,0,5,  27,28,29,  0,0
	dc.w 0,12,5,  30,31,32,  0,0
	dc.w 41,2,5,  33,34,35,  0,0
	dc.w 41,5,13,  36,37,38,  0,0
	dc.w 41,13,24,  39,40,41,  0,0
	dc.w 40,6,12,  42,43,44,  0,0
	dc.w 40,12,0,  45,46,47,  0,0
	dc.w 22,6,40,  48,49,50,  0,0
	dc.w 6,26,12,  51,52,53,  0,0
	dc.w 14,26,6,  54,55,56,  0,0
	dc.w 5,12,634,  57,58,59,  0,0
	dc.w 5,634,23,  60,61,62,  0,0
	dc.w 5,23,13,  63,64,65,  0,0
	dc.w 21,24,25,  66,67,68,  0,0
	dc.w 24,28,25,  69,70,71,  0,0
	dc.w 13,28,24,  72,73,74,  0,0
	dc.w 13,23,28,  75,76,77,  0,0
	dc.w 26,7,12,  78,79,80,  0,0
	dc.w 12,7,634,  81,82,83,  0,0
	dc.w 634,27,23,  84,85,86,  0,0
	dc.w 634,31,27,  87,88,89,  0,0
	dc.w 634,30,31,  90,91,92,  0,0
	dc.w 25,28,29,  93,94,95,  0,0
	dc.w 23,27,29,  96,97,98,  0,0
	dc.w 28,23,29,  99,100,101,  0,0
	dc.w 7,30,634,  102,103,104,  0,0
	dc.w 27,31,32,  105,106,107,  0,0
	dc.w 29,27,8,  108,109,110,  0,0
	dc.w 27,32,8,  111,112,113,  0,0
	dc.w 8,32,635,  114,115,116,  0,0
	dc.w 30,33,31,  117,118,119,  0,0
	dc.w 32,9,15,  120,121,122,  0,0
	dc.w 32,31,9,  123,124,125,  0,0
	dc.w 31,34,9,  126,127,128,  0,0
	dc.w 635,32,15,  129,130,131,  0,0
	dc.w 636,34,31,  132,133,134,  0,0
	dc.w 33,636,31,  135,136,137,  0,0
	dc.w 636,16,34,  138,139,140,  0,0
	dc.w 34,10,9,  141,142,143,  0,0
	dc.w 9,35,15,  144,145,146,  0,0
	dc.w 34,16,10,  147,148,149,  0,0
	dc.w 9,10,36,  150,151,152,  0,0
	dc.w 9,36,35,  153,154,155,  0,0
	dc.w 10,1,36,  156,157,158,  0,0
	dc.w 16,1,10,  159,160,161,  0,0
	dc.w 35,38,17,  162,163,164,  0,0
	dc.w 35,36,38,  165,166,167,  0,0
	dc.w 37,35,17,  168,169,170,  0,0
	dc.w 36,18,38,  171,172,173,  0,0
	dc.w 17,38,19,  174,175,176,  0,0
	dc.w 1,39,18,  177,178,179,  0,0
	dc.w 1,18,36,  180,181,182,  0,0
	dc.w 674,655,673,  183,184,185,  0,0
	dc.w 673,655,652,  186,187,188,  0,0
	dc.w 640,638,644,  189,190,191,  0,0
	dc.w 655,675,652,  192,193,194,  0,0
	dc.w 652,675,658,  195,196,197,  0,0
	dc.w 652,658,640,  198,199,200,  0,0
	dc.w 672,637,653,  201,202,203,  0,0
	dc.w 637,676,653,  204,205,206,  0,0
	dc.w 654,655,674,  207,208,209,  0,0
	dc.w 654,653,655,  210,211,212,  0,0
	dc.w 672,653,654,  213,214,215,  0,0
	dc.w 655,657,675,  216,217,218,  0,0
	dc.w 653,657,655,  219,220,221,  0,0
	dc.w 653,676,657,  222,223,224,  0,0
	dc.w 676,656,657,  225,226,227,  0,0
	dc.w 657,656,660,  228,229,230,  0,0
	dc.w 657,660,675,  231,232,233,  0,0
	dc.w 658,645,641,  234,235,236,  0,0
	dc.w 675,645,658,  237,238,239,  0,0
	dc.w 660,656,663,  240,241,242,  0,0
	dc.w 675,660,663,  243,244,245,  0,0
	dc.w 645,663,646,  246,247,248,  0,0
	dc.w 675,663,645,  249,250,251,  0,0
	dc.w 656,659,663,  252,253,254,  0,0
	dc.w 645,646,661,  255,256,257,  0,0
	dc.w 661,646,642,  258,259,260,  0,0
	dc.w 659,662,647,  261,262,263,  0,0
	dc.w 646,664,666,  264,265,266,  0,0
	dc.w 663,664,646,  267,268,269,  0,0
	dc.w 659,647,663,  270,271,272,  0,0
	dc.w 663,647,664,  273,274,275,  0,0
	dc.w 642,666,665,  276,277,278,  0,0
	dc.w 646,666,642,  279,280,281,  0,0
	dc.w 662,643,647,  282,283,284,  0,0
	dc.w 647,643,677,  285,286,287,  0,0
	dc.w 664,668,666,  288,289,290,  0,0
	dc.w 647,677,668,  291,292,293,  0,0
	dc.w 664,647,668,  294,295,296,  0,0
	dc.w 666,667,665,  297,298,299,  0,0
	dc.w 666,679,667,  300,301,302,  0,0
	dc.w 677,648,678,  303,304,305,  0,0
	dc.w 677,678,668,  306,307,308,  0,0
	dc.w 666,668,679,  309,310,311,  0,0
	dc.w 679,668,649,  312,313,314,  0,0
	dc.w 678,648,669,  315,316,317,  0,0
	dc.w 678,669,680,  318,319,320,  0,0
	dc.w 668,678,680,  321,322,323,  0,0
	dc.w 668,639,649,  324,325,326,  0,0
	dc.w 668,680,639,  327,328,329,  0,0
	dc.w 680,669,670,  330,331,332,  0,0
	dc.w 680,670,681,  333,334,335,  0,0
	dc.w 680,681,639,  336,337,338,  0,0
	dc.w 670,650,681,  339,340,341,  0,0
	dc.w 681,671,639,  342,343,344,  0,0
	dc.w 681,650,651,  345,346,347,  0,0
	dc.w 681,651,671,  348,349,350,  0,0
	dc.w 690,685,682,  351,352,353,  0,0
	dc.w 690,682,689,  354,355,356,  0,0
	dc.w 692,686,682,  357,358,359,  0,0
	dc.w 691,686,692,  360,361,362,  0,0
	dc.w 686,689,682,  363,364,365,  0,0
	dc.w 687,683,685,  366,367,368,  0,0
	dc.w 687,685,690,  369,370,371,  0,0
	dc.w 684,688,692,  372,373,374,  0,0
	dc.w 688,691,692,  375,376,377,  0,0
	dc.w 701,698,694,  378,379,380,  0,0
	dc.w 701,694,697,  381,382,383,  0,0
	dc.w 696,699,695,  384,385,386,  0,0
	dc.w 693,700,702,  387,388,389,  0,0
	dc.w 693,696,700,  390,391,392,  0,0
	dc.w 700,696,695,  393,394,395,  0,0
	dc.w 607,592,605,  396,397,398,  0,0
	dc.w 712,592,607,  399,400,401,  0,0
	dc.w 606,605,593,  402,403,404,  0,0
	dc.w 605,592,593,  405,406,407,  0,0
	dc.w 617,714,595,  408,409,410,  0,0
	dc.w 595,714,598,  411,412,413,  0,0
	dc.w 595,598,594,  414,415,416,  0,0
	dc.w 594,598,596,  417,418,419,  0,0
	dc.w 597,594,596,  420,421,422,  0,0
	dc.w 597,596,599,  423,424,425,  0,0
	dc.w 705,707,714,  426,427,428,  0,0
	dc.w 705,714,617,  429,430,431,  0,0
	dc.w 714,618,598,  432,433,434,  0,0
	dc.w 596,706,620,  435,436,437,  0,0
	dc.w 598,706,596,  438,439,440,  0,0
	dc.w 598,618,706,  441,442,443,  0,0
	dc.w 599,596,620,  444,445,446,  0,0
	dc.w 599,620,708,  447,448,449,  0,0
	dc.w 714,707,618,  450,451,452,  0,0
	dc.w 707,619,618,  453,454,455,  0,0
	dc.w 618,608,706,  456,457,458,  0,0
	dc.w 620,706,600,  459,460,461,  0,0
	dc.w 706,621,600,  462,463,464,  0,0
	dc.w 608,609,621,  465,466,467,  0,0
	dc.w 706,608,621,  468,469,470,  0,0
	dc.w 620,600,708,  471,472,473,  0,0
	dc.w 600,621,622,  474,475,476,  0,0
	dc.w 621,601,622,  477,478,479,  0,0
	dc.w 600,622,715,  480,481,482,  0,0
	dc.w 621,623,601,  483,484,485,  0,0
	dc.w 708,600,715,  486,487,488,  0,0
	dc.w 708,715,709,  489,490,491,  0,0
	dc.w 715,622,602,  492,493,494,  0,0
	dc.w 709,715,602,  495,496,497,  0,0
	dc.w 609,710,621,  498,499,500,  0,0
	dc.w 624,710,609,  501,502,503,  0,0
	dc.w 621,625,623,  504,505,506,  0,0
	dc.w 710,625,621,  507,508,509,  0,0
	dc.w 601,623,711,  510,511,512,  0,0
	dc.w 622,601,711,  513,514,515,  0,0
	dc.w 711,603,604,  516,517,518,  0,0
	dc.w 623,603,711,  519,520,521,  0,0
	dc.w 602,622,711,  522,523,524,  0,0
	dc.w 623,703,603,  525,526,527,  0,0
	dc.w 625,703,623,  528,529,530,  0,0
	dc.w 604,603,606,  531,532,533,  0,0
	dc.w 603,605,606,  534,535,536,  0,0
	dc.w 603,607,605,  537,538,539,  0,0
	dc.w 604,606,626,  540,541,542,  0,0
	dc.w 626,606,616,  543,544,545,  0,0
	dc.w 606,593,616,  546,547,548,  0,0
	dc.w 703,607,603,  549,550,551,  0,0
	dc.w 703,712,607,  552,553,554,  0,0
	dc.w 619,704,618,  555,556,557,  0,0
	dc.w 618,704,608,  558,559,560,  0,0
	dc.w 610,609,627,  561,562,563,  0,0
	dc.w 608,627,609,  564,565,566,  0,0
	dc.w 608,613,627,  567,568,569,  0,0
	dc.w 704,613,608,  570,571,572,  0,0
	dc.w 610,624,609,  573,574,575,  0,0
	dc.w 611,610,627,  576,577,578,  0,0
	dc.w 704,612,613,  579,580,581,  0,0
	dc.w 627,613,716,  582,583,584,  0,0
	dc.w 613,612,614,  585,586,587,  0,0
	dc.w 611,627,628,  588,589,590,  0,0
	dc.w 627,716,628,  591,592,593,  0,0
	dc.w 613,614,716,  594,595,596,  0,0
	dc.w 614,615,716,  597,598,599,  0,0
	dc.w 614,713,615,  600,601,602,  0,0
	dc.w 630,716,591,  603,604,605,  0,0
	dc.w 716,615,591,  606,607,608,  0,0
	dc.w 615,629,591,  609,610,611,  0,0
	dc.w 615,713,629,  612,613,614,  0,0
	dc.w 630,591,629,  615,616,617,  0,0
	dc.w 630,629,713,  618,619,620,  0,0
	dc.w 755,734,717,  621,622,623,  0,0
	dc.w 717,734,733,  624,625,626,  0,0
	dc.w 728,717,733,  627,628,629,  0,0
	dc.w 758,756,738,  630,631,632,  0,0
	dc.w 758,738,760,  633,634,635,  0,0
	dc.w 756,736,738,  636,637,638,  0,0
	dc.w 737,760,719,  639,640,641,  0,0
	dc.w 758,760,737,  642,643,644,  0,0
	dc.w 757,719,761,  645,646,647,  0,0
	dc.w 757,761,759,  648,649,650,  0,0
	dc.w 737,719,757,  651,652,653,  0,0
	dc.w 735,759,761,  654,655,656,  0,0
	dc.w 735,761,720,  657,658,659,  0,0
	dc.w 720,761,721,  660,661,662,  0,0
	dc.w 760,738,740,  663,664,665,  0,0
	dc.w 738,722,740,  666,667,668,  0,0
	dc.w 760,740,739,  669,670,671,  0,0
	dc.w 719,760,739,  672,673,674,  0,0
	dc.w 761,719,762,  675,676,677,  0,0
	dc.w 739,631,762,  678,679,680,  0,0
	dc.w 719,739,762,  681,682,683,  0,0
	dc.w 761,762,721,  684,685,686,  0,0
	dc.w 762,631,764,  687,688,689,  0,0
	dc.w 739,743,104,  690,691,692,  0,0
	dc.w 105,743,744,  693,694,695,  0,0
	dc.w 739,740,743,  696,697,698,  0,0
	dc.w 740,723,730,  699,700,701,  0,0
	dc.w 740,722,723,  702,703,704,  0,0
	dc.w 723,742,741,  705,706,707,  0,0
	dc.w 723,741,730,  708,709,710,  0,0
	dc.w 740,730,743,  711,712,713,  0,0
	dc.w 743,724,744,  714,715,716,  0,0
	dc.w 744,724,745,  717,718,719,  0,0
	dc.w 724,727,731,  720,721,722,  0,0
	dc.w 724,731,745,  723,724,725,  0,0
	dc.w 743,730,724,  726,727,728,  0,0
	dc.w 724,730,727,  729,730,731,  0,0
	dc.w 744,725,765,  732,733,734,  0,0
	dc.w 744,745,725,  735,736,737,  0,0
	dc.w 725,745,766,  738,739,740,  0,0
	dc.w 742,726,741,  741,742,743,  0,0
	dc.w 730,768,747,  744,745,746,  0,0
	dc.w 730,741,768,  747,748,749,  0,0
	dc.w 741,726,746,  750,751,752,  0,0
	dc.w 741,746,768,  753,754,755,  0,0
	dc.w 731,767,632,  756,757,758,  0,0
	dc.w 727,767,731,  759,760,761,  0,0
	dc.w 727,747,767,  762,763,764,  0,0
	dc.w 727,730,747,  765,766,767,  0,0
	dc.w 766,731,632,  768,769,770,  0,0
	dc.w 747,768,755,  771,772,773,  0,0
	dc.w 747,717,767,  774,775,776,  0,0
	dc.w 747,755,717,  777,778,779,  0,0
	dc.w 632,767,728,  780,781,782,  0,0
	dc.w 767,717,728,  783,784,785,  0,0
	dc.w 631,769,764,  786,787,788,  0,0
	dc.w 769,718,763,  789,790,791,  0,0
	dc.w 769,752,718,  792,793,794,  0,0
	dc.w 631,106,769,  795,796,797,  0,0
	dc.w 107,744,750,  798,799,800,  0,0
	dc.w 739,108,631,  801,802,803,  0,0
	dc.w 631,109,110,  804,805,806,  0,0
	dc.w 749,765,748,  807,808,809,  0,0
	dc.w 744,749,750,  810,811,812,  0,0
	dc.w 750,749,748,  813,814,815,  0,0
	dc.w 744,765,749,  816,817,818,  0,0
	dc.w 769,111,752,  819,820,821,  0,0
	dc.w 750,751,771,  822,823,824,  0,0
	dc.w 112,770,113,  825,826,827,  0,0
	dc.w 114,753,752,  828,829,830,  0,0
	dc.w 752,753,754,  831,832,833,  0,0
	dc.w 770,771,732,  834,835,836,  0,0
	dc.w 115,770,772,  837,838,839,  0,0
	dc.w 116,772,753,  840,841,842,  0,0
	dc.w 770,732,772,  843,844,845,  0,0
	dc.w 754,753,729,  846,847,848,  0,0
	dc.w 753,772,729,  849,850,851,  0,0
	dc.w 773,781,780,  852,853,854,  0,0
	dc.w 773,779,781,  855,856,857,  0,0
	dc.w 775,774,782,  858,859,860,  0,0
	dc.w 781,783,780,  861,862,863,  0,0
	dc.w 784,777,785,  864,865,866,  0,0
	dc.w 777,776,778,  867,868,869,  0,0
	dc.w 777,786,785,  870,871,872,  0,0
	dc.w 789,790,792,  873,874,875,  0,0
	dc.w 789,792,798,  876,877,878,  0,0
	dc.w 797,792,790,  879,880,881,  0,0
	dc.w 794,789,798,  882,883,884,  0,0
	dc.w 797,801,792,  885,886,887,  0,0
	dc.w 792,801,795,  888,889,890,  0,0
	dc.w 798,792,795,  891,892,893,  0,0
	dc.w 798,795,793,  894,895,896,  0,0
	dc.w 800,794,796,  897,898,899,  0,0
	dc.w 794,798,793,  900,901,902,  0,0
	dc.w 794,793,796,  903,904,905,  0,0
	dc.w 799,800,796,  906,907,908,  0,0
	dc.w 791,801,797,  909,910,911,  0,0
	dc.w 791,788,801,  912,913,914,  0,0
	dc.w 787,788,791,  915,916,917,  0,0
	dc.w 802,814,808,  918,919,920,  0,0
	dc.w 813,807,810,  921,922,923,  0,0
	dc.w 806,812,814,  924,925,926,  0,0
	dc.w 806,814,802,  927,928,929,  0,0
	dc.w 804,812,806,  930,931,932,  0,0
	dc.w 804,811,812,  933,934,935,  0,0
	dc.w 811,813,809,  936,937,938,  0,0
	dc.w 811,809,812,  939,940,941,  0,0
	dc.w 803,808,805,  942,943,944,  0,0
	dc.w 815,817,816,  945,946,947,  0,0
	dc.w 818,815,819,  948,949,950,  0,0
	dc.w 825,828,846,  951,952,953,  0,0
	dc.w 869,846,847,  954,955,956,  0,0
	dc.w 846,828,847,  957,958,959,  0,0
	dc.w 820,829,831,  960,961,962,  0,0
	dc.w 848,870,831,  963,964,965,  0,0
	dc.w 829,848,831,  966,967,968,  0,0
	dc.w 820,872,851,  969,970,971,  0,0
	dc.w 850,830,842,  972,973,974,  0,0
	dc.w 849,871,870,  975,976,977,  0,0
	dc.w 849,852,871,  978,979,980,  0,0
	dc.w 840,851,854,  981,982,983,  0,0
	dc.w 872,821,854,  984,985,986,  0,0
	dc.w 851,872,854,  987,988,989,  0,0
	dc.w 840,854,830,  990,991,992,  0,0
	dc.w 850,842,852,  993,994,995,  0,0
	dc.w 852,855,871,  996,997,998,  0,0
	dc.w 852,842,855,  999,1000,1001,  0,0
	dc.w 870,871,841,  1002,1003,1004,  0,0
	dc.w 871,855,841,  1005,1006,1007,  0,0
	dc.w 841,855,822,  1008,1009,1010,  0,0
	dc.w 870,841,831,  1011,1012,1013,  0,0
	dc.w 820,831,872,  1014,1015,1016,  0,0
	dc.w 831,853,821,  1017,1018,1019,  0,0
	dc.w 831,821,872,  1020,1021,1022,  0,0
	dc.w 841,822,853,  1023,1024,1025,  0,0
	dc.w 841,853,831,  1026,1027,1028,  0,0
	dc.w 854,821,117,  1029,1030,1031,  0,0
	dc.w 854,118,866,  1032,1033,1034,  0,0
	dc.w 854,832,873,  1035,1036,1037,  0,0
	dc.w 854,866,823,  1038,1039,1040,  0,0
	dc.w 854,823,832,  1041,1042,1043,  0,0
	dc.w 830,854,873,  1044,1045,1046,  0,0
	dc.w 830,833,842,  1047,1048,1049,  0,0
	dc.w 830,873,833,  1050,1051,1052,  0,0
	dc.w 855,833,834,  1053,1054,1055,  0,0
	dc.w 855,842,833,  1056,1057,1058,  0,0
	dc.w 822,855,856,  1059,1060,1061,  0,0
	dc.w 855,834,856,  1062,1063,1064,  0,0
	dc.w 832,823,858,  1065,1066,1067,  0,0
	dc.w 873,832,843,  1068,1069,1070,  0,0
	dc.w 832,858,843,  1071,1072,1073,  0,0
	dc.w 873,843,859,  1074,1075,1076,  0,0
	dc.w 833,873,859,  1077,1078,1079,  0,0
	dc.w 856,834,874,  1080,1081,1082,  0,0
	dc.w 856,857,875,  1083,1084,1085,  0,0
	dc.w 856,874,857,  1086,1087,1088,  0,0
	dc.w 823,875,858,  1089,1090,1091,  0,0
	dc.w 875,857,858,  1092,1093,1094,  0,0
	dc.w 857,824,858,  1095,1096,1097,  0,0
	dc.w 858,824,843,  1098,1099,1100,  0,0
	dc.w 843,824,835,  1101,1102,1103,  0,0
	dc.w 835,862,845,  1104,1105,1106,  0,0
	dc.w 824,862,835,  1107,1108,1109,  0,0
	dc.w 824,876,862,  1110,1111,1112,  0,0
	dc.w 843,835,859,  1113,1114,1115,  0,0
	dc.w 833,859,835,  1116,1117,1118,  0,0
	dc.w 835,845,860,  1119,1120,1121,  0,0
	dc.w 833,835,860,  1122,1123,1124,  0,0
	dc.w 833,860,844,  1125,1126,1127,  0,0
	dc.w 833,844,834,  1128,1129,1130,  0,0
	dc.w 874,844,861,  1131,1132,1133,  0,0
	dc.w 834,844,874,  1134,1135,1136,  0,0
	dc.w 844,860,861,  1137,1138,1139,  0,0
	dc.w 861,860,863,  1140,1141,1142,  0,0
	dc.w 857,874,836,  1143,1144,1145,  0,0
	dc.w 874,861,836,  1146,1147,1148,  0,0
	dc.w 857,836,824,  1149,1150,1151,  0,0
	dc.w 824,836,876,  1152,1153,1154,  0,0
	dc.w 836,838,876,  1155,1156,1157,  0,0
	dc.w 861,863,838,  1158,1159,1160,  0,0
	dc.w 861,838,836,  1161,1162,1163,  0,0
	dc.w 862,828,825,  1164,1165,1166,  0,0
	dc.w 862,876,828,  1167,1168,1169,  0,0
	dc.w 845,862,825,  1170,1171,1172,  0,0
	dc.w 860,845,869,  1173,1174,1175,  0,0
	dc.w 845,846,869,  1176,1177,1178,  0,0
	dc.w 845,825,846,  1179,1180,1181,  0,0
	dc.w 860,869,837,  1182,1183,1184,  0,0
	dc.w 860,837,863,  1185,1186,1187,  0,0
	dc.w 869,847,837,  1188,1189,1190,  0,0
	dc.w 863,837,838,  1191,1192,1193,  0,0
	dc.w 837,828,876,  1194,1195,1196,  0,0
	dc.w 838,837,876,  1197,1198,1199,  0,0
	dc.w 837,847,828,  1200,1201,1202,  0,0
	dc.w 822,877,853,  1203,1204,1205,  0,0
	dc.w 853,877,119,  1206,1207,1208,  0,0
	dc.w 821,120,121,  1209,1210,1211,  0,0
	dc.w 853,122,821,  1212,1213,1214,  0,0
	dc.w 123,867,124,  1215,1216,1217,  0,0
	dc.w 125,878,867,  1218,1219,1220,  0,0
	dc.w 877,878,126,  1221,1222,1223,  0,0
	dc.w 127,867,839,  1224,1225,1226,  0,0
	dc.w 128,839,866,  1227,1228,1229,  0,0
	dc.w 856,865,864,  1230,1231,1232,  0,0
	dc.w 822,864,877,  1233,1234,1235,  0,0
	dc.w 822,856,864,  1236,1237,1238,  0,0
	dc.w 877,864,868,  1239,1240,1241,  0,0
	dc.w 877,868,878,  1242,1243,1244,  0,0
	dc.w 864,879,868,  1245,1246,1247,  0,0
	dc.w 864,865,879,  1248,1249,1250,  0,0
	dc.w 823,866,875,  1251,1252,1253,  0,0
	dc.w 875,866,865,  1254,1255,1256,  0,0
	dc.w 856,875,865,  1257,1258,1259,  0,0
	dc.w 866,839,865,  1260,1261,1262,  0,0
	dc.w 865,839,879,  1263,1264,1265,  0,0
	dc.w 879,826,868,  1266,1267,1268,  0,0
	dc.w 867,878,880,  1269,1270,1271,  0,0
	dc.w 867,880,839,  1272,1273,1274,  0,0
	dc.w 839,882,879,  1275,1276,1277,  0,0
	dc.w 879,882,826,  1278,1279,1280,  0,0
	dc.w 878,868,826,  1281,1282,1283,  0,0
	dc.w 878,826,880,  1284,1285,1286,  0,0
	dc.w 839,880,881,  1287,1288,1289,  0,0
	dc.w 839,881,882,  1290,1291,1292,  0,0
	dc.w 826,882,881,  1293,1294,1295,  0,0
	dc.w 826,881,880,  1296,1297,1298,  0,0
	dc.w 881,827,882,  1299,1300,1301,  0,0
	dc.w 881,882,827,  1302,1303,1304,  0,0
	dc.w 892,894,884,  1305,1306,1307,  0,0
	dc.w 892,902,894,  1308,1309,1310,  0,0
	dc.w 893,884,883,  1311,1312,1313,  0,0
	dc.w 893,883,903,  1314,1315,1316,  0,0
	dc.w 892,884,893,  1317,1318,1319,  0,0
	dc.w 902,904,894,  1320,1321,1322,  0,0
	dc.w 903,883,885,  1323,1324,1325,  0,0
	dc.w 889,900,891,  1326,1327,1328,  0,0
	dc.w 889,885,900,  1329,1330,1331,  0,0
	dc.w 885,883,900,  1332,1333,1334,  0,0
	dc.w 890,886,899,  1335,1336,1337,  0,0
	dc.w 886,888,899,  1338,1339,1340,  0,0
	dc.w 895,891,888,  1341,1342,1343,  0,0
	dc.w 895,889,891,  1344,1345,1346,  0,0
	dc.w 886,895,888,  1347,1348,1349,  0,0
	dc.w 896,899,887,  1350,1351,1352,  0,0
	dc.w 890,899,896,  1353,1354,1355,  0,0
	dc.w 897,898,902,  1356,1357,1358,  0,0
	dc.w 897,887,898,  1359,1360,1361,  0,0
	dc.w 887,901,898,  1362,1363,1364,  0,0
	dc.w 902,898,904,  1365,1366,1367,  0,0
	dc.w 887,899,901,  1368,1369,1370,  0,0
	dc.w 906,908,913,  1371,1372,1373,  0,0
	dc.w 906,915,908,  1374,1375,1376,  0,0
	dc.w 905,909,916,  1377,1378,1379,  0,0
	dc.w 905,912,909,  1380,1381,1382,  0,0
	dc.w 913,909,912,  1383,1384,1385,  0,0
	dc.w 913,908,909,  1386,1387,1388,  0,0
	dc.w 906,911,915,  1389,1390,1391,  0,0
	dc.w 914,911,906,  1392,1393,1394,  0,0
	dc.w 907,914,910,  1395,1396,1397,  0,0
	dc.w 907,911,914,  1398,1399,1400,  0,0
	dc.w 917,932,928,  1401,1402,1403,  0,0
	dc.w 928,932,920,  1404,1405,1406,  0,0
	dc.w 918,920,923,  1407,1408,1409,  0,0
	dc.w 918,927,920,  1410,1411,1412,  0,0
	dc.w 927,928,920,  1413,1414,1415,  0,0
	dc.w 918,923,925,  1416,1417,1418,  0,0
	dc.w 918,925,931,  1419,1420,1421,  0,0
	dc.w 922,931,925,  1422,1423,1424,  0,0
	dc.w 922,925,921,  1425,1426,1427,  0,0
	dc.w 922,921,924,  1428,1429,1430,  0,0
	dc.w 919,922,924,  1431,1432,1433,  0,0
	dc.w 919,924,930,  1434,1435,1436,  0,0
	dc.w 930,924,926,  1437,1438,1439,  0,0
	dc.w 930,926,929,  1440,1441,1442,  0,0
	dc.w 965,951,945,  1443,1444,1445,  0,0
	dc.w 966,936,952,  1446,1447,1448,  0,0
	dc.w 951,966,952,  1449,1450,1451,  0,0
	dc.w 951,952,945,  1452,1453,1454,  0,0
	dc.w 966,967,936,  1455,1456,1457,  0,0
	dc.w 933,952,968,  1458,1459,1460,  0,0
	dc.w 945,952,933,  1461,1462,1463,  0,0
	dc.w 934,937,129,  1464,1465,1466,  0,0
	dc.w 946,934,129,  1467,1468,1469,  0,0
	dc.w 934,968,937,  1470,1471,1472,  0,0
	dc.w 935,967,966,  1473,1474,1475,  0,0
	dc.w 946,129,935,  1476,1477,1478,  0,0
	dc.w 935,129,967,  1479,1480,1481,  0,0
	dc.w 967,953,936,  1482,1483,1484,  0,0
	dc.w 952,936,947,  1485,1486,1487,  0,0
	dc.w 936,953,947,  1488,1489,1490,  0,0
	dc.w 968,952,130,  1491,1492,1493,  0,0
	dc.w 130,132,133,  1494,1495,1496,  0,0
	dc.w 952,132,130,  1497,1498,1499,  0,0
	dc.w 952,947,132,  1500,1501,1502,  0,0
	dc.w 968,130,937,  1503,1504,1505,  0,0
	dc.w 937,133,948,  1506,1507,1508,  0,0
	dc.w 129,937,948,  1509,1510,1511,  0,0
	dc.w 130,133,937,  1512,1513,1514,  0,0
	dc.w 967,134,953,  1515,1516,1517,  0,0
	dc.w 129,948,967,  1518,1519,1520,  0,0
	dc.w 967,948,134,  1521,1522,1523,  0,0
	dc.w 953,134,131,  1524,1525,1526,  0,0
	dc.w 953,131,947,  1527,1528,1529,  0,0
	dc.w 131,134,136,  1530,1531,1532,  0,0
	dc.w 133,132,954,  1533,1534,1535,  0,0
	dc.w 132,947,954,  1536,1537,1538,  0,0
	dc.w 947,131,954,  1539,1540,1541,  0,0
	dc.w 133,954,955,  1542,1543,1544,  0,0
	dc.w 133,955,948,  1545,1546,1547,  0,0
	dc.w 955,954,956,  1548,1549,1550,  0,0
	dc.w 134,948,135,  1551,1552,1553,  0,0
	dc.w 134,135,136,  1554,1555,1556,  0,0
	dc.w 948,955,135,  1557,1558,1559,  0,0
	dc.w 131,136,956,  1560,1561,1562,  0,0
	dc.w 956,136,964,  1563,1564,1565,  0,0
	dc.w 954,131,956,  1566,1567,1568,  0,0
	dc.w 955,956,938,  1569,1570,1571,  0,0
	dc.w 956,964,938,  1572,1573,1574,  0,0
	dc.w 955,938,135,  1575,1576,1577,  0,0
	dc.w 135,938,136,  1578,1579,1580,  0,0
	dc.w 136,938,964,  1581,1582,1583,  0,0
	dc.w 957,939,941,  1584,1585,1586,  0,0
	dc.w 957,941,942,  1587,1588,1589,  0,0
	dc.w 958,137,950,  1590,1591,1592,  0,0
	dc.w 942,137,958,  1593,1594,1595,  0,0
	dc.w 949,940,939,  1596,1597,1598,  0,0
	dc.w 949,950,940,  1599,1600,1601,  0,0
	dc.w 949,958,950,  1602,1603,1604,  0,0
	dc.w 939,940,941,  1605,1606,1607,  0,0
	dc.w 941,940,960,  1608,1609,1610,  0,0
	dc.w 941,960,943,  1611,1612,1613,  0,0
	dc.w 941,943,942,  1614,1615,1616,  0,0
	dc.w 137,962,950,  1617,1618,1619,  0,0
	dc.w 137,138,962,  1620,1621,1622,  0,0
	dc.w 137,943,138,  1623,1624,1625,  0,0
	dc.w 940,950,962,  1626,1627,1628,  0,0
	dc.w 940,962,959,  1629,1630,1631,  0,0
	dc.w 940,959,960,  1632,1633,1634,  0,0
	dc.w 960,959,944,  1635,1636,1637,  0,0
	dc.w 960,944,943,  1638,1639,1640,  0,0
	dc.w 942,943,137,  1641,1642,1643,  0,0
	dc.w 138,961,962,  1644,1645,1646,  0,0
	dc.w 959,962,961,  1647,1648,1649,  0,0
	dc.w 959,961,944,  1650,1651,1652,  0,0
	dc.w 944,961,963,  1653,1654,1655,  0,0
	dc.w 943,944,963,  1656,1657,1658,  0,0
	dc.w 943,963,138,  1659,1660,1661,  0,0
	dc.w 138,963,961,  1662,1663,1664,  0,0
	dc.w 167,142,157,  1665,1666,1667,  0,0
	dc.w 168,155,169,  1668,1669,1670,  0,0
	dc.w 168,169,140,  1671,1672,1673,  0,0
	dc.w 140,169,171,  1674,1675,1676,  0,0
	dc.w 166,141,151,  1677,1678,1679,  0,0
	dc.w 141,144,151,  1680,1681,1682,  0,0
	dc.w 141,139,144,  1683,1684,1685,  0,0
	dc.w 166,151,156,  1686,1687,1688,  0,0
	dc.w 156,151,142,  1689,1690,1691,  0,0
	dc.w 157,142,170,  1692,1693,1694,  0,0
	dc.w 155,158,169,  1695,1696,1697,  0,0
	dc.w 155,157,158,  1698,1699,1700,  0,0
	dc.w 157,170,158,  1701,1702,1703,  0,0
	dc.w 169,150,171,  1704,1705,1706,  0,0
	dc.w 171,150,143,  1707,1708,1709,  0,0
	dc.w 139,143,172,  1710,1711,1712,  0,0
	dc.w 139,171,143,  1713,1714,1715,  0,0
	dc.w 139,172,144,  1716,1717,1718,  0,0
	dc.w 142,151,145,  1719,1720,1721,  0,0
	dc.w 142,145,170,  1722,1723,1724,  0,0
	dc.w 152,159,154,  1725,1726,1727,  0,0
	dc.w 173,164,161,  1728,1729,1730,  0,0
	dc.w 152,154,162,  1731,1732,1733,  0,0
	dc.w 146,162,154,  1734,1735,1736,  0,0
	dc.w 147,164,173,  1737,1738,1739,  0,0
	dc.w 159,163,165,  1740,1741,1742,  0,0
	dc.w 159,165,154,  1743,1744,1745,  0,0
	dc.w 153,149,163,  1746,1747,1748,  0,0
	dc.w 163,149,165,  1749,1750,1751,  0,0
	dc.w 146,154,148,  1752,1753,1754,  0,0
	dc.w 174,146,148,  1755,1756,1757,  0,0
	dc.w 147,174,148,  1758,1759,1760,  0,0
	dc.w 147,148,164,  1761,1762,1763,  0,0
	dc.w 161,164,160,  1764,1765,1766,  0,0
	dc.w 153,160,149,  1767,1768,1769,  0,0
	dc.w 164,149,160,  1770,1771,1772,  0,0
	dc.w 196,189,185,  1773,1774,1775,  0,0
	dc.w 175,177,197,  1776,1777,1778,  0,0
	dc.w 179,180,188,  1779,1780,1781,  0,0
	dc.w 179,187,180,  1782,1783,1784,  0,0
	dc.w 185,189,186,  1785,1786,1787,  0,0
	dc.w 175,197,176,  1788,1789,1790,  0,0
	dc.w 178,175,176,  1791,1792,1793,  0,0
	dc.w 196,188,180,  1794,1795,1796,  0,0
	dc.w 198,184,195,  1797,1798,1799,  0,0
	dc.w 198,195,190,  1800,1801,1802,  0,0
	dc.w 190,195,191,  1803,1804,1805,  0,0
	dc.w 190,191,183,  1806,1807,1808,  0,0
	dc.w 192,194,181,  1809,1810,1811,  0,0
	dc.w 193,192,181,  1812,1813,1814,  0,0
	dc.w 192,183,194,  1815,1816,1817,  0,0
	dc.w 193,181,200,  1818,1819,1820,  0,0
	dc.w 199,193,200,  1821,1822,1823,  0,0
	dc.w 199,200,182,  1824,1825,1826,  0,0
	dc.w 205,201,204,  1827,1828,1829,  0,0
	dc.w 206,207,203,  1830,1831,1832,  0,0
	dc.w 205,202,201,  1833,1834,1835,  0,0
	dc.w 206,203,205,  1836,1837,1838,  0,0
	dc.w 205,203,202,  1839,1840,1841,  0,0
	dc.w 210,212,208,  1842,1843,1844,  0,0
	dc.w 209,208,211,  1845,1846,1847,  0,0
	dc.w 210,208,209,  1848,1849,1850,  0,0
	dc.w 215,214,217,  1851,1852,1853,  0,0
	dc.w 214,213,216,  1854,1855,1856,  0,0
	dc.w 214,216,217,  1857,1858,1859,  0,0
	dc.w 538,541,546,  1860,1861,1862,  0,0
	dc.w 546,541,539,  1863,1864,1865,  0,0
	dc.w 538,218,541,  1866,1867,1868,  0,0
	dc.w 218,540,541,  1869,1870,1871,  0,0
	dc.w 393,542,219,  1872,1873,1874,  0,0
	dc.w 393,260,520,  1875,1876,1877,  0,0
	dc.w 393,520,542,  1878,1879,1880,  0,0
	dc.w 360,393,219,  1881,1882,1883,  0,0
	dc.w 544,88,260,  1884,1885,1886,  0,0
	dc.w 260,88,520,  1887,1888,1889,  0,0
	dc.w 222,544,543,  1890,1891,1892,  0,0
	dc.w 359,544,545,  1893,1894,1895,  0,0
	dc.w 543,544,359,  1896,1897,1898,  0,0
	dc.w 545,544,260,  1899,1900,1901,  0,0
	dc.w 220,545,360,  1902,1903,1904,  0,0
	dc.w 360,545,393,  1905,1906,1907,  0,0
	dc.w 545,260,393,  1908,1909,1910,  0,0
	dc.w 546,539,547,  1911,1912,1913,  0,0
	dc.w 223,395,548,  1914,1915,1916,  0,0
	dc.w 547,395,223,  1917,1918,1919,  0,0
	dc.w 547,539,395,  1920,1921,1922,  0,0
	dc.w 548,395,394,  1923,1924,1925,  0,0
	dc.w 539,221,395,  1926,1927,1928,  0,0
	dc.w 394,395,221,  1929,1930,1931,  0,0
	dc.w 396,394,221,  1932,1933,1934,  0,0
	dc.w 396,221,398,  1935,1936,1937,  0,0
	dc.w 398,221,87,  1938,1939,1940,  0,0
	dc.w 549,224,397,  1941,1942,1943,  0,0
	dc.w 403,397,224,  1944,1945,1946,  0,0
	dc.w 549,397,550,  1947,1948,1949,  0,0
	dc.w 396,398,397,  1950,1951,1952,  0,0
	dc.w 397,398,550,  1953,1954,1955,  0,0
	dc.w 403,396,397,  1956,1957,1958,  0,0
	dc.w 398,87,88,  1959,1960,1961,  0,0
	dc.w 399,398,88,  1962,1963,1964,  0,0
	dc.w 399,550,398,  1965,1966,1967,  0,0
	dc.w 544,399,88,  1968,1969,1970,  0,0
	dc.w 555,399,544,  1971,1972,1973,  0,0
	dc.w 549,551,224,  1974,1975,1976,  0,0
	dc.w 400,554,549,  1977,1978,1979,  0,0
	dc.w 549,554,551,  1980,1981,1982,  0,0
	dc.w 399,400,549,  1983,1984,1985,  0,0
	dc.w 399,549,550,  1986,1987,1988,  0,0
	dc.w 552,225,400,  1989,1990,1991,  0,0
	dc.w 225,554,400,  1992,1993,1994,  0,0
	dc.w 553,552,400,  1995,1996,1997,  0,0
	dc.w 553,400,399,  1998,1999,2000,  0,0
	dc.w 222,555,544,  2001,2002,2003,  0,0
	dc.w 553,399,555,  2004,2005,2006,  0,0
	dc.w 548,361,223,  2007,2008,2009,  0,0
	dc.w 401,361,548,  2010,2011,2012,  0,0
	dc.w 362,226,401,  2013,2014,2015,  0,0
	dc.w 226,556,401,  2016,2017,2018,  0,0
	dc.w 401,556,361,  2019,2020,2021,  0,0
	dc.w 401,558,557,  2022,2023,2024,  0,0
	dc.w 557,362,401,  2025,2026,2027,  0,0
	dc.w 401,548,394,  2028,2029,2030,  0,0
	dc.w 401,394,558,  2031,2032,2033,  0,0
	dc.w 558,394,396,  2034,2035,2036,  0,0
	dc.w 559,557,558,  2037,2038,2039,  0,0
	dc.w 227,402,560,  2040,2041,2042,  0,0
	dc.w 561,402,227,  2043,2044,2045,  0,0
	dc.w 402,562,560,  2046,2047,2048,  0,0
	dc.w 559,558,402,  2049,2050,2051,  0,0
	dc.w 559,402,561,  2052,2053,2054,  0,0
	dc.w 403,224,562,  2055,2056,2057,  0,0
	dc.w 558,396,403,  2058,2059,2060,  0,0
	dc.w 558,403,402,  2061,2062,2063,  0,0
	dc.w 402,403,562,  2064,2065,2066,  0,0
	dc.w 404,363,563,  2067,2068,2069,  0,0
	dc.w 231,404,563,  2070,2071,2072,  0,0
	dc.w 231,563,564,  2073,2074,2075,  0,0
	dc.w 261,229,566,  2076,2077,2078,  0,0
	dc.w 566,229,404,  2079,2080,2081,  0,0
	dc.w 261,565,229,  2082,2083,2084,  0,0
	dc.w 364,232,261,  2085,2086,2087,  0,0
	dc.w 232,565,261,  2088,2089,2090,  0,0
	dc.w 231,566,404,  2091,2092,2093,  0,0
	dc.w 364,261,566,  2094,2095,2096,  0,0
	dc.w 262,230,565,  2097,2098,2099,  0,0
	dc.w 232,405,262,  2100,2101,2102,  0,0
	dc.w 232,262,565,  2103,2104,2105,  0,0
	dc.w 231,564,406,  2106,2107,2108,  0,0
	dc.w 568,406,567,  2109,2110,2111,  0,0
	dc.w 406,564,567,  2112,2113,2114,  0,0
	dc.w 234,569,233,  2115,2116,2117,  0,0
	dc.w 569,407,233,  2118,2119,2120,  0,0
	dc.w 568,567,569,  2121,2122,2123,  0,0
	dc.w 569,567,407,  2124,2125,2126,  0,0
	dc.w 263,408,570,  2127,2128,2129,  0,0
	dc.w 408,352,571,  2130,2131,2132,  0,0
	dc.w 263,352,408,  2133,2134,2135,  0,0
	dc.w 352,263,390,  2136,2137,2138,  0,0
	dc.w 263,570,390,  2139,2140,2141,  0,0
	dc.w 232,572,405,  2142,2143,2144,  0,0
	dc.w 365,264,572,  2145,2146,2147,  0,0
	dc.w 572,264,405,  2148,2149,2150,  0,0
	dc.w 409,573,264,  2151,2152,2153,  0,0
	dc.w 235,573,409,  2154,2155,2156,  0,0
	dc.w 365,409,264,  2157,2158,2159,  0,0
	dc.w 234,233,366,  2160,2161,2162,  0,0
	dc.w 234,366,237,  2163,2164,2165,  0,0
	dc.w 366,236,237,  2166,2167,2168,  0,0
	dc.w 367,234,410,  2169,2170,2171,  0,0
	dc.w 234,237,410,  2172,2173,2174,  0,0
	dc.w 235,574,575,  2175,2176,2177,  0,0
	dc.w 367,410,574,  2178,2179,2180,  0,0
	dc.w 410,368,574,  2181,2182,2183,  0,0
	dc.w 574,368,575,  2184,2185,2186,  0,0
	dc.w 410,237,368,  2187,2188,2189,  0,0
	dc.w 235,575,265,  2190,2191,2192,  0,0
	dc.w 235,265,573,  2193,2194,2195,  0,0
	dc.w 265,575,238,  2196,2197,2198,  0,0
	dc.w 577,579,576,  2199,2200,2201,  0,0
	dc.w 578,369,411,  2202,2203,2204,  0,0
	dc.w 579,411,576,  2205,2206,2207,  0,0
	dc.w 579,578,411,  2208,2209,2210,  0,0
	dc.w 239,579,577,  2211,2212,2213,  0,0
	dc.w 412,266,580,  2214,2215,2216,  0,0
	dc.w 416,414,413,  2217,2218,2219,  0,0
	dc.w 413,581,266,  2220,2221,2222,  0,0
	dc.w 418,266,417,  2223,2224,2225,  0,0
	dc.w 418,413,266,  2226,2227,2228,  0,0
	dc.w 418,416,413,  2229,2230,2231,  0,0
	dc.w 417,412,369,  2232,2233,2234,  0,0
	dc.w 578,417,369,  2235,2236,2237,  0,0
	dc.w 417,266,412,  2238,2239,2240,  0,0
	dc.w 583,415,414,  2241,2242,2243,  0,0
	dc.w 416,583,414,  2244,2245,2246,  0,0
	dc.w 370,415,583,  2247,2248,2249,  0,0
	dc.w 370,582,415,  2250,2251,2252,  0,0
	dc.w 420,585,583,  2253,2254,2255,  0,0
	dc.w 420,583,416,  2256,2257,2258,  0,0
	dc.w 420,416,418,  2259,2260,2261,  0,0
	dc.w 371,579,239,  2262,2263,2264,  0,0
	dc.w 584,578,579,  2265,2266,2267,  0,0
	dc.w 584,244,578,  2268,2269,2270,  0,0
	dc.w 243,584,371,  2271,2272,2273,  0,0
	dc.w 584,579,371,  2274,2275,2276,  0,0
	dc.w 244,417,578,  2277,2278,2279,  0,0
	dc.w 419,418,417,  2280,2281,2282,  0,0
	dc.w 419,417,244,  2283,2284,2285,  0,0
	dc.w 421,585,420,  2286,2287,2288,  0,0
	dc.w 586,421,420,  2289,2290,2291,  0,0
	dc.w 586,420,418,  2292,2293,2294,  0,0
	dc.w 419,586,418,  2295,2296,2297,  0,0
	dc.w 267,584,243,  2298,2299,2300,  0,0
	dc.w 372,244,584,  2301,2302,2303,  0,0
	dc.w 267,372,584,  2304,2305,2306,  0,0
	dc.w 587,372,267,  2307,2308,2309,  0,0
	dc.w 422,243,588,  2310,2311,2312,  0,0
	dc.w 422,267,243,  2313,2314,2315,  0,0
	dc.w 372,419,244,  2316,2317,2318,  0,0
	dc.w 589,419,372,  2319,2320,2321,  0,0
	dc.w 587,589,372,  2322,2323,2324,  0,0
	dc.w 587,590,589,  2325,2326,2327,  0,0
	dc.w 423,586,419,  2328,2329,2330,  0,0
	dc.w 423,419,589,  2331,2332,2333,  0,0
	dc.w 424,421,586,  2334,2335,2336,  0,0
	dc.w 423,424,586,  2337,2338,2339,  0,0
	dc.w 425,424,423,  2340,2341,2342,  0,0
	dc.w 590,425,423,  2343,2344,2345,  0,0
	dc.w 425,297,424,  2346,2347,2348,  0,0
	dc.w 590,423,589,  2349,2350,2351,  0,0
	dc.w 374,426,299,  2352,2353,2354,  0,0
	dc.w 298,426,374,  2355,2356,2357,  0,0
	dc.w 373,300,298,  2358,2359,2360,  0,0
	dc.w 301,374,240,  2361,2362,2363,  0,0
	dc.w 374,373,298,  2364,2365,2366,  0,0
	dc.w 301,373,374,  2367,2368,2369,  0,0
	dc.w 428,304,427,  2370,2371,2372,  0,0
	dc.w 427,304,302,  2373,2374,2375,  0,0
	dc.w 429,428,427,  2376,2377,2378,  0,0
	dc.w 373,427,300,  2379,2380,2381,  0,0
	dc.w 429,427,373,  2382,2383,2384,  0,0
	dc.w 303,228,428,  2385,2386,2387,  0,0
	dc.w 428,228,304,  2388,2389,2390,  0,0
	dc.w 305,303,428,  2391,2392,2393,  0,0
	dc.w 305,428,429,  2394,2395,2396,  0,0
	dc.w 312,305,432,  2397,2398,2399,  0,0
	dc.w 432,305,429,  2400,2401,2402,  0,0
	dc.w 432,429,301,  2403,2404,2405,  0,0
	dc.w 301,429,373,  2406,2407,2408,  0,0
	dc.w 307,308,306,  2409,2410,2411,  0,0
	dc.w 309,240,308,  2412,2413,2414,  0,0
	dc.w 307,430,308,  2415,2416,2417,  0,0
	dc.w 430,309,308,  2418,2419,2420,  0,0
	dc.w 268,301,240,  2421,2422,2423,  0,0
	dc.w 309,268,240,  2424,2425,2426,  0,0
	dc.w 311,301,268,  2427,2428,2429,  0,0
	dc.w 431,311,268,  2430,2431,2432,  0,0
	dc.w 434,309,430,  2433,2434,2435,  0,0
	dc.w 431,268,309,  2436,2437,2438,  0,0
	dc.w 434,431,309,  2439,2440,2441,  0,0
	dc.w 311,269,432,  2442,2443,2444,  0,0
	dc.w 311,432,301,  2445,2446,2447,  0,0
	dc.w 269,312,432,  2448,2449,2450,  0,0
	dc.w 314,312,269,  2451,2452,2453,  0,0
	dc.w 437,314,313,  2454,2455,2456,  0,0
	dc.w 313,314,269,  2457,2458,2459,  0,0
	dc.w 431,313,311,  2460,2461,2462,  0,0
	dc.w 313,269,311,  2463,2464,2465,  0,0
	dc.w 270,307,310,  2466,2467,2468,  0,0
	dc.w 270,310,315,  2469,2470,2471,  0,0
	dc.w 270,430,307,  2472,2473,2474,  0,0
	dc.w 316,270,433,  2475,2476,2477,  0,0
	dc.w 433,270,315,  2478,2479,2480,  0,0
	dc.w 270,434,430,  2481,2482,2483,  0,0
	dc.w 317,434,270,  2484,2485,2486,  0,0
	dc.w 317,318,434,  2487,2488,2489,  0,0
	dc.w 318,431,434,  2490,2491,2492,  0,0
	dc.w 435,318,317,  2493,2494,2495,  0,0
	dc.w 317,270,316,  2496,2497,2498,  0,0
	dc.w 436,313,431,  2499,2500,2501,  0,0
	dc.w 436,431,318,  2502,2503,2504,  0,0
	dc.w 436,437,313,  2505,2506,2507,  0,0
	dc.w 438,437,436,  2508,2509,2510,  0,0
	dc.w 439,438,436,  2511,2512,2513,  0,0
	dc.w 438,238,437,  2514,2515,2516,  0,0
	dc.w 439,436,318,  2517,2518,2519,  0,0
	dc.w 435,439,318,  2520,2521,2522,  0,0
	dc.w 319,442,440,  2523,2524,2525,  0,0
	dc.w 442,322,441,  2526,2527,2528,  0,0
	dc.w 322,320,441,  2529,2530,2531,  0,0
	dc.w 442,441,440,  2532,2533,2534,  0,0
	dc.w 441,321,375,  2535,2536,2537,  0,0
	dc.w 440,441,375,  2538,2539,2540,  0,0
	dc.w 323,241,442,  2541,2542,2543,  0,0
	dc.w 241,322,442,  2544,2545,2546,  0,0
	dc.w 443,442,319,  2547,2548,2549,  0,0
	dc.w 323,442,443,  2550,2551,2552,  0,0
	dc.w 322,324,320,  2553,2554,2555,  0,0
	dc.w 445,324,322,  2556,2557,2558,  0,0
	dc.w 444,326,325,  2559,2560,2561,  0,0
	dc.w 445,325,324,  2562,2563,2564,  0,0
	dc.w 444,325,445,  2565,2566,2567,  0,0
	dc.w 97,326,444,  2568,2569,2570,  0,0
	dc.w 95,444,445,  2571,2572,2573,  0,0
	dc.w 241,445,322,  2574,2575,2576,  0,0
	dc.w 241,527,445,  2577,2578,2579,  0,0
	dc.w 527,95,445,  2580,2581,2582,  0,0
	dc.w 447,328,446,  2583,2584,2585,  0,0
	dc.w 328,327,446,  2586,2587,2588,  0,0
	dc.w 447,446,326,  2589,2590,2591,  0,0
	dc.w 448,242,447,  2592,2593,2594,  0,0
	dc.w 242,328,447,  2595,2596,2597,  0,0
	dc.w 97,448,326,  2598,2599,2600,  0,0
	dc.w 448,447,326,  2601,2602,2603,  0,0
	dc.w 329,330,323,  2604,2605,2606,  0,0
	dc.w 449,241,323,  2607,2608,2609,  0,0
	dc.w 330,449,323,  2610,2611,2612,  0,0
	dc.w 245,330,329,  2613,2614,2615,  0,0
	dc.w 331,448,97,  2616,2617,2618,  0,0
	dc.w 331,450,448,  2619,2620,2621,  0,0
	dc.w 450,242,448,  2622,2623,2624,  0,0
	dc.w 451,450,331,  2625,2626,2627,  0,0
	dc.w 247,450,451,  2628,2629,2630,  0,0
	dc.w 451,452,246,  2631,2632,2633,  0,0
	dc.w 452,451,331,  2634,2635,2636,  0,0
	dc.w 332,245,453,  2637,2638,2639,  0,0
	dc.w 453,245,329,  2640,2641,2642,  0,0
	dc.w 332,454,245,  2643,2644,2645,  0,0
	dc.w 271,454,455,  2646,2647,2648,  0,0
	dc.w 271,358,454,  2649,2650,2651,  0,0
	dc.w 455,454,332,  2652,2653,2654,  0,0
	dc.w 271,333,246,  2655,2656,2657,  0,0
	dc.w 271,246,358,  2658,2659,2660,  0,0
	dc.w 368,271,455,  2661,2662,2663,  0,0
	dc.w 456,451,246,  2664,2665,2666,  0,0
	dc.w 333,456,246,  2667,2668,2669,  0,0
	dc.w 376,247,451,  2670,2671,2672,  0,0
	dc.w 456,376,451,  2673,2674,2675,  0,0
	dc.w 456,334,376,  2676,2677,2678,  0,0
	dc.w 335,457,377,  2679,2680,2681,  0,0
	dc.w 336,337,335,  2682,2683,2684,  0,0
	dc.w 378,336,460,  2685,2686,2687,  0,0
	dc.w 458,335,377,  2688,2689,2690,  0,0
	dc.w 458,336,335,  2691,2692,2693,  0,0
	dc.w 460,336,458,  2694,2695,2696,  0,0
	dc.w 336,272,337,  2697,2698,2699,  0,0
	dc.w 272,459,337,  2700,2701,2702,  0,0
	dc.w 272,338,459,  2703,2704,2705,  0,0
	dc.w 378,272,336,  2706,2707,2708,  0,0
	dc.w 273,42,44,  2709,2710,2711,  0,0
	dc.w 273,43,42,  2712,2713,2714,  0,0
	dc.w 46,460,45,  2715,2716,2717,  0,0
	dc.w 273,46,45,  2718,2719,2720,  0,0
	dc.w 273,45,43,  2721,2722,2723,  0,0
	dc.w 50,46,273,  2724,2725,2726,  0,0
	dc.w 46,274,460,  2727,2728,2729,  0,0
	dc.w 274,378,460,  2730,2731,2732,  0,0
	dc.w 50,274,46,  2733,2734,2735,  0,0
	dc.w 461,272,378,  2736,2737,2738,  0,0
	dc.w 47,338,272,  2739,2740,2741,  0,0
	dc.w 461,47,272,  2742,2743,2744,  0,0
	dc.w 48,47,461,  2745,2746,2747,  0,0
	dc.w 463,461,274,  2748,2749,2750,  0,0
	dc.w 274,461,378,  2751,2752,2753,  0,0
	dc.w 463,48,461,  2754,2755,2756,  0,0
	dc.w 275,273,44,  2757,2758,2759,  0,0
	dc.w 275,44,49,  2760,2761,2762,  0,0
	dc.w 275,50,273,  2763,2764,2765,  0,0
	dc.w 52,50,275,  2766,2767,2768,  0,0
	dc.w 51,52,275,  2769,2770,2771,  0,0
	dc.w 51,275,462,  2772,2773,2774,  0,0
	dc.w 462,275,49,  2775,2776,2777,  0,0
	dc.w 52,53,50,  2778,2779,2780,  0,0
	dc.w 54,274,50,  2781,2782,2783,  0,0
	dc.w 53,54,50,  2784,2785,2786,  0,0
	dc.w 55,54,53,  2787,2788,2789,  0,0
	dc.w 55,56,54,  2790,2791,2792,  0,0
	dc.w 55,53,52,  2793,2794,2795,  0,0
	dc.w 54,463,274,  2796,2797,2798,  0,0
	dc.w 463,57,48,  2799,2800,2801,  0,0
	dc.w 464,57,463,  2802,2803,2804,  0,0
	dc.w 56,464,463,  2805,2806,2807,  0,0
	dc.w 56,463,54,  2808,2809,2810,  0,0
	dc.w 465,566,231,  2811,2812,2813,  0,0
	dc.w 465,231,58,  2814,2815,2816,  0,0
	dc.w 276,364,465,  2817,2818,2819,  0,0
	dc.w 465,364,566,  2820,2821,2822,  0,0
	dc.w 466,60,232,  2823,2824,2825,  0,0
	dc.w 466,232,364,  2826,2827,2828,  0,0
	dc.w 276,466,364,  2829,2830,2831,  0,0
	dc.w 59,249,466,  2832,2833,2834,  0,0
	dc.w 249,60,466,  2835,2836,2837,  0,0
	dc.w 280,466,276,  2838,2839,2840,  0,0
	dc.w 59,466,280,  2841,2842,2843,  0,0
	dc.w 248,465,58,  2844,2845,2846,  0,0
	dc.w 473,465,248,  2847,2848,2849,  0,0
	dc.w 473,280,465,  2850,2851,2852,  0,0
	dc.w 280,276,465,  2853,2854,2855,  0,0
	dc.w 467,569,234,  2856,2857,2858,  0,0
	dc.w 467,234,61,  2859,2860,2861,  0,0
	dc.w 277,568,467,  2862,2863,2864,  0,0
	dc.w 467,568,569,  2865,2866,2867,  0,0
	dc.w 468,58,231,  2868,2869,2870,  0,0
	dc.w 468,231,406,  2871,2872,2873,  0,0
	dc.w 468,406,568,  2874,2875,2876,  0,0
	dc.w 277,468,568,  2877,2878,2879,  0,0
	dc.w 62,248,468,  2880,2881,2882,  0,0
	dc.w 248,58,468,  2883,2884,2885,  0,0
	dc.w 283,468,277,  2886,2887,2888,  0,0
	dc.w 62,468,283,  2889,2890,2891,  0,0
	dc.w 250,467,61,  2892,2893,2894,  0,0
	dc.w 476,467,250,  2895,2896,2897,  0,0
	dc.w 476,283,467,  2898,2899,2900,  0,0
	dc.w 283,277,467,  2901,2902,2903,  0,0
	dc.w 469,572,232,  2904,2905,2906,  0,0
	dc.w 469,232,60,  2907,2908,2909,  0,0
	dc.w 278,365,469,  2910,2911,2912,  0,0
	dc.w 469,365,572,  2913,2914,2915,  0,0
	dc.w 470,64,235,  2916,2917,2918,  0,0
	dc.w 470,235,409,  2919,2920,2921,  0,0
	dc.w 470,409,365,  2922,2923,2924,  0,0
	dc.w 278,470,365,  2925,2926,2927,  0,0
	dc.w 63,251,470,  2928,2929,2930,  0,0
	dc.w 251,64,470,  2931,2932,2933,  0,0
	dc.w 281,470,278,  2934,2935,2936,  0,0
	dc.w 63,470,281,  2937,2938,2939,  0,0
	dc.w 249,469,60,  2940,2941,2942,  0,0
	dc.w 474,469,249,  2943,2944,2945,  0,0
	dc.w 474,281,469,  2946,2947,2948,  0,0
	dc.w 281,278,469,  2949,2950,2951,  0,0
	dc.w 471,574,235,  2952,2953,2954,  0,0
	dc.w 471,235,64,  2955,2956,2957,  0,0
	dc.w 279,367,471,  2958,2959,2960,  0,0
	dc.w 471,367,574,  2961,2962,2963,  0,0
	dc.w 472,61,234,  2964,2965,2966,  0,0
	dc.w 472,234,367,  2967,2968,2969,  0,0
	dc.w 279,472,367,  2970,2971,2972,  0,0
	dc.w 65,250,472,  2973,2974,2975,  0,0
	dc.w 250,61,472,  2976,2977,2978,  0,0
	dc.w 282,472,279,  2979,2980,2981,  0,0
	dc.w 65,472,282,  2982,2983,2984,  0,0
	dc.w 251,471,64,  2985,2986,2987,  0,0
	dc.w 475,471,251,  2988,2989,2990,  0,0
	dc.w 475,282,471,  2991,2992,2993,  0,0
	dc.w 282,279,471,  2994,2995,2996,  0,0
	dc.w 481,473,248,  2997,2998,2999,  0,0
	dc.w 66,481,248,  3000,3001,3002,  0,0
	dc.w 284,280,481,  3003,3004,3005,  0,0
	dc.w 481,280,473,  3006,3007,3008,  0,0
	dc.w 67,249,477,  3009,3010,3011,  0,0
	dc.w 477,249,59,  3012,3013,3014,  0,0
	dc.w 477,59,280,  3015,3016,3017,  0,0
	dc.w 284,477,280,  3018,3019,3020,  0,0
	dc.w 483,474,249,  3021,3022,3023,  0,0
	dc.w 67,483,249,  3024,3025,3026,  0,0
	dc.w 285,281,483,  3027,3028,3029,  0,0
	dc.w 483,281,474,  3030,3031,3032,  0,0
	dc.w 68,251,478,  3033,3034,3035,  0,0
	dc.w 478,251,63,  3036,3037,3038,  0,0
	dc.w 478,63,281,  3039,3040,3041,  0,0
	dc.w 285,478,281,  3042,3043,3044,  0,0
	dc.w 485,475,251,  3045,3046,3047,  0,0
	dc.w 68,485,251,  3048,3049,3050,  0,0
	dc.w 286,282,485,  3051,3052,3053,  0,0
	dc.w 485,282,475,  3054,3055,3056,  0,0
	dc.w 69,250,479,  3057,3058,3059,  0,0
	dc.w 479,250,65,  3060,3061,3062,  0,0
	dc.w 479,65,282,  3063,3064,3065,  0,0
	dc.w 286,479,282,  3066,3067,3068,  0,0
	dc.w 487,476,250,  3069,3070,3071,  0,0
	dc.w 69,487,250,  3072,3073,3074,  0,0
	dc.w 287,283,487,  3075,3076,3077,  0,0
	dc.w 487,283,476,  3078,3079,3080,  0,0
	dc.w 66,248,480,  3081,3082,3083,  0,0
	dc.w 480,248,62,  3084,3085,3086,  0,0
	dc.w 480,62,283,  3087,3088,3089,  0,0
	dc.w 287,480,283,  3090,3091,3092,  0,0
	dc.w 289,481,489,  3093,3094,3095,  0,0
	dc.w 289,284,481,  3096,3097,3098,  0,0
	dc.w 379,481,66,  3099,3100,3101,  0,0
	dc.w 489,481,379,  3102,3103,3104,  0,0
	dc.w 380,477,482,  3105,3106,3107,  0,0
	dc.w 380,67,477,  3108,3109,3110,  0,0
	dc.w 289,477,284,  3111,3112,3113,  0,0
	dc.w 482,477,289,  3114,3115,3116,  0,0
	dc.w 490,290,483,  3117,3118,3119,  0,0
	dc.w 290,285,483,  3120,3121,3122,  0,0
	dc.w 380,483,67,  3123,3124,3125,  0,0
	dc.w 490,483,380,  3126,3127,3128,  0,0
	dc.w 484,381,478,  3129,3130,3131,  0,0
	dc.w 381,68,478,  3132,3133,3134,  0,0
	dc.w 290,478,285,  3135,3136,3137,  0,0
	dc.w 290,484,478,  3138,3139,3140,  0,0
	dc.w 492,288,485,  3141,3142,3143,  0,0
	dc.w 288,286,485,  3144,3145,3146,  0,0
	dc.w 381,485,68,  3147,3148,3149,  0,0
	dc.w 492,485,381,  3150,3151,3152,  0,0
	dc.w 486,382,479,  3153,3154,3155,  0,0
	dc.w 382,69,479,  3156,3157,3158,  0,0
	dc.w 288,479,286,  3159,3160,3161,  0,0
	dc.w 486,479,288,  3162,3163,3164,  0,0
	dc.w 291,487,493,  3165,3166,3167,  0,0
	dc.w 291,287,487,  3168,3169,3170,  0,0
	dc.w 382,487,69,  3171,3172,3173,  0,0
	dc.w 493,487,382,  3174,3175,3176,  0,0
	dc.w 488,379,480,  3177,3178,3179,  0,0
	dc.w 379,66,480,  3180,3181,3182,  0,0
	dc.w 291,480,287,  3183,3184,3185,  0,0
	dc.w 488,480,291,  3186,3187,3188,  0,0
	dc.w 384,482,70,  3189,3190,3191,  0,0
	dc.w 495,482,289,  3192,3193,3194,  0,0
	dc.w 495,70,482,  3195,3196,3197,  0,0
	dc.w 384,380,482,  3198,3199,3200,  0,0
	dc.w 494,489,379,  3201,3202,3203,  0,0
	dc.w 495,489,494,  3204,3205,3206,  0,0
	dc.w 495,289,489,  3207,3208,3209,  0,0
	dc.w 491,484,290,  3210,3211,3212,  0,0
	dc.w 491,290,292,  3213,3214,3215,  0,0
	dc.w 491,253,381,  3216,3217,3218,  0,0
	dc.w 491,381,484,  3219,3220,3221,  0,0
	dc.w 496,490,380,  3222,3223,3224,  0,0
	dc.w 384,496,380,  3225,3226,3227,  0,0
	dc.w 496,292,290,  3228,3229,3230,  0,0
	dc.w 496,290,490,  3231,3232,3233,  0,0
	dc.w 293,486,288,  3234,3235,3236,  0,0
	dc.w 383,382,293,  3237,3238,3239,  0,0
	dc.w 293,382,486,  3240,3241,3242,  0,0
	dc.w 497,492,381,  3243,3244,3245,  0,0
	dc.w 497,381,253,  3246,3247,3248,  0,0
	dc.w 293,288,497,  3249,3250,3251,  0,0
	dc.w 497,288,492,  3252,3253,3254,  0,0
	dc.w 494,488,291,  3255,3256,3257,  0,0
	dc.w 498,494,291,  3258,3259,3260,  0,0
	dc.w 494,379,488,  3261,3262,3263,  0,0
	dc.w 498,493,382,  3264,3265,3266,  0,0
	dc.w 383,498,382,  3267,3268,3269,  0,0
	dc.w 498,291,493,  3270,3271,3272,  0,0
	dc.w 499,70,495,  3273,3274,3275,  0,0
	dc.w 252,495,494,  3276,3277,3278,  0,0
	dc.w 499,495,252,  3279,3280,3281,  0,0
	dc.w 500,293,497,  3282,3283,3284,  0,0
	dc.w 500,497,253,  3285,3286,3287,  0,0
	dc.w 385,383,294,  3288,3289,3290,  0,0
	dc.w 294,383,293,  3291,3292,3293,  0,0
	dc.w 294,293,500,  3294,3295,3296,  0,0
	dc.w 502,498,383,  3297,3298,3299,  0,0
	dc.w 295,494,498,  3300,3301,3302,  0,0
	dc.w 252,494,295,  3303,3304,3305,  0,0
	dc.w 385,502,383,  3306,3307,3308,  0,0
	dc.w 295,498,502,  3309,3310,3311,  0,0
	dc.w 296,73,70,  3312,3313,3314,  0,0
	dc.w 296,70,499,  3315,3316,3317,  0,0
	dc.w 73,384,70,  3318,3319,3320,  0,0
	dc.w 71,499,252,  3321,3322,3323,  0,0
	dc.w 71,296,499,  3324,3325,3326,  0,0
	dc.w 339,292,496,  3327,3328,3329,  0,0
	dc.w 75,253,491,  3330,3331,3332,  0,0
	dc.w 339,75,491,  3333,3334,3335,  0,0
	dc.w 339,491,292,  3336,3337,3338,  0,0
	dc.w 73,496,384,  3339,3340,3341,  0,0
	dc.w 73,339,496,  3342,3343,3344,  0,0
	dc.w 75,500,253,  3345,3346,3347,  0,0
	dc.w 503,501,294,  3348,3349,3350,  0,0
	dc.w 501,385,294,  3351,3352,3353,  0,0
	dc.w 75,503,500,  3354,3355,3356,  0,0
	dc.w 503,294,500,  3357,3358,3359,  0,0
	dc.w 77,252,295,  3360,3361,3362,  0,0
	dc.w 77,295,72,  3363,3364,3365,  0,0
	dc.w 501,72,502,  3366,3367,3368,  0,0
	dc.w 501,502,385,  3369,3370,3371,  0,0
	dc.w 72,295,502,  3372,3373,3374,  0,0
	dc.w 77,71,252,  3375,3376,3377,  0,0
	dc.w 505,73,296,  3378,3379,3380,  0,0
	dc.w 74,296,71,  3381,3382,3383,  0,0
	dc.w 78,339,73,  3384,3385,3386,  0,0
	dc.w 506,503,75,  3387,3388,3389,  0,0
	dc.w 506,504,503,  3390,3391,3392,  0,0
	dc.w 504,501,503,  3393,3394,3395,  0,0
	dc.w 508,72,501,  3396,3397,3398,  0,0
	dc.w 77,72,508,  3399,3400,3401,  0,0
	dc.w 504,508,501,  3402,3403,3404,  0,0
	dc.w 74,505,296,  3405,3406,3407,  0,0
	dc.w 505,79,73,  3408,3409,3410,  0,0
	dc.w 78,73,79,  3411,3412,3413,  0,0
	dc.w 78,75,339,  3414,3415,3416,  0,0
	dc.w 76,75,78,  3417,3418,3419,  0,0
	dc.w 76,506,75,  3420,3421,3422,  0,0
	dc.w 76,504,506,  3423,3424,3425,  0,0
	dc.w 507,504,76,  3426,3427,3428,  0,0
	dc.w 74,71,77,  3429,3430,3431,  0,0
	dc.w 340,74,77,  3432,3433,3434,  0,0
	dc.w 507,508,504,  3435,3436,3437,  0,0
	dc.w 507,77,508,  3438,3439,3440,  0,0
	dc.w 510,505,74,  3441,3442,3443,  0,0
	dc.w 509,505,510,  3444,3445,3446,  0,0
	dc.w 80,76,78,  3447,3448,3449,  0,0
	dc.w 509,79,505,  3450,3451,3452,  0,0
	dc.w 340,77,507,  3453,3454,3455,  0,0
	dc.w 342,510,74,  3456,3457,3458,  0,0
	dc.w 343,78,79,  3459,3460,3461,  0,0
	dc.w 343,80,78,  3462,3463,3464,  0,0
	dc.w 341,76,80,  3465,3466,3467,  0,0
	dc.w 341,507,76,  3468,3469,3470,  0,0
	dc.w 342,74,340,  3471,3472,3473,  0,0
	dc.w 254,340,507,  3474,3475,3476,  0,0
	dc.w 511,386,509,  3477,3478,3479,  0,0
	dc.w 387,511,510,  3480,3481,3482,  0,0
	dc.w 511,509,510,  3483,3484,3485,  0,0
	dc.w 387,510,342,  3486,3487,3488,  0,0
	dc.w 386,79,509,  3489,3490,3491,  0,0
	dc.w 386,343,79,  3492,3493,3494,  0,0
	dc.w 512,80,343,  3495,3496,3497,  0,0
	dc.w 341,254,507,  3498,3499,3500,  0,0
	dc.w 254,342,340,  3501,3502,3503,  0,0
	dc.w 255,386,511,  3504,3505,3506,  0,0
	dc.w 255,512,343,  3507,3508,3509,  0,0
	dc.w 255,343,386,  3510,3511,3512,  0,0
	dc.w 512,341,80,  3513,3514,3515,  0,0
	dc.w 256,254,341,  3516,3517,3518,  0,0
	dc.w 345,256,341,  3519,3520,3521,  0,0
	dc.w 345,341,512,  3522,3523,3524,  0,0
	dc.w 346,342,256,  3525,3526,3527,  0,0
	dc.w 256,342,254,  3528,3529,3530,  0,0
	dc.w 387,342,346,  3531,3532,3533,  0,0
	dc.w 81,344,387,  3534,3535,3536,  0,0
	dc.w 344,255,511,  3537,3538,3539,  0,0
	dc.w 344,511,387,  3540,3541,3542,  0,0
	dc.w 513,512,255,  3543,3544,3545,  0,0
	dc.w 82,345,512,  3546,3547,3548,  0,0
	dc.w 513,82,512,  3549,3550,3551,  0,0
	dc.w 257,256,345,  3552,3553,3554,  0,0
	dc.w 82,257,345,  3555,3556,3557,  0,0
	dc.w 257,346,256,  3558,3559,3560,  0,0
	dc.w 81,387,346,  3561,3562,3563,  0,0
	dc.w 347,344,81,  3564,3565,3566,  0,0
	dc.w 388,344,347,  3567,3568,3569,  0,0
	dc.w 349,388,347,  3570,3571,3572,  0,0
	dc.w 83,347,81,  3573,3574,3575,  0,0
	dc.w 388,255,344,  3576,3577,3578,  0,0
	dc.w 348,255,388,  3579,3580,3581,  0,0
	dc.w 348,513,255,  3582,3583,3584,  0,0
	dc.w 349,348,388,  3585,3586,3587,  0,0
	dc.w 514,82,513,  3588,3589,3590,  0,0
	dc.w 348,514,513,  3591,3592,3593,  0,0
	dc.w 515,257,82,  3594,3595,3596,  0,0
	dc.w 514,515,82,  3597,3598,3599,  0,0
	dc.w 84,257,515,  3600,3601,3602,  0,0
	dc.w 84,346,257,  3603,3604,3605,  0,0
	dc.w 84,81,346,  3606,3607,3608,  0,0
	dc.w 83,84,85,  3609,3610,3611,  0,0
	dc.w 83,81,84,  3612,3613,3614,  0,0
	dc.w 349,347,83,  3615,3616,3617,  0,0
	dc.w 258,349,350,  3618,3619,3620,  0,0
	dc.w 350,349,83,  3621,3622,3623,  0,0
	dc.w 351,350,83,  3624,3625,3626,  0,0
	dc.w 258,348,349,  3627,3628,3629,  0,0
	dc.w 517,348,258,  3630,3631,3632,  0,0
	dc.w 516,514,348,  3633,3634,3635,  0,0
	dc.w 517,516,348,  3636,3637,3638,  0,0
	dc.w 516,389,515,  3639,3640,3641,  0,0
	dc.w 516,515,514,  3642,3643,3644,  0,0
	dc.w 517,389,516,  3645,3646,3647,  0,0
	dc.w 389,84,515,  3648,3649,3650,  0,0
	dc.w 389,85,84,  3651,3652,3653,  0,0
	dc.w 351,83,85,  3654,3655,3656,  0,0
	dc.w 353,350,351,  3657,3658,3659,  0,0
	dc.w 390,391,389,  3660,3661,3662,  0,0
	dc.w 390,389,517,  3663,3664,3665,  0,0
	dc.w 391,85,389,  3666,3667,3668,  0,0
	dc.w 391,351,85,  3669,3670,3671,  0,0
	dc.w 353,351,391,  3672,3673,3674,  0,0
	dc.w 571,350,353,  3675,3676,3677,  0,0
	dc.w 571,258,350,  3678,3679,3680,  0,0
	dc.w 408,571,353,  3681,3682,3683,  0,0
	dc.w 352,258,571,  3684,3685,3686,  0,0
	dc.w 390,517,352,  3687,3688,3689,  0,0
	dc.w 352,517,258,  3690,3691,3692,  0,0
	dc.w 570,391,390,  3693,3694,3695,  0,0
	dc.w 570,408,353,  3696,3697,3698,  0,0
	dc.w 570,353,391,  3699,3700,3701,  0,0
	dc.w 540,518,541,  3702,3703,3704,  0,0
	dc.w 540,86,518,  3705,3706,3707,  0,0
	dc.w 221,519,89,  3708,3709,3710,  0,0
	dc.w 539,519,221,  3711,3712,3713,  0,0
	dc.w 541,519,539,  3714,3715,3716,  0,0
	dc.w 541,518,519,  3717,3718,3719,  0,0
	dc.w 221,89,87,  3720,3721,3722,  0,0
	dc.w 87,89,354,  3723,3724,3725,  0,0
	dc.w 87,354,259,  3726,3727,3728,  0,0
	dc.w 88,87,259,  3729,3730,3731,  0,0
	dc.w 520,259,355,  3732,3733,3734,  0,0
	dc.w 520,88,259,  3735,3736,3737,  0,0
	dc.w 542,520,355,  3738,3739,3740,  0,0
	dc.w 219,542,521,  3741,3742,3743,  0,0
	dc.w 266,521,356,  3744,3745,3746,  0,0
	dc.w 540,522,86,  3747,3748,3749,  0,0
	dc.w 266,356,522,  3750,3751,3752,  0,0
	dc.w 377,524,525,  3753,3754,3755,  0,0
	dc.w 377,457,524,  3756,3757,3758,  0,0
	dc.w 460,525,94,  3759,3760,3761,  0,0
	dc.w 460,458,525,  3762,3763,3764,  0,0
	dc.w 458,377,525,  3765,3766,3767,  0,0
	dc.w 45,460,94,  3768,3769,3770,  0,0
	dc.w 45,94,43,  3771,3772,3773,  0,0
	dc.w 42,43,526,  3774,3775,3776,  0,0
	dc.w 96,527,241,  3777,3778,3779,  0,0
	dc.w 527,529,95,  3780,3781,3782,  0,0
	dc.w 96,529,527,  3783,3784,3785,  0,0
	dc.w 528,97,444,  3786,3787,3788,  0,0
	dc.w 444,95,529,  3789,3790,3791,  0,0
	dc.w 528,444,529,  3792,3793,3794,  0,0
	dc.w 245,533,330,  3795,3796,3797,  0,0
	dc.w 533,357,330,  3798,3799,3800,  0,0
	dc.w 530,96,241,  3801,3802,3803,  0,0
	dc.w 449,530,241,  3804,3805,3806,  0,0
	dc.w 330,530,449,  3807,3808,3809,  0,0
	dc.w 330,357,530,  3810,3811,3812,  0,0
	dc.w 531,331,97,  3813,3814,3815,  0,0
	dc.w 531,97,528,  3816,3817,3818,  0,0
	dc.w 246,452,532,  3819,3820,3821,  0,0
	dc.w 452,531,532,  3822,3823,3824,  0,0
	dc.w 452,331,531,  3825,3826,3827,  0,0
	dc.w 246,532,98,  3828,3829,3830,  0,0
	dc.w 358,246,98,  3831,3832,3833,  0,0
	dc.w 535,100,220,  3834,3835,3836,  0,0
	dc.w 374,299,536,  3837,3838,3839,  0,0
	dc.w 308,537,306,  3840,3841,3842,  0,0
	dc.w 459,218,538,  3843,3844,3845,  0,0
	dc.w 459,538,337,  3846,3847,3848,  0,0
	dc.w 337,538,546,  3849,3850,3851,  0,0
	dc.w 457,223,524,  3852,3853,3854,  0,0
	dc.w 457,547,223,  3855,3856,3857,  0,0
	dc.w 335,547,457,  3858,3859,3860,  0,0
	dc.w 335,546,547,  3861,3862,3863,  0,0
	dc.w 337,546,335,  3864,3865,3866,  0,0
	dc.w 464,588,57,  3867,3868,3869,  0,0
	dc.w 588,243,57,  3870,3871,3872,  0,0
	dc.w 57,243,48,  3873,3874,3875,  0,0
	dc.w 243,371,48,  3876,3877,3878,  0,0
	dc.w 48,371,47,  3879,3880,3881,  0,0
	dc.w 371,239,47,  3882,3883,3884,  0,0
	dc.w 338,577,459,  3885,3886,3887,  0,0
	dc.w 239,577,338,  3888,3889,3890,  0,0
	dc.w 47,239,338,  3891,3892,3893,  0,0
	dc.w 577,218,459,  3894,3895,3896,  0,0
	dc.w 412,580,540,  3897,3898,3899,  0,0
	dc.w 577,576,218,  3900,3901,3902,  0,0
	dc.w 576,411,218,  3903,3904,3905,  0,0
	dc.w 218,411,540,  3906,3907,3908,  0,0
	dc.w 411,369,540,  3909,3910,3911,  0,0
	dc.w 369,412,540,  3912,3913,3914,  0,0
	dc.w 580,522,540,  3915,3916,3917,  0,0
	dc.w 266,522,580,  3918,3919,3920,  0,0
	dc.w 266,581,521,  3921,3922,3923,  0,0
	dc.w 581,219,521,  3924,3925,3926,  0,0
	dc.w 413,219,581,  3927,3928,3929,  0,0
	dc.w 582,220,415,  3930,3931,3932,  0,0
	dc.w 414,219,413,  3933,3934,3935,  0,0
	dc.w 415,219,414,  3936,3937,3938,  0,0
	dc.w 415,220,360,  3939,3940,3941,  0,0
	dc.w 415,360,219,  3942,3943,3944,  0,0
	dc.w 306,103,585,  3945,3946,3947,  0,0
	dc.w 585,103,102,  3948,3949,3950,  0,0
	dc.w 585,102,583,  3951,3952,3953,  0,0
	dc.w 583,102,370,  3954,3955,3956,  0,0
	dc.w 102,535,370,  3957,3958,3959,  0,0
	dc.w 582,535,220,  3960,3961,3962,  0,0
	dc.w 370,535,582,  3963,3964,3965,  0,0
	dc.w 306,537,103,  3966,3967,3968,  0,0
	dc.w 433,424,297,  3969,3970,3971,  0,0
	dc.w 433,315,424,  3972,3973,3974,  0,0
	dc.w 315,310,424,  3975,3976,3977,  0,0
	dc.w 424,310,421,  3978,3979,3980,  0,0
	dc.w 421,306,585,  3981,3982,3983,  0,0
	dc.w 310,307,421,  3984,3985,3986,  0,0
	dc.w 421,307,306,  3987,3988,3989,  0,0
	dc.w 575,453,238,  3990,3991,3992,  0,0
	dc.w 368,455,575,  3993,3994,3995,  0,0
	dc.w 575,455,332,  3996,3997,3998,  0,0
	dc.w 575,332,453,  3999,4000,4001,  0,0
	dc.w 441,227,321,  4002,4003,4004,  0,0
	dc.w 441,320,227,  4005,4006,4007,  0,0
	dc.w 320,561,227,  4008,4009,4010,  0,0
	dc.w 324,561,320,  4011,4012,4013,  0,0
	dc.w 446,327,226,  4014,4015,4016,  0,0
	dc.w 446,226,362,  4017,4018,4019,  0,0
	dc.w 326,446,362,  4020,4021,4022,  0,0
	dc.w 326,362,557,  4023,4024,4025,  0,0
	dc.w 324,559,561,  4026,4027,4028,  0,0
	dc.w 325,559,324,  4029,4030,4031,  0,0
	dc.w 325,557,559,  4032,4033,4034,  0,0
	dc.w 325,326,557,  4035,4036,4037,  0,0
	dc.w 303,375,228,  4038,4039,4040,  0,0
	dc.w 303,440,375,  4041,4042,4043,  0,0
	dc.w 319,440,303,  4044,4045,4046,  0,0
	dc.w 305,319,303,  4047,4048,4049,  0,0
	dc.w 443,319,305,  4050,4051,4052,  0,0
	dc.w 312,443,305,  4053,4054,4055,  0,0
	dc.w 312,323,443,  4056,4057,4058,  0,0
	dc.w 314,323,312,  4059,4060,4061,  0,0
	dc.w 329,323,314,  4062,4063,4064,  0,0
	dc.w 437,329,314,  4065,4066,4067,  0,0
	dc.w 238,453,437,  4068,4069,4070,  0,0
	dc.w 453,329,437,  4071,4072,4073,  0,0
	dc.w 368,237,271,  4074,4075,4076,  0,0
	dc.w 236,334,456,  4077,4078,4079,  0,0
	dc.w 237,236,456,  4080,4081,4082,  0,0
	dc.w 237,456,333,  4083,4084,4085,  0,0
	dc.w 237,333,271,  4086,4087,4088,  0,0
	dc.w 524,223,392,  4089,4090,4091,  0,0
	dc.w 226,91,90,  4092,4093,4094,  0,0
	dc.w 361,392,223,  4095,4096,4097,  0,0
	dc.w 226,90,556,  4098,4099,4100,  0,0
	dc.w 556,90,361,  4101,4102,4103,  0,0
	dc.w 361,90,523,  4104,4105,4106,  0,0
	dc.w 361,523,392,  4107,4108,4109,  0,0
	dc.w 42,526,93,  4110,4111,4112,  0,0
	dc.w 242,93,328,  4113,4114,4115,  0,0
	dc.w 92,91,226,  4116,4117,4118,  0,0
	dc.w 328,93,92,  4119,4120,4121,  0,0
	dc.w 92,226,327,  4122,4123,4124,  0,0
	dc.w 328,92,327,  4125,4126,4127,  0,0
	dc.w 42,93,242,  4128,4129,4130,  0,0
	dc.w 236,462,334,  4131,4132,4133,  0,0
	dc.w 462,376,334,  4134,4135,4136,  0,0
	dc.w 462,49,376,  4137,4138,4139,  0,0
	dc.w 49,44,376,  4140,4141,4142,  0,0
	dc.w 450,42,242,  4143,4144,4145,  0,0
	dc.w 44,42,450,  4146,4147,4148,  0,0
	dc.w 44,450,247,  4149,4150,4151,  0,0
	dc.w 376,44,247,  4152,4153,4154,  0,0
	dc.w 366,462,236,  4155,4156,4157,  0,0
	dc.w 366,51,462,  4158,4159,4160,  0,0
	dc.w 233,51,366,  4161,4162,4163,  0,0
	dc.w 233,52,51,  4164,4165,4166,  0,0
	dc.w 407,52,233,  4167,4168,4169,  0,0
	dc.w 567,55,407,  4170,4171,4172,  0,0
	dc.w 407,55,52,  4173,4174,4175,  0,0
	dc.w 563,363,588,  4176,4177,4178,  0,0
	dc.w 563,588,464,  4179,4180,4181,  0,0
	dc.w 563,464,56,  4182,4183,4184,  0,0
	dc.w 567,564,55,  4185,4186,4187,  0,0
	dc.w 564,563,56,  4188,4189,4190,  0,0
	dc.w 564,56,55,  4191,4192,4193,  0,0
	dc.w 363,422,588,  4194,4195,4196,  0,0
	dc.w 363,267,422,  4197,4198,4199,  0,0
	dc.w 404,267,363,  4200,4201,4202,  0,0
	dc.w 230,425,590,  4203,4204,4205,  0,0
	dc.w 404,587,267,  4206,4207,4208,  0,0
	dc.w 229,587,404,  4209,4210,4211,  0,0
	dc.w 565,230,590,  4212,4213,4214,  0,0
	dc.w 229,565,590,  4215,4216,4217,  0,0
	dc.w 229,590,587,  4218,4219,4220,  0,0
	dc.w 425,230,297,  4221,4222,4223,  0,0
	dc.w 297,230,433,  4224,4225,4226,  0,0
	dc.w 230,262,433,  4227,4228,4229,  0,0
	dc.w 262,405,316,  4230,4231,4232,  0,0
	dc.w 316,433,262,  4233,4234,4235,  0,0
	dc.w 405,264,317,  4236,4237,4238,  0,0
	dc.w 265,438,439,  4239,4240,4241,  0,0
	dc.w 573,265,439,  4242,4243,4244,  0,0
	dc.w 573,439,435,  4245,4246,4247,  0,0
	dc.w 264,573,435,  4248,4249,4250,  0,0
	dc.w 264,435,317,  4251,4252,4253,  0,0
	dc.w 265,238,438,  4254,4255,4256,  0,0
	dc.w 317,316,405,  4257,4258,4259,  0,0
	dc.w 220,100,545,  4260,4261,4262,  0,0
	dc.w 534,543,99,  4263,4264,4265,  0,0
	dc.w 99,543,359,  4266,4267,4268,  0,0
	dc.w 100,99,359,  4269,4270,4271,  0,0
	dc.w 545,100,359,  4272,4273,4274,  0,0
	dc.w 101,536,299,  4275,4276,4277,  0,0
	dc.w 298,552,553,  4278,4279,4280,  0,0
	dc.w 298,553,426,  4281,4282,4283,  0,0
	dc.w 426,553,555,  4284,4285,4286,  0,0
	dc.w 426,555,299,  4287,4288,4289,  0,0
	dc.w 299,555,222,  4290,4291,4292,  0,0
	dc.w 299,222,101,  4293,4294,4295,  0,0
	dc.w 101,222,534,  4296,4297,4298,  0,0
	dc.w 222,543,534,  4299,4300,4301,  0,0
	dc.w 427,302,225,  4302,4303,4304,  0,0
	dc.w 427,225,300,  4305,4306,4307,  0,0
	dc.w 298,300,552,  4308,4309,4310,  0,0
	dc.w 300,225,552,  4311,4312,4313,  0,0
tcoords_neuron_bak:				;u,v
	dc.s	0.192988,0.081207
	dc.s	0.194774,0.080708
	dc.s	0.194289,0.078418
	dc.s	0.192988,0.081207
	dc.s	0.193961,0.082951
	dc.s	0.194774,0.080708
	dc.s	0.456195,0.086176
	dc.s	0.440901,0.084968
	dc.s	0.456521,0.097915
	dc.s	0.172554,0.185573
	dc.s	0.186724,0.181607
	dc.s	0.187801,0.176527
	dc.s	0.172554,0.185573
	dc.s	0.186566,0.188969
	dc.s	0.186724,0.181607
	dc.s	0.451531,0.117526
	dc.s	0.454286,0.120096
	dc.s	0.411365,0.098310
	dc.s	0.454286,0.120096
	dc.s	0.456869,0.118939
	dc.s	0.418465,0.099670
	dc.s	0.454286,0.120096
	dc.s	0.418465,0.099670
	dc.s	0.411365,0.098310
	dc.s	0.456869,0.118939
	dc.s	0.455578,0.110133
	dc.s	0.418465,0.099670
	dc.s	0.456521,0.097915
	dc.s	0.440901,0.084968
	dc.s	0.425054,0.088973
	dc.s	0.440901,0.084968
	dc.s	0.420137,0.076867
	dc.s	0.425054,0.088973
	dc.s	0.455578,0.110133
	dc.s	0.456521,0.097915
	dc.s	0.425054,0.088973
	dc.s	0.455578,0.110133
	dc.s	0.425054,0.088973
	dc.s	0.415904,0.091626
	dc.s	0.455578,0.110133
	dc.s	0.415904,0.091626
	dc.s	0.418465,0.099670
	dc.s	0.186724,0.181607
	dc.s	0.200531,0.180994
	dc.s	0.205327,0.173943
	dc.s	0.186724,0.181607
	dc.s	0.205327,0.173943
	dc.s	0.187801,0.176527
	dc.s	0.186566,0.188969
	dc.s	0.200531,0.180994
	dc.s	0.186724,0.181607
	dc.s	0.200531,0.180994
	dc.s	0.216262,0.180683
	dc.s	0.205327,0.173943
	dc.s	0.206815,0.188804
	dc.s	0.216262,0.180683
	dc.s	0.200531,0.180994
	dc.s	0.425054,0.088973
	dc.s	0.420137,0.076867
	dc.s	0.350906,0.036632
	dc.s	0.425054,0.088973
	dc.s	0.350906,0.036632
	dc.s	0.351171,0.046987
	dc.s	0.425054,0.088973
	dc.s	0.351171,0.046987
	dc.s	0.415904,0.091626
	dc.s	0.411365,0.098310
	dc.s	0.418465,0.099670
	dc.s	0.347828,0.053740
	dc.s	0.418465,0.099670
	dc.s	0.352547,0.054194
	dc.s	0.347828,0.053740
	dc.s	0.415904,0.091626
	dc.s	0.352547,0.054194
	dc.s	0.418465,0.099670
	dc.s	0.415904,0.091626
	dc.s	0.351171,0.046987
	dc.s	0.352547,0.054194
	dc.s	0.216262,0.180683
	dc.s	0.256195,0.164235
	dc.s	0.205327,0.173943
	dc.s	0.205327,0.173943
	dc.s	0.256195,0.164235
	dc.s	0.261292,0.157212
	dc.s	0.350906,0.036632
	dc.s	0.328444,0.037444
	dc.s	0.351171,0.046987
	dc.s	0.350906,0.036632
	dc.s	0.293458,0.024400
	dc.s	0.328444,0.037444
	dc.s	0.350906,0.036632
	dc.s	0.326599,0.025348
	dc.s	0.293458,0.024400
	dc.s	0.347828,0.053740
	dc.s	0.352547,0.054194
	dc.s	0.328124,0.042901
	dc.s	0.351171,0.046987
	dc.s	0.328444,0.037444
	dc.s	0.328124,0.042901
	dc.s	0.352547,0.054194
	dc.s	0.351171,0.046987
	dc.s	0.328124,0.042901
	dc.s	0.256195,0.164235
	dc.s	0.281222,0.154004
	dc.s	0.261292,0.157212
	dc.s	0.328444,0.037444
	dc.s	0.293458,0.024400
	dc.s	0.299683,0.032741
	dc.s	0.328124,0.042901
	dc.s	0.328444,0.037444
	dc.s	0.308526,0.037221
	dc.s	0.328444,0.037444
	dc.s	0.299683,0.032741
	dc.s	0.308526,0.037221
	dc.s	0.308526,0.037221
	dc.s	0.299683,0.032741
	dc.s	0.292676,0.035675
	dc.s	0.281222,0.154004
	dc.s	0.299060,0.154076
	dc.s	0.314547,0.145783
	dc.s	0.299683,0.032741
	dc.s	0.280121,0.031565
	dc.s	0.282394,0.036767
	dc.s	0.299683,0.032741
	dc.s	0.293458,0.024400
	dc.s	0.280121,0.031565
	dc.s	0.293458,0.024400
	dc.s	0.279582,0.026342
	dc.s	0.280121,0.031565
	dc.s	0.292676,0.035675
	dc.s	0.299683,0.032741
	dc.s	0.282394,0.036767
	dc.s	0.319270,0.152845
	dc.s	0.328007,0.147197
	dc.s	0.314547,0.145783
	dc.s	0.299060,0.154076
	dc.s	0.319270,0.152845
	dc.s	0.314547,0.145783
	dc.s	0.319270,0.152845
	dc.s	0.343456,0.153511
	dc.s	0.328007,0.147197
	dc.s	0.279582,0.026342
	dc.s	0.256584,0.039644
	dc.s	0.280121,0.031565
	dc.s	0.280121,0.031565
	dc.s	0.249969,0.053293
	dc.s	0.282394,0.036767
	dc.s	0.328007,0.147197
	dc.s	0.343456,0.153511
	dc.s	0.354116,0.148679
	dc.s	0.280121,0.031565
	dc.s	0.256584,0.039644
	dc.s	0.216444,0.068049
	dc.s	0.280121,0.031565
	dc.s	0.216444,0.068049
	dc.s	0.249969,0.053293
	dc.s	0.354116,0.148679
	dc.s	0.399516,0.158393
	dc.s	0.400835,0.153794
	dc.s	0.343456,0.153511
	dc.s	0.399516,0.158393
	dc.s	0.354116,0.148679
	dc.s	0.249969,0.053293
	dc.s	0.194774,0.080708
	dc.s	0.198528,0.083062
	dc.s	0.249969,0.053293
	dc.s	0.216444,0.068049
	dc.s	0.194774,0.080708
	dc.s	0.228552,0.067774
	dc.s	0.249969,0.053293
	dc.s	0.198528,0.083062
	dc.s	0.216444,0.068049
	dc.s	0.194289,0.078418
	dc.s	0.194774,0.080708
	dc.s	0.198528,0.083062
	dc.s	0.194774,0.080708
	dc.s	0.193961,0.082951
	dc.s	0.399516,0.158393
	dc.s	0.426218,0.159353
	dc.s	0.424709,0.156740
	dc.s	0.399516,0.158393
	dc.s	0.424709,0.156740
	dc.s	0.400835,0.153794
	dc.s	0.158751,0.374850
	dc.s	0.157499,0.387089
	dc.s	0.166876,0.374343
	dc.s	0.166876,0.374343
	dc.s	0.157499,0.387089
	dc.s	0.164216,0.386079
	dc.s	0.172427,0.386398
	dc.s	0.175600,0.406111
	dc.s	0.178728,0.389224
	dc.s	0.157499,0.387089
	dc.s	0.157892,0.412028
	dc.s	0.164216,0.386079
	dc.s	0.164216,0.386079
	dc.s	0.157892,0.412028
	dc.s	0.165915,0.401999
	dc.s	0.164216,0.386079
	dc.s	0.165915,0.401999
	dc.s	0.172427,0.386398
	dc.s	0.017074,0.766754
	dc.s	0.029861,0.759540
	dc.s	0.024040,0.777857
	dc.s	0.029861,0.759540
	dc.s	0.032045,0.777365
	dc.s	0.024040,0.777857
	dc.s	0.492392,0.249560
	dc.s	0.485478,0.246475
	dc.s	0.493812,0.241151
	dc.s	0.492392,0.249560
	dc.s	0.490145,0.264226
	dc.s	0.485478,0.246475
	dc.s	0.017074,0.766754
	dc.s	0.024040,0.777857
	dc.s	0.016980,0.783196
	dc.s	0.485478,0.246475
	dc.s	0.478150,0.260332
	dc.s	0.464717,0.245146
	dc.s	0.490145,0.264226
	dc.s	0.478150,0.260332
	dc.s	0.485478,0.246475
	dc.s	0.024040,0.777857
	dc.s	0.032045,0.777365
	dc.s	0.026582,0.794091
	dc.s	0.490521,0.271680
	dc.s	0.448850,0.256605
	dc.s	0.478150,0.260332
	dc.s	0.026582,0.794091
	dc.s	0.031943,0.827908
	dc.s	0.026012,0.828450
	dc.s	0.478150,0.260332
	dc.s	0.448598,0.250855
	dc.s	0.464717,0.245146
	dc.s	0.165915,0.401999
	dc.s	0.160590,0.425632
	dc.s	0.168571,0.419987
	dc.s	0.464717,0.245146
	dc.s	0.451178,0.236292
	dc.s	0.474517,0.238168
	dc.s	0.026012,0.828450
	dc.s	0.031943,0.827908
	dc.s	0.013017,0.902265
	dc.s	0.464717,0.245146
	dc.s	0.448598,0.250855
	dc.s	0.389394,0.215498
	dc.s	0.451178,0.236292
	dc.s	0.389394,0.215498
	dc.s	0.386171,0.203316
	dc.s	0.464717,0.245146
	dc.s	0.389394,0.215498
	dc.s	0.451178,0.236292
	dc.s	0.031943,0.827908
	dc.s	0.018294,0.910652
	dc.s	0.013017,0.902265
	dc.s	0.160590,0.425632
	dc.s	0.160929,0.487078
	dc.s	0.164581,0.438387
	dc.s	0.164581,0.438387
	dc.s	0.160929,0.487078
	dc.s	0.167058,0.488459
	dc.s	0.018294,0.910652
	dc.s	0.019554,0.937874
	dc.s	0.014898,0.947015
	dc.s	0.386171,0.203316
	dc.s	0.358602,0.200558
	dc.s	0.355378,0.193777
	dc.s	0.389394,0.215498
	dc.s	0.358602,0.200558
	dc.s	0.386171,0.203316
	dc.s	0.018294,0.910652
	dc.s	0.014898,0.947015
	dc.s	0.013017,0.902265
	dc.s	0.389394,0.215498
	dc.s	0.350544,0.205901
	dc.s	0.358602,0.200558
	dc.s	0.167058,0.488459
	dc.s	0.160769,0.519328
	dc.s	0.168548,0.519824
	dc.s	0.160929,0.487078
	dc.s	0.160769,0.519328
	dc.s	0.167058,0.488459
	dc.s	0.019554,0.937874
	dc.s	0.019097,0.958627
	dc.s	0.014898,0.947015
	dc.s	0.188773,0.393058
	dc.s	0.192128,0.406154
	dc.s	0.190799,0.425112
	dc.s	0.358602,0.200558
	dc.s	0.315216,0.203171
	dc.s	0.355378,0.193777
	dc.s	0.014898,0.947015
	dc.s	0.019290,0.972917
	dc.s	0.016380,0.982182
	dc.s	0.358602,0.200558
	dc.s	0.350544,0.205901
	dc.s	0.315216,0.203171
	dc.s	0.160769,0.519328
	dc.s	0.163681,0.540597
	dc.s	0.168548,0.519824
	dc.s	0.160769,0.519328
	dc.s	0.159224,0.564415
	dc.s	0.163681,0.540597
	dc.s	0.190799,0.425112
	dc.s	0.194548,0.440973
	dc.s	0.189453,0.441085
	dc.s	0.325316,0.206096
	dc.s	0.312978,0.209061
	dc.s	0.315216,0.203171
	dc.s	0.355378,0.193777
	dc.s	0.315216,0.203171
	dc.s	0.318247,0.195214
	dc.s	0.318247,0.195214
	dc.s	0.315216,0.203171
	dc.s	0.297038,0.208241
	dc.s	0.189453,0.441085
	dc.s	0.194548,0.440973
	dc.s	0.186850,0.486465
	dc.s	0.189453,0.441085
	dc.s	0.186850,0.486465
	dc.s	0.182366,0.479064
	dc.s	0.315216,0.203171
	dc.s	0.312978,0.209061
	dc.s	0.286165,0.225561
	dc.s	0.315216,0.203171
	dc.s	0.250567,0.246583
	dc.s	0.297038,0.208241
	dc.s	0.315216,0.203171
	dc.s	0.286165,0.225561
	dc.s	0.250567,0.246583
	dc.s	0.182366,0.479064
	dc.s	0.186850,0.486465
	dc.s	0.175705,0.514869
	dc.s	0.286165,0.225561
	dc.s	0.263090,0.245948
	dc.s	0.238806,0.261247
	dc.s	0.286165,0.225561
	dc.s	0.238806,0.261247
	dc.s	0.250567,0.246583
	dc.s	0.175705,0.514869
	dc.s	0.170440,0.558019
	dc.s	0.168879,0.549239
	dc.s	0.238806,0.261247
	dc.s	0.228280,0.263601
	dc.s	0.250567,0.246583
	dc.s	0.168879,0.549239
	dc.s	0.170440,0.558019
	dc.s	0.169249,0.563193
	dc.s	0.238806,0.261247
	dc.s	0.229376,0.265268
	dc.s	0.228280,0.263601
	dc.s	0.249271,0.745506
	dc.s	0.240544,0.738080
	dc.s	0.236805,0.750355
	dc.s	0.249271,0.745506
	dc.s	0.236805,0.750355
	dc.s	0.247163,0.753655
	dc.s	0.231731,0.762050
	dc.s	0.244239,0.762315
	dc.s	0.236805,0.750355
	dc.s	0.240359,0.769962
	dc.s	0.244239,0.762315
	dc.s	0.231731,0.762050
	dc.s	0.244239,0.762315
	dc.s	0.247163,0.753655
	dc.s	0.236805,0.750355
	dc.s	0.248942,0.736780
	dc.s	0.239292,0.732161
	dc.s	0.240544,0.738080
	dc.s	0.248942,0.736780
	dc.s	0.240544,0.738080
	dc.s	0.249271,0.745506
	dc.s	0.229891,0.772139
	dc.s	0.235624,0.774444
	dc.s	0.231731,0.762050
	dc.s	0.235624,0.774444
	dc.s	0.240359,0.769962
	dc.s	0.231731,0.762050
	dc.s	0.394051,0.913659
	dc.s	0.380217,0.921604
	dc.s	0.385932,0.933039
	dc.s	0.394051,0.913659
	dc.s	0.385932,0.933039
	dc.s	0.399597,0.930511
	dc.s	0.399597,0.865570
	dc.s	0.387203,0.886351
	dc.s	0.385250,0.878889
	dc.s	0.394587,0.844068
	dc.s	0.384409,0.869047
	dc.s	0.380217,0.863913
	dc.s	0.394587,0.844068
	dc.s	0.399597,0.865570
	dc.s	0.384409,0.869047
	dc.s	0.384409,0.869047
	dc.s	0.399597,0.865570
	dc.s	0.385250,0.878889
	dc.s	0.467582,0.873090
	dc.s	0.477071,0.885344
	dc.s	0.475219,0.879045
	dc.s	0.092947,0.971983
	dc.s	0.092488,0.980766
	dc.s	0.089840,0.967193
	dc.s	0.474846,0.868574
	dc.s	0.475219,0.879045
	dc.s	0.479731,0.883459
	dc.s	0.475219,0.879045
	dc.s	0.477071,0.885344
	dc.s	0.479731,0.883459
	dc.s	0.398524,0.636215
	dc.s	0.401873,0.681548
	dc.s	0.406059,0.641048
	dc.s	0.406059,0.641048
	dc.s	0.401873,0.681548
	dc.s	0.408715,0.685968
	dc.s	0.406059,0.641048
	dc.s	0.408715,0.685968
	dc.s	0.418258,0.637665
	dc.s	0.418258,0.637665
	dc.s	0.408715,0.685968
	dc.s	0.419295,0.685719
	dc.s	0.424170,0.634098
	dc.s	0.418258,0.637665
	dc.s	0.419295,0.685719
	dc.s	0.424170,0.634098
	dc.s	0.419295,0.685719
	dc.s	0.424230,0.695413
	dc.s	0.396242,0.646614
	dc.s	0.400719,0.707388
	dc.s	0.401873,0.681548
	dc.s	0.396242,0.646614
	dc.s	0.401873,0.681548
	dc.s	0.398524,0.636215
	dc.s	0.401873,0.681548
	dc.s	0.402896,0.723750
	dc.s	0.408715,0.685968
	dc.s	0.419295,0.685719
	dc.s	0.414541,0.718371
	dc.s	0.421485,0.714119
	dc.s	0.408715,0.685968
	dc.s	0.414541,0.718371
	dc.s	0.419295,0.685719
	dc.s	0.408715,0.685968
	dc.s	0.402896,0.723750
	dc.s	0.414541,0.718371
	dc.s	0.424230,0.695413
	dc.s	0.419295,0.685719
	dc.s	0.421485,0.714119
	dc.s	0.424230,0.695413
	dc.s	0.421485,0.714119
	dc.s	0.423552,0.733921
	dc.s	0.401873,0.681548
	dc.s	0.400719,0.707388
	dc.s	0.402896,0.723750
	dc.s	0.400719,0.707388
	dc.s	0.397670,0.726738
	dc.s	0.402896,0.723750
	dc.s	0.402896,0.723750
	dc.s	0.396085,0.738600
	dc.s	0.414541,0.718371
	dc.s	0.421485,0.714119
	dc.s	0.414541,0.718371
	dc.s	0.422529,0.762907
	dc.s	0.414541,0.718371
	dc.s	0.413343,0.770473
	dc.s	0.422529,0.762907
	dc.s	0.396085,0.738600
	dc.s	0.400562,0.752261
	dc.s	0.413343,0.770473
	dc.s	0.414541,0.718371
	dc.s	0.396085,0.738600
	dc.s	0.413343,0.770473
	dc.s	0.421485,0.714119
	dc.s	0.422529,0.762907
	dc.s	0.423552,0.733921
	dc.s	0.422529,0.762907
	dc.s	0.413343,0.770473
	dc.s	0.430699,0.789910
	dc.s	0.413343,0.770473
	dc.s	0.424093,0.791884
	dc.s	0.430699,0.789910
	dc.s	0.422529,0.762907
	dc.s	0.430699,0.789910
	dc.s	0.426334,0.768850
	dc.s	0.413343,0.770473
	dc.s	0.421856,0.795787
	dc.s	0.424093,0.791884
	dc.s	0.423552,0.733921
	dc.s	0.422529,0.762907
	dc.s	0.426334,0.768850
	dc.s	0.423552,0.733921
	dc.s	0.426334,0.768850
	dc.s	0.427756,0.768073
	dc.s	0.426334,0.768850
	dc.s	0.430699,0.789910
	dc.s	0.433407,0.789060
	dc.s	0.427756,0.768073
	dc.s	0.426334,0.768850
	dc.s	0.433407,0.789060
	dc.s	0.080341,0.820838
	dc.s	0.089397,0.833524
	dc.s	0.086321,0.839471
	dc.s	0.086296,0.825338
	dc.s	0.089397,0.833524
	dc.s	0.080341,0.820838
	dc.s	0.086321,0.839471
	dc.s	0.097316,0.868736
	dc.s	0.093669,0.866095
	dc.s	0.407038,0.767616
	dc.s	0.421124,0.800029
	dc.s	0.413343,0.770473
	dc.s	0.424093,0.791884
	dc.s	0.421856,0.795787
	dc.s	0.440689,0.808378
	dc.s	0.430699,0.789910
	dc.s	0.424093,0.791884
	dc.s	0.440689,0.808378
	dc.s	0.440689,0.808378
	dc.s	0.458792,0.852240
	dc.s	0.461990,0.841293
	dc.s	0.421856,0.795787
	dc.s	0.458792,0.852240
	dc.s	0.440689,0.808378
	dc.s	0.433407,0.789060
	dc.s	0.430699,0.789910
	dc.s	0.440689,0.808378
	dc.s	0.093669,0.866095
	dc.s	0.092737,0.920822
	dc.s	0.086679,0.943085
	dc.s	0.097316,0.868736
	dc.s	0.092737,0.920822
	dc.s	0.093669,0.866095
	dc.s	0.461990,0.841293
	dc.s	0.458792,0.852240
	dc.s	0.474846,0.868574
	dc.s	0.458792,0.852240
	dc.s	0.475219,0.879045
	dc.s	0.474846,0.868574
	dc.s	0.458792,0.852240
	dc.s	0.467582,0.873090
	dc.s	0.475219,0.879045
	dc.s	0.461990,0.841293
	dc.s	0.474846,0.868574
	dc.s	0.470505,0.853488
	dc.s	0.470505,0.853488
	dc.s	0.474846,0.868574
	dc.s	0.478845,0.875131
	dc.s	0.474846,0.868574
	dc.s	0.479731,0.883459
	dc.s	0.478845,0.875131
	dc.s	0.092737,0.920822
	dc.s	0.089840,0.967193
	dc.s	0.086679,0.943085
	dc.s	0.092737,0.920822
	dc.s	0.092947,0.971983
	dc.s	0.089840,0.967193
	dc.s	0.397670,0.726738
	dc.s	0.389736,0.738020
	dc.s	0.402896,0.723750
	dc.s	0.402896,0.723750
	dc.s	0.389736,0.738020
	dc.s	0.396085,0.738600
	dc.s	0.394698,0.755754
	dc.s	0.400562,0.752261
	dc.s	0.381513,0.759017
	dc.s	0.396085,0.738600
	dc.s	0.381513,0.759017
	dc.s	0.400562,0.752261
	dc.s	0.396085,0.738600
	dc.s	0.372958,0.758167
	dc.s	0.381513,0.759017
	dc.s	0.389736,0.738020
	dc.s	0.372958,0.758167
	dc.s	0.396085,0.738600
	dc.s	0.394698,0.755754
	dc.s	0.401853,0.759335
	dc.s	0.400562,0.752261
	dc.s	0.383510,0.759924
	dc.s	0.394698,0.755754
	dc.s	0.381513,0.759017
	dc.s	0.389736,0.738020
	dc.s	0.364921,0.758768
	dc.s	0.372958,0.758167
	dc.s	0.381513,0.759017
	dc.s	0.372958,0.758167
	dc.s	0.337844,0.788042
	dc.s	0.372958,0.758167
	dc.s	0.364921,0.758768
	dc.s	0.341962,0.778364
	dc.s	0.383510,0.759924
	dc.s	0.381513,0.759017
	dc.s	0.357678,0.778927
	dc.s	0.381513,0.759017
	dc.s	0.337844,0.788042
	dc.s	0.357678,0.778927
	dc.s	0.372958,0.758167
	dc.s	0.341962,0.778364
	dc.s	0.337844,0.788042
	dc.s	0.341962,0.778364
	dc.s	0.312866,0.790874
	dc.s	0.337844,0.788042
	dc.s	0.107421,0.412512
	dc.s	0.108624,0.442834
	dc.s	0.111479,0.445108
	dc.s	0.117254,0.428804
	dc.s	0.117527,0.412520
	dc.s	0.120289,0.455613
	dc.s	0.117527,0.412520
	dc.s	0.121871,0.443322
	dc.s	0.120289,0.455613
	dc.s	0.312866,0.790874
	dc.s	0.298222,0.792543
	dc.s	0.301685,0.793595
	dc.s	0.111479,0.445108
	dc.s	0.108624,0.442834
	dc.s	0.107927,0.459022
	dc.s	0.117254,0.428804
	dc.s	0.120289,0.455613
	dc.s	0.118262,0.458767
	dc.s	0.107666,0.431948
	dc.s	0.107927,0.459022
	dc.s	0.108624,0.442834
	dc.s	0.206630,0.400423
	dc.s	0.199010,0.399531
	dc.s	0.200523,0.396393
	dc.s	0.060614,0.560834
	dc.s	0.061170,0.566091
	dc.s	0.058265,0.564743
	dc.s	0.056341,0.555552
	dc.s	0.060614,0.560834
	dc.s	0.058265,0.564743
	dc.s	0.254935,0.133374
	dc.s	0.246045,0.130190
	dc.s	0.170706,0.137057
	dc.s	0.254935,0.133374
	dc.s	0.170706,0.137057
	dc.s	0.184831,0.142764
	dc.s	0.246045,0.130190
	dc.s	0.225965,0.125782
	dc.s	0.170706,0.137057
	dc.s	0.430850,0.389219
	dc.s	0.389603,0.384783
	dc.s	0.388481,0.375008
	dc.s	0.455922,0.403611
	dc.s	0.389603,0.384783
	dc.s	0.430850,0.389219
	dc.s	0.445721,0.384609
	dc.s	0.388481,0.375008
	dc.s	0.390398,0.367395
	dc.s	0.445721,0.384609
	dc.s	0.390398,0.367395
	dc.s	0.449040,0.378113
	dc.s	0.430850,0.389219
	dc.s	0.388481,0.375008
	dc.s	0.445721,0.384609
	dc.s	0.047409,0.767691
	dc.s	0.053204,0.796027
	dc.s	0.046918,0.870587
	dc.s	0.047409,0.767691
	dc.s	0.046918,0.870587
	dc.s	0.042923,0.828473
	dc.s	0.042923,0.828473
	dc.s	0.046918,0.870587
	dc.s	0.041864,0.895137
	dc.s	0.184831,0.142764
	dc.s	0.170706,0.137057
	dc.s	0.151149,0.151267
	dc.s	0.170706,0.137057
	dc.s	0.139798,0.151361
	dc.s	0.151149,0.151267
	dc.s	0.389603,0.384783
	dc.s	0.355507,0.376848
	dc.s	0.359669,0.368209
	dc.s	0.388481,0.375008
	dc.s	0.389603,0.384783
	dc.s	0.359669,0.368209
	dc.s	0.390398,0.367395
	dc.s	0.388481,0.375008
	dc.s	0.369441,0.363354
	dc.s	0.359669,0.368209
	dc.s	0.355834,0.358998
	dc.s	0.369441,0.363354
	dc.s	0.388481,0.375008
	dc.s	0.359669,0.368209
	dc.s	0.369441,0.363354
	dc.s	0.046918,0.870587
	dc.s	0.047702,0.895395
	dc.s	0.041864,0.895137
	dc.s	0.047702,0.895395
	dc.s	0.050729,0.910392
	dc.s	0.046410,0.906902
	dc.s	0.359669,0.368209
	dc.s	0.318653,0.368556
	dc.s	0.339347,0.344012
	dc.s	0.339347,0.344012
	dc.s	0.318653,0.368556
	dc.s	0.328558,0.354681
	dc.s	0.359669,0.368209
	dc.s	0.355507,0.376848
	dc.s	0.318653,0.368556
	dc.s	0.151149,0.151267
	dc.s	0.114241,0.167572
	dc.s	0.098022,0.178259
	dc.s	0.151149,0.151267
	dc.s	0.139798,0.151361
	dc.s	0.114241,0.167572
	dc.s	0.114241,0.167572
	dc.s	0.095194,0.171180
	dc.s	0.093091,0.175013
	dc.s	0.114241,0.167572
	dc.s	0.093091,0.175013
	dc.s	0.098022,0.178259
	dc.s	0.355507,0.376848
	dc.s	0.292961,0.373176
	dc.s	0.318653,0.368556
	dc.s	0.318653,0.368556
	dc.s	0.306120,0.364282
	dc.s	0.328558,0.354681
	dc.s	0.328558,0.354681
	dc.s	0.306120,0.364282
	dc.s	0.304899,0.359423
	dc.s	0.306120,0.364282
	dc.s	0.284956,0.369077
	dc.s	0.285383,0.363681
	dc.s	0.306120,0.364282
	dc.s	0.285383,0.363681
	dc.s	0.304899,0.359423
	dc.s	0.318653,0.368556
	dc.s	0.292961,0.373176
	dc.s	0.306120,0.364282
	dc.s	0.306120,0.364282
	dc.s	0.292961,0.373176
	dc.s	0.284956,0.369077
	dc.s	0.059496,0.442772
	dc.s	0.056806,0.451566
	dc.s	0.054151,0.445824
	dc.s	0.059496,0.442772
	dc.s	0.062468,0.456763
	dc.s	0.056806,0.451566
	dc.s	0.056806,0.451566
	dc.s	0.062468,0.456763
	dc.s	0.058694,0.472678
	dc.s	0.095194,0.171180
	dc.s	0.074189,0.167894
	dc.s	0.093091,0.175013
	dc.s	0.098022,0.178259
	dc.s	0.028527,0.166664
	dc.s	0.047222,0.172138
	dc.s	0.098022,0.178259
	dc.s	0.093091,0.175013
	dc.s	0.028527,0.166664
	dc.s	0.093091,0.175013
	dc.s	0.074189,0.167894
	dc.s	0.038646,0.162763
	dc.s	0.093091,0.175013
	dc.s	0.038646,0.162763
	dc.s	0.028527,0.166664
	dc.s	0.062211,0.471689
	dc.s	0.063604,0.519469
	dc.s	0.056834,0.516297
	dc.s	0.067898,0.474990
	dc.s	0.063604,0.519469
	dc.s	0.062211,0.471689
	dc.s	0.284956,0.369077
	dc.s	0.244445,0.389242
	dc.s	0.244543,0.383679
	dc.s	0.284956,0.369077
	dc.s	0.292961,0.373176
	dc.s	0.244445,0.389242
	dc.s	0.058694,0.472678
	dc.s	0.062211,0.471689
	dc.s	0.056834,0.516297
	dc.s	0.047222,0.172138
	dc.s	0.028527,0.166664
	dc.s	0.008922,0.170455
	dc.s	0.244445,0.389242
	dc.s	0.200523,0.396393
	dc.s	0.244543,0.383679
	dc.s	0.244445,0.389242
	dc.s	0.206630,0.400423
	dc.s	0.200523,0.396393
	dc.s	0.056834,0.516297
	dc.s	0.063604,0.519469
	dc.s	0.056341,0.555552
	dc.s	0.063604,0.519469
	dc.s	0.060614,0.560834
	dc.s	0.056341,0.555552
	dc.s	0.355834,0.358998
	dc.s	0.352784,0.351579
	dc.s	0.361308,0.358482
	dc.s	0.049359,0.916752
	dc.s	0.047517,0.924872
	dc.s	0.044726,0.914363
	dc.s	0.049359,0.916752
	dc.s	0.053334,0.943770
	dc.s	0.047517,0.924872
	dc.s	0.050729,0.910392
	dc.s	0.056500,0.934545
	dc.s	0.049359,0.916752
	dc.s	0.339347,0.344012
	dc.s	0.328558,0.354681
	dc.s	0.332779,0.343842
	dc.s	0.359669,0.368209
	dc.s	0.339347,0.344012
	dc.s	0.355834,0.358998
	dc.s	0.355834,0.358998
	dc.s	0.339347,0.344012
	dc.s	0.338547,0.329835
	dc.s	0.222891,0.878671
	dc.s	0.232177,0.876408
	dc.s	0.226961,0.883401
	dc.s	0.221820,0.870061
	dc.s	0.222891,0.878671
	dc.s	0.216104,0.883162
	dc.s	0.216104,0.883162
	dc.s	0.222891,0.878671
	dc.s	0.226961,0.883401
	dc.s	0.221820,0.870061
	dc.s	0.232177,0.876408
	dc.s	0.222891,0.878671
	dc.s	0.049359,0.916752
	dc.s	0.056500,0.934545
	dc.s	0.053334,0.943770
	dc.s	0.216104,0.883162
	dc.s	0.221112,0.895315
	dc.s	0.223375,0.929517
	dc.s	0.264324,0.352442
	dc.s	0.237029,0.355190
	dc.s	0.250962,0.347640
	dc.s	0.056500,0.934545
	dc.s	0.052055,0.968379
	dc.s	0.053334,0.943770
	dc.s	0.053334,0.943770
	dc.s	0.052055,0.968379
	dc.s	0.051670,0.966092
	dc.s	0.237029,0.355190
	dc.s	0.222663,0.357449
	dc.s	0.202451,0.353080
	dc.s	0.250962,0.347640
	dc.s	0.237029,0.355190
	dc.s	0.190317,0.346824
	dc.s	0.056500,0.934545
	dc.s	0.052220,0.978716
	dc.s	0.052055,0.968379
	dc.s	0.237029,0.355190
	dc.s	0.202451,0.353080
	dc.s	0.190317,0.346824
	dc.s	0.051670,0.966092
	dc.s	0.052055,0.968379
	dc.s	0.048405,0.980273
	dc.s	0.205271,0.346809
	dc.s	0.190317,0.346824
	dc.s	0.183099,0.340719
	dc.s	0.172149,0.456501
	dc.s	0.175886,0.467240
	dc.s	0.172259,0.476069
	dc.s	0.172149,0.456501
	dc.s	0.179768,0.454202
	dc.s	0.175886,0.467240
	dc.s	0.380217,0.890403
	dc.s	0.399597,0.905437
	dc.s	0.399278,0.909783
	dc.s	0.175886,0.467240
	dc.s	0.177890,0.476610
	dc.s	0.172259,0.476069
	dc.s	0.129909,0.405538
	dc.s	0.134385,0.405730
	dc.s	0.129750,0.432093
	dc.s	0.134385,0.405730
	dc.s	0.141585,0.404572
	dc.s	0.136181,0.416160
	dc.s	0.134385,0.405730
	dc.s	0.133357,0.447015
	dc.s	0.129750,0.432093
	dc.s	0.402746,0.939369
	dc.s	0.376505,0.940473
	dc.s	0.374863,0.955384
	dc.s	0.402746,0.939369
	dc.s	0.374863,0.955384
	dc.s	0.396174,0.953018
	dc.s	0.360463,0.936835
	dc.s	0.374863,0.955384
	dc.s	0.376505,0.940473
	dc.s	0.077881,0.714983
	dc.s	0.068765,0.722722
	dc.s	0.084581,0.728521
	dc.s	0.360463,0.936835
	dc.s	0.365488,0.974464
	dc.s	0.374863,0.955384
	dc.s	0.374863,0.955384
	dc.s	0.365488,0.974464
	dc.s	0.376335,0.979118
	dc.s	0.396174,0.953018
	dc.s	0.374863,0.955384
	dc.s	0.376335,0.979118
	dc.s	0.396174,0.953018
	dc.s	0.376335,0.979118
	dc.s	0.393895,0.975860
	dc.s	0.077092,0.705435
	dc.s	0.077881,0.714983
	dc.s	0.107069,0.729610
	dc.s	0.077881,0.714983
	dc.s	0.084581,0.728521
	dc.s	0.111049,0.744118
	dc.s	0.077881,0.714983
	dc.s	0.111049,0.744118
	dc.s	0.107069,0.729610
	dc.s	0.087208,0.701835
	dc.s	0.077092,0.705435
	dc.s	0.107069,0.729610
	dc.s	0.103690,0.492138
	dc.s	0.092028,0.549633
	dc.s	0.095081,0.495640
	dc.s	0.103690,0.492138
	dc.s	0.097944,0.561553
	dc.s	0.092028,0.549633
	dc.s	0.113914,0.486136
	dc.s	0.097944,0.561553
	dc.s	0.103690,0.492138
	dc.s	0.317339,0.804697
	dc.s	0.320745,0.842888
	dc.s	0.313963,0.811069
	dc.s	0.345058,0.828195
	dc.s	0.354258,0.813551
	dc.s	0.346886,0.836015
	dc.s	0.327620,0.803389
	dc.s	0.328130,0.844982
	dc.s	0.320745,0.842888
	dc.s	0.327620,0.803389
	dc.s	0.320745,0.842888
	dc.s	0.317339,0.804697
	dc.s	0.338244,0.803671
	dc.s	0.328130,0.844982
	dc.s	0.327620,0.803389
	dc.s	0.338244,0.803671
	dc.s	0.345993,0.810022
	dc.s	0.328130,0.844982
	dc.s	0.345993,0.810022
	dc.s	0.345058,0.828195
	dc.s	0.336310,0.860869
	dc.s	0.345993,0.810022
	dc.s	0.336310,0.860869
	dc.s	0.328130,0.844982
	dc.s	0.311975,0.813180
	dc.s	0.313963,0.811069
	dc.s	0.318109,0.868797
	dc.s	0.078982,0.454220
	dc.s	0.094350,0.456238
	dc.s	0.098088,0.449640
	dc.s	0.072110,0.451070
	dc.s	0.078982,0.454220
	dc.s	0.088592,0.448390
	dc.s	0.455071,0.375445
	dc.s	0.454085,0.370556
	dc.s	0.456915,0.375350
	dc.s	0.463510,0.678018
	dc.s	0.469111,0.697579
	dc.s	0.465609,0.697852
	dc.s	0.469111,0.697579
	dc.s	0.467385,0.702838
	dc.s	0.465609,0.697852
	dc.s	0.227235,0.987627
	dc.s	0.229931,0.979511
	dc.s	0.200602,0.921324
	dc.s	0.233658,0.972417
	dc.s	0.214434,0.936535
	dc.s	0.200602,0.921324
	dc.s	0.229931,0.979511
	dc.s	0.233658,0.972417
	dc.s	0.200602,0.921324
	dc.s	0.266105,0.363338
	dc.s	0.192675,0.365291
	dc.s	0.214496,0.373235
	dc.s	0.460319,0.623268
	dc.s	0.462836,0.562856
	dc.s	0.472109,0.548103
	dc.s	0.238249,0.968878
	dc.s	0.214146,0.929734
	dc.s	0.214434,0.936535
	dc.s	0.464983,0.445726
	dc.s	0.465907,0.486335
	dc.s	0.460666,0.488842
	dc.s	0.212088,0.376525
	dc.s	0.214496,0.373235
	dc.s	0.179042,0.371475
	dc.s	0.192675,0.365291
	dc.s	0.178330,0.359155
	dc.s	0.179042,0.371475
	dc.s	0.214496,0.373235
	dc.s	0.192675,0.365291
	dc.s	0.179042,0.371475
	dc.s	0.456834,0.575142
	dc.s	0.469329,0.531624
	dc.s	0.462836,0.562856
	dc.s	0.474467,0.454537
	dc.s	0.463218,0.516888
	dc.s	0.465907,0.486335
	dc.s	0.465907,0.486335
	dc.s	0.455500,0.522221
	dc.s	0.460666,0.488842
	dc.s	0.465907,0.486335
	dc.s	0.463218,0.516888
	dc.s	0.455500,0.522221
	dc.s	0.457688,0.483464
	dc.s	0.460666,0.488842
	dc.s	0.454567,0.505428
	dc.s	0.214146,0.929734
	dc.s	0.197172,0.894349
	dc.s	0.203171,0.913706
	dc.s	0.454567,0.505428
	dc.s	0.455500,0.522221
	dc.s	0.447319,0.529415
	dc.s	0.214434,0.936535
	dc.s	0.203171,0.913706
	dc.s	0.200602,0.921324
	dc.s	0.227235,0.987627
	dc.s	0.200602,0.921324
	dc.s	0.192321,0.910701
	dc.s	0.200602,0.921324
	dc.s	0.189203,0.891220
	dc.s	0.185359,0.891209
	dc.s	0.206957,0.362969
	dc.s	0.178330,0.359155
	dc.s	0.192675,0.365291
	dc.s	0.203171,0.913706
	dc.s	0.190511,0.885747
	dc.s	0.189203,0.891220
	dc.s	0.203171,0.913706
	dc.s	0.189203,0.891220
	dc.s	0.200602,0.921324
	dc.s	0.179042,0.371475
	dc.s	0.178330,0.359155
	dc.s	0.164391,0.349492
	dc.s	0.179042,0.371475
	dc.s	0.164391,0.349492
	dc.s	0.153532,0.344691
	dc.s	0.469329,0.531624
	dc.s	0.483761,0.492143
	dc.s	0.485730,0.494959
	dc.s	0.240622,0.811341
	dc.s	0.249928,0.843600
	dc.s	0.256171,0.836184
	dc.s	0.179042,0.371475
	dc.s	0.156393,0.355842
	dc.s	0.151593,0.364010
	dc.s	0.462836,0.562856
	dc.s	0.469329,0.531624
	dc.s	0.485730,0.494959
	dc.s	0.462836,0.562856
	dc.s	0.492916,0.488032
	dc.s	0.472109,0.548103
	dc.s	0.462836,0.562856
	dc.s	0.485730,0.494959
	dc.s	0.492916,0.488032
	dc.s	0.455500,0.522221
	dc.s	0.451113,0.559421
	dc.s	0.444907,0.559251
	dc.s	0.455500,0.522221
	dc.s	0.463218,0.516888
	dc.s	0.451113,0.559421
	dc.s	0.447319,0.529415
	dc.s	0.455500,0.522221
	dc.s	0.440428,0.550928
	dc.s	0.455500,0.522221
	dc.s	0.444907,0.559251
	dc.s	0.440428,0.550928
	dc.s	0.267970,0.834392
	dc.s	0.256171,0.836184
	dc.s	0.264268,0.840236
	dc.s	0.153778,0.367859
	dc.s	0.151593,0.364010
	dc.s	0.136723,0.365822
	dc.s	0.151593,0.364010
	dc.s	0.151067,0.356736
	dc.s	0.136723,0.365822
	dc.s	0.485730,0.494959
	dc.s	0.486678,0.475522
	dc.s	0.490006,0.475965
	dc.s	0.492916,0.488032
	dc.s	0.485730,0.494959
	dc.s	0.490006,0.475965
	dc.s	0.440428,0.550928
	dc.s	0.444907,0.559251
	dc.s	0.438198,0.572603
	dc.s	0.381817,0.575849
	dc.s	0.375149,0.574399
	dc.s	0.376779,0.579140
	dc.s	0.381817,0.575849
	dc.s	0.357012,0.556755
	dc.s	0.375149,0.574399
	dc.s	0.256171,0.836184
	dc.s	0.260729,0.845385
	dc.s	0.264268,0.840236
	dc.s	0.260729,0.845385
	dc.s	0.265791,0.846147
	dc.s	0.264268,0.840236
	dc.s	0.375149,0.574399
	dc.s	0.345342,0.563672
	dc.s	0.375575,0.580510
	dc.s	0.151067,0.356736
	dc.s	0.123402,0.357781
	dc.s	0.136723,0.365822
	dc.s	0.136723,0.365822
	dc.s	0.123402,0.357781
	dc.s	0.118439,0.368400
	dc.s	0.118439,0.368400
	dc.s	0.091889,0.368840
	dc.s	0.091644,0.374996
	dc.s	0.123402,0.357781
	dc.s	0.091889,0.368840
	dc.s	0.118439,0.368400
	dc.s	0.123402,0.357781
	dc.s	0.066251,0.371244
	dc.s	0.091889,0.368840
	dc.s	0.486678,0.475522
	dc.s	0.486750,0.457013
	dc.s	0.490006,0.475965
	dc.s	0.451113,0.559421
	dc.s	0.450983,0.572693
	dc.s	0.449685,0.592322
	dc.s	0.486750,0.457013
	dc.s	0.480892,0.434017
	dc.s	0.484899,0.427142
	dc.s	0.492916,0.488032
	dc.s	0.486750,0.457013
	dc.s	0.484899,0.427142
	dc.s	0.451113,0.559421
	dc.s	0.449890,0.622761
	dc.s	0.444245,0.586084
	dc.s	0.451113,0.559421
	dc.s	0.444245,0.586084
	dc.s	0.444907,0.559251
	dc.s	0.438198,0.572603
	dc.s	0.444245,0.586084
	dc.s	0.437075,0.593643
	dc.s	0.444907,0.559251
	dc.s	0.444245,0.586084
	dc.s	0.438198,0.572603
	dc.s	0.444245,0.586084
	dc.s	0.449890,0.622761
	dc.s	0.437075,0.593643
	dc.s	0.437075,0.593643
	dc.s	0.449890,0.622761
	dc.s	0.441948,0.621249
	dc.s	0.375149,0.574399
	dc.s	0.357012,0.556755
	dc.s	0.338500,0.556755
	dc.s	0.357012,0.556755
	dc.s	0.334941,0.550308
	dc.s	0.338500,0.556755
	dc.s	0.152417,0.353889
	dc.s	0.118817,0.354431
	dc.s	0.123402,0.357781
	dc.s	0.123402,0.357781
	dc.s	0.118817,0.354431
	dc.s	0.066251,0.371244
	dc.s	0.338500,0.556755
	dc.s	0.307174,0.551238
	dc.s	0.290391,0.555432
	dc.s	0.334941,0.550308
	dc.s	0.309855,0.547467
	dc.s	0.307174,0.551238
	dc.s	0.334941,0.550308
	dc.s	0.307174,0.551238
	dc.s	0.338500,0.556755
	dc.s	0.091889,0.368840
	dc.s	0.010514,0.398947
	dc.s	0.015562,0.398986
	dc.s	0.091889,0.368840
	dc.s	0.066251,0.371244
	dc.s	0.010514,0.398947
	dc.s	0.091644,0.374996
	dc.s	0.091889,0.368840
	dc.s	0.015562,0.398986
	dc.s	0.484899,0.427142
	dc.s	0.480892,0.434017
	dc.s	0.465818,0.387785
	dc.s	0.480892,0.434017
	dc.s	0.456915,0.375350
	dc.s	0.465818,0.387785
	dc.s	0.480892,0.434017
	dc.s	0.455071,0.375445
	dc.s	0.456915,0.375350
	dc.s	0.449890,0.622761
	dc.s	0.463510,0.678018
	dc.s	0.454778,0.670461
	dc.s	0.449890,0.622761
	dc.s	0.454778,0.670461
	dc.s	0.441948,0.621249
	dc.s	0.463510,0.678018
	dc.s	0.465609,0.697852
	dc.s	0.454778,0.670461
	dc.s	0.441948,0.621249
	dc.s	0.454778,0.670461
	dc.s	0.440544,0.623728
	dc.s	0.268282,0.551084
	dc.s	0.243682,0.558849
	dc.s	0.290391,0.555432
	dc.s	0.307174,0.551238
	dc.s	0.268282,0.551084
	dc.s	0.290391,0.555432
	dc.s	0.268282,0.551084
	dc.s	0.247216,0.554910
	dc.s	0.243682,0.558849
	dc.s	0.190511,0.885747
	dc.s	0.180675,0.876229
	dc.s	0.189203,0.891220
	dc.s	0.189203,0.891220
	dc.s	0.180675,0.876229
	dc.s	0.178493,0.877930
	dc.s	0.178330,0.359155
	dc.s	0.168325,0.349893
	dc.s	0.164391,0.349492
	dc.s	0.189203,0.891220
	dc.s	0.178493,0.877930
	dc.s	0.185359,0.891209
	dc.s	0.071140,0.359743
	dc.s	0.059891,0.347710
	dc.s	0.067559,0.363304
	dc.s	0.071140,0.359743
	dc.s	0.056103,0.345587
	dc.s	0.059891,0.347710
	dc.s	0.180675,0.876229
	dc.s	0.157516,0.860549
	dc.s	0.178493,0.877930
	dc.s	0.067559,0.363304
	dc.s	0.059891,0.347710
	dc.s	0.052502,0.355506
	dc.s	0.240430,0.833299
	dc.s	0.238231,0.855034
	dc.s	0.249928,0.843600
	dc.s	0.440428,0.550928
	dc.s	0.430110,0.554344
	dc.s	0.431207,0.548377
	dc.s	0.190511,0.885747
	dc.s	0.175947,0.862495
	dc.s	0.180675,0.876229
	dc.s	0.447319,0.529415
	dc.s	0.440428,0.550928
	dc.s	0.431207,0.548377
	dc.s	0.180675,0.876229
	dc.s	0.175947,0.862495
	dc.s	0.155064,0.853467
	dc.s	0.180675,0.876229
	dc.s	0.155064,0.853467
	dc.s	0.157516,0.860549
	dc.s	0.431207,0.548377
	dc.s	0.406204,0.564044
	dc.s	0.406115,0.561810
	dc.s	0.431207,0.548377
	dc.s	0.430110,0.554344
	dc.s	0.406204,0.564044
	dc.s	0.256171,0.836184
	dc.s	0.249928,0.843600
	dc.s	0.260729,0.845385
	dc.s	0.260729,0.845385
	dc.s	0.249928,0.843600
	dc.s	0.254397,0.848241
	dc.s	0.440428,0.550928
	dc.s	0.437058,0.554738
	dc.s	0.430110,0.554344
	dc.s	0.249928,0.843600
	dc.s	0.238231,0.855034
	dc.s	0.254397,0.848241
	dc.s	0.254397,0.848241
	dc.s	0.238231,0.855034
	dc.s	0.239599,0.857745
	dc.s	0.154201,0.850984
	dc.s	0.131980,0.842571
	dc.s	0.155064,0.853467
	dc.s	0.059891,0.347710
	dc.s	0.056103,0.345587
	dc.s	0.027620,0.367533
	dc.s	0.234751,0.848729
	dc.s	0.224592,0.858232
	dc.s	0.238231,0.855034
	dc.s	0.238231,0.855034
	dc.s	0.221108,0.864547
	dc.s	0.239599,0.857745
	dc.s	0.406204,0.564044
	dc.s	0.372846,0.590943
	dc.s	0.384162,0.580084
	dc.s	0.157516,0.860549
	dc.s	0.155064,0.853467
	dc.s	0.131980,0.842571
	dc.s	0.157516,0.860549
	dc.s	0.131980,0.842571
	dc.s	0.132432,0.848641
	dc.s	0.052502,0.355506
	dc.s	0.027620,0.367533
	dc.s	0.009795,0.378572
	dc.s	0.238231,0.855034
	dc.s	0.214995,0.859592
	dc.s	0.221108,0.864547
	dc.s	0.131980,0.842571
	dc.s	0.117425,0.839421
	dc.s	0.115499,0.844999
	dc.s	0.131980,0.842571
	dc.s	0.115499,0.844999
	dc.s	0.132432,0.848641
	dc.s	0.214995,0.859592
	dc.s	0.201144,0.860784
	dc.s	0.221108,0.864547
	dc.s	0.115499,0.844999
	dc.s	0.117425,0.839421
	dc.s	0.098241,0.843851
	dc.s	0.112417,0.894894
	dc.s	0.112259,0.933201
	dc.s	0.119820,0.928616
	dc.s	0.112417,0.894894
	dc.s	0.105106,0.900728
	dc.s	0.112259,0.933201
	dc.s	0.124686,0.890876
	dc.s	0.119820,0.928616
	dc.s	0.126934,0.922396
	dc.s	0.124686,0.890876
	dc.s	0.126934,0.922396
	dc.s	0.131216,0.888504
	dc.s	0.112417,0.894894
	dc.s	0.119820,0.928616
	dc.s	0.124686,0.890876
	dc.s	0.105106,0.900728
	dc.s	0.111300,0.980060
	dc.s	0.112259,0.933201
	dc.s	0.131216,0.888504
	dc.s	0.126934,0.922396
	dc.s	0.129234,0.886864
	dc.s	0.123806,0.881745
	dc.s	0.121852,0.985912
	dc.s	0.118793,0.989345
	dc.s	0.123806,0.881745
	dc.s	0.129234,0.886864
	dc.s	0.121852,0.985912
	dc.s	0.129234,0.886864
	dc.s	0.126934,0.922396
	dc.s	0.121852,0.985912
	dc.s	0.125678,0.459097
	dc.s	0.131900,0.455850
	dc.s	0.126260,0.505208
	dc.s	0.131900,0.455850
	dc.s	0.131629,0.560869
	dc.s	0.126260,0.505208
	dc.s	0.137089,0.453294
	dc.s	0.135384,0.549199
	dc.s	0.131629,0.560869
	dc.s	0.137089,0.453294
	dc.s	0.141823,0.456475
	dc.s	0.135384,0.549199
	dc.s	0.131900,0.455850
	dc.s	0.137089,0.453294
	dc.s	0.131629,0.560869
	dc.s	0.175550,0.900441
	dc.s	0.180869,0.952145
	dc.s	0.169495,0.900123
	dc.s	0.183034,0.901880
	dc.s	0.180869,0.952145
	dc.s	0.175550,0.900441
	dc.s	0.162625,0.899334
	dc.s	0.167409,0.943601
	dc.s	0.158407,0.909740
	dc.s	0.162625,0.899334
	dc.s	0.169495,0.900123
	dc.s	0.167409,0.943601
	dc.s	0.169495,0.900123
	dc.s	0.177653,0.991412
	dc.s	0.167409,0.943601
	dc.s	0.158407,0.909740
	dc.s	0.167409,0.943601
	dc.s	0.167059,0.989638
	dc.s	0.169495,0.900123
	dc.s	0.180869,0.952145
	dc.s	0.177653,0.991412
	dc.s	0.320284,0.936835
	dc.s	0.317169,0.973682
	dc.s	0.328677,0.952765
	dc.s	0.320284,0.936835
	dc.s	0.308951,0.974966
	dc.s	0.317169,0.973682
	dc.s	0.351235,0.955829
	dc.s	0.328254,0.977385
	dc.s	0.334263,0.979118
	dc.s	0.351235,0.955829
	dc.s	0.340474,0.957857
	dc.s	0.328254,0.977385
	dc.s	0.328677,0.952765
	dc.s	0.328254,0.977385
	dc.s	0.340474,0.957857
	dc.s	0.328677,0.952765
	dc.s	0.317169,0.973682
	dc.s	0.328254,0.977385
	dc.s	0.244812,0.702216
	dc.s	0.270752,0.730069
	dc.s	0.269475,0.744118
	dc.s	0.259296,0.701835
	dc.s	0.270752,0.730069
	dc.s	0.244812,0.702216
	dc.s	0.279514,0.728494
	dc.s	0.259296,0.701835
	dc.s	0.287095,0.726653
	dc.s	0.279514,0.728494
	dc.s	0.270752,0.730069
	dc.s	0.259296,0.701835
	dc.s	0.064428,0.722769
	dc.s	0.043295,0.744118
	dc.s	0.064537,0.722313
	dc.s	0.064537,0.722313
	dc.s	0.043295,0.744118
	dc.s	0.042402,0.741440
	dc.s	0.063151,0.702917
	dc.s	0.042402,0.741440
	dc.s	0.040320,0.733522
	dc.s	0.063151,0.702917
	dc.s	0.064423,0.713427
	dc.s	0.042402,0.741440
	dc.s	0.064423,0.713427
	dc.s	0.064537,0.722313
	dc.s	0.042402,0.741440
	dc.s	0.063151,0.702917
	dc.s	0.040320,0.733522
	dc.s	0.037619,0.726655
	dc.s	0.063151,0.702917
	dc.s	0.037619,0.726655
	dc.s	0.050961,0.703221
	dc.s	0.034635,0.702103
	dc.s	0.050961,0.703221
	dc.s	0.037619,0.726655
	dc.s	0.034635,0.702103
	dc.s	0.037619,0.726655
	dc.s	0.030687,0.725763
	dc.s	0.034635,0.702103
	dc.s	0.030687,0.725763
	dc.s	0.022254,0.724892
	dc.s	0.028833,0.701835
	dc.s	0.034635,0.702103
	dc.s	0.022254,0.724892
	dc.s	0.243583,0.778496
	dc.s	0.249271,0.797187
	dc.s	0.236676,0.779935
	dc.s	0.236676,0.779935
	dc.s	0.249271,0.797187
	dc.s	0.244234,0.797876
	dc.s	0.236676,0.779935
	dc.s	0.244234,0.797876
	dc.s	0.229891,0.781094
	dc.s	0.076395,0.762136
	dc.s	0.069450,0.771804
	dc.s	0.070046,0.776970
	dc.s	0.064703,0.782969
	dc.s	0.064243,0.821326
	dc.s	0.066836,0.798675
	dc.s	0.069450,0.771804
	dc.s	0.064703,0.782969
	dc.s	0.066836,0.798675
	dc.s	0.446964,0.992295
	dc.s	0.421823,0.992033
	dc.s	0.442262,0.989631
	dc.s	0.283703,0.784170
	dc.s	0.280914,0.801927
	dc.s	0.286649,0.822644
	dc.s	0.442404,0.980764
	dc.s	0.421823,0.992033
	dc.s	0.439238,0.976167
	dc.s	0.442262,0.989631
	dc.s	0.421823,0.992033
	dc.s	0.442404,0.980764
	dc.s	0.430394,0.401107
	dc.s	0.381126,0.399010
	dc.s	0.397818,0.395432
	dc.s	0.266721,0.768796
	dc.s	0.262499,0.767817
	dc.s	0.270303,0.798429
	dc.s	0.453638,0.971667
	dc.s	0.439238,0.976167
	dc.s	0.407200,0.980087
	dc.s	0.274247,0.781854
	dc.s	0.280914,0.801927
	dc.s	0.283703,0.784170
	dc.s	0.266721,0.768796
	dc.s	0.270303,0.798429
	dc.s	0.274247,0.781854
	dc.s	0.274247,0.781854
	dc.s	0.270303,0.798429
	dc.s	0.280914,0.801927
	dc.s	0.280914,0.801927
	dc.s	0.287526,0.871540
	dc.s	0.286649,0.822644
	dc.s	0.066836,0.798675
	dc.s	0.064243,0.821326
	dc.s	0.070115,0.890440
	dc.s	0.064243,0.821326
	dc.s	0.066288,0.869774
	dc.s	0.070115,0.890440
	dc.s	0.439238,0.976167
	dc.s	0.421823,0.992033
	dc.s	0.394403,0.982859
	dc.s	0.394403,0.982859
	dc.s	0.330649,0.990346
	dc.s	0.343182,0.985526
	dc.s	0.421823,0.992033
	dc.s	0.330649,0.990346
	dc.s	0.394403,0.982859
	dc.s	0.421823,0.992033
	dc.s	0.332325,0.994284
	dc.s	0.330649,0.990346
	dc.s	0.415651,0.401110
	dc.s	0.368635,0.401536
	dc.s	0.381126,0.399010
	dc.s	0.381126,0.399010
	dc.s	0.315053,0.405038
	dc.s	0.305888,0.402665
	dc.s	0.397818,0.395432
	dc.s	0.381126,0.399010
	dc.s	0.305888,0.402665
	dc.s	0.394403,0.982859
	dc.s	0.343182,0.985526
	dc.s	0.407200,0.980087
	dc.s	0.280914,0.801927
	dc.s	0.283848,0.908476
	dc.s	0.287526,0.871540
	dc.s	0.270303,0.798429
	dc.s	0.279645,0.890289
	dc.s	0.280914,0.801927
	dc.s	0.280914,0.801927
	dc.s	0.279645,0.890289
	dc.s	0.283848,0.908476
	dc.s	0.066288,0.869774
	dc.s	0.067811,0.906990
	dc.s	0.069693,0.932930
	dc.s	0.066288,0.869774
	dc.s	0.069693,0.932930
	dc.s	0.070115,0.890440
	dc.s	0.281770,0.934509
	dc.s	0.283848,0.908476
	dc.s	0.272130,0.960743
	dc.s	0.343182,0.985526
	dc.s	0.330649,0.990346
	dc.s	0.297811,0.985040
	dc.s	0.330649,0.990346
	dc.s	0.332325,0.994284
	dc.s	0.297811,0.985040
	dc.s	0.332325,0.994284
	dc.s	0.292396,0.988939
	dc.s	0.297811,0.985040
	dc.s	0.343182,0.985526
	dc.s	0.297811,0.985040
	dc.s	0.304656,0.983298
	dc.s	0.315053,0.405038
	dc.s	0.273695,0.406648
	dc.s	0.305888,0.402665
	dc.s	0.304656,0.983298
	dc.s	0.297811,0.985040
	dc.s	0.269100,0.976505
	dc.s	0.283848,0.908476
	dc.s	0.279645,0.890289
	dc.s	0.276891,0.927126
	dc.s	0.283848,0.908476
	dc.s	0.276891,0.927126
	dc.s	0.272130,0.960743
	dc.s	0.305888,0.402665
	dc.s	0.273695,0.406648
	dc.s	0.267765,0.404621
	dc.s	0.069693,0.932930
	dc.s	0.067363,0.961270
	dc.s	0.070226,0.959045
	dc.s	0.070226,0.959045
	dc.s	0.067363,0.961270
	dc.s	0.066210,0.976840
	dc.s	0.297811,0.985040
	dc.s	0.292396,0.988939
	dc.s	0.269100,0.976505
	dc.s	0.273695,0.406648
	dc.s	0.234161,0.406422
	dc.s	0.242590,0.404739
	dc.s	0.234161,0.406422
	dc.s	0.215451,0.402174
	dc.s	0.242590,0.404739
	dc.s	0.275975,0.921934
	dc.s	0.269727,0.950334
	dc.s	0.276891,0.927126
	dc.s	0.276891,0.927126
	dc.s	0.269727,0.950334
	dc.s	0.272130,0.960743
	dc.s	0.272130,0.960743
	dc.s	0.269727,0.950334
	dc.s	0.262143,0.974532
	dc.s	0.141114,0.561315
	dc.s	0.151769,0.545919
	dc.s	0.146811,0.524940
	dc.s	0.028105,0.418636
	dc.s	0.024715,0.457948
	dc.s	0.020396,0.462067
	dc.s	0.080261,0.559101
	dc.s	0.079527,0.534890
	dc.s	0.083102,0.538955
	dc.s	0.071432,0.560264
	dc.s	0.079527,0.534890
	dc.s	0.080261,0.559101
	dc.s	0.010537,0.410886
	dc.s	0.009166,0.481947
	dc.s	0.013631,0.446147
	dc.s	0.010537,0.410886
	dc.s	0.004891,0.497265
	dc.s	0.009166,0.481947
	dc.s	0.010537,0.410886
	dc.s	0.003360,0.473472
	dc.s	0.004891,0.497265
	dc.s	0.151769,0.545919
	dc.s	0.154672,0.510677
	dc.s	0.146811,0.524940
	dc.s	0.146811,0.524940
	dc.s	0.154672,0.510677
	dc.s	0.149118,0.497351
	dc.s	0.146811,0.524940
	dc.s	0.149118,0.497351
	dc.s	0.149155,0.476782
	dc.s	0.024715,0.457948
	dc.s	0.023379,0.508812
	dc.s	0.020396,0.462067
	dc.s	0.079527,0.534890
	dc.s	0.083323,0.497468
	dc.s	0.083102,0.538955
	dc.s	0.079527,0.534890
	dc.s	0.078647,0.493211
	dc.s	0.083323,0.497468
	dc.s	0.079527,0.534890
	dc.s	0.076426,0.518082
	dc.s	0.078647,0.493211
	dc.s	0.009166,0.481947
	dc.s	0.004891,0.497265
	dc.s	0.010493,0.542805
	dc.s	0.154672,0.510677
	dc.s	0.153623,0.454499
	dc.s	0.153228,0.473325
	dc.s	0.154672,0.510677
	dc.s	0.153228,0.473325
	dc.s	0.149118,0.497351
	dc.s	0.149118,0.497351
	dc.s	0.153228,0.473325
	dc.s	0.148597,0.465195
	dc.s	0.024664,0.488216
	dc.s	0.027409,0.523364
	dc.s	0.023379,0.508812
	dc.s	0.071432,0.560264
	dc.s	0.076426,0.518082
	dc.s	0.079527,0.534890
	dc.s	0.078647,0.493211
	dc.s	0.078320,0.473239
	dc.s	0.083323,0.497468
	dc.s	0.010568,0.522378
	dc.s	0.010493,0.542805
	dc.s	0.018812,0.568788
	dc.s	0.153228,0.473325
	dc.s	0.147193,0.433273
	dc.s	0.148597,0.465195
	dc.s	0.148597,0.465195
	dc.s	0.147193,0.433273
	dc.s	0.145152,0.433080
	dc.s	0.149155,0.476782
	dc.s	0.148597,0.465195
	dc.s	0.145152,0.433080
	dc.s	0.023379,0.508812
	dc.s	0.036547,0.561038
	dc.s	0.027653,0.537427
	dc.s	0.078647,0.493211
	dc.s	0.076127,0.472167
	dc.s	0.078320,0.473239
	dc.s	0.374161,0.874064
	dc.s	0.363987,0.904429
	dc.s	0.370588,0.905820
	dc.s	0.040820,0.449659
	dc.s	0.033643,0.449528
	dc.s	0.042442,0.506199
	dc.s	0.330500,0.877474
	dc.s	0.340336,0.913749
	dc.s	0.304114,0.881174
	dc.s	0.304114,0.881174
	dc.s	0.340336,0.913749
	dc.s	0.323059,0.911838
	dc.s	0.292872,0.852117
	dc.s	0.298561,0.861123
	dc.s	0.292510,0.917602
	dc.s	0.346229,0.869281
	dc.s	0.350152,0.913160
	dc.s	0.353090,0.914906
	dc.s	0.298561,0.861123
	dc.s	0.299857,0.902976
	dc.s	0.295424,0.914711
	dc.s	0.348072,0.858866
	dc.s	0.353090,0.914906
	dc.s	0.356416,0.859553
	dc.s	0.356416,0.859553
	dc.s	0.353090,0.914906
	dc.s	0.363987,0.904429
	dc.s	0.370588,0.905820
	dc.s	0.363987,0.904429
	dc.s	0.361221,0.933289
	dc.s	0.338691,0.871901
	dc.s	0.346397,0.923696
	dc.s	0.340336,0.913749
	dc.s	0.033643,0.449528
	dc.s	0.032721,0.497106
	dc.s	0.042481,0.522203
	dc.s	0.032721,0.497106
	dc.s	0.046090,0.538089
	dc.s	0.042481,0.522203
	dc.s	0.340336,0.913749
	dc.s	0.343957,0.930481
	dc.s	0.323059,0.911838
	dc.s	0.323059,0.911838
	dc.s	0.343957,0.930481
	dc.s	0.332654,0.932151
	dc.s	0.314850,0.911615
	dc.s	0.332654,0.932151
	dc.s	0.327446,0.937308
	dc.s	0.314850,0.911615
	dc.s	0.323059,0.911838
	dc.s	0.332654,0.932151
	dc.s	0.299857,0.902976
	dc.s	0.301174,0.929558
	dc.s	0.295424,0.914711
	dc.s	0.363987,0.904429
	dc.s	0.353090,0.914906
	dc.s	0.354681,0.929255
	dc.s	0.363987,0.904429
	dc.s	0.354681,0.929255
	dc.s	0.361221,0.933289
	dc.s	0.242657,0.873151
	dc.s	0.242320,0.901927
	dc.s	0.245611,0.912728
	dc.s	0.143571,0.884169
	dc.s	0.143434,0.951551
	dc.s	0.138767,0.903960
	dc.s	0.242657,0.873151
	dc.s	0.245611,0.912728
	dc.s	0.248302,0.887528
	dc.s	0.255477,0.886750
	dc.s	0.248302,0.887528
	dc.s	0.245611,0.912728
	dc.s	0.091188,0.434388
	dc.s	0.047125,0.437885
	dc.s	0.103118,0.441350
	dc.s	0.242320,0.901927
	dc.s	0.240833,0.888110
	dc.s	0.241576,0.983268
	dc.s	0.242320,0.901927
	dc.s	0.241576,0.983268
	dc.s	0.245611,0.912728
	dc.s	0.242451,0.882084
	dc.s	0.243501,0.974056
	dc.s	0.240833,0.888110
	dc.s	0.240833,0.888110
	dc.s	0.243501,0.974056
	dc.s	0.241576,0.983268
	dc.s	0.255477,0.886750
	dc.s	0.245611,0.912728
	dc.s	0.251177,0.951528
	dc.s	0.092006,0.423549
	dc.s	0.091584,0.415270
	dc.s	0.034281,0.428920
	dc.s	0.091188,0.434388
	dc.s	0.092006,0.423549
	dc.s	0.034281,0.428920
	dc.s	0.091188,0.434388
	dc.s	0.034281,0.428920
	dc.s	0.047125,0.437885
	dc.s	0.138767,0.903960
	dc.s	0.143434,0.951551
	dc.s	0.134372,0.909871
	dc.s	0.242451,0.882084
	dc.s	0.246141,0.881235
	dc.s	0.243501,0.974056
	dc.s	0.143434,0.951551
	dc.s	0.140569,0.994250
	dc.s	0.134372,0.909871
	dc.s	0.222473,0.701835
	dc.s	0.198300,0.744118
	dc.s	0.230951,0.706946
	dc.s	0.154222,0.740947
	dc.s	0.173702,0.744118
	dc.s	0.194072,0.704778
	dc.s	0.120100,0.705029
	dc.s	0.147560,0.744118
	dc.s	0.131389,0.702804
	dc.s	0.120100,0.705029
	dc.s	0.105277,0.701835
	dc.s	0.147560,0.744118
	dc.s	0.230951,0.706946
	dc.s	0.198300,0.744118
	dc.s	0.240584,0.711713
	dc.s	0.154222,0.740947
	dc.s	0.194072,0.704778
	dc.s	0.185245,0.701835
	dc.s	0.151789,0.729786
	dc.s	0.154222,0.740947
	dc.s	0.185245,0.701835
	dc.s	0.142426,0.708570
	dc.s	0.131389,0.702804
	dc.s	0.147560,0.744118
	dc.s	0.357752,0.849223
	dc.s	0.367386,0.869304
	dc.s	0.369108,0.863237
	dc.s	0.357752,0.849223
	dc.s	0.369108,0.863237
	dc.s	0.360646,0.836764
	dc.s	0.360646,0.836764
	dc.s	0.369108,0.863237
	dc.s	0.376118,0.862218
	dc.s	0.360646,0.836764
	dc.s	0.376118,0.862218
	dc.s	0.363541,0.829870
	dc.s	0.366781,0.827021
	dc.s	0.373250,0.843127
	dc.s	0.377132,0.845586
	dc.s	0.371989,0.829845
	dc.s	0.366781,0.827021
	dc.s	0.377132,0.845586
	dc.s	0.366781,0.827021
	dc.s	0.363541,0.829870
	dc.s	0.373250,0.843127
	dc.s	0.317078,0.707876
	dc.s	0.325395,0.719527
	dc.s	0.329982,0.714829
	dc.s	0.323165,0.700147
	dc.s	0.317078,0.707876
	dc.s	0.329982,0.714829
	dc.s	0.323165,0.700147
	dc.s	0.329982,0.714829
	dc.s	0.336457,0.709872
	dc.s	0.105752,0.546966
	dc.s	0.122317,0.567793
	dc.s	0.107224,0.557832
	dc.s	0.111287,0.531002
	dc.s	0.115759,0.525510
	dc.s	0.124940,0.553214
	dc.s	0.105752,0.546966
	dc.s	0.125132,0.564210
	dc.s	0.122317,0.567793
	dc.s	0.111287,0.531002
	dc.s	0.124940,0.553214
	dc.s	0.105752,0.546966
	dc.s	0.105752,0.546966
	dc.s	0.124940,0.553214
	dc.s	0.125132,0.564210
	dc.s	0.182427,0.405861
	dc.s	0.165450,0.426285
	dc.s	0.174551,0.449840
	dc.s	0.183415,0.425834
	dc.s	0.174551,0.449840
	dc.s	0.185723,0.429331
	dc.s	0.182427,0.405861
	dc.s	0.174551,0.449840
	dc.s	0.183415,0.425834
	dc.s	0.290677,0.932812
	dc.s	0.287799,0.957024
	dc.s	0.306239,0.956438
	dc.s	0.287799,0.957024
	dc.s	0.296320,0.975095
	dc.s	0.307178,0.966742
	dc.s	0.287799,0.957024
	dc.s	0.307178,0.966742
	dc.s	0.306239,0.956438
	dc.s	0.217217,0.527801
	dc.s	0.203755,0.544773
	dc.s	0.229162,0.530176
	dc.s	0.229162,0.530176
	dc.s	0.203755,0.544773
	dc.s	0.213246,0.548865
	dc.s	0.217217,0.527801
	dc.s	0.210111,0.524523
	dc.s	0.203755,0.544773
	dc.s	0.210111,0.524523
	dc.s	0.195109,0.537273
	dc.s	0.203755,0.544773
	dc.s	0.209526,0.670592
	dc.s	0.233484,0.681500
	dc.s	0.223308,0.671091
	dc.s	0.067446,0.586856
	dc.s	0.062963,0.597907
	dc.s	0.080837,0.587906
	dc.s	0.067446,0.586856
	dc.s	0.080837,0.587906
	dc.s	0.090047,0.572655
	dc.s	0.055172,0.587768
	dc.s	0.067446,0.586856
	dc.s	0.080447,0.576830
	dc.s	0.047321,0.608043
	dc.s	0.082676,0.598058
	dc.s	0.062963,0.597907
	dc.s	0.062963,0.597907
	dc.s	0.082676,0.598058
	dc.s	0.080837,0.587906
	dc.s	0.032597,0.616393
	dc.s	0.047321,0.608043
	dc.s	0.037658,0.607224
	dc.s	0.041035,0.600171
	dc.s	0.047321,0.608043
	dc.s	0.043223,0.594729
	dc.s	0.037658,0.607224
	dc.s	0.047321,0.608043
	dc.s	0.041035,0.600171
	dc.s	0.043223,0.594729
	dc.s	0.047321,0.608043
	dc.s	0.062963,0.597907
	dc.s	0.043758,0.590245
	dc.s	0.043223,0.594729
	dc.s	0.055172,0.587768
	dc.s	0.196516,0.662815
	dc.s	0.183850,0.664132
	dc.s	0.209526,0.670592
	dc.s	0.043223,0.594729
	dc.s	0.062963,0.597907
	dc.s	0.067446,0.586856
	dc.s	0.229162,0.530176
	dc.s	0.213246,0.548865
	dc.s	0.259940,0.530667
	dc.s	0.143970,0.652023
	dc.s	0.136918,0.639505
	dc.s	0.131916,0.657000
	dc.s	0.143830,0.639377
	dc.s	0.136918,0.639505
	dc.s	0.143970,0.652023
	dc.s	0.143830,0.639377
	dc.s	0.130852,0.591999
	dc.s	0.136918,0.639505
	dc.s	0.131916,0.657000
	dc.s	0.136918,0.639505
	dc.s	0.119936,0.649704
	dc.s	0.130852,0.591999
	dc.s	0.123566,0.598013
	dc.s	0.136918,0.639505
	dc.s	0.119936,0.649704
	dc.s	0.136918,0.639505
	dc.s	0.123566,0.598013
	dc.s	0.086414,0.651221
	dc.s	0.119936,0.649704
	dc.s	0.123566,0.598013
	dc.s	0.086414,0.651221
	dc.s	0.123566,0.598013
	dc.s	0.090339,0.618720
	dc.s	0.090339,0.618720
	dc.s	0.123566,0.598013
	dc.s	0.098998,0.597751
	dc.s	0.053352,0.644655
	dc.s	0.055444,0.658762
	dc.s	0.077063,0.641230
	dc.s	0.070335,0.664111
	dc.s	0.077063,0.641230
	dc.s	0.055444,0.658762
	dc.s	0.053352,0.644655
	dc.s	0.077063,0.641230
	dc.s	0.071206,0.629848
	dc.s	0.086414,0.651221
	dc.s	0.090339,0.618720
	dc.s	0.077063,0.641230
	dc.s	0.077063,0.641230
	dc.s	0.090339,0.618720
	dc.s	0.071206,0.629848
	dc.s	0.070335,0.664111
	dc.s	0.086414,0.651221
	dc.s	0.077063,0.641230
	dc.s	0.090339,0.618720
	dc.s	0.098998,0.597751
	dc.s	0.082676,0.598058
	dc.s	0.054850,0.629724
	dc.s	0.090339,0.618720
	dc.s	0.082676,0.598058
	dc.s	0.054850,0.629724
	dc.s	0.071206,0.629848
	dc.s	0.090339,0.618720
	dc.s	0.047321,0.608043
	dc.s	0.054850,0.629724
	dc.s	0.082676,0.598058
	dc.s	0.032272,0.626135
	dc.s	0.054850,0.629724
	dc.s	0.047321,0.608043
	dc.s	0.053352,0.644655
	dc.s	0.043793,0.657126
	dc.s	0.055444,0.658762
	dc.s	0.037318,0.645575
	dc.s	0.031021,0.657094
	dc.s	0.053352,0.644655
	dc.s	0.053352,0.644655
	dc.s	0.031021,0.657094
	dc.s	0.043793,0.657126
	dc.s	0.054850,0.629724
	dc.s	0.037318,0.645575
	dc.s	0.053352,0.644655
	dc.s	0.054850,0.629724
	dc.s	0.053352,0.644655
	dc.s	0.071206,0.629848
	dc.s	0.353397,0.695743
	dc.s	0.365486,0.701577
	dc.s	0.351283,0.704748
	dc.s	0.365486,0.701577
	dc.s	0.362527,0.713485
	dc.s	0.351283,0.704748
	dc.s	0.030580,0.636808
	dc.s	0.027474,0.647740
	dc.s	0.037318,0.645575
	dc.s	0.030580,0.636808
	dc.s	0.037318,0.645575
	dc.s	0.054850,0.629724
	dc.s	0.032597,0.616393
	dc.s	0.032272,0.626135
	dc.s	0.047321,0.608043
	dc.s	0.030580,0.636808
	dc.s	0.054850,0.629724
	dc.s	0.032272,0.626135
	dc.s	0.131916,0.657000
	dc.s	0.138379,0.664997
	dc.s	0.143970,0.652023
	dc.s	0.126212,0.668590
	dc.s	0.138379,0.664997
	dc.s	0.131916,0.657000
	dc.s	0.123165,0.677427
	dc.s	0.135459,0.677243
	dc.s	0.126212,0.668590
	dc.s	0.135459,0.677243
	dc.s	0.136064,0.672614
	dc.s	0.126212,0.668590
	dc.s	0.126212,0.668590
	dc.s	0.136064,0.672614
	dc.s	0.138379,0.664997
	dc.s	0.126212,0.668590
	dc.s	0.083893,0.668603
	dc.s	0.106374,0.680870
	dc.s	0.106374,0.680870
	dc.s	0.123165,0.677427
	dc.s	0.126212,0.668590
	dc.s	0.126212,0.668590
	dc.s	0.131916,0.657000
	dc.s	0.119936,0.649704
	dc.s	0.126212,0.668590
	dc.s	0.119936,0.649704
	dc.s	0.083893,0.668603
	dc.s	0.083893,0.668603
	dc.s	0.119936,0.649704
	dc.s	0.086414,0.651221
	dc.s	0.080992,0.684462
	dc.s	0.106374,0.680870
	dc.s	0.083893,0.668603
	dc.s	0.346899,0.532309
	dc.s	0.362104,0.534657
	dc.s	0.348002,0.541206
	dc.s	0.361825,0.525595
	dc.s	0.362104,0.534657
	dc.s	0.346899,0.532309
	dc.s	0.069575,0.678179
	dc.s	0.055539,0.674306
	dc.s	0.055440,0.683924
	dc.s	0.080992,0.684462
	dc.s	0.083893,0.668603
	dc.s	0.069575,0.678179
	dc.s	0.373493,0.523401
	dc.s	0.362104,0.534657
	dc.s	0.361825,0.525595
	dc.s	0.070335,0.664111
	dc.s	0.055444,0.658762
	dc.s	0.055539,0.674306
	dc.s	0.083893,0.668603
	dc.s	0.086414,0.651221
	dc.s	0.070335,0.664111
	dc.s	0.083893,0.668603
	dc.s	0.070335,0.664111
	dc.s	0.069575,0.678179
	dc.s	0.069575,0.678179
	dc.s	0.070335,0.664111
	dc.s	0.055539,0.674306
	dc.s	0.181049,0.751368
	dc.s	0.204421,0.756383
	dc.s	0.207543,0.760823
	dc.s	0.179093,0.773660
	dc.s	0.181049,0.751368
	dc.s	0.207543,0.760823
	dc.s	0.179093,0.773660
	dc.s	0.207543,0.760823
	dc.s	0.212532,0.772984
	dc.s	0.146634,0.765030
	dc.s	0.149883,0.749520
	dc.s	0.166568,0.768951
	dc.s	0.166568,0.768951
	dc.s	0.149883,0.749520
	dc.s	0.181049,0.751368
	dc.s	0.146634,0.765030
	dc.s	0.121459,0.752196
	dc.s	0.149883,0.749520
	dc.s	0.009608,0.116720
	dc.s	0.007824,0.090705
	dc.s	0.005369,0.114029
	dc.s	0.129463,0.773808
	dc.s	0.121459,0.752196
	dc.s	0.146634,0.765030
	dc.s	0.179093,0.773660
	dc.s	0.166568,0.768951
	dc.s	0.181049,0.751368
	dc.s	0.009608,0.116720
	dc.s	0.005369,0.114029
	dc.s	0.008296,0.140957
	dc.s	0.179397,0.577814
	dc.s	0.182421,0.580435
	dc.s	0.199653,0.575384
	dc.s	0.129463,0.773808
	dc.s	0.095457,0.773634
	dc.s	0.099924,0.761342
	dc.s	0.129463,0.773808
	dc.s	0.099924,0.761342
	dc.s	0.121459,0.752196
	dc.s	0.179093,0.773660
	dc.s	0.212532,0.772984
	dc.s	0.185531,0.782174
	dc.s	0.186842,0.790952
	dc.s	0.185531,0.782174
	dc.s	0.214893,0.787494
	dc.s	0.185531,0.782174
	dc.s	0.212532,0.772984
	dc.s	0.214893,0.787494
	dc.s	0.179333,0.808333
	dc.s	0.185656,0.799756
	dc.s	0.213107,0.809255
	dc.s	0.185656,0.799756
	dc.s	0.214665,0.798773
	dc.s	0.213107,0.809255
	dc.s	0.186842,0.790952
	dc.s	0.214893,0.787494
	dc.s	0.185656,0.799756
	dc.s	0.185656,0.799756
	dc.s	0.214893,0.787494
	dc.s	0.214665,0.798773
	dc.s	0.302945,0.721039
	dc.s	0.303419,0.709304
	dc.s	0.310527,0.717816
	dc.s	0.303419,0.709304
	dc.s	0.293440,0.718462
	dc.s	0.291147,0.701659
	dc.s	0.302945,0.721039
	dc.s	0.293440,0.718462
	dc.s	0.303419,0.709304
	dc.s	0.484086,0.065915
	dc.s	0.485234,0.069766
	dc.s	0.479732,0.067635
	dc.s	0.485234,0.069766
	dc.s	0.483616,0.072903
	dc.s	0.479732,0.067635
	dc.s	0.129463,0.773808
	dc.s	0.123116,0.782436
	dc.s	0.095457,0.773634
	dc.s	0.121919,0.791309
	dc.s	0.093349,0.788737
	dc.s	0.123116,0.782436
	dc.s	0.123116,0.782436
	dc.s	0.093349,0.788737
	dc.s	0.095457,0.773634
	dc.s	0.123103,0.800241
	dc.s	0.094330,0.807862
	dc.s	0.093349,0.788737
	dc.s	0.129414,0.808760
	dc.s	0.094330,0.807862
	dc.s	0.123103,0.800241
	dc.s	0.121919,0.791309
	dc.s	0.123103,0.800241
	dc.s	0.093349,0.788737
	dc.s	0.179333,0.808333
	dc.s	0.213107,0.809255
	dc.s	0.208641,0.821075
	dc.s	0.179333,0.808333
	dc.s	0.208641,0.821075
	dc.s	0.182515,0.831179
	dc.s	0.427865,0.435235
	dc.s	0.424745,0.438131
	dc.s	0.404737,0.431361
	dc.s	0.008601,0.044739
	dc.s	0.007361,0.070384
	dc.s	0.004582,0.047017
	dc.s	0.179333,0.808333
	dc.s	0.182515,0.831179
	dc.s	0.161620,0.817237
	dc.s	0.129414,0.808760
	dc.s	0.142011,0.813421
	dc.s	0.120571,0.831556
	dc.s	0.008601,0.044739
	dc.s	0.004582,0.047017
	dc.s	0.006745,0.021012
	dc.s	0.161620,0.817237
	dc.s	0.153793,0.833240
	dc.s	0.142011,0.813421
	dc.s	0.142011,0.813421
	dc.s	0.153793,0.833240
	dc.s	0.120571,0.831556
	dc.s	0.161620,0.817237
	dc.s	0.182515,0.831179
	dc.s	0.153793,0.833240
	dc.s	0.129414,0.808760
	dc.s	0.120571,0.831556
	dc.s	0.099187,0.823102
	dc.s	0.129414,0.808760
	dc.s	0.099187,0.823102
	dc.s	0.094330,0.807862
	dc.s	0.099187,0.823102
	dc.s	0.120571,0.831556
	dc.s	0.101942,0.827693
	dc.s	0.289687,0.657941
	dc.s	0.281424,0.644508
	dc.s	0.284848,0.659230
	dc.s	0.267011,0.645885
	dc.s	0.265666,0.665703
	dc.s	0.273479,0.663798
	dc.s	0.281424,0.644508
	dc.s	0.273479,0.663798
	dc.s	0.284848,0.659230
	dc.s	0.281424,0.644508
	dc.s	0.267011,0.645885
	dc.s	0.273479,0.663798
	dc.s	0.211987,0.491526
	dc.s	0.202927,0.505100
	dc.s	0.209767,0.519962
	dc.s	0.256236,0.666246
	dc.s	0.248617,0.672939
	dc.s	0.258598,0.673385
	dc.s	0.212474,0.649119
	dc.s	0.223570,0.664463
	dc.s	0.234819,0.665644
	dc.s	0.234819,0.665644
	dc.s	0.238330,0.672672
	dc.s	0.248617,0.672939
	dc.s	0.215975,0.633366
	dc.s	0.248617,0.672939
	dc.s	0.242540,0.634246
	dc.s	0.215975,0.633366
	dc.s	0.234819,0.665644
	dc.s	0.248617,0.672939
	dc.s	0.215975,0.633366
	dc.s	0.212474,0.649119
	dc.s	0.234819,0.665644
	dc.s	0.242540,0.634246
	dc.s	0.256236,0.666246
	dc.s	0.265666,0.665703
	dc.s	0.267011,0.645885
	dc.s	0.242540,0.634246
	dc.s	0.265666,0.665703
	dc.s	0.242540,0.634246
	dc.s	0.248617,0.672939
	dc.s	0.256236,0.666246
	dc.s	0.177963,0.645433
	dc.s	0.194271,0.657902
	dc.s	0.223570,0.664463
	dc.s	0.212474,0.649119
	dc.s	0.177963,0.645433
	dc.s	0.223570,0.664463
	dc.s	0.180943,0.651205
	dc.s	0.194271,0.657902
	dc.s	0.177963,0.645433
	dc.s	0.180943,0.651205
	dc.s	0.183385,0.656901
	dc.s	0.194271,0.657902
	dc.s	0.191752,0.626202
	dc.s	0.172656,0.636482
	dc.s	0.177963,0.645433
	dc.s	0.191752,0.626202
	dc.s	0.177963,0.645433
	dc.s	0.212474,0.649119
	dc.s	0.191752,0.626202
	dc.s	0.212474,0.649119
	dc.s	0.215975,0.633366
	dc.s	0.288159,0.614273
	dc.s	0.281424,0.644508
	dc.s	0.289756,0.632240
	dc.s	0.272310,0.601711
	dc.s	0.267011,0.645885
	dc.s	0.281424,0.644508
	dc.s	0.272310,0.601711
	dc.s	0.255883,0.609931
	dc.s	0.267011,0.645885
	dc.s	0.284140,0.594073
	dc.s	0.272310,0.601711
	dc.s	0.288159,0.614273
	dc.s	0.272310,0.601711
	dc.s	0.281424,0.644508
	dc.s	0.288159,0.614273
	dc.s	0.255883,0.609931
	dc.s	0.242540,0.634246
	dc.s	0.267011,0.645885
	dc.s	0.217124,0.603150
	dc.s	0.215975,0.633366
	dc.s	0.242540,0.634246
	dc.s	0.217124,0.603150
	dc.s	0.242540,0.634246
	dc.s	0.255883,0.609931
	dc.s	0.173230,0.605105
	dc.s	0.172656,0.636482
	dc.s	0.191752,0.626202
	dc.s	0.193071,0.605026
	dc.s	0.173230,0.605105
	dc.s	0.191752,0.626202
	dc.s	0.193071,0.605026
	dc.s	0.191752,0.626202
	dc.s	0.215975,0.633366
	dc.s	0.217124,0.603150
	dc.s	0.193071,0.605026
	dc.s	0.215975,0.633366
	dc.s	0.265614,0.581496
	dc.s	0.272310,0.601711
	dc.s	0.284140,0.594073
	dc.s	0.241836,0.587604
	dc.s	0.255883,0.609931
	dc.s	0.272310,0.601711
	dc.s	0.265614,0.581496
	dc.s	0.241836,0.587604
	dc.s	0.272310,0.601711
	dc.s	0.235815,0.578344
	dc.s	0.241836,0.587604
	dc.s	0.265614,0.581496
	dc.s	0.273904,0.583283
	dc.s	0.284140,0.594073
	dc.s	0.279455,0.583956
	dc.s	0.273904,0.583283
	dc.s	0.265614,0.581496
	dc.s	0.284140,0.594073
	dc.s	0.241836,0.587604
	dc.s	0.217124,0.603150
	dc.s	0.255883,0.609931
	dc.s	0.212688,0.588333
	dc.s	0.217124,0.603150
	dc.s	0.241836,0.587604
	dc.s	0.235815,0.578344
	dc.s	0.212688,0.588333
	dc.s	0.241836,0.587604
	dc.s	0.235815,0.578344
	dc.s	0.195153,0.581186
	dc.s	0.212688,0.588333
	dc.s	0.194920,0.589859
	dc.s	0.193071,0.605026
	dc.s	0.217124,0.603150
	dc.s	0.194920,0.589859
	dc.s	0.217124,0.603150
	dc.s	0.212688,0.588333
	dc.s	0.176114,0.591850
	dc.s	0.173230,0.605105
	dc.s	0.193071,0.605026
	dc.s	0.194920,0.589859
	dc.s	0.176114,0.591850
	dc.s	0.193071,0.605026
	dc.s	0.185684,0.583100
	dc.s	0.176114,0.591850
	dc.s	0.194920,0.589859
	dc.s	0.195153,0.581186
	dc.s	0.185684,0.583100
	dc.s	0.194920,0.589859
	dc.s	0.185684,0.583100
	dc.s	0.180198,0.583730
	dc.s	0.176114,0.591850
	dc.s	0.195153,0.581186
	dc.s	0.194920,0.589859
	dc.s	0.212688,0.588333
	dc.s	0.329837,0.679836
	dc.s	0.334892,0.688634
	dc.s	0.326592,0.690264
	dc.s	0.343740,0.687815
	dc.s	0.334892,0.688634
	dc.s	0.329837,0.679836
	dc.s	0.362398,0.677680
	dc.s	0.362535,0.688370
	dc.s	0.343740,0.687815
	dc.s	0.361489,0.661569
	dc.s	0.329837,0.679836
	dc.s	0.325878,0.667237
	dc.s	0.329837,0.679836
	dc.s	0.362398,0.677680
	dc.s	0.343740,0.687815
	dc.s	0.361489,0.661569
	dc.s	0.362398,0.677680
	dc.s	0.329837,0.679836
	dc.s	0.381639,0.686369
	dc.s	0.382138,0.700153
	dc.s	0.371244,0.687764
	dc.s	0.371244,0.687764
	dc.s	0.382138,0.700153
	dc.s	0.374214,0.701318
	dc.s	0.375317,0.676884
	dc.s	0.381639,0.686369
	dc.s	0.371244,0.687764
	dc.s	0.362398,0.677680
	dc.s	0.371244,0.687764
	dc.s	0.362535,0.688370
	dc.s	0.375317,0.676884
	dc.s	0.371244,0.687764
	dc.s	0.362398,0.677680
	dc.s	0.388138,0.685074
	dc.s	0.390204,0.698705
	dc.s	0.381639,0.686369
	dc.s	0.381639,0.686369
	dc.s	0.390204,0.698705
	dc.s	0.382138,0.700153
	dc.s	0.388069,0.672763
	dc.s	0.388138,0.685074
	dc.s	0.381639,0.686369
	dc.s	0.388069,0.672763
	dc.s	0.381639,0.686369
	dc.s	0.375317,0.676884
	dc.s	0.389576,0.657908
	dc.s	0.388069,0.672763
	dc.s	0.377943,0.657852
	dc.s	0.377943,0.657852
	dc.s	0.388069,0.672763
	dc.s	0.375317,0.676884
	dc.s	0.377943,0.657852
	dc.s	0.375317,0.676884
	dc.s	0.361489,0.661569
	dc.s	0.361489,0.661569
	dc.s	0.375317,0.676884
	dc.s	0.362398,0.677680
	dc.s	0.306965,0.636576
	dc.s	0.313454,0.662377
	dc.s	0.303778,0.663914
	dc.s	0.333311,0.640465
	dc.s	0.325878,0.667237
	dc.s	0.313454,0.662377
	dc.s	0.306965,0.636576
	dc.s	0.324662,0.630186
	dc.s	0.313454,0.662377
	dc.s	0.324662,0.630186
	dc.s	0.333311,0.640465
	dc.s	0.313454,0.662377
	dc.s	0.351210,0.651072
	dc.s	0.361489,0.661569
	dc.s	0.325878,0.667237
	dc.s	0.333311,0.640465
	dc.s	0.351210,0.651072
	dc.s	0.325878,0.667237
	dc.s	0.367086,0.641904
	dc.s	0.361489,0.661569
	dc.s	0.351210,0.651072
	dc.s	0.357047,0.632188
	dc.s	0.367086,0.641904
	dc.s	0.351210,0.651072
	dc.s	0.340484,0.624275
	dc.s	0.333311,0.640465
	dc.s	0.324662,0.630186
	dc.s	0.357047,0.632188
	dc.s	0.351210,0.651072
	dc.s	0.333311,0.640465
	dc.s	0.340484,0.624275
	dc.s	0.357047,0.632188
	dc.s	0.333311,0.640465
	dc.s	0.367086,0.641904
	dc.s	0.381662,0.650358
	dc.s	0.377943,0.657852
	dc.s	0.367086,0.641904
	dc.s	0.377943,0.657852
	dc.s	0.361489,0.661569
	dc.s	0.381662,0.650358
	dc.s	0.389576,0.657908
	dc.s	0.377943,0.657852
	dc.s	0.321119,0.472566
	dc.s	0.320344,0.489043
	dc.s	0.312158,0.481206
	dc.s	0.325080,0.454065
	dc.s	0.321119,0.472566
	dc.s	0.313397,0.462450
	dc.s	0.377974,0.632290
	dc.s	0.388960,0.642035
	dc.s	0.381662,0.650358
	dc.s	0.357047,0.632188
	dc.s	0.377974,0.632290
	dc.s	0.367086,0.641904
	dc.s	0.377974,0.632290
	dc.s	0.381662,0.650358
	dc.s	0.367086,0.641904
	dc.s	0.321594,0.617072
	dc.s	0.306965,0.636576
	dc.s	0.308411,0.627006
	dc.s	0.321594,0.617072
	dc.s	0.308411,0.627006
	dc.s	0.310184,0.617318
	dc.s	0.321594,0.617072
	dc.s	0.324662,0.630186
	dc.s	0.306965,0.636576
	dc.s	0.318962,0.609635
	dc.s	0.321594,0.617072
	dc.s	0.311373,0.611840
	dc.s	0.311373,0.611840
	dc.s	0.321594,0.617072
	dc.s	0.310184,0.617318
	dc.s	0.321594,0.617072
	dc.s	0.340484,0.624275
	dc.s	0.324662,0.630186
	dc.s	0.340862,0.606366
	dc.s	0.340484,0.624275
	dc.s	0.321594,0.617072
	dc.s	0.340862,0.606366
	dc.s	0.357342,0.616866
	dc.s	0.340484,0.624275
	dc.s	0.357342,0.616866
	dc.s	0.357047,0.632188
	dc.s	0.340484,0.624275
	dc.s	0.355673,0.606952
	dc.s	0.357342,0.616866
	dc.s	0.340862,0.606366
	dc.s	0.340862,0.606366
	dc.s	0.321594,0.617072
	dc.s	0.318962,0.609635
	dc.s	0.370689,0.618373
	dc.s	0.377974,0.632290
	dc.s	0.357047,0.632188
	dc.s	0.370689,0.618373
	dc.s	0.357047,0.632188
	dc.s	0.357342,0.616866
	dc.s	0.370689,0.618373
	dc.s	0.385936,0.624212
	dc.s	0.377974,0.632290
	dc.s	0.376893,0.611128
	dc.s	0.385936,0.624212
	dc.s	0.370689,0.618373
	dc.s	0.370032,0.609242
	dc.s	0.376893,0.611128
	dc.s	0.370689,0.618373
	dc.s	0.327537,0.440483
	dc.s	0.333411,0.437370
	dc.s	0.325080,0.454065
	dc.s	0.370032,0.609242
	dc.s	0.370689,0.618373
	dc.s	0.357342,0.616866
	dc.s	0.355673,0.606952
	dc.s	0.370032,0.609242
	dc.s	0.357342,0.616866
	dc.s	0.328292,0.507179
	dc.s	0.339209,0.505280
	dc.s	0.326605,0.517658
	dc.s	0.339209,0.505280
	dc.s	0.353536,0.508341
	dc.s	0.341859,0.518709
	dc.s	0.353536,0.508341
	dc.s	0.351503,0.518841
	dc.s	0.341859,0.518709
	dc.s	0.339209,0.505280
	dc.s	0.341859,0.518709
	dc.s	0.326605,0.517658
	dc.s	0.341859,0.518709
	dc.s	0.336325,0.532566
	dc.s	0.322163,0.531620
	dc.s	0.326605,0.517658
	dc.s	0.341859,0.518709
	dc.s	0.322163,0.531620
	dc.s	0.326712,0.489650
	dc.s	0.351533,0.495220
	dc.s	0.339209,0.505280
	dc.s	0.351533,0.495220
	dc.s	0.353536,0.508341
	dc.s	0.339209,0.505280
	dc.s	0.327956,0.499253
	dc.s	0.339209,0.505280
	dc.s	0.328292,0.507179
	dc.s	0.326712,0.489650
	dc.s	0.339209,0.505280
	dc.s	0.327956,0.499253
	dc.s	0.353536,0.508341
	dc.s	0.371964,0.517134
	dc.s	0.351503,0.518841
	dc.s	0.368555,0.506982
	dc.s	0.371964,0.517134
	dc.s	0.353536,0.508341
	dc.s	0.384536,0.498670
	dc.s	0.412470,0.517669
	dc.s	0.393701,0.516447
	dc.s	0.368555,0.506982
	dc.s	0.393701,0.516447
	dc.s	0.371964,0.517134
	dc.s	0.384536,0.498670
	dc.s	0.393701,0.516447
	dc.s	0.368555,0.506982
	dc.s	0.394368,0.495348
	dc.s	0.412470,0.517669
	dc.s	0.384536,0.498670
	dc.s	0.101974,0.471500
	dc.s	0.112809,0.470353
	dc.s	0.097033,0.464078
	dc.s	0.351533,0.495220
	dc.s	0.368555,0.506982
	dc.s	0.353536,0.508341
	dc.s	0.080230,0.469125
	dc.s	0.091643,0.472959
	dc.s	0.097033,0.464078
	dc.s	0.363095,0.497610
	dc.s	0.373561,0.499602
	dc.s	0.368555,0.506982
	dc.s	0.421207,0.509081
	dc.s	0.430871,0.514643
	dc.s	0.420553,0.519074
	dc.s	0.430871,0.514643
	dc.s	0.428436,0.522574
	dc.s	0.420553,0.519074
	dc.s	0.421207,0.509081
	dc.s	0.420553,0.519074
	dc.s	0.412470,0.517669
	dc.s	0.413516,0.502061
	dc.s	0.435658,0.502731
	dc.s	0.421207,0.509081
	dc.s	0.435658,0.502731
	dc.s	0.430871,0.514643
	dc.s	0.421207,0.509081
	dc.s	0.394368,0.495348
	dc.s	0.413516,0.502061
	dc.s	0.412470,0.517669
	dc.s	0.413516,0.502061
	dc.s	0.421207,0.509081
	dc.s	0.412470,0.517669
	dc.s	0.328504,0.465439
	dc.s	0.346417,0.472210
	dc.s	0.326712,0.489650
	dc.s	0.346242,0.485702
	dc.s	0.351533,0.495220
	dc.s	0.326712,0.489650
	dc.s	0.346417,0.472210
	dc.s	0.346242,0.485702
	dc.s	0.326712,0.489650
	dc.s	0.357115,0.460538
	dc.s	0.346417,0.472210
	dc.s	0.328504,0.465439
	dc.s	0.406053,0.482682
	dc.s	0.413516,0.502061
	dc.s	0.394368,0.495348
	dc.s	0.406053,0.482682
	dc.s	0.434338,0.490647
	dc.s	0.413516,0.502061
	dc.s	0.434338,0.490647
	dc.s	0.435658,0.502731
	dc.s	0.413516,0.502061
	dc.s	0.422632,0.460748
	dc.s	0.434338,0.490647
	dc.s	0.406053,0.482682
	dc.s	0.432585,0.463308
	dc.s	0.434338,0.490647
	dc.s	0.422632,0.460748
	dc.s	0.422632,0.460748
	dc.s	0.401106,0.468893
	dc.s	0.397164,0.456895
	dc.s	0.401106,0.468893
	dc.s	0.422632,0.460748
	dc.s	0.406053,0.482682
	dc.s	0.345270,0.438353
	dc.s	0.357115,0.460538
	dc.s	0.336401,0.440094
	dc.s	0.336401,0.440094
	dc.s	0.357115,0.460538
	dc.s	0.328504,0.465439
	dc.s	0.345270,0.438353
	dc.s	0.366518,0.456104
	dc.s	0.357115,0.460538
	dc.s	0.389090,0.435589
	dc.s	0.366518,0.456104
	dc.s	0.369156,0.435683
	dc.s	0.389090,0.435589
	dc.s	0.376234,0.455340
	dc.s	0.366518,0.456104
	dc.s	0.369156,0.435683
	dc.s	0.366518,0.456104
	dc.s	0.345270,0.438353
	dc.s	0.389090,0.435589
	dc.s	0.402919,0.436947
	dc.s	0.397164,0.456895
	dc.s	0.389090,0.435589
	dc.s	0.397164,0.456895
	dc.s	0.376234,0.455340
	dc.s	0.379312,0.429399
	dc.s	0.389090,0.435589
	dc.s	0.369156,0.435683
	dc.s	0.421126,0.440637
	dc.s	0.422632,0.460748
	dc.s	0.397164,0.456895
	dc.s	0.402919,0.436947
	dc.s	0.421126,0.440637
	dc.s	0.397164,0.456895
	dc.s	0.430103,0.450419
	dc.s	0.432585,0.463308
	dc.s	0.422632,0.460748
	dc.s	0.421126,0.440637
	dc.s	0.430103,0.450419
	dc.s	0.422632,0.460748
	dc.s	0.421126,0.440637
	dc.s	0.426743,0.441777
	dc.s	0.430103,0.450419
	dc.s	0.149618,0.635416
	dc.s	0.149502,0.646036
	dc.s	0.155331,0.651635
	dc.s	0.239250,0.511311
	dc.s	0.230888,0.523294
	dc.s	0.256037,0.524857
	dc.s	0.242167,0.487043
	dc.s	0.239250,0.511311
	dc.s	0.275943,0.503430
	dc.s	0.270749,0.512215
	dc.s	0.256037,0.524857
	dc.s	0.272022,0.522431
	dc.s	0.270749,0.512215
	dc.s	0.239250,0.511311
	dc.s	0.256037,0.524857
	dc.s	0.275943,0.503430
	dc.s	0.239250,0.511311
	dc.s	0.270749,0.512215
	dc.s	0.239250,0.511311
	dc.s	0.227427,0.502187
	dc.s	0.230888,0.523294
	dc.s	0.227427,0.502187
	dc.s	0.215125,0.520309
	dc.s	0.230888,0.523294
	dc.s	0.227427,0.502187
	dc.s	0.216249,0.508203
	dc.s	0.215125,0.520309
	dc.s	0.242167,0.487043
	dc.s	0.227427,0.502187
	dc.s	0.239250,0.511311
	dc.s	0.284478,0.458919
	dc.s	0.296790,0.495059
	dc.s	0.292826,0.453386
	dc.s	0.284478,0.458919
	dc.s	0.291535,0.499260
	dc.s	0.296790,0.495059
	dc.s	0.269786,0.469095
	dc.s	0.275943,0.503430
	dc.s	0.284122,0.496720
	dc.s	0.284478,0.458919
	dc.s	0.269786,0.469095
	dc.s	0.284122,0.496720
	dc.s	0.284478,0.458919
	dc.s	0.284122,0.496720
	dc.s	0.291535,0.499260
	dc.s	0.265962,0.452147
	dc.s	0.269786,0.469095
	dc.s	0.284478,0.458919
	dc.s	0.269786,0.469095
	dc.s	0.246818,0.465677
	dc.s	0.275943,0.503430
	dc.s	0.246818,0.465677
	dc.s	0.242167,0.487043
	dc.s	0.275943,0.503430
	dc.s	0.265962,0.452147
	dc.s	0.246818,0.465677
	dc.s	0.269786,0.469095
	dc.s	0.228573,0.473911
	dc.s	0.227427,0.502187
	dc.s	0.242167,0.487043
	dc.s	0.218398,0.482028
	dc.s	0.216249,0.508203
	dc.s	0.227427,0.502187
	dc.s	0.228573,0.473911
	dc.s	0.218398,0.482028
	dc.s	0.227427,0.502187
	dc.s	0.220174,0.462312
	dc.s	0.218398,0.482028
	dc.s	0.228573,0.473911
	dc.s	0.231653,0.447507
	dc.s	0.228573,0.473911
	dc.s	0.246818,0.465677
	dc.s	0.246818,0.465677
	dc.s	0.228573,0.473911
	dc.s	0.242167,0.487043
	dc.s	0.231653,0.447507
	dc.s	0.220174,0.462312
	dc.s	0.228573,0.473911
	dc.s	0.283135,0.444911
	dc.s	0.284478,0.458919
	dc.s	0.292826,0.453386
	dc.s	0.283135,0.444911
	dc.s	0.292826,0.453386
	dc.s	0.290916,0.442908
	dc.s	0.283135,0.444911
	dc.s	0.265962,0.452147
	dc.s	0.284478,0.458919
	dc.s	0.271116,0.432501
	dc.s	0.265962,0.452147
	dc.s	0.283135,0.444911
	dc.s	0.282533,0.435048
	dc.s	0.271116,0.432501
	dc.s	0.283135,0.444911
	dc.s	0.282533,0.435048
	dc.s	0.283135,0.444911
	dc.s	0.289566,0.436983
	dc.s	0.289566,0.436983
	dc.s	0.283135,0.444911
	dc.s	0.290916,0.442908
	dc.s	0.271116,0.432501
	dc.s	0.261509,0.442334
	dc.s	0.265962,0.452147
	dc.s	0.245362,0.443363
	dc.s	0.246818,0.465677
	dc.s	0.265962,0.452147
	dc.s	0.261509,0.442334
	dc.s	0.245362,0.443363
	dc.s	0.265962,0.452147
	dc.s	0.252930,0.432169
	dc.s	0.245362,0.443363
	dc.s	0.261509,0.442334
	dc.s	0.252930,0.432169
	dc.s	0.232963,0.434878
	dc.s	0.245362,0.443363
	dc.s	0.252930,0.432169
	dc.s	0.261509,0.442334
	dc.s	0.271116,0.432501
	dc.s	0.245362,0.443363
	dc.s	0.231653,0.447507
	dc.s	0.246818,0.465677
	dc.s	0.231653,0.447507
	dc.s	0.223207,0.445691
	dc.s	0.220174,0.462312
	dc.s	0.225090,0.437353
	dc.s	0.223207,0.445691
	dc.s	0.231653,0.447507
	dc.s	0.232963,0.434878
	dc.s	0.225090,0.437353
	dc.s	0.231653,0.447507
	dc.s	0.232963,0.434878
	dc.s	0.231653,0.447507
	dc.s	0.245362,0.443363
	dc.s	0.015433,0.140396
	dc.s	0.008296,0.140957
	dc.s	0.008581,0.157918
	dc.s	0.015433,0.140396
	dc.s	0.008581,0.157918
	dc.s	0.015512,0.153941
	dc.s	0.015340,0.124364
	dc.s	0.009608,0.116720
	dc.s	0.015433,0.140396
	dc.s	0.015433,0.140396
	dc.s	0.009608,0.116720
	dc.s	0.008296,0.140957
	dc.s	0.015066,0.108319
	dc.s	0.014833,0.094819
	dc.s	0.007824,0.090705
	dc.s	0.015066,0.108319
	dc.s	0.007824,0.090705
	dc.s	0.009608,0.116720
	dc.s	0.015340,0.124364
	dc.s	0.015066,0.108319
	dc.s	0.009608,0.116720
	dc.s	0.032019,0.105779
	dc.s	0.031810,0.090019
	dc.s	0.015066,0.108319
	dc.s	0.031810,0.090019
	dc.s	0.014833,0.094819
	dc.s	0.015066,0.108319
	dc.s	0.032119,0.124484
	dc.s	0.015066,0.108319
	dc.s	0.015340,0.124364
	dc.s	0.032019,0.105779
	dc.s	0.015066,0.108319
	dc.s	0.032119,0.124484
	dc.s	0.032733,0.158953
	dc.s	0.015433,0.140396
	dc.s	0.015512,0.153941
	dc.s	0.032515,0.143196
	dc.s	0.015433,0.140396
	dc.s	0.032733,0.158953
	dc.s	0.032515,0.143196
	dc.s	0.032119,0.124484
	dc.s	0.015433,0.140396
	dc.s	0.032119,0.124484
	dc.s	0.015340,0.124364
	dc.s	0.015433,0.140396
	dc.s	0.014376,0.240488
	dc.s	0.007001,0.240601
	dc.s	0.007126,0.252210
	dc.s	0.014376,0.240488
	dc.s	0.007126,0.252210
	dc.s	0.014075,0.250515
	dc.s	0.014064,0.228436
	dc.s	0.007523,0.228666
	dc.s	0.014376,0.240488
	dc.s	0.014376,0.240488
	dc.s	0.007523,0.228666
	dc.s	0.007001,0.240601
	dc.s	0.014039,0.216359
	dc.s	0.013472,0.206437
	dc.s	0.006441,0.205282
	dc.s	0.014039,0.216359
	dc.s	0.006441,0.205282
	dc.s	0.006642,0.216804
	dc.s	0.014039,0.216359
	dc.s	0.006642,0.216804
	dc.s	0.007523,0.228666
	dc.s	0.014064,0.228436
	dc.s	0.014039,0.216359
	dc.s	0.007523,0.228666
	dc.s	0.031150,0.211809
	dc.s	0.030636,0.198296
	dc.s	0.014039,0.216359
	dc.s	0.030636,0.198296
	dc.s	0.013472,0.206437
	dc.s	0.014039,0.216359
	dc.s	0.031247,0.227791
	dc.s	0.014039,0.216359
	dc.s	0.014064,0.228436
	dc.s	0.031150,0.211809
	dc.s	0.014039,0.216359
	dc.s	0.031247,0.227791
	dc.s	0.031372,0.257335
	dc.s	0.014376,0.240488
	dc.s	0.014075,0.250515
	dc.s	0.031548,0.243790
	dc.s	0.014376,0.240488
	dc.s	0.031372,0.257335
	dc.s	0.031548,0.243790
	dc.s	0.031247,0.227791
	dc.s	0.014376,0.240488
	dc.s	0.031247,0.227791
	dc.s	0.014064,0.228436
	dc.s	0.014376,0.240488
	dc.s	0.015049,0.302358
	dc.s	0.007646,0.302962
	dc.s	0.007450,0.291148
	dc.s	0.015049,0.302358
	dc.s	0.007450,0.291148
	dc.s	0.014471,0.292221
	dc.s	0.015092,0.314631
	dc.s	0.008559,0.315092
	dc.s	0.015049,0.302358
	dc.s	0.015049,0.302358
	dc.s	0.008559,0.315092
	dc.s	0.007646,0.302962
	dc.s	0.015407,0.326868
	dc.s	0.015118,0.337003
	dc.s	0.008128,0.339008
	dc.s	0.015407,0.326868
	dc.s	0.008128,0.339008
	dc.s	0.008005,0.327341
	dc.s	0.015407,0.326868
	dc.s	0.008005,0.327341
	dc.s	0.008559,0.315092
	dc.s	0.015092,0.314631
	dc.s	0.015407,0.326868
	dc.s	0.008559,0.315092
	dc.s	0.032387,0.329965
	dc.s	0.032244,0.343662
	dc.s	0.015407,0.326868
	dc.s	0.032244,0.343662
	dc.s	0.015118,0.337003
	dc.s	0.015407,0.326868
	dc.s	0.032081,0.313788
	dc.s	0.015407,0.326868
	dc.s	0.015092,0.314631
	dc.s	0.032387,0.329965
	dc.s	0.015407,0.326868
	dc.s	0.032081,0.313788
	dc.s	0.031522,0.283913
	dc.s	0.015049,0.302358
	dc.s	0.014471,0.292221
	dc.s	0.032000,0.297600
	dc.s	0.015049,0.302358
	dc.s	0.031522,0.283913
	dc.s	0.032000,0.297600
	dc.s	0.032081,0.313788
	dc.s	0.015049,0.302358
	dc.s	0.032081,0.313788
	dc.s	0.015092,0.314631
	dc.s	0.015049,0.302358
	dc.s	0.013860,0.021658
	dc.s	0.006745,0.021012
	dc.s	0.006601,0.004347
	dc.s	0.013860,0.021658
	dc.s	0.006601,0.004347
	dc.s	0.013611,0.008420
	dc.s	0.014118,0.037350
	dc.s	0.008601,0.044739
	dc.s	0.013860,0.021658
	dc.s	0.013860,0.021658
	dc.s	0.008601,0.044739
	dc.s	0.006745,0.021012
	dc.s	0.014193,0.053093
	dc.s	0.014239,0.066326
	dc.s	0.007361,0.070384
	dc.s	0.014193,0.053093
	dc.s	0.007361,0.070384
	dc.s	0.008601,0.044739
	dc.s	0.014118,0.037350
	dc.s	0.014193,0.053093
	dc.s	0.008601,0.044739
	dc.s	0.031193,0.055671
	dc.s	0.031405,0.071063
	dc.s	0.014193,0.053093
	dc.s	0.031405,0.071063
	dc.s	0.014239,0.066326
	dc.s	0.014193,0.053093
	dc.s	0.030805,0.037389
	dc.s	0.014193,0.053093
	dc.s	0.014118,0.037350
	dc.s	0.031193,0.055671
	dc.s	0.014193,0.053093
	dc.s	0.030805,0.037389
	dc.s	0.030478,0.003703
	dc.s	0.013860,0.021658
	dc.s	0.013611,0.008420
	dc.s	0.030688,0.019110
	dc.s	0.013860,0.021658
	dc.s	0.030478,0.003703
	dc.s	0.030688,0.019110
	dc.s	0.030805,0.037389
	dc.s	0.013860,0.021658
	dc.s	0.030805,0.037389
	dc.s	0.014118,0.037350
	dc.s	0.013860,0.021658
	dc.s	0.046880,0.139738
	dc.s	0.032515,0.143196
	dc.s	0.032733,0.158953
	dc.s	0.047133,0.152685
	dc.s	0.046880,0.139738
	dc.s	0.032733,0.158953
	dc.s	0.046861,0.124409
	dc.s	0.032119,0.124484
	dc.s	0.046880,0.139738
	dc.s	0.046880,0.139738
	dc.s	0.032119,0.124484
	dc.s	0.032515,0.143196
	dc.s	0.046597,0.096187
	dc.s	0.031810,0.090019
	dc.s	0.046581,0.109179
	dc.s	0.046581,0.109179
	dc.s	0.031810,0.090019
	dc.s	0.032019,0.105779
	dc.s	0.046581,0.109179
	dc.s	0.032019,0.105779
	dc.s	0.032119,0.124484
	dc.s	0.046861,0.124409
	dc.s	0.046581,0.109179
	dc.s	0.032119,0.124484
	dc.s	0.046411,0.300165
	dc.s	0.032000,0.297600
	dc.s	0.031522,0.283913
	dc.s	0.046397,0.289002
	dc.s	0.046411,0.300165
	dc.s	0.031522,0.283913
	dc.s	0.046704,0.313301
	dc.s	0.032081,0.313788
	dc.s	0.046411,0.300165
	dc.s	0.046411,0.300165
	dc.s	0.032081,0.313788
	dc.s	0.032000,0.297600
	dc.s	0.047079,0.337552
	dc.s	0.032244,0.343662
	dc.s	0.046818,0.326443
	dc.s	0.046818,0.326443
	dc.s	0.032244,0.343662
	dc.s	0.032387,0.329965
	dc.s	0.046818,0.326443
	dc.s	0.032387,0.329965
	dc.s	0.032081,0.313788
	dc.s	0.046704,0.313301
	dc.s	0.046818,0.326443
	dc.s	0.032081,0.313788
	dc.s	0.045366,0.022446
	dc.s	0.030688,0.019110
	dc.s	0.030478,0.003703
	dc.s	0.045347,0.009753
	dc.s	0.045366,0.022446
	dc.s	0.030478,0.003703
	dc.s	0.045621,0.037343
	dc.s	0.030805,0.037389
	dc.s	0.045366,0.022446
	dc.s	0.045366,0.022446
	dc.s	0.030805,0.037389
	dc.s	0.030688,0.019110
	dc.s	0.045909,0.064905
	dc.s	0.031405,0.071063
	dc.s	0.045670,0.052257
	dc.s	0.045670,0.052257
	dc.s	0.031405,0.071063
	dc.s	0.031193,0.055671
	dc.s	0.045670,0.052257
	dc.s	0.031193,0.055671
	dc.s	0.030805,0.037389
	dc.s	0.045621,0.037343
	dc.s	0.045670,0.052257
	dc.s	0.030805,0.037389
	dc.s	0.045667,0.240353
	dc.s	0.031548,0.243790
	dc.s	0.031372,0.257335
	dc.s	0.045967,0.251344
	dc.s	0.045667,0.240353
	dc.s	0.031372,0.257335
	dc.s	0.045500,0.227367
	dc.s	0.031247,0.227791
	dc.s	0.045667,0.240353
	dc.s	0.045667,0.240353
	dc.s	0.031247,0.227791
	dc.s	0.031548,0.243790
	dc.s	0.045250,0.203358
	dc.s	0.030636,0.198296
	dc.s	0.045222,0.214382
	dc.s	0.045222,0.214382
	dc.s	0.030636,0.198296
	dc.s	0.031150,0.211809
	dc.s	0.045222,0.214382
	dc.s	0.031150,0.211809
	dc.s	0.031247,0.227791
	dc.s	0.045500,0.227367
	dc.s	0.045222,0.214382
	dc.s	0.031247,0.227791
	dc.s	0.067546,0.123239
	dc.s	0.046880,0.139738
	dc.s	0.069178,0.141072
	dc.s	0.067546,0.123239
	dc.s	0.046861,0.124409
	dc.s	0.046880,0.139738
	dc.s	0.068175,0.157036
	dc.s	0.046880,0.139738
	dc.s	0.047133,0.152685
	dc.s	0.069178,0.141072
	dc.s	0.046880,0.139738
	dc.s	0.068175,0.157036
	dc.s	0.067412,0.089514
	dc.s	0.046581,0.109179
	dc.s	0.068887,0.104822
	dc.s	0.067412,0.089514
	dc.s	0.046597,0.096187
	dc.s	0.046581,0.109179
	dc.s	0.067546,0.123239
	dc.s	0.046581,0.109179
	dc.s	0.046861,0.124409
	dc.s	0.068887,0.104822
	dc.s	0.046581,0.109179
	dc.s	0.067546,0.123239
	dc.s	0.067753,0.296628
	dc.s	0.067892,0.312530
	dc.s	0.046411,0.300165
	dc.s	0.067892,0.312530
	dc.s	0.046704,0.313301
	dc.s	0.046411,0.300165
	dc.s	0.067369,0.283706
	dc.s	0.046411,0.300165
	dc.s	0.046397,0.289002
	dc.s	0.067753,0.296628
	dc.s	0.046411,0.300165
	dc.s	0.067369,0.283706
	dc.s	0.067546,0.327431
	dc.s	0.067726,0.340983
	dc.s	0.046818,0.326443
	dc.s	0.067726,0.340983
	dc.s	0.047079,0.337552
	dc.s	0.046818,0.326443
	dc.s	0.067892,0.312530
	dc.s	0.046818,0.326443
	dc.s	0.046704,0.313301
	dc.s	0.067892,0.312530
	dc.s	0.067546,0.327431
	dc.s	0.046818,0.326443
	dc.s	0.065700,0.018663
	dc.s	0.065916,0.036464
	dc.s	0.045366,0.022446
	dc.s	0.065916,0.036464
	dc.s	0.045621,0.037343
	dc.s	0.045366,0.022446
	dc.s	0.065732,0.003667
	dc.s	0.045366,0.022446
	dc.s	0.045347,0.009753
	dc.s	0.065700,0.018663
	dc.s	0.045366,0.022446
	dc.s	0.065732,0.003667
	dc.s	0.066044,0.054037
	dc.s	0.066371,0.069129
	dc.s	0.045670,0.052257
	dc.s	0.066371,0.069129
	dc.s	0.045909,0.064905
	dc.s	0.045670,0.052257
	dc.s	0.065916,0.036464
	dc.s	0.045670,0.052257
	dc.s	0.045621,0.037343
	dc.s	0.066044,0.054037
	dc.s	0.045670,0.052257
	dc.s	0.065916,0.036464
	dc.s	0.066669,0.226456
	dc.s	0.045667,0.240353
	dc.s	0.066339,0.241126
	dc.s	0.066669,0.226456
	dc.s	0.045500,0.227367
	dc.s	0.045667,0.240353
	dc.s	0.066545,0.254652
	dc.s	0.045667,0.240353
	dc.s	0.045967,0.251344
	dc.s	0.066339,0.241126
	dc.s	0.045667,0.240353
	dc.s	0.066545,0.254652
	dc.s	0.066687,0.210784
	dc.s	0.066298,0.198136
	dc.s	0.045222,0.214382
	dc.s	0.066298,0.198136
	dc.s	0.045250,0.203358
	dc.s	0.045222,0.214382
	dc.s	0.066669,0.226456
	dc.s	0.045222,0.214382
	dc.s	0.045500,0.227367
	dc.s	0.066687,0.210784
	dc.s	0.045222,0.214382
	dc.s	0.066669,0.226456
	dc.s	0.108558,0.095778
	dc.s	0.068887,0.104822
	dc.s	0.114895,0.104374
	dc.s	0.107101,0.123010
	dc.s	0.068887,0.104822
	dc.s	0.067546,0.123239
	dc.s	0.107101,0.123010
	dc.s	0.114895,0.104374
	dc.s	0.068887,0.104822
	dc.s	0.108558,0.095778
	dc.s	0.067412,0.089514
	dc.s	0.068887,0.104822
	dc.s	0.106420,0.142331
	dc.s	0.069178,0.141072
	dc.s	0.068175,0.157036
	dc.s	0.107101,0.123010
	dc.s	0.069178,0.141072
	dc.s	0.106420,0.142331
	dc.s	0.107101,0.123010
	dc.s	0.067546,0.123239
	dc.s	0.069178,0.141072
	dc.s	0.105736,0.322025
	dc.s	0.067546,0.327431
	dc.s	0.067892,0.312530
	dc.s	0.105736,0.322025
	dc.s	0.067892,0.312530
	dc.s	0.104167,0.311978
	dc.s	0.105736,0.322025
	dc.s	0.105614,0.330652
	dc.s	0.067726,0.340983
	dc.s	0.105736,0.322025
	dc.s	0.067726,0.340983
	dc.s	0.067546,0.327431
	dc.s	0.104812,0.301604
	dc.s	0.067753,0.296628
	dc.s	0.067369,0.283706
	dc.s	0.108846,0.294283
	dc.s	0.104812,0.301604
	dc.s	0.067369,0.283706
	dc.s	0.104812,0.301604
	dc.s	0.104167,0.311978
	dc.s	0.067892,0.312530
	dc.s	0.104812,0.301604
	dc.s	0.067892,0.312530
	dc.s	0.067753,0.296628
	dc.s	0.099962,0.038551
	dc.s	0.066044,0.054037
	dc.s	0.065916,0.036464
	dc.s	0.101185,0.054007
	dc.s	0.066371,0.069129
	dc.s	0.099962,0.038551
	dc.s	0.099962,0.038551
	dc.s	0.066371,0.069129
	dc.s	0.066044,0.054037
	dc.s	0.095181,0.019847
	dc.s	0.065700,0.018663
	dc.s	0.065732,0.003667
	dc.s	0.095181,0.019847
	dc.s	0.065732,0.003667
	dc.s	0.103538,0.009934
	dc.s	0.099962,0.038551
	dc.s	0.065916,0.036464
	dc.s	0.095181,0.019847
	dc.s	0.095181,0.019847
	dc.s	0.065916,0.036464
	dc.s	0.065700,0.018663
	dc.s	0.105073,0.209978
	dc.s	0.066687,0.210784
	dc.s	0.066669,0.226456
	dc.s	0.103899,0.230648
	dc.s	0.105073,0.209978
	dc.s	0.066669,0.226456
	dc.s	0.105073,0.209978
	dc.s	0.066298,0.198136
	dc.s	0.066687,0.210784
	dc.s	0.103899,0.230648
	dc.s	0.066339,0.241126
	dc.s	0.066545,0.254652
	dc.s	0.101637,0.244652
	dc.s	0.103899,0.230648
	dc.s	0.066545,0.254652
	dc.s	0.103899,0.230648
	dc.s	0.066669,0.226456
	dc.s	0.066339,0.241126
	dc.s	0.138537,0.117469
	dc.s	0.114895,0.104374
	dc.s	0.107101,0.123010
	dc.s	0.135274,0.130766
	dc.s	0.107101,0.123010
	dc.s	0.106420,0.142331
	dc.s	0.138537,0.117469
	dc.s	0.107101,0.123010
	dc.s	0.135274,0.130766
	dc.s	0.122054,0.018794
	dc.s	0.099962,0.038551
	dc.s	0.095181,0.019847
	dc.s	0.122054,0.018794
	dc.s	0.095181,0.019847
	dc.s	0.103538,0.009934
	dc.s	0.129307,0.045865
	dc.s	0.101185,0.054007
	dc.s	0.127986,0.033714
	dc.s	0.127986,0.033714
	dc.s	0.101185,0.054007
	dc.s	0.099962,0.038551
	dc.s	0.127986,0.033714
	dc.s	0.099962,0.038551
	dc.s	0.122054,0.018794
	dc.s	0.126282,0.235093
	dc.s	0.103899,0.230648
	dc.s	0.101637,0.244652
	dc.s	0.128516,0.222160
	dc.s	0.105073,0.209978
	dc.s	0.103899,0.230648
	dc.s	0.134249,0.211943
	dc.s	0.105073,0.209978
	dc.s	0.128516,0.222160
	dc.s	0.130004,0.242413
	dc.s	0.126282,0.235093
	dc.s	0.101637,0.244652
	dc.s	0.128516,0.222160
	dc.s	0.103899,0.230648
	dc.s	0.126282,0.235093
	dc.s	0.171704,0.104705
	dc.s	0.173758,0.091311
	dc.s	0.114895,0.104374
	dc.s	0.171704,0.104705
	dc.s	0.114895,0.104374
	dc.s	0.138537,0.117469
	dc.s	0.173758,0.091311
	dc.s	0.108558,0.095778
	dc.s	0.114895,0.104374
	dc.s	0.170582,0.123224
	dc.s	0.138537,0.117469
	dc.s	0.135274,0.130766
	dc.s	0.170582,0.123224
	dc.s	0.171704,0.104705
	dc.s	0.138537,0.117469
	dc.s	0.167022,0.320264
	dc.s	0.104167,0.311978
	dc.s	0.104812,0.301604
	dc.s	0.167173,0.330528
	dc.s	0.105614,0.330652
	dc.s	0.105736,0.322025
	dc.s	0.167022,0.320264
	dc.s	0.167173,0.330528
	dc.s	0.105736,0.322025
	dc.s	0.167022,0.320264
	dc.s	0.105736,0.322025
	dc.s	0.104167,0.311978
	dc.s	0.174650,0.303625
	dc.s	0.104812,0.301604
	dc.s	0.108846,0.294283
	dc.s	0.174650,0.303625
	dc.s	0.167022,0.320264
	dc.s	0.104812,0.301604
	dc.s	0.164634,0.008713
	dc.s	0.122054,0.018794
	dc.s	0.103538,0.009934
	dc.s	0.163830,0.020969
	dc.s	0.161819,0.040049
	dc.s	0.127986,0.033714
	dc.s	0.161819,0.040049
	dc.s	0.129307,0.045865
	dc.s	0.127986,0.033714
	dc.s	0.164634,0.008713
	dc.s	0.163830,0.020969
	dc.s	0.122054,0.018794
	dc.s	0.163830,0.020969
	dc.s	0.127986,0.033714
	dc.s	0.122054,0.018794
	dc.s	0.191113,0.221219
	dc.s	0.134249,0.211943
	dc.s	0.128516,0.222160
	dc.s	0.191113,0.221219
	dc.s	0.128516,0.222160
	dc.s	0.163150,0.233239
	dc.s	0.162823,0.245622
	dc.s	0.163150,0.233239
	dc.s	0.126282,0.235093
	dc.s	0.162823,0.245622
	dc.s	0.126282,0.235093
	dc.s	0.130004,0.242413
	dc.s	0.163150,0.233239
	dc.s	0.128516,0.222160
	dc.s	0.126282,0.235093
	dc.s	0.191113,0.221219
	dc.s	0.169853,0.212598
	dc.s	0.134249,0.211943
	dc.s	0.214959,0.098573
	dc.s	0.173758,0.091311
	dc.s	0.171704,0.104705
	dc.s	0.230689,0.109887
	dc.s	0.171704,0.104705
	dc.s	0.170582,0.123224
	dc.s	0.218116,0.304382
	dc.s	0.167022,0.320264
	dc.s	0.174650,0.303625
	dc.s	0.189233,0.019219
	dc.s	0.163830,0.020969
	dc.s	0.164634,0.008713
	dc.s	0.189233,0.019219
	dc.s	0.190241,0.033718
	dc.s	0.163830,0.020969
	dc.s	0.190241,0.033718
	dc.s	0.161819,0.040049
	dc.s	0.163830,0.020969
	dc.s	0.190326,0.229650
	dc.s	0.163150,0.233239
	dc.s	0.162823,0.245622
	dc.s	0.191113,0.221219
	dc.s	0.163150,0.233239
	dc.s	0.190326,0.229650
	dc.s	0.191389,0.236462
	dc.s	0.190326,0.229650
	dc.s	0.162823,0.245622
	dc.s	0.230689,0.109887
	dc.s	0.214959,0.098573
	dc.s	0.171704,0.104705
	dc.s	0.215927,0.293580
	dc.s	0.221062,0.297489
	dc.s	0.174650,0.303625
	dc.s	0.218116,0.304382
	dc.s	0.174650,0.303625
	dc.s	0.221062,0.297489
	dc.s	0.218116,0.304382
	dc.s	0.167173,0.330528
	dc.s	0.167022,0.320264
	dc.s	0.221293,0.310155
	dc.s	0.167173,0.330528
	dc.s	0.218116,0.304382
	dc.s	0.218650,0.013281
	dc.s	0.189233,0.019219
	dc.s	0.164634,0.008713
	dc.s	0.218650,0.013281
	dc.s	0.190241,0.033718
	dc.s	0.189233,0.019219
	dc.s	0.230991,0.024584
	dc.s	0.190241,0.033718
	dc.s	0.218650,0.013281
	dc.s	0.230359,0.204276
	dc.s	0.169853,0.212598
	dc.s	0.191113,0.221219
	dc.s	0.243796,0.206228
	dc.s	0.230359,0.204276
	dc.s	0.191113,0.221219
	dc.s	0.232275,0.217328
	dc.s	0.190326,0.229650
	dc.s	0.191389,0.236462
	dc.s	0.232275,0.217328
	dc.s	0.191113,0.221219
	dc.s	0.190326,0.229650
	dc.s	0.245706,0.100367
	dc.s	0.214959,0.098573
	dc.s	0.230689,0.109887
	dc.s	0.248185,0.093710
	dc.s	0.214959,0.098573
	dc.s	0.245706,0.100367
	dc.s	0.263070,0.294688
	dc.s	0.221293,0.310155
	dc.s	0.218116,0.304382
	dc.s	0.249337,0.285152
	dc.s	0.221062,0.297489
	dc.s	0.215927,0.293580
	dc.s	0.243796,0.206228
	dc.s	0.191113,0.221219
	dc.s	0.232275,0.217328
	dc.s	0.270084,0.104600
	dc.s	0.245706,0.100367
	dc.s	0.230689,0.109887
	dc.s	0.293612,0.276660
	dc.s	0.218116,0.304382
	dc.s	0.221062,0.297489
	dc.s	0.293612,0.276660
	dc.s	0.263070,0.294688
	dc.s	0.218116,0.304382
	dc.s	0.289013,0.008848
	dc.s	0.218650,0.013281
	dc.s	0.260197,0.004318
	dc.s	0.289013,0.008848
	dc.s	0.230991,0.024584
	dc.s	0.218650,0.013281
	dc.s	0.269915,0.193813
	dc.s	0.230359,0.204276
	dc.s	0.243796,0.206228
	dc.s	0.281222,0.198670
	dc.s	0.243796,0.206228
	dc.s	0.232275,0.217328
	dc.s	0.307002,0.090349
	dc.s	0.294998,0.085469
	dc.s	0.248185,0.093710
	dc.s	0.315155,0.100300
	dc.s	0.307002,0.090349
	dc.s	0.245706,0.100367
	dc.s	0.307002,0.090349
	dc.s	0.248185,0.093710
	dc.s	0.245706,0.100367
	dc.s	0.315155,0.100300
	dc.s	0.245706,0.100367
	dc.s	0.270084,0.104600
	dc.s	0.294998,0.085469
	dc.s	0.219967,0.094626
	dc.s	0.248185,0.093710
	dc.s	0.296380,0.269291
	dc.s	0.293612,0.276660
	dc.s	0.221062,0.297489
	dc.s	0.307996,0.276422
	dc.s	0.263070,0.294688
	dc.s	0.293612,0.276660
	dc.s	0.289013,0.008848
	dc.s	0.279755,0.016144
	dc.s	0.230991,0.024584
	dc.s	0.281222,0.198670
	dc.s	0.269915,0.193813
	dc.s	0.243796,0.206228
	dc.s	0.332197,0.260739
	dc.s	0.296380,0.269291
	dc.s	0.308323,0.262103
	dc.s	0.332197,0.260739
	dc.s	0.307996,0.276422
	dc.s	0.293612,0.276660
	dc.s	0.332197,0.260739
	dc.s	0.293612,0.276660
	dc.s	0.296380,0.269291
	dc.s	0.304957,0.000012
	dc.s	0.289013,0.008848
	dc.s	0.260197,0.004318
	dc.s	0.307829,0.015758
	dc.s	0.279755,0.016144
	dc.s	0.289013,0.008848
	dc.s	0.320985,0.011028
	dc.s	0.307829,0.015758
	dc.s	0.289013,0.008848
	dc.s	0.320985,0.011028
	dc.s	0.289013,0.008848
	dc.s	0.304957,0.000012
	dc.s	0.321197,0.177854
	dc.s	0.269915,0.193813
	dc.s	0.309355,0.188430
	dc.s	0.309355,0.188430
	dc.s	0.269915,0.193813
	dc.s	0.281222,0.198670
	dc.s	0.315059,0.173976
	dc.s	0.269915,0.193813
	dc.s	0.321197,0.177854
	dc.s	0.360507,0.109123
	dc.s	0.343210,0.095069
	dc.s	0.315155,0.100300
	dc.s	0.343210,0.095069
	dc.s	0.330697,0.087484
	dc.s	0.307002,0.090349
	dc.s	0.343210,0.095069
	dc.s	0.307002,0.090349
	dc.s	0.315155,0.100300
	dc.s	0.346185,0.266627
	dc.s	0.307996,0.276422
	dc.s	0.332197,0.260739
	dc.s	0.337591,0.010728
	dc.s	0.320985,0.011028
	dc.s	0.304957,0.000012
	dc.s	0.343048,0.005653
	dc.s	0.337591,0.010728
	dc.s	0.304957,0.000012
	dc.s	0.337339,0.019992
	dc.s	0.307829,0.015758
	dc.s	0.320985,0.011028
	dc.s	0.337591,0.010728
	dc.s	0.337339,0.019992
	dc.s	0.320985,0.011028
	dc.s	0.338916,0.181423
	dc.s	0.321197,0.177854
	dc.s	0.309355,0.188430
	dc.s	0.360490,0.167844
	dc.s	0.315059,0.173976
	dc.s	0.321197,0.177854
	dc.s	0.384051,0.109271
	dc.s	0.343210,0.095069
	dc.s	0.360507,0.109123
	dc.s	0.378800,0.101955
	dc.s	0.343210,0.095069
	dc.s	0.384051,0.109271
	dc.s	0.407919,0.115506
	dc.s	0.378800,0.101955
	dc.s	0.384051,0.109271
	dc.s	0.414478,0.128046
	dc.s	0.384051,0.109271
	dc.s	0.360507,0.109123
	dc.s	0.380399,0.255896
	dc.s	0.332197,0.260739
	dc.s	0.344634,0.254606
	dc.s	0.390065,0.263519
	dc.s	0.332197,0.260739
	dc.s	0.380399,0.255896
	dc.s	0.390065,0.263519
	dc.s	0.346185,0.266627
	dc.s	0.332197,0.260739
	dc.s	0.409557,0.255957
	dc.s	0.390065,0.263519
	dc.s	0.380399,0.255896
	dc.s	0.381493,0.022000
	dc.s	0.337591,0.010728
	dc.s	0.343048,0.005653
	dc.s	0.386789,0.017952
	dc.s	0.381493,0.022000
	dc.s	0.343048,0.005653
	dc.s	0.381197,0.028798
	dc.s	0.337339,0.019992
	dc.s	0.337591,0.010728
	dc.s	0.381493,0.022000
	dc.s	0.381197,0.028798
	dc.s	0.337591,0.010728
	dc.s	0.381428,0.174837
	dc.s	0.338916,0.181423
	dc.s	0.382919,0.179594
	dc.s	0.381428,0.174837
	dc.s	0.321197,0.177854
	dc.s	0.338916,0.181423
	dc.s	0.381428,0.174837
	dc.s	0.360490,0.167844
	dc.s	0.321197,0.177854
	dc.s	0.414588,0.171735
	dc.s	0.381428,0.174837
	dc.s	0.404436,0.174715
	dc.s	0.414588,0.171735
	dc.s	0.360490,0.167844
	dc.s	0.381428,0.174837
	dc.s	0.407919,0.115506
	dc.s	0.384051,0.109271
	dc.s	0.414478,0.128046
	dc.s	0.439424,0.129811
	dc.s	0.407919,0.115506
	dc.s	0.444139,0.138113
	dc.s	0.444139,0.138113
	dc.s	0.407919,0.115506
	dc.s	0.414478,0.128046
	dc.s	0.444868,0.146096
	dc.s	0.444139,0.138113
	dc.s	0.414478,0.128046
	dc.s	0.441223,0.265908
	dc.s	0.390065,0.263519
	dc.s	0.409557,0.255957
	dc.s	0.441241,0.273802
	dc.s	0.390065,0.263519
	dc.s	0.441223,0.265908
	dc.s	0.412954,0.036708
	dc.s	0.381493,0.022000
	dc.s	0.386789,0.017952
	dc.s	0.437789,0.044993
	dc.s	0.412954,0.036708
	dc.s	0.386789,0.017952
	dc.s	0.412954,0.036708
	dc.s	0.417624,0.044927
	dc.s	0.381197,0.028798
	dc.s	0.412954,0.036708
	dc.s	0.381197,0.028798
	dc.s	0.381493,0.022000
	dc.s	0.437789,0.044993
	dc.s	0.417624,0.044927
	dc.s	0.412954,0.036708
	dc.s	0.419411,0.182053
	dc.s	0.381428,0.174837
	dc.s	0.382919,0.179594
	dc.s	0.419411,0.182053
	dc.s	0.404436,0.174715
	dc.s	0.381428,0.174837
	dc.s	0.445055,0.181811
	dc.s	0.414588,0.171735
	dc.s	0.404436,0.174715
	dc.s	0.475275,0.159470
	dc.s	0.444139,0.138113
	dc.s	0.444868,0.146096
	dc.s	0.479732,0.067635
	dc.s	0.468820,0.069422
	dc.s	0.417624,0.044927
	dc.s	0.479732,0.067635
	dc.s	0.417624,0.044927
	dc.s	0.437789,0.044993
	dc.s	0.470838,0.199352
	dc.s	0.404436,0.174715
	dc.s	0.419411,0.182053
	dc.s	0.470838,0.199352
	dc.s	0.445055,0.181811
	dc.s	0.404436,0.174715
	dc.s	0.475628,0.194808
	dc.s	0.445055,0.181811
	dc.s	0.470838,0.199352
	dc.s	0.482589,0.153073
	dc.s	0.444139,0.138113
	dc.s	0.475275,0.159470
	dc.s	0.482589,0.153073
	dc.s	0.439424,0.129811
	dc.s	0.444139,0.138113
	dc.s	0.486272,0.158106
	dc.s	0.482589,0.153073
	dc.s	0.475275,0.159470
	dc.s	0.487804,0.288548
	dc.s	0.441223,0.265908
	dc.s	0.484603,0.282681
	dc.s	0.483426,0.290929
	dc.s	0.441241,0.273802
	dc.s	0.487804,0.288548
	dc.s	0.487804,0.288548
	dc.s	0.441241,0.273802
	dc.s	0.441223,0.265908
	dc.s	0.483616,0.072903
	dc.s	0.468820,0.069422
	dc.s	0.479732,0.067635
	dc.s	0.485723,0.202570
	dc.s	0.486759,0.199565
	dc.s	0.475628,0.194808
	dc.s	0.485723,0.202570
	dc.s	0.475628,0.194808
	dc.s	0.470838,0.199352
	dc.s	0.195109,0.537273
	dc.s	0.195155,0.552992
	dc.s	0.203755,0.544773
	dc.s	0.195109,0.537273
	dc.s	0.189352,0.549305
	dc.s	0.195155,0.552992
	dc.s	0.219173,0.553230
	dc.s	0.201747,0.556431
	dc.s	0.205149,0.560959
	dc.s	0.130852,0.591999
	dc.s	0.128782,0.580332
	dc.s	0.123566,0.598013
	dc.s	0.203755,0.544773
	dc.s	0.201747,0.556431
	dc.s	0.213246,0.548865
	dc.s	0.203755,0.544773
	dc.s	0.195155,0.552992
	dc.s	0.201747,0.556431
	dc.s	0.123566,0.598013
	dc.s	0.123417,0.583783
	dc.s	0.098998,0.597751
	dc.s	0.098998,0.597751
	dc.s	0.123417,0.583783
	dc.s	0.106134,0.582640
	dc.s	0.098998,0.597751
	dc.s	0.106134,0.582640
	dc.s	0.094267,0.580196
	dc.s	0.082676,0.598058
	dc.s	0.098998,0.597751
	dc.s	0.094267,0.580196
	dc.s	0.336457,0.726227
	dc.s	0.327297,0.742783
	dc.s	0.317078,0.736984
	dc.s	0.080837,0.587906
	dc.s	0.082676,0.598058
	dc.s	0.094267,0.580196
	dc.s	0.318337,0.723403
	dc.s	0.336457,0.726227
	dc.s	0.317078,0.736984
	dc.s	0.223308,0.671091
	dc.s	0.233484,0.681500
	dc.s	0.242468,0.678996
	dc.s	0.248617,0.672939
	dc.s	0.242468,0.678996
	dc.s	0.252499,0.681588
	dc.s	0.269565,0.673587
	dc.s	0.260138,0.679782
	dc.s	0.267607,0.684462
	dc.s	0.248617,0.672939
	dc.s	0.252499,0.681588
	dc.s	0.260138,0.679782
	dc.s	0.272022,0.522431
	dc.s	0.279378,0.533596
	dc.s	0.281032,0.525718
	dc.s	0.272022,0.522431
	dc.s	0.266504,0.526303
	dc.s	0.279378,0.533596
	dc.s	0.275943,0.503430
	dc.s	0.281032,0.525718
	dc.s	0.287776,0.516980
	dc.s	0.275943,0.503430
	dc.s	0.270749,0.512215
	dc.s	0.281032,0.525718
	dc.s	0.270749,0.512215
	dc.s	0.272022,0.522431
	dc.s	0.281032,0.525718
	dc.s	0.284122,0.496720
	dc.s	0.275943,0.503430
	dc.s	0.287776,0.516980
	dc.s	0.284122,0.496720
	dc.s	0.287776,0.516980
	dc.s	0.291535,0.499260
	dc.s	0.296790,0.495059
	dc.s	0.291535,0.499260
	dc.s	0.299551,0.510798
	dc.s	0.085349,0.479500
	dc.s	0.091643,0.472959
	dc.s	0.080230,0.469125
	dc.s	0.091643,0.472959
	dc.s	0.095365,0.483457
	dc.s	0.101974,0.471500
	dc.s	0.085349,0.479500
	dc.s	0.095365,0.483457
	dc.s	0.091643,0.472959
	dc.s	0.111748,0.482257
	dc.s	0.122514,0.469088
	dc.s	0.112809,0.470353
	dc.s	0.112809,0.470353
	dc.s	0.101974,0.471500
	dc.s	0.095365,0.483457
	dc.s	0.111748,0.482257
	dc.s	0.112809,0.470353
	dc.s	0.095365,0.483457
	dc.s	0.357115,0.460538
	dc.s	0.354028,0.468810
	dc.s	0.346417,0.472210
	dc.s	0.354028,0.468810
	dc.s	0.352209,0.477902
	dc.s	0.346417,0.472210
	dc.s	0.353505,0.485688
	dc.s	0.356719,0.491891
	dc.s	0.351533,0.495220
	dc.s	0.346242,0.485702
	dc.s	0.353505,0.485688
	dc.s	0.351533,0.495220
	dc.s	0.346417,0.472210
	dc.s	0.353505,0.485688
	dc.s	0.346242,0.485702
	dc.s	0.346417,0.472210
	dc.s	0.352209,0.477902
	dc.s	0.353505,0.485688
	dc.s	0.394840,0.484268
	dc.s	0.406053,0.482682
	dc.s	0.394368,0.495348
	dc.s	0.394840,0.484268
	dc.s	0.394368,0.495348
	dc.s	0.383462,0.495461
	dc.s	0.397164,0.456895
	dc.s	0.401106,0.468893
	dc.s	0.390881,0.469270
	dc.s	0.401106,0.468893
	dc.s	0.394840,0.484268
	dc.s	0.390881,0.469270
	dc.s	0.401106,0.468893
	dc.s	0.406053,0.482682
	dc.s	0.394840,0.484268
	dc.s	0.397164,0.456895
	dc.s	0.390881,0.469270
	dc.s	0.383322,0.460833
	dc.s	0.376234,0.455340
	dc.s	0.397164,0.456895
	dc.s	0.383322,0.460833
	dc.s	0.175189,0.657700
	dc.s	0.175576,0.664916
	dc.s	0.184417,0.661403
	dc.s	0.329837,0.679836
	dc.s	0.326592,0.690264
	dc.s	0.320043,0.692012
	dc.s	0.313454,0.662377
	dc.s	0.301773,0.671628
	dc.s	0.303778,0.663914
	dc.s	0.215125,0.520309
	dc.s	0.210111,0.524523
	dc.s	0.217217,0.527801
	dc.s	0.215125,0.520309
	dc.s	0.217217,0.527801
	dc.s	0.230888,0.523294
	dc.s	0.230888,0.523294
	dc.s	0.217217,0.527801
	dc.s	0.229162,0.530176
	dc.s	0.149502,0.646036
	dc.s	0.143970,0.652023
	dc.s	0.154880,0.659099
	dc.s	0.149502,0.646036
	dc.s	0.143830,0.639377
	dc.s	0.143970,0.652023
	dc.s	0.149618,0.635416
	dc.s	0.143830,0.639377
	dc.s	0.149502,0.646036
	dc.s	0.149618,0.635416
	dc.s	0.146425,0.608148
	dc.s	0.143830,0.639377
	dc.s	0.230888,0.523294
	dc.s	0.229162,0.530176
	dc.s	0.256037,0.524857
	dc.s	0.283744,0.583277
	dc.s	0.279455,0.583956
	dc.s	0.288250,0.590813
	dc.s	0.279455,0.583956
	dc.s	0.284140,0.594073
	dc.s	0.288250,0.590813
	dc.s	0.223207,0.445691
	dc.s	0.217503,0.449297
	dc.s	0.220174,0.462312
	dc.s	0.284140,0.594073
	dc.s	0.288159,0.614273
	dc.s	0.293137,0.605836
	dc.s	0.293137,0.605836
	dc.s	0.288159,0.614273
	dc.s	0.294866,0.623656
	dc.s	0.214090,0.471647
	dc.s	0.211987,0.491526
	dc.s	0.218398,0.482028
	dc.s	0.216249,0.508203
	dc.s	0.209767,0.519962
	dc.s	0.215125,0.520309
	dc.s	0.211987,0.491526
	dc.s	0.209767,0.519962
	dc.s	0.216249,0.508203
	dc.s	0.218398,0.482028
	dc.s	0.211987,0.491526
	dc.s	0.216249,0.508203
	dc.s	0.209767,0.519962
	dc.s	0.210111,0.524523
	dc.s	0.215125,0.520309
	dc.s	0.256236,0.666246
	dc.s	0.258598,0.673385
	dc.s	0.269565,0.673587
	dc.s	0.209767,0.519962
	dc.s	0.205502,0.521388
	dc.s	0.210111,0.524523
	dc.s	0.284848,0.659230
	dc.s	0.273479,0.663798
	dc.s	0.288622,0.662064
	dc.s	0.288622,0.662064
	dc.s	0.273479,0.663798
	dc.s	0.269565,0.673587
	dc.s	0.273479,0.663798
	dc.s	0.265666,0.665703
	dc.s	0.269565,0.673587
	dc.s	0.265666,0.665703
	dc.s	0.256236,0.666246
	dc.s	0.269565,0.673587
	dc.s	0.258598,0.673385
	dc.s	0.260138,0.679782
	dc.s	0.269565,0.673587
	dc.s	0.248617,0.672939
	dc.s	0.260138,0.679782
	dc.s	0.258598,0.673385
	dc.s	0.248617,0.672939
	dc.s	0.238330,0.672672
	dc.s	0.242468,0.678996
	dc.s	0.238330,0.672672
	dc.s	0.223308,0.671091
	dc.s	0.242468,0.678996
	dc.s	0.234819,0.665644
	dc.s	0.223308,0.671091
	dc.s	0.238330,0.672672
	dc.s	0.183385,0.656901
	dc.s	0.184417,0.661403
	dc.s	0.194271,0.657902
	dc.s	0.223570,0.664463
	dc.s	0.223308,0.671091
	dc.s	0.234819,0.665644
	dc.s	0.194271,0.657902
	dc.s	0.223308,0.671091
	dc.s	0.223570,0.664463
	dc.s	0.194271,0.657902
	dc.s	0.184417,0.661403
	dc.s	0.196516,0.662815
	dc.s	0.194271,0.657902
	dc.s	0.196516,0.662815
	dc.s	0.223308,0.671091
	dc.s	0.164539,0.632502
	dc.s	0.165209,0.642281
	dc.s	0.172656,0.636482
	dc.s	0.172656,0.636482
	dc.s	0.165209,0.642281
	dc.s	0.170590,0.648202
	dc.s	0.172656,0.636482
	dc.s	0.170590,0.648202
	dc.s	0.177963,0.645433
	dc.s	0.177963,0.645433
	dc.s	0.170590,0.648202
	dc.s	0.180943,0.651205
	dc.s	0.170590,0.648202
	dc.s	0.175189,0.657700
	dc.s	0.180943,0.651205
	dc.s	0.183385,0.656901
	dc.s	0.175189,0.657700
	dc.s	0.184417,0.661403
	dc.s	0.180943,0.651205
	dc.s	0.175189,0.657700
	dc.s	0.183385,0.656901
	dc.s	0.164539,0.632502
	dc.s	0.159832,0.639832
	dc.s	0.165209,0.642281
	dc.s	0.176057,0.583019
	dc.s	0.176114,0.591850
	dc.s	0.180198,0.583730
	dc.s	0.176057,0.583019
	dc.s	0.172636,0.588225
	dc.s	0.176114,0.591850
	dc.s	0.310184,0.617318
	dc.s	0.308411,0.627006
	dc.s	0.304363,0.621133
	dc.s	0.176114,0.591850
	dc.s	0.168877,0.597431
	dc.s	0.173230,0.605105
	dc.s	0.173230,0.605105
	dc.s	0.164539,0.632502
	dc.s	0.172656,0.636482
	dc.s	0.308411,0.627006
	dc.s	0.306965,0.636576
	dc.s	0.301610,0.635083
	dc.s	0.173230,0.605105
	dc.s	0.166871,0.606524
	dc.s	0.164539,0.632502
	dc.s	0.120571,0.831556
	dc.s	0.105320,0.832707
	dc.s	0.101942,0.827693
	dc.s	0.153793,0.833240
	dc.s	0.142322,0.837739
	dc.s	0.120571,0.831556
	dc.s	0.349901,0.432269
	dc.s	0.369156,0.435683
	dc.s	0.345270,0.438353
	dc.s	0.120571,0.831556
	dc.s	0.115339,0.835252
	dc.s	0.105320,0.832707
	dc.s	0.341859,0.518709
	dc.s	0.346899,0.532309
	dc.s	0.336325,0.532566
	dc.s	0.341859,0.518709
	dc.s	0.351503,0.518841
	dc.s	0.346899,0.532309
	dc.s	0.351503,0.518841
	dc.s	0.361825,0.525595
	dc.s	0.346899,0.532309
	dc.s	0.371964,0.517134
	dc.s	0.361825,0.525595
	dc.s	0.351503,0.518841
	dc.s	0.420553,0.519074
	dc.s	0.428436,0.522574
	dc.s	0.427830,0.527278
	dc.s	0.420553,0.519074
	dc.s	0.427830,0.527278
	dc.s	0.415565,0.523097
	dc.s	0.120062,0.682731
	dc.s	0.128164,0.680934
	dc.s	0.123165,0.677427
	dc.s	0.412470,0.517669
	dc.s	0.415565,0.523097
	dc.s	0.398815,0.522767
	dc.s	0.371964,0.517134
	dc.s	0.373493,0.523401
	dc.s	0.361825,0.525595
	dc.s	0.393701,0.516447
	dc.s	0.373493,0.523401
	dc.s	0.371964,0.517134
	dc.s	0.393701,0.516447
	dc.s	0.398815,0.522767
	dc.s	0.373493,0.523401
	dc.s	0.393701,0.516447
	dc.s	0.412470,0.517669
	dc.s	0.398815,0.522767
	dc.s	0.321268,0.517244
	dc.s	0.322163,0.531620
	dc.s	0.317130,0.531393
	dc.s	0.321268,0.517244
	dc.s	0.326605,0.517658
	dc.s	0.322163,0.531620
	dc.s	0.328292,0.507179
	dc.s	0.326605,0.517658
	dc.s	0.321268,0.517244
	dc.s	0.322244,0.504464
	dc.s	0.328292,0.507179
	dc.s	0.321268,0.517244
	dc.s	0.327956,0.499253
	dc.s	0.328292,0.507179
	dc.s	0.322244,0.504464
	dc.s	0.320344,0.489043
	dc.s	0.327956,0.499253
	dc.s	0.322244,0.504464
	dc.s	0.320344,0.489043
	dc.s	0.326712,0.489650
	dc.s	0.327956,0.499253
	dc.s	0.321119,0.472566
	dc.s	0.326712,0.489650
	dc.s	0.320344,0.489043
	dc.s	0.328504,0.465439
	dc.s	0.326712,0.489650
	dc.s	0.321119,0.472566
	dc.s	0.325080,0.454065
	dc.s	0.328504,0.465439
	dc.s	0.321119,0.472566
	dc.s	0.333411,0.437370
	dc.s	0.336401,0.440094
	dc.s	0.325080,0.454065
	dc.s	0.336401,0.440094
	dc.s	0.328504,0.465439
	dc.s	0.325080,0.454065
	dc.s	0.153793,0.833240
	dc.s	0.182515,0.831179
	dc.s	0.164839,0.837398
	dc.s	0.424745,0.438131
	dc.s	0.426743,0.441777
	dc.s	0.421126,0.440637
	dc.s	0.182515,0.831179
	dc.s	0.205116,0.825478
	dc.s	0.201028,0.830709
	dc.s	0.404737,0.431361
	dc.s	0.421126,0.440637
	dc.s	0.402919,0.436947
	dc.s	0.404737,0.431361
	dc.s	0.402919,0.436947
	dc.s	0.389090,0.435589
	dc.s	0.154880,0.659099
	dc.s	0.143970,0.652023
	dc.s	0.151139,0.660792
	dc.s	0.135459,0.677243
	dc.s	0.143371,0.681177
	dc.s	0.144456,0.672287
	dc.s	0.138379,0.664997
	dc.s	0.151139,0.660792
	dc.s	0.143970,0.652023
	dc.s	0.135459,0.677243
	dc.s	0.144456,0.672287
	dc.s	0.136064,0.672614
	dc.s	0.136064,0.672614
	dc.s	0.144456,0.672287
	dc.s	0.138379,0.664997
	dc.s	0.138379,0.664997
	dc.s	0.144456,0.672287
	dc.s	0.147796,0.664887
	dc.s	0.138379,0.664997
	dc.s	0.147796,0.664887
	dc.s	0.151139,0.660792
	dc.s	0.441695,0.498480
	dc.s	0.447191,0.514020
	dc.s	0.443079,0.515319
	dc.s	0.435658,0.502731
	dc.s	0.443079,0.515319
	dc.s	0.430871,0.514643
	dc.s	0.439792,0.519223
	dc.s	0.435723,0.530567
	dc.s	0.427830,0.527278
	dc.s	0.430871,0.514643
	dc.s	0.443079,0.515319
	dc.s	0.439792,0.519223
	dc.s	0.439792,0.519223
	dc.s	0.427830,0.527278
	dc.s	0.428436,0.522574
	dc.s	0.430871,0.514643
	dc.s	0.439792,0.519223
	dc.s	0.428436,0.522574
	dc.s	0.441695,0.498480
	dc.s	0.443079,0.515319
	dc.s	0.435658,0.502731
	dc.s	0.424745,0.438131
	dc.s	0.430726,0.441139
	dc.s	0.426743,0.441777
	dc.s	0.430726,0.441139
	dc.s	0.430103,0.450419
	dc.s	0.426743,0.441777
	dc.s	0.430726,0.441139
	dc.s	0.433807,0.446989
	dc.s	0.430103,0.450419
	dc.s	0.290916,0.442908
	dc.s	0.292826,0.453386
	dc.s	0.296436,0.446382
	dc.s	0.434338,0.490647
	dc.s	0.441695,0.498480
	dc.s	0.435658,0.502731
	dc.s	0.437126,0.457334
	dc.s	0.441695,0.498480
	dc.s	0.434338,0.490647
	dc.s	0.292826,0.453386
	dc.s	0.301159,0.487125
	dc.s	0.298787,0.459436
	dc.s	0.430103,0.450419
	dc.s	0.437126,0.457334
	dc.s	0.432585,0.463308
	dc.s	0.427865,0.435235
	dc.s	0.430726,0.441139
	dc.s	0.424745,0.438131
	dc.s	0.287627,0.431003
	dc.s	0.282533,0.435048
	dc.s	0.289566,0.436983
	dc.s	0.213107,0.809255
	dc.s	0.216500,0.816035
	dc.s	0.208641,0.821075
	dc.s	0.275682,0.427448
	dc.s	0.271116,0.432501
	dc.s	0.282533,0.435048
	dc.s	0.214665,0.798773
	dc.s	0.220806,0.804737
	dc.s	0.213107,0.809255
	dc.s	0.253689,0.425925
	dc.s	0.252930,0.432169
	dc.s	0.265088,0.426203
	dc.s	0.265088,0.426203
	dc.s	0.252930,0.432169
	dc.s	0.271116,0.432501
	dc.s	0.226734,0.431532
	dc.s	0.222247,0.433992
	dc.s	0.221086,0.438103
	dc.s	0.280626,0.578016
	dc.s	0.279455,0.583956
	dc.s	0.283744,0.583277
	dc.s	0.226734,0.431532
	dc.s	0.225090,0.437353
	dc.s	0.232963,0.434878
	dc.s	0.214893,0.787494
	dc.s	0.212532,0.772984
	dc.s	0.221284,0.786743
	dc.s	0.212532,0.772984
	dc.s	0.207543,0.760823
	dc.s	0.216427,0.766986
	dc.s	0.239024,0.427633
	dc.s	0.232963,0.434878
	dc.s	0.252930,0.432169
	dc.s	0.277690,0.580239
	dc.s	0.273904,0.583283
	dc.s	0.279455,0.583956
	dc.s	0.277690,0.580239
	dc.s	0.265614,0.581496
	dc.s	0.273904,0.583283
	dc.s	0.181049,0.751368
	dc.s	0.191583,0.749145
	dc.s	0.204421,0.756383
	dc.s	0.182421,0.580435
	dc.s	0.185684,0.583100
	dc.s	0.195153,0.581186
	dc.s	0.255705,0.574709
	dc.s	0.235815,0.578344
	dc.s	0.265614,0.581496
	dc.s	0.226390,0.572655
	dc.s	0.235815,0.578344
	dc.s	0.255705,0.574709
	dc.s	0.199653,0.575384
	dc.s	0.182421,0.580435
	dc.s	0.195153,0.581186
	dc.s	0.226390,0.572655
	dc.s	0.199653,0.575384
	dc.s	0.195153,0.581186
	dc.s	0.226390,0.572655
	dc.s	0.195153,0.581186
	dc.s	0.235815,0.578344
	dc.s	0.185684,0.583100
	dc.s	0.182421,0.580435
	dc.s	0.180198,0.583730
	dc.s	0.180198,0.583730
	dc.s	0.182421,0.580435
	dc.s	0.176057,0.583019
	dc.s	0.182421,0.580435
	dc.s	0.179397,0.577814
	dc.s	0.176057,0.583019
	dc.s	0.099924,0.761342
	dc.s	0.095457,0.773634
	dc.s	0.091500,0.767435
	dc.s	0.318962,0.609635
	dc.s	0.311373,0.611840
	dc.s	0.312864,0.606363
	dc.s	0.095457,0.773634
	dc.s	0.093349,0.788737
	dc.s	0.086251,0.789313
	dc.s	0.374684,0.605722
	dc.s	0.376893,0.611128
	dc.s	0.370032,0.609242
	dc.s	0.094330,0.807862
	dc.s	0.099187,0.823102
	dc.s	0.091016,0.818455
	dc.s	0.359429,0.601678
	dc.s	0.370032,0.609242
	dc.s	0.355673,0.606952
	dc.s	0.093349,0.788737
	dc.s	0.094330,0.807862
	dc.s	0.087157,0.804109
	dc.s	0.093349,0.788737
	dc.s	0.087157,0.804109
	dc.s	0.086251,0.789313
	dc.s	0.099187,0.823102
	dc.s	0.101942,0.827693
	dc.s	0.095308,0.825309
	dc.s	0.340862,0.606366
	dc.s	0.318962,0.609635
	dc.s	0.325167,0.602641
	dc.s	0.043758,0.590245
	dc.s	0.035417,0.593722
	dc.s	0.043223,0.594729
	dc.s	0.029842,0.605252
	dc.s	0.037658,0.607224
	dc.s	0.033081,0.599312
	dc.s	0.033081,0.599312
	dc.s	0.037658,0.607224
	dc.s	0.041035,0.600171
	dc.s	0.035417,0.593722
	dc.s	0.033081,0.599312
	dc.s	0.041035,0.600171
	dc.s	0.043223,0.594729
	dc.s	0.035417,0.593722
	dc.s	0.041035,0.600171
	dc.s	0.025543,0.610498
	dc.s	0.020297,0.613572
	dc.s	0.023890,0.620281
	dc.s	0.343740,0.687815
	dc.s	0.353397,0.695743
	dc.s	0.342725,0.694371
	dc.s	0.023961,0.637847
	dc.s	0.030580,0.636808
	dc.s	0.024857,0.628784
	dc.s	0.024857,0.628784
	dc.s	0.030580,0.636808
	dc.s	0.032272,0.626135
	dc.s	0.024857,0.628784
	dc.s	0.032272,0.626135
	dc.s	0.023890,0.620281
	dc.s	0.023890,0.620281
	dc.s	0.032272,0.626135
	dc.s	0.032597,0.616393
	dc.s	0.023890,0.620281
	dc.s	0.032597,0.616393
	dc.s	0.025543,0.610498
	dc.s	0.025543,0.610498
	dc.s	0.032597,0.616393
	dc.s	0.029842,0.605252
	dc.s	0.032597,0.616393
	dc.s	0.037658,0.607224
	dc.s	0.029842,0.605252
	dc.s	0.371244,0.687764
	dc.s	0.374214,0.701318
	dc.s	0.365486,0.701577
	dc.s	0.371244,0.687764
	dc.s	0.365486,0.701577
	dc.s	0.362535,0.688370
	dc.s	0.343740,0.687815
	dc.s	0.362535,0.688370
	dc.s	0.353397,0.695743
	dc.s	0.362535,0.688370
	dc.s	0.365486,0.701577
	dc.s	0.353397,0.695743
