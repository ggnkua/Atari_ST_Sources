 dc.w 12  ; NUMCAM    
 dc.w 91  ; NUMVERTS  
 dc.w 480  ; TNUMVERTS 
 dc.w 160  ; NUMFACES  
 dc.s 0.789582  ; camera_fov 
 dc.l camera_hisp  ; camera     
 dc.l coords_housesky  ; coords     
 dc.l faces_housesky   ; faces      
 dc.l tcoords_housesky ; tcoords    
 dc.l tex_housesky+20 ; palette    
 dc.l textures_housesky ; textures    
textures_housesky: 
 dc.l tex_housesky+20+768+256*256*0 
tex_housesky: incbin "house\sky.apx"
camera_housesky:				;x,y,z , rx,ry,rz,rw , time
	dc.s -29.509800,-3.129400,-0.528000,0.198500,-0.960100,0.197100,1.604500,0.000000
	dc.s -13.996200,-3.129400,1.363700,0.198500,-0.960100,0.197100,1.604500,0.200000
	dc.s -4.245200,-3.129400,-4.687400,0.136700,-0.938900,0.316000,2.369800,0.400000
	dc.s 9.126600,-3.129400,3.105500,-0.288200,-0.902100,0.321200,4.502500,0.600000
	dc.s 8.078500,7.870600,2.716400,0.048600,-0.997900,-0.043600,4.818500,0.800000
	dc.s 0.017300,7.870600,2.846700,-0.136800,-0.987500,0.077700,5.239100,1.000000
coords_housesky:				;x,y,z
	dc.s	0.000000,100.000000,0.000000
	dc.s	25.989193,96.193840,-8.444400
	dc.s	0.000000,96.193840,-27.326653
	dc.s	50.000000,85.065079,-16.245985
	dc.s	26.286554,89.442719,-36.180340
	dc.s	0.000000,85.065079,-52.573109
	dc.s	70.204643,67.460892,-22.810871
	dc.s	52.573109,72.360680,-44.721359
	dc.s	26.286554,72.360680,-63.819660
	dc.s	0.000000,67.460892,-73.817535
	dc.s	85.065079,44.721359,-27.639320
	dc.s	70.204643,50.572090,-50.137527
	dc.s	50.000000,52.573109,-68.819092
	dc.s	25.989193,50.572090,-82.261932
	dc.s	0.000000,44.721359,-89.442719
	dc.s	16.062202,96.193840,22.107727
	dc.s	30.901701,85.065079,42.532539
	dc.s	42.532539,89.442719,13.819660
	dc.s	43.388855,67.460892,59.719639
	dc.s	58.778526,72.360680,36.180340
	dc.s	68.819092,72.360680,5.278641
	dc.s	52.573109,44.721359,72.360680
	dc.s	69.378052,50.572090,51.275234
	dc.s	80.901703,52.573109,26.286554
	dc.s	86.266846,50.572090,-0.703145
	dc.s	-16.062202,96.193840,22.107727
	dc.s	-30.901701,85.065079,42.532539
	dc.s	0.000000,89.442719,44.721359
	dc.s	-43.388855,67.460892,59.719639
	dc.s	-16.245985,72.360680,67.082039
	dc.s	16.245985,72.360680,67.082039
	dc.s	-52.573109,44.721359,72.360680
	dc.s	-27.326653,50.572090,81.827370
	dc.s	0.000000,52.573109,85.065079
	dc.s	27.326653,50.572090,81.827370
	dc.s	-25.989193,96.193840,-8.444400
	dc.s	-50.000000,85.065079,-16.245985
	dc.s	-42.532539,89.442719,13.819660
	dc.s	-70.204643,67.460892,-22.810871
	dc.s	-68.819092,72.360680,5.278641
	dc.s	-58.778526,72.360680,36.180340
	dc.s	-85.065079,44.721359,-27.639320
	dc.s	-86.266846,50.572090,-0.703145
	dc.s	-80.901703,52.573109,26.286554
	dc.s	-69.378052,50.572090,51.275234
	dc.s	-26.286554,89.442719,-36.180340
	dc.s	-26.286554,72.360680,-63.819660
	dc.s	-52.573109,72.360680,-44.721359
	dc.s	-25.989193,50.572090,-82.261932
	dc.s	-50.000000,52.573109,-68.819092
	dc.s	-70.204643,50.572090,-50.137527
	dc.s	16.062202,23.245440,-95.925262
	dc.s	42.532539,27.639320,-86.180344
	dc.s	30.901701,0.000000,-95.105652
	dc.s	68.819092,27.639320,-67.082039
	dc.s	58.778526,0.000000,-80.901703
	dc.s	86.266846,23.245440,-44.918598
	dc.s	80.901703,0.000000,-58.778526
	dc.s	96.193840,23.245440,-14.366472
	dc.s	95.105652,27.639320,13.819660
	dc.s	100.000000,0.000000,0.000000
	dc.s	85.065079,27.639320,44.721359
	dc.s	95.105652,0.000000,30.901701
	dc.s	69.378052,23.245440,68.164040
	dc.s	80.901703,0.000000,58.778526
	dc.s	43.388855,23.245440,87.046288
	dc.s	16.245985,27.639320,94.721359
	dc.s	30.901701,0.000000,95.105652
	dc.s	-16.245985,27.639320,94.721359
	dc.s	0.000000,0.000000,100.000000
	dc.s	-43.388855,23.245440,87.046288
	dc.s	-30.901701,0.000000,95.105652
	dc.s	-69.378052,23.245440,68.164040
	dc.s	-85.065079,27.639320,44.721359
	dc.s	-80.901703,0.000000,58.778526
	dc.s	-95.105652,27.639320,13.819660
	dc.s	-95.105652,0.000000,30.901701
	dc.s	-96.193840,23.245440,-14.366472
	dc.s	-100.000000,0.000000,0.000000
	dc.s	-86.266846,23.245440,-44.918598
	dc.s	-68.819092,27.639320,-67.082039
	dc.s	-80.901703,0.000000,-58.778526
	dc.s	-42.532539,27.639320,-86.180344
	dc.s	-58.778526,0.000000,-80.901703
	dc.s	-16.062202,23.245440,-95.925262
	dc.s	-30.901701,0.000000,-95.105652
	dc.s	95.105652,0.000000,-30.901701
	dc.s	58.778526,0.000000,80.901703
	dc.s	-58.778526,0.000000,80.901703
	dc.s	-95.105652,0.000000,-30.901701
	dc.s	0.000000,0.000000,-100.000000
faces_housesky:				;f1,f2,f3 , tf1,tf2,tf3 , texnum , flag
	dc.w 1,2,0,  0,1,2,  0,0
	dc.w 3,4,1,  3,4,5,  0,0
	dc.w 5,2,4,  6,7,8,  0,0
	dc.w 4,2,1,  9,10,11,  0,0
	dc.w 6,7,3,  12,13,14,  0,0
	dc.w 7,8,4,  15,16,17,  0,0
	dc.w 9,5,8,  18,19,20,  0,0
	dc.w 7,4,3,  21,22,23,  0,0
	dc.w 8,5,4,  24,25,26,  0,0
	dc.w 10,11,6,  27,28,29,  0,0
	dc.w 11,12,7,  30,31,32,  0,0
	dc.w 13,8,12,  33,34,35,  0,0
	dc.w 14,9,13,  36,37,38,  0,0
	dc.w 11,7,6,  39,40,41,  0,0
	dc.w 12,8,7,  42,43,44,  0,0
	dc.w 13,9,8,  45,46,47,  0,0
	dc.w 15,1,0,  48,49,50,  0,0
	dc.w 16,17,15,  51,52,53,  0,0
	dc.w 3,1,17,  54,55,56,  0,0
	dc.w 17,1,15,  57,58,59,  0,0
	dc.w 18,19,16,  60,61,62,  0,0
	dc.w 19,20,17,  63,64,65,  0,0
	dc.w 6,3,20,  66,67,68,  0,0
	dc.w 19,17,16,  69,70,71,  0,0
	dc.w 20,3,17,  72,73,74,  0,0
	dc.w 21,22,18,  75,76,77,  0,0
	dc.w 22,23,19,  78,79,80,  0,0
	dc.w 24,20,23,  81,82,83,  0,0
	dc.w 10,6,24,  84,85,86,  0,0
	dc.w 22,19,18,  87,88,89,  0,0
	dc.w 23,20,19,  90,91,92,  0,0
	dc.w 24,6,20,  93,94,95,  0,0
	dc.w 25,15,0,  96,97,98,  0,0
	dc.w 26,27,25,  99,100,101,  0,0
	dc.w 16,15,27,  102,103,104,  0,0
	dc.w 27,15,25,  105,106,107,  0,0
	dc.w 28,29,26,  108,109,110,  0,0
	dc.w 29,30,27,  111,112,113,  0,0
	dc.w 18,16,30,  114,115,116,  0,0
	dc.w 29,27,26,  117,118,119,  0,0
	dc.w 30,16,27,  120,121,122,  0,0
	dc.w 31,32,28,  123,124,125,  0,0
	dc.w 32,33,29,  126,127,128,  0,0
	dc.w 34,30,33,  129,130,131,  0,0
	dc.w 21,18,34,  132,133,134,  0,0
	dc.w 32,29,28,  135,136,137,  0,0
	dc.w 33,30,29,  138,139,140,  0,0
	dc.w 34,18,30,  141,142,143,  0,0
	dc.w 25,0,35,  144,145,146,  0,0
	dc.w 36,37,35,  147,148,149,  0,0
	dc.w 26,25,37,  150,151,152,  0,0
	dc.w 37,25,35,  153,154,155,  0,0
	dc.w 38,39,36,  156,157,158,  0,0
	dc.w 40,37,39,  159,160,161,  0,0
	dc.w 28,26,40,  162,163,164,  0,0
	dc.w 39,37,36,  165,166,167,  0,0
	dc.w 40,26,37,  168,169,170,  0,0
	dc.w 41,42,38,  171,172,173,  0,0
	dc.w 42,43,39,  174,175,176,  0,0
	dc.w 44,40,43,  177,178,179,  0,0
	dc.w 31,28,44,  180,181,182,  0,0
	dc.w 42,39,38,  183,184,185,  0,0
	dc.w 43,40,39,  186,187,188,  0,0
	dc.w 44,28,40,  189,190,191,  0,0
	dc.w 35,0,2,  192,193,194,  0,0
	dc.w 5,45,2,  195,196,197,  0,0
	dc.w 36,35,45,  198,199,200,  0,0
	dc.w 45,35,2,  201,202,203,  0,0
	dc.w 9,46,5,  204,205,206,  0,0
	dc.w 47,45,46,  207,208,209,  0,0
	dc.w 38,36,47,  210,211,212,  0,0
	dc.w 46,45,5,  213,214,215,  0,0
	dc.w 47,36,45,  216,217,218,  0,0
	dc.w 14,48,9,  219,220,221,  0,0
	dc.w 48,49,46,  222,223,224,  0,0
	dc.w 50,47,49,  225,226,227,  0,0
	dc.w 41,38,50,  228,229,230,  0,0
	dc.w 48,46,9,  231,232,233,  0,0
	dc.w 49,47,46,  234,235,236,  0,0
	dc.w 50,38,47,  237,238,239,  0,0
	dc.w 51,14,13,  240,241,242,  0,0
	dc.w 52,13,12,  243,244,245,  0,0
	dc.w 53,51,52,  246,247,248,  0,0
	dc.w 51,13,52,  249,250,251,  0,0
	dc.w 54,12,11,  252,253,254,  0,0
	dc.w 55,52,54,  255,256,257,  0,0
	dc.w 54,52,12,  258,259,260,  0,0
	dc.w 55,53,52,  261,262,263,  0,0
	dc.w 56,11,10,  264,265,266,  0,0
	dc.w 57,54,56,  267,268,269,  0,0
	dc.w 56,54,11,  270,271,272,  0,0
	dc.w 57,55,54,  273,274,275,  0,0
	dc.w 58,10,24,  276,277,278,  0,0
	dc.w 59,24,23,  279,280,281,  0,0
	dc.w 60,58,59,  282,283,284,  0,0
	dc.w 58,24,59,  285,286,287,  0,0
	dc.w 61,23,22,  288,289,290,  0,0
	dc.w 62,59,61,  291,292,293,  0,0
	dc.w 61,59,23,  294,295,296,  0,0
	dc.w 62,60,59,  297,298,299,  0,0
	dc.w 63,22,21,  300,301,302,  0,0
	dc.w 64,61,63,  303,304,305,  0,0
	dc.w 63,61,22,  306,307,308,  0,0
	dc.w 64,62,61,  309,310,311,  0,0
	dc.w 65,21,34,  312,313,314,  0,0
	dc.w 66,34,33,  315,316,317,  0,0
	dc.w 67,65,66,  318,319,320,  0,0
	dc.w 65,34,66,  321,322,323,  0,0
	dc.w 68,33,32,  324,325,326,  0,0
	dc.w 69,66,68,  327,328,329,  0,0
	dc.w 66,33,68,  330,331,332,  0,0
	dc.w 69,67,66,  333,334,335,  0,0
	dc.w 70,32,31,  336,337,338,  0,0
	dc.w 71,68,70,  339,340,341,  0,0
	dc.w 70,68,32,  342,343,344,  0,0
	dc.w 69,68,71,  345,346,347,  0,0
	dc.w 72,31,44,  348,349,350,  0,0
	dc.w 73,44,43,  351,352,353,  0,0
	dc.w 74,72,73,  354,355,356,  0,0
	dc.w 72,44,73,  357,358,359,  0,0
	dc.w 75,43,42,  360,361,362,  0,0
	dc.w 76,73,75,  363,364,365,  0,0
	dc.w 73,43,75,  366,367,368,  0,0
	dc.w 74,73,76,  369,370,371,  0,0
	dc.w 77,42,41,  372,373,374,  0,0
	dc.w 78,75,77,  375,376,377,  0,0
	dc.w 77,75,42,  378,379,380,  0,0
	dc.w 76,75,78,  381,382,383,  0,0
	dc.w 79,41,50,  384,385,386,  0,0
	dc.w 80,50,49,  387,388,389,  0,0
	dc.w 81,79,80,  390,391,392,  0,0
	dc.w 79,50,80,  393,394,395,  0,0
	dc.w 82,49,48,  396,397,398,  0,0
	dc.w 83,80,82,  399,400,401,  0,0
	dc.w 80,49,82,  402,403,404,  0,0
	dc.w 81,80,83,  405,406,407,  0,0
	dc.w 84,48,14,  408,409,410,  0,0
	dc.w 85,82,84,  411,412,413,  0,0
	dc.w 84,82,48,  414,415,416,  0,0
	dc.w 83,82,85,  417,418,419,  0,0
	dc.w 60,86,58,  420,421,422,  0,0
	dc.w 86,57,56,  423,424,425,  0,0
	dc.w 58,56,10,  426,427,428,  0,0
	dc.w 86,56,58,  429,430,431,  0,0
	dc.w 67,87,65,  432,433,434,  0,0
	dc.w 87,64,63,  435,436,437,  0,0
	dc.w 65,63,21,  438,439,440,  0,0
	dc.w 87,63,65,  441,442,443,  0,0
	dc.w 88,72,74,  444,445,446,  0,0
	dc.w 71,70,88,  447,448,449,  0,0
	dc.w 70,31,72,  450,451,452,  0,0
	dc.w 88,70,72,  453,454,455,  0,0
	dc.w 89,79,81,  456,457,458,  0,0
	dc.w 78,77,89,  459,460,461,  0,0
	dc.w 77,41,79,  462,463,464,  0,0
	dc.w 89,77,79,  465,466,467,  0,0
	dc.w 53,90,51,  468,469,470,  0,0
	dc.w 85,84,90,  471,472,473,  0,0
	dc.w 84,14,51,  474,475,476,  0,0
	dc.w 90,84,51,  477,478,479,  0,0
tcoords_housesky:				;u,v
	dc.s	0.550000,0.734340
	dc.s	0.750000,0.734340
	dc.s	0.650000,0.994500
	dc.s	0.550000,0.515970
	dc.s	0.650000,0.581495
	dc.s	0.550000,0.734340
	dc.s	0.750000,0.515970
	dc.s	0.750000,0.734340
	dc.s	0.650000,0.581495
	dc.s	0.650000,0.581495
	dc.s	0.750000,0.734340
	dc.s	0.550000,0.734340
	dc.s	0.550000,0.342620
	dc.s	0.612184,0.382081
	dc.s	0.550000,0.515970
	dc.s	0.612184,0.382081
	dc.s	0.687816,0.382081
	dc.s	0.650000,0.581495
	dc.s	0.750000,0.342620
	dc.s	0.750000,0.515970
	dc.s	0.687816,0.382081
	dc.s	0.612184,0.382081
	dc.s	0.650000,0.581495
	dc.s	0.550000,0.515970
	dc.s	0.687816,0.382081
	dc.s	0.750000,0.515970
	dc.s	0.650000,0.581495
	dc.s	0.550000,0.200791
	dc.s	0.598703,0.232730
	dc.s	0.550000,0.342620
	dc.s	0.598703,0.232730
	dc.s	0.650000,0.244227
	dc.s	0.612184,0.382081
	dc.s	0.701297,0.232730
	dc.s	0.687816,0.382081
	dc.s	0.650000,0.244227
	dc.s	0.750000,0.200791
	dc.s	0.750000,0.342620
	dc.s	0.701297,0.232730
	dc.s	0.598703,0.232730
	dc.s	0.612184,0.382081
	dc.s	0.550000,0.342620
	dc.s	0.650000,0.244227
	dc.s	0.687816,0.382081
	dc.s	0.612184,0.382081
	dc.s	0.701297,0.232730
	dc.s	0.750000,0.342620
	dc.s	0.687816,0.382081
	dc.s	0.350000,0.734340
	dc.s	0.550000,0.734340
	dc.s	0.450000,0.994500
	dc.s	0.350000,0.515970
	dc.s	0.450000,0.581495
	dc.s	0.350000,0.734340
	dc.s	0.550000,0.515970
	dc.s	0.550000,0.734340
	dc.s	0.450000,0.581495
	dc.s	0.450000,0.581495
	dc.s	0.550000,0.734340
	dc.s	0.350000,0.734340
	dc.s	0.350000,0.342620
	dc.s	0.412184,0.382081
	dc.s	0.350000,0.515970
	dc.s	0.412184,0.382081
	dc.s	0.487816,0.382081
	dc.s	0.450000,0.581495
	dc.s	0.550000,0.342620
	dc.s	0.550000,0.515970
	dc.s	0.487816,0.382081
	dc.s	0.412184,0.382081
	dc.s	0.450000,0.581495
	dc.s	0.350000,0.515970
	dc.s	0.487816,0.382081
	dc.s	0.550000,0.515970
	dc.s	0.450000,0.581495
	dc.s	0.350000,0.200791
	dc.s	0.398703,0.232730
	dc.s	0.350000,0.342620
	dc.s	0.398703,0.232730
	dc.s	0.450000,0.244227
	dc.s	0.412184,0.382081
	dc.s	0.501297,0.232730
	dc.s	0.487816,0.382081
	dc.s	0.450000,0.244227
	dc.s	0.550000,0.200791
	dc.s	0.550000,0.342620
	dc.s	0.501297,0.232730
	dc.s	0.398703,0.232730
	dc.s	0.412184,0.382081
	dc.s	0.350000,0.342620
	dc.s	0.450000,0.244227
	dc.s	0.487816,0.382081
	dc.s	0.412184,0.382081
	dc.s	0.501297,0.232730
	dc.s	0.550000,0.342620
	dc.s	0.487816,0.382081
	dc.s	0.150000,0.734340
	dc.s	0.350000,0.734340
	dc.s	0.250000,0.994500
	dc.s	0.150000,0.515970
	dc.s	0.250000,0.581495
	dc.s	0.150000,0.734340
	dc.s	0.350000,0.515970
	dc.s	0.350000,0.734340
	dc.s	0.250000,0.581495
	dc.s	0.250000,0.581495
	dc.s	0.350000,0.734340
	dc.s	0.150000,0.734340
	dc.s	0.150000,0.342620
	dc.s	0.212184,0.382081
	dc.s	0.150000,0.515970
	dc.s	0.212184,0.382081
	dc.s	0.287816,0.382081
	dc.s	0.250000,0.581495
	dc.s	0.350000,0.342620
	dc.s	0.350000,0.515970
	dc.s	0.287816,0.382081
	dc.s	0.212184,0.382081
	dc.s	0.250000,0.581495
	dc.s	0.150000,0.515970
	dc.s	0.287816,0.382081
	dc.s	0.350000,0.515970
	dc.s	0.250000,0.581495
	dc.s	0.150000,0.200791
	dc.s	0.198703,0.232730
	dc.s	0.150000,0.342620
	dc.s	0.198703,0.232730
	dc.s	0.250000,0.244227
	dc.s	0.212184,0.382081
	dc.s	0.301297,0.232730
	dc.s	0.287816,0.382081
	dc.s	0.250000,0.244227
	dc.s	0.350000,0.200791
	dc.s	0.350000,0.342620
	dc.s	0.301297,0.232730
	dc.s	0.198703,0.232730
	dc.s	0.212184,0.382081
	dc.s	0.150000,0.342620
	dc.s	0.250000,0.244227
	dc.s	0.287816,0.382081
	dc.s	0.212184,0.382081
	dc.s	0.301297,0.232730
	dc.s	0.350000,0.342620
	dc.s	0.287816,0.382081
	dc.s	0.150000,0.734340
	dc.s	0.050000,0.994500
	dc.s	-0.050000,0.734340
	dc.s	0.950000,0.515970
	dc.s	1.050000,0.581495
	dc.s	0.950000,0.734340
	dc.s	0.150000,0.515970
	dc.s	0.150000,0.734340
	dc.s	0.050000,0.581495
	dc.s	0.050000,0.581495
	dc.s	0.150000,0.734340
	dc.s	-0.050000,0.734340
	dc.s	0.950000,0.342620
	dc.s	1.012184,0.382081
	dc.s	0.950000,0.515970
	dc.s	0.087816,0.382081
	dc.s	0.050000,0.581495
	dc.s	0.012184,0.382081
	dc.s	0.150000,0.342620
	dc.s	0.150000,0.515970
	dc.s	0.087816,0.382081
	dc.s	1.012184,0.382081
	dc.s	1.050000,0.581495
	dc.s	0.950000,0.515970
	dc.s	0.087816,0.382081
	dc.s	0.150000,0.515970
	dc.s	0.050000,0.581495
	dc.s	0.950000,0.200791
	dc.s	0.998703,0.232730
	dc.s	0.950000,0.342620
	dc.s	-0.001297,0.232730
	dc.s	0.050000,0.244227
	dc.s	0.012184,0.382081
	dc.s	0.101297,0.232730
	dc.s	0.087816,0.382081
	dc.s	0.050000,0.244227
	dc.s	0.150000,0.200791
	dc.s	0.150000,0.342620
	dc.s	0.101297,0.232730
	dc.s	0.998703,0.232730
	dc.s	1.012184,0.382081
	dc.s	0.950000,0.342620
	dc.s	0.050000,0.244227
	dc.s	0.087816,0.382081
	dc.s	0.012184,0.382081
	dc.s	0.101297,0.232730
	dc.s	0.150000,0.342620
	dc.s	0.087816,0.382081
	dc.s	0.950000,0.734340
	dc.s	0.850000,0.994500
	dc.s	0.750000,0.734340
	dc.s	0.750000,0.515970
	dc.s	0.850000,0.581495
	dc.s	0.750000,0.734340
	dc.s	0.950000,0.515970
	dc.s	0.950000,0.734340
	dc.s	0.850000,0.581495
	dc.s	0.850000,0.581495
	dc.s	0.950000,0.734340
	dc.s	0.750000,0.734340
	dc.s	0.750000,0.342620
	dc.s	0.812184,0.382081
	dc.s	0.750000,0.515970
	dc.s	0.887816,0.382081
	dc.s	0.850000,0.581495
	dc.s	0.812184,0.382081
	dc.s	0.950000,0.342620
	dc.s	0.950000,0.515970
	dc.s	0.887816,0.382081
	dc.s	0.812184,0.382081
	dc.s	0.850000,0.581495
	dc.s	0.750000,0.515970
	dc.s	0.887816,0.382081
	dc.s	0.950000,0.515970
	dc.s	0.850000,0.581495
	dc.s	0.750000,0.200791
	dc.s	0.798703,0.232730
	dc.s	0.750000,0.342620
	dc.s	0.798703,0.232730
	dc.s	0.850000,0.244227
	dc.s	0.812184,0.382081
	dc.s	0.901297,0.232730
	dc.s	0.887816,0.382081
	dc.s	0.850000,0.244227
	dc.s	0.950000,0.200791
	dc.s	0.950000,0.342620
	dc.s	0.901297,0.232730
	dc.s	0.798703,0.232730
	dc.s	0.812184,0.382081
	dc.s	0.750000,0.342620
	dc.s	0.850000,0.244227
	dc.s	0.887816,0.382081
	dc.s	0.812184,0.382081
	dc.s	0.901297,0.232730
	dc.s	0.950000,0.342620
	dc.s	0.887816,0.382081
	dc.s	0.723595,0.098765
	dc.s	0.750000,0.200791
	dc.s	0.701297,0.232730
	dc.s	0.677034,0.118167
	dc.s	0.701297,0.232730
	dc.s	0.650000,0.244227
	dc.s	0.700000,0.003697
	dc.s	0.723595,0.098765
	dc.s	0.677034,0.118167
	dc.s	0.723595,0.098765
	dc.s	0.701297,0.232730
	dc.s	0.677034,0.118167
	dc.s	0.622966,0.118167
	dc.s	0.650000,0.244227
	dc.s	0.598703,0.232730
	dc.s	0.650000,0.003697
	dc.s	0.677034,0.118167
	dc.s	0.622966,0.118167
	dc.s	0.622966,0.118167
	dc.s	0.677034,0.118167
	dc.s	0.650000,0.244227
	dc.s	0.650000,0.003697
	dc.s	0.700000,0.003697
	dc.s	0.677034,0.118167
	dc.s	0.576405,0.098765
	dc.s	0.598703,0.232730
	dc.s	0.550000,0.200791
	dc.s	0.600000,0.003697
	dc.s	0.622966,0.118167
	dc.s	0.576405,0.098765
	dc.s	0.576405,0.098765
	dc.s	0.622966,0.118167
	dc.s	0.598703,0.232730
	dc.s	0.600000,0.003697
	dc.s	0.650000,0.003697
	dc.s	0.622966,0.118167
	dc.s	0.523595,0.098765
	dc.s	0.550000,0.200791
	dc.s	0.501297,0.232730
	dc.s	0.477034,0.118167
	dc.s	0.501297,0.232730
	dc.s	0.450000,0.244227
	dc.s	0.500000,0.003697
	dc.s	0.523595,0.098765
	dc.s	0.477034,0.118167
	dc.s	0.523595,0.098765
	dc.s	0.501297,0.232730
	dc.s	0.477034,0.118167
	dc.s	0.422966,0.118167
	dc.s	0.450000,0.244227
	dc.s	0.398703,0.232730
	dc.s	0.450000,0.003697
	dc.s	0.477034,0.118167
	dc.s	0.422966,0.118167
	dc.s	0.422966,0.118167
	dc.s	0.477034,0.118167
	dc.s	0.450000,0.244227
	dc.s	0.450000,0.003697
	dc.s	0.500000,0.003697
	dc.s	0.477034,0.118167
	dc.s	0.376405,0.098765
	dc.s	0.398703,0.232730
	dc.s	0.350000,0.200791
	dc.s	0.400000,0.003697
	dc.s	0.422966,0.118167
	dc.s	0.376405,0.098765
	dc.s	0.376405,0.098765
	dc.s	0.422966,0.118167
	dc.s	0.398703,0.232730
	dc.s	0.400000,0.003697
	dc.s	0.450000,0.003697
	dc.s	0.422966,0.118167
	dc.s	0.323595,0.098765
	dc.s	0.350000,0.200791
	dc.s	0.301297,0.232730
	dc.s	0.277034,0.118167
	dc.s	0.301297,0.232730
	dc.s	0.250000,0.244227
	dc.s	0.300000,0.003697
	dc.s	0.323595,0.098765
	dc.s	0.277034,0.118167
	dc.s	0.323595,0.098765
	dc.s	0.301297,0.232730
	dc.s	0.277034,0.118167
	dc.s	0.222966,0.118167
	dc.s	0.250000,0.244227
	dc.s	0.198703,0.232730
	dc.s	0.250000,0.003697
	dc.s	0.277034,0.118167
	dc.s	0.222966,0.118167
	dc.s	0.277034,0.118167
	dc.s	0.250000,0.244227
	dc.s	0.222966,0.118167
	dc.s	0.250000,0.003697
	dc.s	0.300000,0.003697
	dc.s	0.277034,0.118167
	dc.s	0.176405,0.098765
	dc.s	0.198703,0.232730
	dc.s	0.150000,0.200791
	dc.s	0.200000,0.003697
	dc.s	0.222966,0.118167
	dc.s	0.176405,0.098765
	dc.s	0.176405,0.098765
	dc.s	0.222966,0.118167
	dc.s	0.198703,0.232730
	dc.s	0.250000,0.003697
	dc.s	0.222966,0.118167
	dc.s	0.200000,0.003697
	dc.s	0.123595,0.098765
	dc.s	0.150000,0.200791
	dc.s	0.101297,0.232730
	dc.s	0.077034,0.118167
	dc.s	0.101297,0.232730
	dc.s	0.050000,0.244227
	dc.s	0.100000,0.003697
	dc.s	0.123595,0.098765
	dc.s	0.077034,0.118167
	dc.s	0.123595,0.098765
	dc.s	0.101297,0.232730
	dc.s	0.077034,0.118167
	dc.s	0.022966,0.118167
	dc.s	0.050000,0.244227
	dc.s	-0.001297,0.232730
	dc.s	0.050000,0.003697
	dc.s	0.077034,0.118167
	dc.s	0.022966,0.118167
	dc.s	0.077034,0.118167
	dc.s	0.050000,0.244227
	dc.s	0.022966,0.118167
	dc.s	0.100000,0.003697
	dc.s	0.077034,0.118167
	dc.s	0.050000,0.003697
	dc.s	0.976405,0.098765
	dc.s	0.998703,0.232730
	dc.s	0.950000,0.200791
	dc.s	1.000000,0.003697
	dc.s	1.022966,0.118167
	dc.s	0.976405,0.098765
	dc.s	0.976405,0.098765
	dc.s	1.022966,0.118167
	dc.s	0.998703,0.232730
	dc.s	0.050000,0.003697
	dc.s	0.022966,0.118167
	dc.s	0.000000,0.003697
	dc.s	0.923595,0.098765
	dc.s	0.950000,0.200791
	dc.s	0.901297,0.232730
	dc.s	0.877034,0.118167
	dc.s	0.901297,0.232730
	dc.s	0.850000,0.244227
	dc.s	0.900000,0.003697
	dc.s	0.923595,0.098765
	dc.s	0.877034,0.118167
	dc.s	0.923595,0.098765
	dc.s	0.901297,0.232730
	dc.s	0.877034,0.118167
	dc.s	0.822966,0.118167
	dc.s	0.850000,0.244227
	dc.s	0.798703,0.232730
	dc.s	0.850000,0.003697
	dc.s	0.877034,0.118167
	dc.s	0.822966,0.118167
	dc.s	0.877034,0.118167
	dc.s	0.850000,0.244227
	dc.s	0.822966,0.118167
	dc.s	0.900000,0.003697
	dc.s	0.877034,0.118167
	dc.s	0.850000,0.003697
	dc.s	0.776405,0.098765
	dc.s	0.798703,0.232730
	dc.s	0.750000,0.200791
	dc.s	0.800000,0.003697
	dc.s	0.822966,0.118167
	dc.s	0.776405,0.098765
	dc.s	0.776405,0.098765
	dc.s	0.822966,0.118167
	dc.s	0.798703,0.232730
	dc.s	0.850000,0.003697
	dc.s	0.822966,0.118167
	dc.s	0.800000,0.003697
	dc.s	0.500000,0.003697
	dc.s	0.550000,0.003697
	dc.s	0.523595,0.098765
	dc.s	0.550000,0.003697
	dc.s	0.600000,0.003697
	dc.s	0.576405,0.098765
	dc.s	0.523595,0.098765
	dc.s	0.576405,0.098765
	dc.s	0.550000,0.200791
	dc.s	0.550000,0.003697
	dc.s	0.576405,0.098765
	dc.s	0.523595,0.098765
	dc.s	0.300000,0.003697
	dc.s	0.350000,0.003697
	dc.s	0.323595,0.098765
	dc.s	0.350000,0.003697
	dc.s	0.400000,0.003697
	dc.s	0.376405,0.098765
	dc.s	0.323595,0.098765
	dc.s	0.376405,0.098765
	dc.s	0.350000,0.200791
	dc.s	0.350000,0.003697
	dc.s	0.376405,0.098765
	dc.s	0.323595,0.098765
	dc.s	0.150000,0.003697
	dc.s	0.123595,0.098765
	dc.s	0.100000,0.003697
	dc.s	0.200000,0.003697
	dc.s	0.176405,0.098765
	dc.s	0.150000,0.003697
	dc.s	0.176405,0.098765
	dc.s	0.150000,0.200791
	dc.s	0.123595,0.098765
	dc.s	0.150000,0.003697
	dc.s	0.176405,0.098765
	dc.s	0.123595,0.098765
	dc.s	0.950000,0.003697
	dc.s	0.923595,0.098765
	dc.s	0.900000,0.003697
	dc.s	1.000000,0.003697
	dc.s	0.976405,0.098765
	dc.s	0.950000,0.003697
	dc.s	0.976405,0.098765
	dc.s	0.950000,0.200791
	dc.s	0.923595,0.098765
	dc.s	0.950000,0.003697
	dc.s	0.976405,0.098765
	dc.s	0.923595,0.098765
	dc.s	0.700000,0.003697
	dc.s	0.750000,0.003697
	dc.s	0.723595,0.098765
	dc.s	0.800000,0.003697
	dc.s	0.776405,0.098765
	dc.s	0.750000,0.003697
	dc.s	0.776405,0.098765
	dc.s	0.750000,0.200791
	dc.s	0.723595,0.098765
	dc.s	0.750000,0.003697
	dc.s	0.776405,0.098765
	dc.s	0.723595,0.098765
