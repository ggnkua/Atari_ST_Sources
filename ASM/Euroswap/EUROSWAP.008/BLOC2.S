		
alpha1	dc.b	'ABCDEFGHIJKLMNOPQRSTUVWXYZ.!?,1234567890 '
	even
*  nom des jeux 
txt_p0	dc.b	'EUROSWAP CD 970',-1	; 20 caracteres maxi	
	even 
txt_p1	dc.b	'TRANSARTICA -B-',-1	; 18 maxi
	even
txt_p2	dc.b    'SNOOFY',-1	; 16 maxi
	even
the_scr	
	DC.B	" PASSWORDS-EUROSWAP PRESENTS YOU HIS CD 970   "
	DC.B	" WITH TRANSARTICA (B) - PACKED BY ORION -REPLICANTS, WARNING : THE EUROSWAP CD 971 REQUISITE !, YOU CAN TYPE ALSO THE THREE NUMERICAL TOUCH FOR SNOOFY... "
	DC.B	" SADEMAN FROM EXO7-EUROSWAP AT KEYBOARD IN THIS MOMENT...I WANT SAY THAT : REAL GREETINGS SO "
	DC.B	" GREETS TO SPEEDLIGHT AND TYPHON FROM THE OVERLANDERS, X-RAY FROM ELECTRA... "
	DC.B	" SNOCKS GREETS TO ALDO & PROSPER...SNOCKS GREETS IS A GREET FOR GREETING AN "
	DC.B	" ALL OLD FRIENDS.....SKYWALKER FROM EXO7 ALSO AT KEYBOARD NOW...MEGA BIG HELLO AND GREETING TO : "
	DC.B	" AXYLAN - SADMAN - R-BOY - DR TRAP - RED BARONS - GUICHE - GOOFY - BVCA - MICHAWK "
	DC.B	" - OXYD - CORPO - DR CLONE - HITCHER - FAST EASY - INFIRMIER - ETERNAL - HYSTERIA "
	DC.B	" - OVERLANDERS - TBO - AND OTHERS CONTACTS ON ATARI...."
	DC.B	" AND NOW I LEAVE THE KEYBOARD AND GIVE IT TO LAURENZO FROM PASSWORDS-EUROSWAP..."
	DC.B    "IT'S LAURENZO AT KEYBOARD NOW...I WANT PRESENT YOU THE ALLIANCE OF EUROSWAP..."
	DC.B    "THIS ALLIANCE IS THE UNION OF THREE CREWS NAMED > PASSWORDS > SELECT > EXO7 "
	DC.B    "THE CURRENT MEMBERS ARE IN THIS MOMENT FOR PASSWORDS - THE WAY TO FUNLAND ! : LAURENZO - DARKO - "
	DC.B    "- TESTAMENT -  PHYMAX -  ARCHON - THE COP - SPA 160 - FRANCOIS - THE BIKER - YNEXYX - "
	DC.B    " WINNER - TEX - BOBO STE - LOLO 77 - ST 123 - LA FLECHE - ZASTAPH - ANTAEUS ..." 
	DC.B    " - ...FOR SELECT : SARK - WARRIOR - KILLER'S -  ....FOR EXO7 : SADEMAN - "
	DC.B    " - SKYWALKER - .......BESTS REGARDS TO : "
	DC.B    "REPLICANTS + FUZION + ICS + VMAX + ULTIMATE + POMPEY PIRATES + RADIATION + THUNDERBIRDS + "
	DC.B    "CYNIX + BAD BOYS BELGIUM + POSITIVITY + APEX DEV. + ANIMAL MINE + ZUUL + ILLUSIONS + "
	DC.B    "EAGLES + SYNDICATE + IMPACT + TSB + EXTRACT + KGB + SECTOR ONE + HMD + PIRACY + JEDI, ATLANTIS, GANDJA KID, COL PEPPERS,-1 "
	
	even

;   nom des fichiers prg
fil1	dc.b	"",0
	even
fil2	dc.b	"",0
	even
fil3	dc.b	"SNOOFY.prg",0
        even
