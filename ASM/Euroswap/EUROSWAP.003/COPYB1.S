*
*  NEOchrome V2.27 cut buffer contents (left justified):
*  by Chaos, Inc. of the Delta Force (member of The Union)
*
*    pixels/scanline    = $0010 (bytes/scanline: $0008)
*  # scanlines (height) = $0008
*
*  Hardware color pallet  (color 0 to 15):
*
*      $0000,$0122,$0445,$0677,$0710,$0510,$0710,$0700
*      $0777,$0777,$0677,$0777,$0777,$0510,$0600,$0700
*
*
		dc.w	$3C00,$0000,$0000,$0000,$2E00,$7000,$0000,$0000
		dc.w	$ED00,$7200,$0000,$0000,$9F00,$6000,$0000,$0000
		dc.w	$F900,$0600,$0000,$0000,$F500,$4E00,$0000,$0000
		dc.w	$7200,$0C00,$0000,$0000,$3C00,$0000,$0000,$0000
