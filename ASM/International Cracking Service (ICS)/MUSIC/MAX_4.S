* MUSIC RIPPED BY: EMLING/DEFLECT/ICS

	MOVE.W	#$20,-(SP)
	TRAP	#1
	ADDQ.L	#2,SP

	MOVE.W	#3,-(SP)
	TRAP	#14
	ADDQ.L	#2,SP
 
	MOVE.B	#1,$FFF8260

	MOVEQ	#1,D0
	JSR	MUSIC
	MOVE.L	#MUSIC+8,$4D2

RET	CMP.B	#185,$FFFC02
	BNE	RET
	CLR.L	$4D2
	CLR.L	-(SP)
	TRAP	#1

MUSIC	INCBIN	MUSIC\MAX_4.MUS
