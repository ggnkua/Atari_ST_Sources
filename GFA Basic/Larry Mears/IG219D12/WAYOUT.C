int wayout[] =
{
	100, 477, -1, 15, 1, 3, -16384, -1,
	-4572, 12, 0, -1, -1966, 3, 19661, 1,
	-31588, 0, 1, -4080, -256, -4080, -256, 10,
	12944, 0, 0, 10, 12944, 293, -5746, -264,
	-17086, 282, 10212, -275, -15067, -264, -17086, 40,
	0, 0, 0, 0, 0, 0, 0, 0,
	0, 0, 0, 0, 0, 0, 0, 0
};
