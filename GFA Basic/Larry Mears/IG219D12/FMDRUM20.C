int fmdrum20[] =
{
	4, 1250, -1, 15, 1, 3, -16384, -1,
	-8192, 0, 0, -1, -8937, 0, 0, 0,
	0, 0, 1, -4057, 2971, -4057, 2971, 338,
	5214, 0, 0, 4056, -2971, 1537, -10240, -1118,
	572, 1537, -10240, -1118, 572, -1118, 572, 0,
	1, 0, 0, 0, 0, 0, 0, 0,
	0, 0, 0, 0, 0, 0, 0, 0
};
