int dias[] =
{
	140, 25, -1, 15, 1, 0, -13797, -1,
	-983, 14, -19661, -1, -17203, 6, 0, 5,
	-15729, 0, 1, 7487, 26809, 7487, 26809, -1,
	1410, 1616, 31150, -1, -17677, 12285, 0, -2580,
	9830, 10319, 26214, -3072, -16384, -2580, 9830, 0,
	0, 0, 0, 0, 0, 0, 0, 0,
	0, 0, 0, 0, 0, 0, 0, 0
};
