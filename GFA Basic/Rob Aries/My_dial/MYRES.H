/* resource set indices for MYRES */

#define REQUEST    0 /* form/dialog */

#define BATCHCOP   1 /* form/dialog */

#define DOSELECT   2 /* form/dialog */

#define DEFAULTS   3 /* form/dialog */

