/* resource set indicies for LSTSPRIT */

#define MENU1    0	/* menu tree */

#define FORM2    1	/* form/dialog */

