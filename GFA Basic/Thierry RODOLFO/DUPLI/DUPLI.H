/* Resource Datei Indizes f�r DUPLI */

#define MENU     0   /* Menuebaum */
