#define TREE1 0  	/* TREE */
#define NLQEIN 2  	/* OBJECT in TREE #0 */
#define NLQAUS 3  	/* OBJECT in TREE #0 */
#define PROPEIN 6  	/* OBJECT in TREE #0 */
#define PROPAUS 7  	/* OBJECT in TREE #0 */
#define KURSEIN 10  	/* OBJECT in TREE #0 */
#define KURSAUS 11  	/* OBJECT in TREE #0 */
#define SCHMEIN 45  	/* OBJECT in TREE #0 */
#define SCHMAUS 46  	/* OBJECT in TREE #0 */
#define DOPPEIN 18  	/* OBJECT in TREE #0 */
#define DOPPAUS 19  	/* OBJECT in TREE #0 */
#define FETTEIN 14  	/* OBJECT in TREE #0 */
#define FETTAUS 15  	/* OBJECT in TREE #0 */
#define PERFEIN 22  	/* OBJECT in TREE #0 */
#define PERFAUS 23  	/* OBJECT in TREE #0 */
#define LREIN 26  	/* OBJECT in TREE #0 */
#define LRAUS 27  	/* OBJECT in TREE #0 */
#define PAPEIN 30  	/* OBJECT in TREE #0 */
#define PAPAUS 31  	/* OBJECT in TREE #0 */
#define ELITE 34  	/* OBJECT in TREE #0 */
#define PCA 35  	/* OBJECT in TREE #0 */
#define ACHTEL 37  	/* OBJECT in TREE #0 */
#define SECHSTEL 38  	/* OBJECT in TREE #0 */
#define PROBE 39  	/* OBJECT in TREE #0 */
#define INIT 40  	/* OBJECT in TREE #0 */
#define ABBRUCH 41  	/* OBJECT in TREE #0 */
