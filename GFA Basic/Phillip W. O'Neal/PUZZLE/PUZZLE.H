/* Resource File Indices for PUZZLE */

#define MAIN     0   /* Form/Dialog */
