/* Resource File Indices for HAVEAFIT */

#define MENU     0   /* Menu Tree */
