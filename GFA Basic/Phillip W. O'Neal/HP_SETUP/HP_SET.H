/* Resource File Indices for HP_SET */

#define MAIN     0   /* Form/Dialog */
