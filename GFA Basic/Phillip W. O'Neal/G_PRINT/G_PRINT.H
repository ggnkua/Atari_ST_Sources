/* Resource file indices for G_PRINT. */

#define MENU             0   /* Menu-tree */

#define MAIN             1   /* Form/Dialog-box */

#define SELECT_FONT      2   /* Form/Dialog-box */

#define PAGE             3   /* Form/Dialog-box */
