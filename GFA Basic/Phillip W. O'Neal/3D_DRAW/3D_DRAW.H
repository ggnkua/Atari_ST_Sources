/* Resource file indices for 3D_DRAW. */

#define MENU             0   /* Menu-tree */

#define OBJECT_EDIT      1   /* Form/Dialog-box */

#define PREFERENCES      2   /* Form/Dialog-box */

#define SCALE            3   /* Form/Dialog-box */

#define MOVE             4   /* Form/Dialog-box */

#define FLIP             5   /* Form/Dialog-box */
