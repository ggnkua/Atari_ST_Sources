/* Resource file indices for DALEKS. */

#define MENU             0   /* Menu-tree */

#define ICONS            1   /* Form/Dialog-box */
