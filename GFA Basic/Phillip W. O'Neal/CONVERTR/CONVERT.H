/* Resource File Indices for CONVERT */

#define MAIN     0   /* Form/Dialog */

#define MENU     1   /* Menu Tree */
