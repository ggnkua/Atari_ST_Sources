/* Resource File Indices for FULL_DIR */

#define MENU     0   /* Menu Tree */

#define MAIN     1   /* Form/Dialog */

#define STATUS   2   /* Form/Dialog */
