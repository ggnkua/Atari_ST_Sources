/* Resource file indices for GDOSTEST. */

#define MENU             0   /* Menu-tree */

#define MAIN             1   /* Form/Dialog-box */

#define TITLE            2   /* Form/Dialog-box */

#define PICK             3   /* Form/Dialog-box */
