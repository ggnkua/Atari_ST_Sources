/* resource set indicies for TEST */

#define FORM     0	/* form/dialog */
#define WINDOW   0	/* BOX in tree FORM */
#define RECT1    1	/* BOX in tree FORM */
#define RADIO1   2	/* BUTTON in tree FORM */
#define RADIO2   3	/* BUTTON in tree FORM */
#define RADIO3   4	/* BUTTON in tree FORM */
#define RECT2    5	/* BOX in tree FORM */
#define RADIOA   6	/* BUTTON in tree FORM */
#define RADIOB   7	/* BUTTON in tree FORM */
#define RADIOC   8	/* BUTTON in tree FORM */
#define ICON1    9	/* ICON in tree FORM */
#define ICON2    10	/* ICON in tree FORM */
#define ICON4    11	/* ICON in tree FORM */
#define ICON3    12	/* ICON in tree FORM */
#define STRING1  13	/* BUTTON in tree FORM */
#define CANCEL   14	/* BUTTON in tree FORM */
#define OK       15	/* BUTTON in tree FORM */
#define EDIT     16	/* FTEXT in tree FORM */
#define ROBJE    17	/* STRING in tree FORM */

