* 
.dc.w    $0024,$0026,$0000,$0000,$0000,$0000,$0000,$0000
.dc.w    $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
.dc.w    $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
.dc.w    $FE00,$0000,$0003,$FF80,$0000,$000F,$01E0,$0000
.dc.w    $001C,$1070,$0000,$0038,$1038,$0000,$0070,$101C
.dc.w    $0000,$0060,$004C,$0000,$00C0,$00C6,$0000,$00C0
.dc.w    $0186,$0000,$0180,$8303,$0000,$0180,$C603,$0000
.dc.w    $0180,$6C03,$0000,$01B8,$383B,$0000,$0180,$1003
.dc.w    $0000,$0180,$0003,$0000,$0180,$0003,$0000,$00C0
.dc.w    $0006,$0000,$00C0,$0006,$0000,$0060,$000C,$0000
.dc.w    $0070,$101C,$0000,$0038,$1038,$0000,$001C,$1070
.dc.w    $0000,$000F,$01E0,$0000,$0003,$FF80,$0000,$0000
.dc.w    $FE00,$0000,$0000,$0000,$0000,$0000,$0000,$0000
.dc.w    $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
.dc.w    $0000
