* 
.dc.w    $0017,$0025,$0000,$0000,$0000,$0000,$0000,$0000
.dc.w    $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
.dc.w    $0000,$000F,$FF00,$0000,$003F,$FFC0,$0000,$007F
.dc.w    $FFE0,$0000,$00F0,$00F0,$0000,$01F6,$06F8,$0000
.dc.w    $01F7,$FEF8,$0000,$01E7,$0E78,$0000,$01CE,$0738
.dc.w    $0000,$009E,$0790,$0000,$003F,$0FC0,$0000,$007F
.dc.w    $FFE0,$0000,$007F,$FFE0,$0000,$007F,$FFE0,$0000
.dc.w    $007F,$FFE0,$0000,$000C,$0300,$0000,$0000,$0000
.dc.w    $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
.dc.w    $0000,$0000
