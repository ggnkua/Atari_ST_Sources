* 
.dc.w    $002E,$002E,$0000,$0000,$0000,$0000,$0000,$0000
.dc.w    $0000,$0000,$0000,$0000,$0000,$0000,$0000,$1C00
.dc.w    $0000,$0000,$3200,$0000,$0000,$2100,$0000,$0000
.dc.w    $2080,$0000,$0000,$2040,$0000,$0000,$1020,$0000
.dc.w    $0000,$0D10,$0000,$0000,$0638,$0000,$0000,$0264
.dc.w    $0000,$0000,$019E,$0000,$0000,$00A5,$0000,$0000
.dc.w    $00A4,$8000,$0000,$0D24,$4000,$0000,$133F,$A000
.dc.w    $0000,$2102,$E000,$0000,$2102,$1000,$0000,$2181
.dc.w    $1000,$0000,$7080,$8800,$0000,$D8C0,$8800,$0000
.dc.w    $8840,$4800,$0000,$8BC0,$2400,$0000,$DCC0,$0400
.dc.w    $0001,$6520,$0400,$0001,$2620,$0400,$0001,$3660
.dc.w    $0400,$0001,$0BE0,$0400,$0000,$C660,$0400,$0000
.dc.w    $EFD0,$0400,$0000,$BBA8,$0400,$0000,$5F58,$0C00
.dc.w    $0000,$62A0,$0C00,$0000,$3050,$C400,$0000,$100F
.dc.w    $0400,$0000,$0C04,$0200,$0000,$030A,$0200,$0000
.dc.w    $01F9,$0100,$0000,$0074,$8080,$0000,$0032,$0000
.dc.w    $0000,$0000,$0000,$0000,$0000,$0000,$0000,$0000
.dc.w    $0000,$0000,$0000,$0000,$0000,$0000,$0000
