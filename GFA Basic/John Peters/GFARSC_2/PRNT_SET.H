/* resource set indicies for PRNT_SET */

#define PRNTSET  0	/* form/dialog */
#define DMP      3	/* BUTTON in tree PRNTSET */
#define DAISY    4	/* BUTTON in tree PRNTSET */
#define MONO     6	/* BUTTON in tree PRNTSET */
#define COLOUR   7	/* BUTTON in tree PRNTSET */
#define ATARIP   9	/* BUTTON in tree PRNTSET */
#define EPSON    10	/* BUTTON in tree PRNTSET */
#define DRAFT    12	/* BUTTON in tree PRNTSET */
#define NLQ      13	/* BUTTON in tree PRNTSET */
#define CENTRONC 15	/* BUTTON in tree PRNTSET */
#define RS232    16	/* BUTTON in tree PRNTSET */
#define CONTINUS 18	/* BUTTON in tree PRNTSET */
#define SINGLE   19	/* BUTTON in tree PRNTSET */
#define PRTOK    20	/* BUTTON in tree PRNTSET */
