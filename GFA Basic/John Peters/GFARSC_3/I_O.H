/* resource set indicies for I_O */

#define EDIT     0	/* form/dialog */
#define DECREMNT 1	/* BOXCHAR in tree EDIT */
#define ENTRYNO  2	/* FTEXT in tree EDIT */
#define INCRMT   3	/* BOXCHAR in tree EDIT */
#define NAME     4	/* FTEXT in tree EDIT */
#define LOCATN   5	/* FTEXT in tree EDIT */
#define COMMENT  6	/* FTEXT in tree EDIT */
#define PHONENO  7	/* FTEXT in tree EDIT */
#define FILE     8	/* STRING in tree EDIT */
#define FILENAME 9	/* FTEXT in tree EDIT */
#define CANCEL   10	/* BUTTON in tree EDIT */
#define SAVE     11	/* BUTTON in tree EDIT */
