/* Resource-Set indicies fuer CO_DEMO */

#define MENUELEI 0	/* Menuebaum */
#define DESKINFO 9	/* STRING in Baum MENUELEI */
#define DATLADEN 18	/* STRING in Baum MENUELEI */
#define DATSICH  19	/* STRING in Baum MENUELEI */
#define DATENDE  21	/* STRING in Baum MENUELEI */
#define EINGNAME 23	/* STRING in Baum MENUELEI */
#define EINGKFZ  24	/* STRING in Baum MENUELEI */
#define EINGDING 25	/* STRING in Baum MENUELEI */
#define AUSGPRT  27	/* STRING in Baum MENUELEI */
#define AUSGFILE 28	/* STRING in Baum MENUELEI */

#define FORMINFO 1	/* Formula/Dialog */
#define INFOOK   1	/* BUTTON in Baum FORMINFO */

#define FORMEING 2	/* Formula/Dialog */
#define EINGNORM 4	/* BUTTON in Baum FORMEING */
#define EINGUNNO 5	/* BUTTON in Baum FORMEING */
#define EINGEGAL 6	/* BUTTON in Baum FORMEING */
#define EINEDIT1 7	/* FTEXT in Baum FORMEING */
#define EINEDIT2 8	/* FTEXT in Baum FORMEING */
#define EINGOK   9	/* BUTTON in Baum FORMEING */
#define EINGABBR 10	/* BUTTON in Baum FORMEING */

