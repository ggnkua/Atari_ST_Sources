/* resource set indicies for DEPACK_D */

#define MENU     0	/* form/dialog */
#define CADRE1   0	/* BOX in tree MENU */
#define DEPACK   1	/* BUTTON in tree MENU */
#define QUIT     2	/* BUTTON in tree MENU */
#define MENUVERS 10	/* TEXT in tree MENU */

#define INFO     1	/* form/dialog */
#define INFOBOX  0	/* BOX in tree INFO */
#define INF1     3	/* TEXT in tree INFO */
#define INF2     5	/* TEXT in tree INFO */
#define INF3     7	/* TEXT in tree INFO */
#define INF4     9	/* TEXT in tree INFO */
#define INF5     11	/* TEXT in tree INFO */
#define INFOOK   13	/* BUTTON in tree INFO */

#define AUTHOR   2	/* form/dialog */
#define AUTHORBX 0	/* BOX in tree AUTHOR */
#define AUTHOROK 14	/* BUTTON in tree AUTHOR */

#define AUTOD    3	/* form/dialog */
#define AUTODBOX 0	/* BOX in tree AUTOD */
#define AUTODOK  6	/* BUTTON in tree AUTOD */
