;
; ------------
; Sphere no 0
; ------------
;

sphere0    dc.b 46,-15,-3
           dc.b 41,-26,-5
           dc.b 24,42,-5
           dc.b 35,-32,-10
           dc.b 46,-7,-16
           dc.b 9,-48,-4
           dc.b 42,-12,-22
           dc.b 40,10,-25
           dc.b 38,11,-28
           dc.b 10,47,-8
           dc.b 12,-46,-11
           dc.b 30,21,-33
           dc.b 30,0,-38
           dc.b 13,-42,-20
           dc.b 20,-27,-35
           dc.b 21,3,-44
           dc.b 9,42,-24
           dc.b 13,-22,-41
           dc.b 0,-49,-1
           dc.b 8,10,-47
           dc.b 3,32,-37
           dc.b 0,41,-26
           dc.b -1,35,-34
           dc.b -4,-21,-44
           dc.b -7,27,-40
           dc.b -5,-45,-20
           dc.b -15,0,-46
           dc.b -4,-48,-11
           dc.b -20,14,-42
           dc.b -19,31,-32
           dc.b -27,-1,-40
           dc.b -30,5,-38
           dc.b -31,-15,-34
           dc.b -35,6,-34
           dc.b -6,49,-5
           dc.b -35,-21,-25
           dc.b -39,-15,-24
           dc.b -31,-34,-16
           dc.b 0,-49,0
           dc.b -35,-31,-12
           dc.b -33,34,-9
           dc.b 0,50,0
           dc.b -47,12,-6
           dc.b -38,-30,-2
           dc.b -41,27,0
           dc.b -47,-10,3
           dc.b -33,35,4
           dc.b -7,-49,1
           dc.b -37,30,10
           dc.b -19,-44,7
           dc.b -10,-48,4
           dc.b -23,-41,12
           dc.b -39,15,24
           dc.b -33,-25,24
           dc.b -26,36,21
           dc.b -7,48,6
           dc.b -2,49,2
           dc.b -22,-32,29
           dc.b -25,19,38
           dc.b -24,1,42
           dc.b 0,-49,0
           dc.b -11,-39,27
           dc.b -15,1,46
           dc.b -6,-42,24
           dc.b -4,-40,27
           dc.b -5,-3,48
           dc.b 0,-41,26
           dc.b 1,25,42
           dc.b 5,-3,48
           dc.b 3,-46,18
           dc.b 6,-40,27
           dc.b 10,35,32
           dc.b 5,-47,14
           dc.b 17,-29,35
           dc.b 9,-46,16
           dc.b 11,45,16
           dc.b 0,49,0
           dc.b 13,-45,14
           dc.b 20,-40,19
           dc.b 9,-48,7
           dc.b 39,-8,28
           dc.b 5,49,3
           dc.b 19,-44,10
           dc.b 7,-49,3
           dc.b 45,10,16
           dc.b 0,-49,0
           dc.b 8,49,1
           dc.b 46,15,6
           dc.b 40,27,2
           dc.b 11,-48,0
           dc.b 48,9,-3
           dc.b 15,47,-2
           dc.b 45,15,-9
           dc.b 46,12,-13
           dc.b 11,-48,-4
           dc.b 39,24,-17
           dc.b 43,7,-23
           dc.b 16,-46,-10
           dc.b 25,38,-18
           dc.b 20,41,-17
           dc.b 9,-48,-9
           dc.b 30,17,-34
           dc.b 10,46,-13
           dc.b 21,-32,-31
           dc.b 23,-15,-40
           dc.b 15,-34,-32
           dc.b 13,-34,-33
           dc.b 5,-46,-16
           dc.b 10,21,-43
           dc.b 6,-35,-34
           dc.b 1,-47,-15
           dc.b 0,-49,-8
           dc.b -1,-18,-45
           dc.b -2,41,-26
           dc.b -7,19,-45
           dc.b -6,-43,-24
           dc.b -11,-33,-35
           dc.b 0,49,-1
           dc.b 0,49,0
           dc.b -11,-44,-19
           dc.b -26,-16,-38
           dc.b -25,-27,-32
           dc.b -19,-40,-21
           dc.b -33,17,-31
           dc.b -7,-48,-6
           dc.b -28,-35,-20
           dc.b -33,30,-20
           dc.b -30,-36,-15
           dc.b -10,48,-4
           dc.b -13,-47,-4
           dc.b -29,38,-8
           dc.b -41,26,-8
           dc.b -45,18,-6
           dc.b -48,9,-3
           dc.b -12,-48,0
           dc.b -43,23,3
           dc.b -47,11,6
           dc.b -47,-4,10
           dc.b -26,40,7
           dc.b -46,7,16
           dc.b -36,-28,16
           dc.b -20,-44,10
           dc.b -40,11,25
           dc.b -39,2,28
           dc.b -36,10,30
           dc.b -34,-12,33
           dc.b -25,32,28
           dc.b -18,39,23
           dc.b -22,-28,33
           dc.b -20,-29,34
           dc.b -18,26,37
           dc.b -5,47,12
           dc.b -3,48,11
           dc.b -3,47,15
           dc.b -5,38,30
           dc.b -2,40,27
           dc.b -1,8,48
           dc.b 0,-49,7
           dc.b 5,1,48
           dc.b 4,-43,23
           dc.b 11,-5,47
           dc.b 13,22,41
           dc.b 4,-48,11
           dc.b 21,-13,43
           dc.b 23,-15,40
           dc.b 22,29,33
           dc.b 16,42,20
           dc.b 20,-39,22
           dc.b 22,38,21
           dc.b 32,25,27
           dc.b 10,48,7
           dc.b 41,-7,25
           dc.b 15,-46,7
           dc.b 42,19,18
           dc.b 31,-37,11
           dc.b 7,49,2
           dc.b 30,38,6
           dc.b 16,-46,2
           dc.b 48,-2,3
           dc.b 49,-6,0
;
; ------------
; Sphere no 1
; ------------
;

sphere1    dc.b 48,-16,-3
           dc.b 43,-27,-6
           dc.b 25,44,-5
           dc.b 37,-34,-10
           dc.b 47,-8,-17
           dc.b 9,-50,-4
           dc.b 44,-12,-23
           dc.b 42,10,-26
           dc.b 40,11,-29
           dc.b 11,49,-9
           dc.b 12,-48,-12
           dc.b 31,21,-34
           dc.b 31,0,-40
           dc.b 14,-44,-21
           dc.b 21,-29,-37
           dc.b 22,3,-45
           dc.b 10,44,-25
           dc.b 14,-23,-43
           dc.b 0,-51,-1
           dc.b 8,10,-49
           dc.b 4,33,-38
           dc.b 0,43,-27
           dc.b -1,36,-35
           dc.b -4,-21,-46
           dc.b -7,28,-42
           dc.b -5,-47,-20
           dc.b -15,0,-48
           dc.b -4,-50,-12
           dc.b -21,15,-44
           dc.b -20,32,-34
           dc.b -28,-1,-42
           dc.b -31,5,-40
           dc.b -32,-16,-36
           dc.b -36,6,-35
           dc.b -6,51,-5
           dc.b -37,-22,-27
           dc.b -41,-16,-25
           dc.b -33,-35,-17
           dc.b 0,-51,0
           dc.b -37,-32,-13
           dc.b -35,36,-10
           dc.b 0,52,0
           dc.b -49,12,-6
           dc.b -39,-32,-2
           dc.b -43,29,0
           dc.b -49,-10,3
           dc.b -35,37,5
           dc.b -8,-51,1
           dc.b -38,32,11
           dc.b -20,-46,7
           dc.b -10,-50,4
           dc.b -24,-43,13
           dc.b -41,16,25
           dc.b -35,-26,25
           dc.b -26,38,22
           dc.b -7,50,6
           dc.b -2,51,2
           dc.b -24,-34,30
           dc.b -26,20,38
           dc.b -25,1,44
           dc.b 0,-51,0
           dc.b -11,-41,28
           dc.b -15,1,48
           dc.b -6,-44,25
           dc.b -5,-42,28
           dc.b -5,-3,50
           dc.b -1,-43,28
           dc.b 1,26,44
           dc.b 5,-3,50
           dc.b 3,-47,19
           dc.b 7,-42,28
           dc.b 11,37,34
           dc.b 5,-49,14
           dc.b 18,-30,37
           dc.b 10,-47,17
           dc.b 11,47,17
           dc.b 0,51,0
           dc.b 14,-47,15
           dc.b 20,-42,20
           dc.b 9,-50,7
           dc.b 41,-9,29
           dc.b 6,51,4
           dc.b 20,-46,10
           dc.b 8,-51,3
           dc.b 46,10,17
           dc.b 0,-51,0
           dc.b 8,51,1
           dc.b 48,16,6
           dc.b 42,28,2
           dc.b 11,-50,0
           dc.b 50,9,-3
           dc.b 15,49,-2
           dc.b 47,16,-10
           dc.b 48,12,-13
           dc.b 11,-50,-4
           dc.b 41,25,-18
           dc.b 45,8,-23
           dc.b 16,-47,-10
           dc.b 25,40,-18
           dc.b 22,43,-18
           dc.b 10,-49,-9
           dc.b 32,17,-35
           dc.b 10,48,-13
           dc.b 21,-33,-32
           dc.b 24,-16,-42
           dc.b 16,-35,-34
           dc.b 14,-35,-35
           dc.b 5,-48,-17
           dc.b 11,21,-45
           dc.b 6,-36,-35
           dc.b 1,-49,-15
           dc.b 0,-51,-8
           dc.b -1,-19,-47
           dc.b -3,43,-28
           dc.b -8,20,-46
           dc.b -6,-45,-25
           dc.b -11,-34,-36
           dc.b 0,51,-1
           dc.b 0,51,0
           dc.b -11,-46,-19
           dc.b -27,-16,-40
           dc.b -26,-29,-33
           dc.b -20,-42,-22
           dc.b -34,17,-33
           dc.b -7,-50,-6
           dc.b -29,-36,-21
           dc.b -34,31,-21
           dc.b -30,-38,-16
           dc.b -11,50,-5
           dc.b -14,-49,-5
           dc.b -30,40,-8
           dc.b -43,27,-9
           dc.b -47,19,-6
           dc.b -50,9,-3
           dc.b -12,-50,0
           dc.b -44,24,3
           dc.b -49,11,6
           dc.b -49,-4,10
           dc.b -27,42,7
           dc.b -47,8,17
           dc.b -38,-29,17
           dc.b -21,-45,11
           dc.b -42,11,26
           dc.b -41,2,29
           dc.b -38,10,32
           dc.b -35,-12,34
           dc.b -26,33,28
           dc.b -19,40,25
           dc.b -23,-29,34
           dc.b -21,-30,36
           dc.b -19,27,39
           dc.b -5,49,13
           dc.b -4,50,12
           dc.b -3,49,15
           dc.b -5,40,31
           dc.b -3,42,28
           dc.b -1,9,50
           dc.b 0,-51,8
           dc.b 5,1,50
           dc.b 4,-45,24
           dc.b 12,-5,49
           dc.b 14,23,43
           dc.b 4,-50,11
           dc.b 21,-14,44
           dc.b 24,-16,42
           dc.b 23,30,34
           dc.b 16,44,21
           dc.b 21,-40,23
           dc.b 23,40,22
           dc.b 34,26,28
           dc.b 11,49,8
           dc.b 43,-8,27
           dc.b 15,-48,8
           dc.b 42,20,19
           dc.b 31,-38,11
           dc.b 8,51,2
           dc.b 31,40,6
           dc.b 16,-48,2
           dc.b 50,-2,3
           dc.b 51,-7,0
;
; ------------
; Sphere no 2
; ------------
;

sphere2    dc.b 50,-16,-3
           dc.b 44,-28,-6
           dc.b 26,46,-5
           dc.b 38,-35,-11
           dc.b 49,-8,-18
           dc.b 10,-52,-4
           dc.b 45,-13,-24
           dc.b 44,11,-27
           dc.b 42,12,-30
           dc.b 11,51,-9
           dc.b 13,-50,-13
           dc.b 32,22,-35
           dc.b 32,0,-41
           dc.b 15,-46,-22
           dc.b 22,-30,-38
           dc.b 23,3,-47
           dc.b 10,45,-25
           dc.b 14,-24,-45
           dc.b 0,-53,-1
           dc.b 9,11,-51
           dc.b 4,34,-40
           dc.b 1,45,-28
           dc.b -1,38,-37
           dc.b -5,-22,-47
           dc.b -7,29,-44
           dc.b -5,-48,-21
           dc.b -16,0,-50
           dc.b -4,-52,-12
           dc.b -22,15,-45
           dc.b -20,33,-35
           dc.b -29,-1,-43
           dc.b -32,5,-41
           dc.b -34,-16,-37
           dc.b -38,6,-36
           dc.b -6,53,-5
           dc.b -38,-23,-28
           dc.b -43,-16,-27
           dc.b -34,-36,-18
           dc.b 0,-53,0
           dc.b -38,-33,-14
           dc.b -36,37,-10
           dc.b 0,54,0
           dc.b -51,13,-7
           dc.b -41,-33,-2
           dc.b -44,30,0
           dc.b -51,-11,3
           dc.b -36,38,5
           dc.b -8,-53,1
           dc.b -40,33,11
           dc.b -21,-48,7
           dc.b -11,-52,5
           dc.b -25,-45,13
           dc.b -43,16,27
           dc.b -37,-27,27
           dc.b -27,39,23
           dc.b -7,52,7
           dc.b -2,53,2
           dc.b -24,-35,31
           dc.b -27,21,40
           dc.b -26,1,45
           dc.b 0,-53,0
           dc.b -11,-43,29
           dc.b -16,1,50
           dc.b -6,-46,26
           dc.b -5,-44,29
           dc.b -5,-3,52
           dc.b -1,-44,29
           dc.b 1,27,45
           dc.b 5,-3,52
           dc.b 3,-49,20
           dc.b 7,-44,29
           dc.b 11,38,35
           dc.b 6,-51,15
           dc.b 18,-31,38
           dc.b 10,-49,18
           dc.b 11,49,17
           dc.b 0,53,0
           dc.b 14,-49,15
           dc.b 21,-44,20
           dc.b 9,-52,8
           dc.b 42,-9,31
           dc.b 6,53,4
           dc.b 21,-48,11
           dc.b 8,-53,3
           dc.b 48,11,17
           dc.b 0,-53,0
           dc.b 9,53,2
           dc.b 50,16,7
           dc.b 44,29,3
           dc.b 12,-52,0
           dc.b 52,10,-3
           dc.b 16,51,-2
           dc.b 49,16,-10
           dc.b 49,13,-14
           dc.b 12,-52,-4
           dc.b 42,26,-19
           dc.b 46,8,-24
           dc.b 17,-49,-11
           dc.b 26,41,-19
           dc.b 22,44,-19
           dc.b 10,-51,-9
           dc.b 33,18,-37
           dc.b 11,50,-14
           dc.b 22,-34,-33
           dc.b 25,-16,-44
           dc.b 17,-36,-35
           dc.b 14,-36,-36
           dc.b 5,-50,-18
           dc.b 11,22,-46
           dc.b 6,-38,-37
           dc.b 1,-51,-16
           dc.b 0,-53,-9
           dc.b -1,-20,-49
           dc.b -3,44,-29
           dc.b -8,21,-48
           dc.b -6,-46,-26
           dc.b -12,-36,-38
           dc.b 0,53,-1
           dc.b 0,53,0
           dc.b -12,-48,-20
           dc.b -28,-17,-42
           dc.b -27,-30,-34
           dc.b -20,-43,-23
           dc.b -35,18,-34
           dc.b -8,-52,-7
           dc.b -30,-38,-22
           dc.b -36,32,-22
           dc.b -31,-39,-16
           dc.b -11,52,-5
           dc.b -14,-51,-5
           dc.b -31,41,-9
           dc.b -44,28,-9
           dc.b -49,20,-6
           dc.b -52,10,-3
           dc.b -13,-52,0
           dc.b -46,25,3
           dc.b -51,12,7
           dc.b -51,-4,11
           dc.b -28,44,8
           dc.b -49,8,18
           dc.b -40,-30,17
           dc.b -22,-47,11
           dc.b -44,12,27
           dc.b -42,2,31
           dc.b -39,11,33
           dc.b -37,-13,36
           dc.b -27,34,30
           dc.b -20,42,26
           dc.b -24,-30,36
           dc.b -21,-31,37
           dc.b -19,28,40
           dc.b -5,51,13
           dc.b -4,52,12
           dc.b -4,51,16
           dc.b -5,41,32
           dc.b -3,44,29
           dc.b -1,9,52
           dc.b 0,-53,8
           dc.b 5,1,52
           dc.b 4,-47,25
           dc.b 12,-5,51
           dc.b 14,24,45
           dc.b 4,-52,12
           dc.b 22,-14,45
           dc.b 25,-16,44
           dc.b 24,31,35
           dc.b 17,45,22
           dc.b 22,-42,24
           dc.b 23,41,22
           dc.b 35,27,29
           dc.b 11,51,8
           dc.b 44,-8,28
           dc.b 16,-50,8
           dc.b 44,21,19
           dc.b 33,-40,12
           dc.b 8,53,2
           dc.b 32,41,6
           dc.b 17,-50,2
           dc.b 52,-2,3
           dc.b 53,-7,0
;
; ------------
; Sphere no 3
; ------------
;

sphere3    dc.b 52,-17,-3
           dc.b 46,-29,-6
           dc.b 27,48,-5
           dc.b 40,-36,-11
           dc.b 51,-8,-18
           dc.b 10,-54,-4
           dc.b 47,-13,-25
           dc.b 45,11,-28
           dc.b 43,12,-31
           dc.b 12,53,-10
           dc.b 14,-52,-13
           dc.b 33,23,-37
           dc.b 33,0,-43
           dc.b 15,-48,-23
           dc.b 23,-31,-39
           dc.b 24,3,-49
           dc.b 10,47,-26
           dc.b 15,-25,-46
           dc.b 0,-55,-1
           dc.b 9,11,-53
           dc.b 4,35,-41
           dc.b 1,46,-29
           dc.b -1,39,-38
           dc.b -5,-23,-49
           dc.b -7,30,-45
           dc.b -5,-50,-22
           dc.b -16,0,-52
           dc.b -5,-54,-12
           dc.b -23,16,-47
           dc.b -21,35,-37
           dc.b -30,-1,-45
           dc.b -33,5,-43
           dc.b -35,-17,-39
           dc.b -39,6,-38
           dc.b -6,55,-5
           dc.b -40,-24,-29
           dc.b -44,-17,-28
           dc.b -35,-38,-18
           dc.b 0,-55,0
           dc.b -40,-35,-14
           dc.b -38,38,-11
           dc.b 0,56,0
           dc.b -53,13,-7
           dc.b -43,-34,-3
           dc.b -46,31,0
           dc.b -53,-11,3
           dc.b -37,40,5
           dc.b -8,-55,1
           dc.b -42,34,12
           dc.b -22,-50,8
           dc.b -11,-54,5
           dc.b -26,-46,14
           dc.b -44,17,28
           dc.b -38,-28,28
           dc.b -29,40,24
           dc.b -7,54,7
           dc.b -2,55,2
           dc.b -25,-36,33
           dc.b -28,21,42
           dc.b -27,1,47
           dc.b 0,-55,0
           dc.b -12,-44,30
           dc.b -16,1,52
           dc.b -6,-48,27
           dc.b -5,-45,31
           dc.b -5,-3,54
           dc.b -1,-46,30
           dc.b 1,28,47
           dc.b 5,-3,54
           dc.b 3,-51,20
           dc.b 7,-45,31
           dc.b 11,40,36
           dc.b 6,-52,16
           dc.b 19,-32,40
           dc.b 10,-51,18
           dc.b 12,51,18
           dc.b 0,55,0
           dc.b 14,-51,16
           dc.b 23,-45,22
           dc.b 9,-54,8
           dc.b 44,-9,32
           dc.b 6,55,4
           dc.b 22,-49,11
           dc.b 8,-55,3
           dc.b 50,11,18
           dc.b 0,-55,0
           dc.b 9,54,2
           dc.b 52,17,7
           dc.b 45,30,3
           dc.b 12,-54,0
           dc.b 53,10,-3
           dc.b 17,52,-2
           dc.b 51,17,-11
           dc.b 51,13,-14
           dc.b 12,-54,-4
           dc.b 43,27,-19
           dc.b 48,8,-25
           dc.b 17,-51,-11
           dc.b 28,43,-20
           dc.b 23,46,-19
           dc.b 10,-53,-10
           dc.b 34,19,-38
           dc.b 11,52,-14
           dc.b 23,-35,-34
           dc.b 26,-17,-45
           dc.b 17,-38,-35
           dc.b 14,-38,-37
           dc.b 6,-52,-19
           dc.b 12,23,-48
           dc.b 6,-39,-38
           dc.b 1,-52,-17
           dc.b 0,-54,-9
           dc.b -1,-20,-50
           dc.b -3,46,-30
           dc.b -8,21,-50
           dc.b -6,-48,-27
           dc.b -12,-37,-38
           dc.b 0,55,-1
           dc.b 0,55,0
           dc.b -12,-49,-21
           dc.b -29,-18,-43
           dc.b -28,-31,-36
           dc.b -21,-45,-23
           dc.b -37,19,-36
           dc.b -8,-54,-7
           dc.b -31,-39,-22
           dc.b -37,33,-23
           dc.b -33,-40,-17
           dc.b -12,54,-5
           dc.b -15,-53,-5
           dc.b -33,43,-9
           dc.b -45,29,-9
           dc.b -50,20,-7
           dc.b -53,10,-3
           dc.b -13,-54,0
           dc.b -48,26,3
           dc.b -53,12,7
           dc.b -53,-4,11
           dc.b -30,45,8
           dc.b -51,8,18
           dc.b -41,-32,18
           dc.b -22,-49,12
           dc.b -45,12,28
           dc.b -44,2,32
           dc.b -41,11,34
           dc.b -38,-13,37
           dc.b -28,35,31
           dc.b -20,44,26
           dc.b -25,-32,37
           dc.b -22,-32,38
           dc.b -20,29,42
           dc.b -5,53,14
           dc.b -4,54,13
           dc.b -4,52,17
           dc.b -6,43,34
           dc.b -3,45,31
           dc.b -1,9,54
           dc.b 0,-55,8
           dc.b 5,1,54
           dc.b 4,-48,26
           dc.b 13,-5,53
           dc.b 15,25,46
           dc.b 4,-54,12
           dc.b 23,-15,47
           dc.b 26,-17,45
           dc.b 25,32,37
           dc.b 17,47,22
           dc.b 22,-44,25
           dc.b 25,43,24
           dc.b 36,28,30
           dc.b 12,53,8
           dc.b 46,-8,29
           dc.b 17,-52,9
           dc.b 46,21,20
           dc.b 34,-41,12
           dc.b 8,55,2
           dc.b 34,43,7
           dc.b 18,-52,2
           dc.b 54,-2,3
           dc.b 55,-7,0
;
; ------------
; Sphere no 4
; ------------
;

sphere4    dc.b 54,-17,-3
           dc.b 48,-30,-6
           dc.b 28,49,-6
           dc.b 41,-38,-11
           dc.b 53,-9,-19
           dc.b 10,-56,-4
           dc.b 49,-14,-26
           dc.b 47,12,-29
           dc.b 45,13,-32
           dc.b 12,55,-10
           dc.b 14,-54,-13
           dc.b 34,24,-38
           dc.b 35,1,-44
           dc.b 16,-49,-24
           dc.b 24,-32,-41
           dc.b 24,4,-51
           dc.b 11,49,-27
           dc.b 15,-26,-48
           dc.b 0,-57,-2
           dc.b 9,12,-55
           dc.b 4,37,-43
           dc.b 1,48,-30
           dc.b -1,41,-40
           dc.b -5,-24,-51
           dc.b -8,31,-47
           dc.b -5,-52,-23
           dc.b -17,-1,-54
           dc.b -5,-56,-13
           dc.b -24,16,-49
           dc.b -22,36,-38
           dc.b -31,-2,-47
           dc.b -35,6,-44
           dc.b -36,-17,-40
           dc.b -41,7,-39
           dc.b -7,57,-6
           dc.b -42,-25,-30
           dc.b -46,-17,-29
           dc.b -37,-39,-19
           dc.b 0,-57,0
           dc.b -42,-36,-15
           dc.b -39,40,-11
           dc.b 0,58,0
           dc.b -55,14,-7
           dc.b -44,-35,-3
           dc.b -48,32,0
           dc.b -55,-12,3
           dc.b -39,41,5
           dc.b -9,-57,2
           dc.b -43,35,12
           dc.b -23,-52,8
           dc.b -12,-56,5
           dc.b -27,-48,14
           dc.b -46,17,29
           dc.b -39,-29,28
           dc.b -29,42,25
           dc.b -8,56,8
           dc.b -2,57,2
           dc.b -26,-38,33
           dc.b -29,22,43
           dc.b -28,2,49
           dc.b 0,-57,1
           dc.b -12,-46,31
           dc.b -17,2,54
           dc.b -7,-49,28
           dc.b -5,-47,32
           dc.b -5,-4,56
           dc.b -1,-48,31
           dc.b 1,29,49
           dc.b 5,-4,56
           dc.b 3,-53,21
           dc.b 7,-47,32
           dc.b 12,41,38
           dc.b 6,-54,16
           dc.b 20,-34,41
           dc.b 11,-53,19
           dc.b 12,52,19
           dc.b 0,57,0
           dc.b 15,-52,17
           dc.b 23,-47,22
           dc.b 10,-56,8
           dc.b 46,-10,33
           dc.b 7,57,4
           dc.b 22,-51,12
           dc.b 9,-57,4
           dc.b 52,12,19
           dc.b 0,-57,0
           dc.b 10,56,2
           dc.b 54,17,7
           dc.b 47,31,3
           dc.b 13,-56,0
           dc.b 55,11,-3
           dc.b 17,54,-2
           dc.b 53,17,-11
           dc.b 53,14,-15
           dc.b 13,-56,-4
           dc.b 45,28,-20
           dc.b 50,9,-26
           dc.b 18,-53,-11
           dc.b 29,45,-21
           dc.b 24,48,-20
           dc.b 10,-55,-10
           dc.b 36,19,-40
           dc.b 11,54,-14
           dc.b 24,-37,-36
           dc.b 27,-17,-47
           dc.b 18,-39,-37
           dc.b 15,-39,-38
           dc.b 6,-54,-19
           dc.b 12,24,-50
           dc.b 7,-41,-40
           dc.b 1,-54,-17
           dc.b 0,-56,-10
           dc.b -1,-21,-52
           dc.b -3,48,-31
           dc.b -9,22,-52
           dc.b -7,-50,-28
           dc.b -13,-38,-40
           dc.b -1,57,-2
           dc.b 0,57,-1
           dc.b -13,-51,-22
           dc.b -30,-18,-44
           dc.b -29,-32,-37
           dc.b -22,-46,-25
           dc.b -38,19,-37
           dc.b -9,-56,-7
           dc.b -33,-41,-24
           dc.b -39,34,-24
           dc.b -34,-42,-18
           dc.b -13,56,-6
           dc.b -15,-55,-5
           dc.b -34,45,-9
           dc.b -47,30,-10
           dc.b -52,21,-7
           dc.b -55,11,-3
           dc.b -14,-56,0
           dc.b -50,27,3
           dc.b -55,13,7
           dc.b -55,-5,11
           dc.b -31,47,9
           dc.b -53,9,19
           dc.b -42,-33,19
           dc.b -23,-51,12
           dc.b -47,13,29
           dc.b -46,3,33
           dc.b -42,12,35
           dc.b -40,-14,38
           dc.b -29,37,32
           dc.b -21,45,27
           dc.b -26,-33,38
           dc.b -23,-34,39
           dc.b -21,30,44
           dc.b -5,55,14
           dc.b -4,56,14
           dc.b -4,54,17
           dc.b -6,45,35
           dc.b -3,47,32
           dc.b -1,10,56
           dc.b 0,-57,9
           dc.b 5,2,56
           dc.b 4,-50,27
           dc.b 13,-6,55
           dc.b 15,26,48
           dc.b 5,-56,12
           dc.b 24,-15,49
           dc.b 27,-17,47
           dc.b 25,34,38
           dc.b 18,49,23
           dc.b 23,-45,26
           dc.b 25,45,25
           dc.b 38,29,32
           dc.b 12,55,8
           dc.b 48,-9,30
           dc.b 17,-54,9
           dc.b 48,22,21
           dc.b 35,-43,12
           dc.b 9,57,2
           dc.b 35,45,7
           dc.b 18,-54,2
           dc.b 56,-3,3
           dc.b 57,-8,0
;
; ------------
; Sphere no 5
; ------------
;

sphere5    dc.b 56,-18,-3
           dc.b 49,-31,-6
           dc.b 29,51,-6
           dc.b 43,-39,-12
           dc.b 55,-9,-20
           dc.b 10,-58,-4
           dc.b 51,-14,-27
           dc.b 49,12,-30
           dc.b 46,13,-34
           dc.b 13,57,-10
           dc.b 15,-56,-14
           dc.b 36,25,-40
           dc.b 36,1,-46
           dc.b 16,-51,-24
           dc.b 24,-33,-42
           dc.b 25,4,-53
           dc.b 11,50,-28
           dc.b 16,-27,-50
           dc.b 0,-59,-2
           dc.b 10,12,-57
           dc.b 4,38,-44
           dc.b 1,50,-31
           dc.b -1,42,-41
           dc.b -5,-25,-53
           dc.b -8,32,-49
           dc.b -6,-54,-24
           dc.b -18,-1,-56
           dc.b -5,-57,-13
           dc.b -24,17,-51
           dc.b -23,37,-39
           dc.b -32,-2,-48
           dc.b -36,6,-46
           dc.b -38,-18,-42
           dc.b -42,7,-40
           dc.b -7,59,-6
           dc.b -42,-26,-31
           dc.b -48,-18,-30
           dc.b -37,-40,-20
           dc.b 0,-59,0
           dc.b -43,-37,-15
           dc.b -41,41,-11
           dc.b 0,60,0
           dc.b -57,14,-8
           dc.b -46,-36,-3
           dc.b -49,33,0
           dc.b -57,-12,4
           dc.b -40,43,5
           dc.b -9,-59,2
           dc.b -45,36,12
           dc.b -24,-53,8
           dc.b -12,-58,5
           dc.b -28,-50,15
           dc.b -48,18,30
           dc.b -41,-30,29
           dc.b -30,43,25
           dc.b -8,58,8
           dc.b -2,59,2
           dc.b -27,-39,35
           dc.b -30,23,45
           dc.b -29,2,51
           dc.b 0,-59,1
           dc.b -13,-47,33
           dc.b -18,2,56
           dc.b -7,-51,29
           dc.b -5,-49,33
           dc.b -6,-4,58
           dc.b -1,-49,32
           dc.b 1,30,50
           dc.b 6,-4,58
           dc.b 3,-55,22
           dc.b 8,-49,32
           dc.b 12,43,38
           dc.b 7,-56,17
           dc.b 21,-35,43
           dc.b 11,-55,19
           dc.b 13,54,19
           dc.b 0,59,0
           dc.b 16,-54,17
           dc.b 24,-49,23
           dc.b 10,-58,8
           dc.b 47,-10,34
           dc.b 7,59,4
           dc.b 23,-53,12
           dc.b 9,-59,4
           dc.b 54,12,19
           dc.b 0,-59,0
           dc.b 10,58,2
           dc.b 56,18,7
           dc.b 49,32,3
           dc.b 13,-58,0
           dc.b 57,11,-4
           dc.b 18,56,-2
           dc.b 55,18,-11
           dc.b 55,14,-15
           dc.b 13,-58,-4
           dc.b 47,29,-21
           dc.b 52,9,-27
           dc.b 19,-55,-12
           dc.b 29,46,-21
           dc.b 25,49,-21
           dc.b 11,-57,-11
           dc.b 37,20,-41
           dc.b 12,56,-15
           dc.b 25,-38,-37
           dc.b 28,-18,-49
           dc.b 18,-40,-38
           dc.b 16,-40,-39
           dc.b 6,-56,-19
           dc.b 13,25,-52
           dc.b 7,-42,-41
           dc.b 1,-56,-18
           dc.b 0,-58,-10
           dc.b -1,-22,-54
           dc.b -3,49,-32
           dc.b -9,23,-54
           dc.b -7,-51,-29
           dc.b -13,-40,-41
           dc.b -1,59,-2
           dc.b 0,59,-1
           dc.b -13,-53,-23
           dc.b -31,-19,-46
           dc.b -30,-33,-38
           dc.b -23,-48,-26
           dc.b -40,20,-38
           dc.b -9,-58,-7
           dc.b -33,-42,-24
           dc.b -39,36,-24
           dc.b -35,-43,-18
           dc.b -13,57,-6
           dc.b -15,-57,-5
           dc.b -35,46,-10
           dc.b -48,31,-10
           dc.b -54,22,-7
           dc.b -57,11,-4
           dc.b -14,-58,0
           dc.b -51,28,3
           dc.b -57,13,8
           dc.b -57,-5,12
           dc.b -32,49,9
           dc.b -55,9,20
           dc.b -44,-34,19
           dc.b -24,-52,13
           dc.b -49,13,30
           dc.b -47,3,34
           dc.b -44,12,37
           dc.b -41,-14,40
           dc.b -30,38,33
           dc.b -22,47,28
           dc.b -27,-34,40
           dc.b -24,-35,41
           dc.b -21,31,44
           dc.b -6,57,15
           dc.b -4,57,14
           dc.b -4,56,18
           dc.b -6,46,36
           dc.b -3,49,33
           dc.b -2,10,58
           dc.b 0,-59,9
           dc.b 6,2,58
           dc.b 5,-52,28
           dc.b 14,-6,57
           dc.b 16,27,50
           dc.b 5,-58,12
           dc.b 24,-16,51
           dc.b 28,-18,49
           dc.b 26,35,39
           dc.b 19,50,24
           dc.b 24,-47,26
           dc.b 26,46,25
           dc.b 39,30,32
           dc.b 12,57,9
           dc.b 50,-9,31
           dc.b 18,-56,9
           dc.b 50,23,22
           dc.b 37,-44,13
           dc.b 9,59,2
           dc.b 36,46,7
           dc.b 19,-56,2
           dc.b 58,-3,4
           dc.b 59,-8,0
;
; ------------
; Sphere no 6
; ------------
;

sphere6    dc.b 57,-19,-4
           dc.b 51,-32,-7
           dc.b 30,53,-6
           dc.b 44,-40,-12
           dc.b 57,-9,-20
           dc.b 10,-60,-4
           dc.b 52,-14,-28
           dc.b 50,12,-31
           dc.b 48,13,-35
           dc.b 13,59,-11
           dc.b 15,-57,-15
           dc.b 37,26,-41
           dc.b 37,1,-48
           dc.b 17,-53,-25
           dc.b 25,-34,-44
           dc.b 26,4,-54
           dc.b 11,52,-29
           dc.b 16,-28,-52
           dc.b 0,-61,-2
           dc.b 10,12,-59
           dc.b 4,39,-46
           dc.b 1,51,-32
           dc.b -1,43,-42
           dc.b -5,-26,-55
           dc.b -8,33,-50
           dc.b -6,-56,-25
           dc.b -18,-1,-58
           dc.b -5,-59,-14
           dc.b -25,18,-53
           dc.b -24,39,-41
           dc.b -34,-2,-50
           dc.b -37,6,-48
           dc.b -38,-19,-43
           dc.b -43,7,-42
           dc.b -7,61,-6
           dc.b -44,-27,-32
           dc.b -49,-19,-30
           dc.b -39,-42,-21
           dc.b 0,-61,0
           dc.b -45,-39,-16
           dc.b -42,43,-12
           dc.b 0,62,0
           dc.b -59,14,-8
           dc.b -47,-38,-3
           dc.b -51,34,0
           dc.b -59,-12,4
           dc.b -42,44,5
           dc.b -9,-61,2
           dc.b -46,38,13
           dc.b -25,-55,9
           dc.b -12,-60,5
           dc.b -29,-51,15
           dc.b -49,19,30
           dc.b -42,-31,31
           dc.b -32,45,26
           dc.b -8,60,8
           dc.b -2,61,2
           dc.b -28,-40,36
           dc.b -31,24,47
           dc.b -30,2,52
           dc.b 0,-61,1
           dc.b -13,-49,34
           dc.b -18,2,58
           dc.b -7,-53,30
           dc.b -6,-50,34
           dc.b -6,-4,60
           dc.b -1,-51,33
           dc.b 1,31,52
           dc.b 6,-4,60
           dc.b 4,-57,23
           dc.b 8,-50,33
           dc.b 13,44,40
           dc.b 7,-58,18
           dc.b 21,-36,44
           dc.b 12,-57,20
           dc.b 13,56,20
           dc.b 0,61,0
           dc.b 16,-56,18
           dc.b 25,-50,24
           dc.b 10,-60,8
           dc.b 49,-10,35
           dc.b 7,61,4
           dc.b 24,-55,13
           dc.b 9,-61,4
           dc.b 56,12,20
           dc.b 0,-61,0
           dc.b 10,60,2
           dc.b 57,19,8
           dc.b 50,33,3
           dc.b 13,-60,0
           dc.b 59,11,-4
           dc.b 19,58,-2
           dc.b 56,19,-12
           dc.b 57,14,-16
           dc.b 13,-60,-4
           dc.b 49,30,-21
           dc.b 53,9,-28
           dc.b 20,-57,-12
           dc.b 31,48,-22
           dc.b 26,51,-21
           dc.b 12,-59,-11
           dc.b 38,21,-43
           dc.b 12,58,-16
           dc.b 26,-39,-38
           dc.b 29,-19,-50
           dc.b 19,-42,-40
           dc.b 16,-42,-41
           dc.b 6,-57,-20
           dc.b 13,26,-54
           dc.b 7,-43,-42
           dc.b 2,-58,-19
           dc.b 0,-60,-10
           dc.b -1,-23,-56
           dc.b -3,51,-33
           dc.b -9,24,-56
           dc.b -7,-53,-30
           dc.b -14,-41,-43
           dc.b -1,61,-2
           dc.b 0,61,-1
           dc.b -14,-55,-24
           dc.b -32,-20,-48
           dc.b -31,-34,-40
           dc.b -24,-50,-26
           dc.b -41,21,-40
           dc.b -9,-60,-7
           dc.b -34,-43,-25
           dc.b -41,37,-25
           dc.b -37,-45,-19
           dc.b -14,59,-6
           dc.b -16,-59,-6
           dc.b -37,48,-10
           dc.b -50,32,-10
           dc.b -56,23,-7
           dc.b -59,11,-4
           dc.b -14,-60,0
           dc.b -53,29,3
           dc.b -59,13,8
           dc.b -59,-5,12
           dc.b -33,50,9
           dc.b -57,9,20
           dc.b -45,-35,20
           dc.b -25,-54,13
           dc.b -50,13,31
           dc.b -49,3,35
           dc.b -45,12,38
           dc.b -43,-14,41
           dc.b -31,39,34
           dc.b -23,48,29
           dc.b -27,-35,41
           dc.b -25,-36,43
           dc.b -22,32,46
           dc.b -6,59,16
           dc.b -4,59,15
           dc.b -4,58,19
           dc.b -6,48,38
           dc.b -3,50,34
           dc.b -2,10,60
           dc.b 0,-61,9
           dc.b 6,2,60
           dc.b 5,-54,29
           dc.b 14,-6,59
           dc.b 16,28,52
           dc.b 5,-60,12
           dc.b 25,-17,53
           dc.b 29,-19,50
           dc.b 27,36,41
           dc.b 19,52,25
           dc.b 25,-48,28
           dc.b 28,48,27
           dc.b 40,31,34
           dc.b 13,59,9
           dc.b 51,-9,32
           dc.b 19,-57,10
           dc.b 52,24,23
           dc.b 38,-46,14
           dc.b 9,61,2
           dc.b 38,48,8
           dc.b 20,-58,2
           dc.b 60,-3,4
           dc.b 61,-8,0
;
; ------------
; Sphere no 7
; ------------
;

sphere7    dc.b 59,-19,-4
           dc.b 53,-33,-7
           dc.b 31,54,-6
           dc.b 46,-41,-13
           dc.b 59,-10,-21
           dc.b 11,-62,-5
           dc.b 54,-15,-29
           dc.b 52,13,-32
           dc.b 50,14,-36
           dc.b 13,61,-11
           dc.b 15,-59,-15
           dc.b 38,27,-43
           dc.b 38,1,-49
           dc.b 17,-54,-26
           dc.b 26,-35,-45
           dc.b 27,4,-56
           dc.b 12,54,-30
           dc.b 17,-29,-54
           dc.b 0,-63,-2
           dc.b 10,13,-61
           dc.b 5,41,-48
           dc.b 1,53,-33
           dc.b -1,45,-44
           dc.b -6,-27,-57
           dc.b -9,34,-52
           dc.b -6,-58,-26
           dc.b -19,-1,-59
           dc.b -5,-61,-14
           dc.b -26,18,-54
           dc.b -24,40,-42
           dc.b -35,-2,-52
           dc.b -38,6,-49
           dc.b -40,-19,-44
           dc.b -45,7,-43
           dc.b -8,63,-7
           dc.b -46,-28,-33
           dc.b -50,-19,-31
           dc.b -40,-43,-21
           dc.b 0,-63,0
           dc.b -46,-40,-16
           dc.b -44,44,-12
           dc.b 0,64,0
           dc.b -61,15,-8
           dc.b -49,-39,-3
           dc.b -53,35,0
           dc.b -61,-13,4
           dc.b -43,46,6
           dc.b -10,-63,2
           dc.b -48,39,13
           dc.b -26,-57,9
           dc.b -13,-62,6
           dc.b -30,-53,15
           dc.b -50,19,31
           dc.b -43,-32,31
           dc.b -32,46,27
           dc.b -9,62,9
           dc.b -2,63,2
           dc.b -29,-41,37
           dc.b -32,25,48
           dc.b -31,2,54
           dc.b 0,-63,1
           dc.b -14,-51,35
           dc.b -19,2,59
           dc.b -7,-54,31
           dc.b -6,-52,35
           dc.b -6,-4,62
           dc.b -1,-53,34
           dc.b 1,32,54
           dc.b 6,-4,62
           dc.b 4,-58,24
           dc.b 8,-52,34
           dc.b 13,46,41
           dc.b 7,-60,18
           dc.b 22,-37,45
           dc.b 12,-58,21
           dc.b 14,58,21
           dc.b 0,63,0
           dc.b 17,-58,19
           dc.b 25,-52,25
           dc.b 11,-62,9
           dc.b 50,-11,37
           dc.b 8,63,5
           dc.b 25,-57,13
           dc.b 10,-63,4
           dc.b 58,13,21
           dc.b 0,-63,0
           dc.b 11,62,2
           dc.b 59,19,8
           dc.b 52,34,3
           dc.b 14,-62,0
           dc.b 61,12,-4
           dc.b 19,60,-2
           dc.b 58,19,-12
           dc.b 59,15,-17
           dc.b 14,-62,-5
           dc.b 50,31,-22
           dc.b 55,10,-29
           dc.b 21,-58,-13
           dc.b 32,49,-23
           dc.b 26,53,-22
           dc.b 12,-61,-11
           dc.b 40,21,-44
           dc.b 12,60,-16
           dc.b 27,-41,-40
           dc.b 30,-19,-51
           dc.b 20,-43,-41
           dc.b 17,-43,-42
           dc.b 6,-59,-20
           dc.b 14,27,-56
           dc.b 7,-45,-44
           dc.b 2,-60,-19
           dc.b 0,-62,-11
           dc.b -2,-23,-58
           dc.b -3,53,-34
           dc.b -10,25,-57
           dc.b -7,-55,-31
           dc.b -14,-42,-44
           dc.b -1,63,-2
           dc.b 0,63,-1
           dc.b -14,-57,-25
           dc.b -33,-20,-49
           dc.b -32,-35,-41
           dc.b -24,-51,-27
           dc.b -43,21,-41
           dc.b -9,-62,-8
           dc.b -36,-45,-26
           dc.b -43,38,-27
           dc.b -37,-46,-20
           dc.b -14,61,-6
           dc.b -16,-61,-6
           dc.b -38,49,-11
           dc.b -52,33,-11
           dc.b -58,23,-8
           dc.b -61,12,-4
           dc.b -15,-62,0
           dc.b -55,30,3
           dc.b -61,14,8
           dc.b -61,-5,13
           dc.b -34,52,9
           dc.b -59,10,21
           dc.b -47,-36,21
           dc.b -26,-56,14
           dc.b -52,14,32
           dc.b -50,3,37
           dc.b -47,13,39
           dc.b -44,-15,43
           dc.b -32,41,36
           dc.b -24,50,30
           dc.b -29,-36,43
           dc.b -25,-37,44
           dc.b -23,33,48
           dc.b -6,61,16
           dc.b -4,61,15
           dc.b -4,60,19
           dc.b -6,49,39
           dc.b -3,52,35
           dc.b -2,11,62
           dc.b 0,-63,10
           dc.b 6,2,62
           dc.b 5,-55,30
           dc.b 15,-6,61
           dc.b 17,29,54
           dc.b 5,-62,13
           dc.b 26,-17,54
           dc.b 30,-19,51
           dc.b 28,37,42
           dc.b 20,54,26
           dc.b 26,-50,28
           dc.b 28,49,27
           dc.b 42,32,35
           dc.b 13,61,9
           dc.b 53,-10,33
           dc.b 19,-59,10
           dc.b 52,25,23
           dc.b 39,-47,14
           dc.b 10,63,3
           dc.b 39,49,8
           dc.b 20,-60,2
           dc.b 62,-3,4
           dc.b 63,-8,0
;
; ------------
; Sphere no 8
; ------------
;

sphere8    dc.b 61,-20,-4
           dc.b 54,-34,-7
           dc.b 32,56,-6
           dc.b 47,-43,-13
           dc.b 61,-10,-22
           dc.b 11,-64,-5
           dc.b 56,-15,-30
           dc.b 54,13,-33
           dc.b 51,14,-37
           dc.b 14,63,-12
           dc.b 16,-61,-15
           dc.b 39,27,-43
           dc.b 40,1,-51
           dc.b 18,-56,-27
           dc.b 27,-36,-46
           dc.b 28,4,-58
           dc.b 12,55,-31
           dc.b 17,-29,-55
           dc.b 0,-65,-2
           dc.b 11,13,-63
           dc.b 5,42,-49
           dc.b 1,55,-34
           dc.b -1,46,-45
           dc.b -6,-27,-58
           dc.b -9,35,-54
           dc.b -6,-59,-26
           dc.b -20,-1,-61
           dc.b -6,-63,-15
           dc.b -27,19,-56
           dc.b -25,41,-44
           dc.b -36,-2,-53
           dc.b -40,6,-51
           dc.b -41,-20,-46
           dc.b -46,8,-45
           dc.b -8,64,-7
           dc.b -47,-28,-34
           dc.b -52,-20,-32
           dc.b -42,-45,-22
           dc.b 0,-65,0
           dc.b -47,-41,-17
           dc.b -45,45,-12
           dc.b 0,66,0
           dc.b -63,15,-8
           dc.b -51,-40,-3
           dc.b -54,36,0
           dc.b -63,-13,4
           dc.b -44,47,6
           dc.b -10,-64,2
           dc.b -49,40,14
           dc.b -26,-59,9
           dc.b -13,-64,6
           dc.b -30,-55,16
           dc.b -52,20,32
           dc.b -45,-33,32
           dc.b -34,48,28
           dc.b -9,64,9
           dc.b -2,65,2
           dc.b -30,-43,38
           dc.b -33,25,49
           dc.b -32,2,56
           dc.b 0,-65,1
           dc.b -14,-52,36
           dc.b -20,2,61
           dc.b -7,-56,32
           dc.b -6,-54,36
           dc.b -6,-4,64
           dc.b -1,-54,35
           dc.b 1,33,56
           dc.b 6,-4,64
           dc.b 4,-60,24
           dc.b 8,-54,35
           dc.b 13,47,42
           dc.b 7,-62,19
           dc.b 23,-38,47
           dc.b 12,-60,21
           dc.b 14,60,21
           dc.b 0,65,0
           dc.b 17,-60,19
           dc.b 26,-54,25
           dc.b 11,-64,9
           dc.b 51,-11,37
           dc.b 8,65,5
           dc.b 25,-58,13
           dc.b 10,-64,4
           dc.b 60,13,21
           dc.b 0,-65,0
           dc.b 11,64,2
           dc.b 61,20,8
           dc.b 54,35,3
           dc.b 14,-64,0
           dc.b 63,12,-4
           dc.b 20,62,-2
           dc.b 60,20,-12
           dc.b 61,15,-17
           dc.b 14,-64,-5
           dc.b 52,31,-23
           dc.b 57,10,-30
           dc.b 21,-60,-13
           dc.b 33,51,-24
           dc.b 27,54,-23
           dc.b 12,-63,-12
           dc.b 41,22,-46
           dc.b 13,62,-17
           dc.b 27,-42,-41
           dc.b 31,-20,-53
           dc.b 21,-45,-43
           dc.b 17,-45,-44
           dc.b 7,-61,-21
           dc.b 14,27,-57
           dc.b 7,-46,-45
           dc.b 2,-62,-20
           dc.b 0,-64,-11
           dc.b -2,-24,-60
           dc.b -3,54,-35
           dc.b -10,25,-59
           dc.b -7,-57,-32
           dc.b -15,-44,-46
           dc.b -1,65,-2
           dc.b 0,65,-1
           dc.b -14,-58,-25
           dc.b -34,-21,-51
           dc.b -33,-36,-42
           dc.b -25,-53,-28
           dc.b -44,22,-43
           dc.b -9,-64,-8
           dc.b -37,-46,-27
           dc.b -44,39,-27
           dc.b -39,-48,-21
           dc.b -15,63,-6
           dc.b -17,-63,-6
           dc.b -39,51,-11
           dc.b -53,34,-11
           dc.b -60,24,-8
           dc.b -63,12,-4
           dc.b -15,-64,0
           dc.b -57,30,4
           dc.b -63,14,8
           dc.b -63,-5,13
           dc.b -35,54,10
           dc.b -61,10,22
           dc.b -49,-37,21
           dc.b -26,-58,14
           dc.b -54,14,33
           dc.b -52,3,38
           dc.b -49,13,41
           dc.b -46,-15,44
           dc.b -33,42,37
           dc.b -24,52,31
           dc.b -30,-37,44
           dc.b -26,-38,45
           dc.b -24,34,49
           dc.b -7,63,17
           dc.b -5,63,16
           dc.b -5,62,20
           dc.b -7,51,40
           dc.b -3,54,36
           dc.b -2,11,63
           dc.b 0,-64,10
           dc.b 6,2,64
           dc.b 5,-57,30
           dc.b 15,-6,63
           dc.b 17,29,55
           dc.b 5,-64,13
           dc.b 27,-18,56
           dc.b 31,-20,53
           dc.b 29,38,43
           dc.b 20,55,26
           dc.b 26,-52,29
           dc.b 29,51,28
           dc.b 43,33,36
           dc.b 14,63,10
           dc.b 55,-10,34
           dc.b 20,-61,10
           dc.b 54,25,24
           dc.b 41,-49,15
           dc.b 10,64,3
           dc.b 40,51,8
           dc.b 21,-62,3
           dc.b 64,-3,4
           dc.b 65,-9,0
;
; ------------
; Sphere no 9
; ------------
;

sphere9    dc.b 63,-21,-4
           dc.b 56,-36,-7
           dc.b 34,58,-7
           dc.b 49,-44,-14
           dc.b 62,-10,-22
           dc.b 12,-66,-5
           dc.b 57,-16,-30
           dc.b 55,14,-34
           dc.b 53,15,-38
           dc.b 14,65,-12
           dc.b 17,-63,-16
           dc.b 40,28,-45
           dc.b 41,1,-52
           dc.b 19,-58,-29
           dc.b 28,-38,-48
           dc.b 29,4,-60
           dc.b 13,57,-33
           dc.b 18,-30,-57
           dc.b 0,-67,-2
           dc.b 11,14,-64
           dc.b 5,43,-51
           dc.b 1,57,-36
           dc.b -1,48,-47
           dc.b -6,-28,-60
           dc.b -9,37,-56
           dc.b -6,-61,-27
           dc.b -20,-1,-63
           dc.b -6,-65,-15
           dc.b -28,19,-58
           dc.b -26,42,-45
           dc.b -37,-2,-55
           dc.b -41,7,-52
           dc.b -42,-21,-47
           dc.b -48,8,-46
           dc.b -8,66,-7
           dc.b -49,-29,-35
           dc.b -54,-21,-33
           dc.b -43,-46,-23
           dc.b 0,-67,0
           dc.b -48,-42,-17
           dc.b -46,47,-13
           dc.b 0,68,0
           dc.b -64,16,-9
           dc.b -52,-41,-3
           dc.b -56,38,0
           dc.b -65,-14,4
           dc.b -46,48,6
           dc.b -10,-66,2
           dc.b -50,41,14
           dc.b -27,-61,9
           dc.b -14,-65,6
           dc.b -32,-57,17
           dc.b -54,21,33
           dc.b -46,-35,34
           dc.b -35,49,29
           dc.b -10,66,9
           dc.b -2,67,2
           dc.b -31,-44,40
           dc.b -34,26,51
           dc.b -33,2,58
           dc.b 0,-67,1
           dc.b -14,-54,37
           dc.b -20,2,63
           dc.b -8,-58,33
           dc.b -6,-55,38
           dc.b -7,-4,66
           dc.b -1,-56,37
           dc.b 2,34,57
           dc.b 7,-4,66
           dc.b 4,-62,25
           dc.b 9,-55,37
           dc.b 14,48,44
           dc.b 8,-64,20
           dc.b 24,-39,49
           dc.b 13,-62,22
           dc.b 15,62,22
           dc.b 0,67,0
           dc.b 18,-62,20
           dc.b 28,-55,27
           dc.b 12,-65,10
           dc.b 53,-11,38
           dc.b 8,67,5
           dc.b 26,-60,14
           dc.b 10,-66,4
           dc.b 62,14,22
           dc.b 0,-67,0
           dc.b 11,66,2
           dc.b 63,21,8
           dc.b 56,37,3
           dc.b 15,-66,0
           dc.b 65,12,-4
           dc.b 21,64,-3
           dc.b 62,21,-13
           dc.b 62,16,-17
           dc.b 15,-65,-5
           dc.b 53,32,-23
           dc.b 59,10,-31
           dc.b 22,-62,-13
           dc.b 33,52,-24
           dc.b 29,56,-24
           dc.b 12,-65,-12
           dc.b 42,23,-46
           dc.b 14,63,-18
           dc.b 29,-43,-43
           dc.b 32,-21,-55
           dc.b 21,-46,-44
           dc.b 18,-46,-45
           dc.b 7,-63,-22
           dc.b 14,28,-59
           dc.b 8,-48,-47
           dc.b 2,-64,-21
           dc.b 0,-66,-11
           dc.b -2,-25,-62
           dc.b -3,56,-37
           dc.b -10,26,-61
           dc.b -8,-58,-32
           dc.b -15,-45,-47
           dc.b -1,67,-2
           dc.b 0,67,-1
           dc.b -15,-60,-25
           dc.b -35,-22,-53
           dc.b -34,-38,-44
           dc.b -26,-55,-28
           dc.b -45,23,-43
           dc.b -10,-66,-8
           dc.b -38,-48,-28
           dc.b -45,40,-28
           dc.b -40,-49,-21
           dc.b -15,65,-6
           dc.b -17,-65,-6
           dc.b -40,52,-11
           dc.b -55,36,-11
           dc.b -62,25,-8
           dc.b -65,12,-4
           dc.b -16,-65,0
           dc.b -59,31,4
           dc.b -65,15,9
           dc.b -65,-5,13
           dc.b -37,55,10
           dc.b -62,10,22
           dc.b -50,-39,22
           dc.b -27,-60,14
           dc.b -55,15,34
           dc.b -54,3,39
           dc.b -50,14,42
           dc.b -46,-16,45
           dc.b -34,43,38
           dc.b -25,53,32
           dc.b -30,-39,45
           dc.b -27,-39,47
           dc.b -24,36,51
           dc.b -7,65,17
           dc.b -5,65,16
           dc.b -5,64,21
           dc.b -7,52,41
           dc.b -4,55,38
           dc.b -2,11,65
           dc.b 0,-66,10
           dc.b 7,2,66
           dc.b 5,-59,31
           dc.b 16,-7,65
           dc.b 18,30,57
           dc.b 5,-65,14
           dc.b 28,-18,58
           dc.b 32,-21,55
           dc.b 30,39,45
           dc.b 22,57,28
           dc.b 27,-53,30
           dc.b 30,52,29
           dc.b 44,34,37
           dc.b 14,65,10
           dc.b 56,-10,35
           dc.b 21,-63,11
           dc.b 56,26,25
           dc.b 42,-50,15
           dc.b 10,66,3
           dc.b 41,52,8
           dc.b 22,-63,3
           dc.b 66,-3,4
           dc.b 67,-9,0
;
; ------------
; Sphere no 10
; ------------
;

sphere10    dc.b 65,-21,-4
           dc.b 58,-37,-8
           dc.b 35,60,-7
           dc.b 49,-45,-14
           dc.b 64,-10,-23
           dc.b 12,-68,-5
           dc.b 59,-16,-31
           dc.b 57,14,-36
           dc.b 55,15,-39
           dc.b 15,66,-12
           dc.b 17,-65,-17
           dc.b 42,29,-46
           dc.b 42,1,-54
           dc.b 20,-60,-29
           dc.b 29,-39,-50
           dc.b 30,4,-62
           dc.b 13,59,-34
           dc.b 19,-31,-58
           dc.b 0,-69,-2
           dc.b 11,14,-66
           dc.b 5,44,-52
           dc.b 1,58,-37
           dc.b -1,49,-48
           dc.b -6,-29,-62
           dc.b -10,38,-57
           dc.b -7,-63,-28
           dc.b -21,-1,-65
           dc.b -6,-67,-16
           dc.b -28,20,-59
           dc.b -27,44,-46
           dc.b -38,-2,-57
           dc.b -42,7,-54
           dc.b -44,-21,-49
           dc.b -49,8,-47
           dc.b -9,68,-7
           dc.b -50,-30,-36
           dc.b -55,-21,-34
           dc.b -45,-47,-23
           dc.b 0,-69,0
           dc.b -50,-44,-18
           dc.b -48,48,-13
           dc.b 0,70,0
           dc.b -66,16,-9
           dc.b -54,-43,-3
           dc.b -58,39,0
           dc.b -67,-14,4
           dc.b -47,50,6
           dc.b -11,-68,2
           dc.b -52,43,15
           dc.b -28,-62,10
           dc.b -14,-67,6
           dc.b -33,-58,17
           dc.b -55,21,34
           dc.b -48,-36,35
           dc.b -36,51,30
           dc.b -10,68,9
           dc.b -2,69,2
           dc.b -32,-45,40
           dc.b -35,27,53
           dc.b -34,2,59
           dc.b 0,-69,1
           dc.b -15,-55,38
           dc.b -21,2,65
           dc.b -8,-60,34
           dc.b -6,-57,39
           dc.b -7,-4,68
           dc.b -1,-58,38
           dc.b 2,35,59
           dc.b 7,-4,68
           dc.b 4,-64,26
           dc.b 9,-57,38
           dc.b 14,50,45
           dc.b 8,-66,20
           dc.b 24,-41,50
           dc.b 13,-64,23
           dc.b 15,63,23
           dc.b 0,69,0
           dc.b 18,-63,20
           dc.b 28,-57,27
           dc.b 12,-67,10
           dc.b 55,-12,39
           dc.b 8,69,5
           dc.b 27,-62,14
           dc.b 10,-68,4
           dc.b 63,14,23
           dc.b 0,-69,0
           dc.b 12,68,2
           dc.b 65,21,9
           dc.b 57,38,4
           dc.b 15,-68,0
           dc.b 67,13,-4
           dc.b 21,66,-3
           dc.b 64,21,-13
           dc.b 64,16,-18
           dc.b 15,-67,-5
           dc.b 55,33,-24
           dc.b 60,10,-32
           dc.b 22,-64,-14
           dc.b 35,54,-25
           dc.b 29,58,-25
           dc.b 13,-67,-13
           dc.b 43,23,-48
           dc.b 14,65,-18
           dc.b 29,-44,-43
           dc.b 33,-21,-57
           dc.b 22,-47,-45
           dc.b 19,-47,-47
           dc.b 7,-65,-23
           dc.b 15,29,-61
           dc.b 8,-49,-48
           dc.b 2,-66,-21
           dc.b 0,-68,-12
           dc.b -2,-26,-63
           dc.b -4,58,-38
           dc.b -11,27,-63
           dc.b -8,-60,-33
           dc.b -16,-46,-49
           dc.b -1,69,-2
           dc.b 0,69,-1
           dc.b -15,-62,-26
           dc.b -36,-22,-54
           dc.b -35,-39,-45
           dc.b -27,-56,-30
           dc.b -46,23,-45
           dc.b -10,-68,-8
           dc.b -39,-49,-28
           dc.b -46,42,-29
           dc.b -41,-51,-22
           dc.b -16,67,-7
           dc.b -18,-66,-6
           dc.b -42,54,-12
           dc.b -57,37,-12
           dc.b -63,26,-8
           dc.b -67,13,-4
           dc.b -16,-67,0
           dc.b -60,32,4
           dc.b -67,15,9
           dc.b -67,-6,14
           dc.b -38,57,11
           dc.b -64,10,23
           dc.b -52,-40,23
           dc.b -28,-61,15
           dc.b -57,15,36
           dc.b -55,3,40
           dc.b -52,14,43
           dc.b -48,-16,46
           dc.b -35,44,39
           dc.b -26,55,33
           dc.b -31,-40,47
           dc.b -28,-41,48
           dc.b -25,37,53
           dc.b -7,66,18
           dc.b -5,67,17
           dc.b -5,66,21
           dc.b -7,54,43
           dc.b -4,57,39
           dc.b -2,12,67
           dc.b 0,-68,11
           dc.b 7,2,68
           dc.b 5,-61,32
           dc.b 16,-7,66
           dc.b 19,31,58
           dc.b 5,-67,14
           dc.b 29,-19,60
           dc.b 33,-21,57
           dc.b 31,41,46
           dc.b 22,59,29
           dc.b 28,-55,31
           dc.b 31,54,30
           dc.b 45,35,38
           dc.b 15,67,11
           dc.b 58,-10,36
           dc.b 22,-65,11
           dc.b 58,27,26
           dc.b 43,-52,15
           dc.b 11,68,3
           dc.b 43,54,9
           dc.b 22,-65,3
           dc.b 68,-3,4
           dc.b 69,-9,0
;
; ------------
; Sphere no 11
; ------------
;

sphere11    dc.b 67,-22,-4
           dc.b 60,-38,-8
           dc.b 36,61,-7
           dc.b 51,-47,-14
           dc.b 66,-11,-24
           dc.b 12,-70,-5
           dc.b 60,-17,-32
           dc.b 59,14,-37
           dc.b 56,16,-41
           dc.b 16,68,-13
           dc.b 17,-67,-17
           dc.b 43,30,-48
           dc.b 43,1,-55
           dc.b 20,-61,-30
           dc.b 29,-40,-51
           dc.b 31,5,-63
           dc.b 14,61,-35
           dc.b 19,-32,-60
           dc.b 0,-71,-2
           dc.b 12,14,-68
           dc.b 5,46,-54
           dc.b 1,60,-38
           dc.b -1,50,-49
           dc.b -6,-30,-64
           dc.b -10,39,-59
           dc.b -7,-65,-29
           dc.b -21,-1,-67
           dc.b -6,-69,-16
           dc.b -29,21,-61
           dc.b -27,45,-47
           dc.b -39,-2,-58
           dc.b -43,7,-55
           dc.b -45,-22,-50
           dc.b -51,8,-49
           dc.b -9,70,-7
           dc.b -51,-31,-37
           dc.b -57,-22,-36
           dc.b -45,-49,-24
           dc.b 0,-71,0
           dc.b -51,-45,-18
           dc.b -49,50,-14
           dc.b 0,72,0
           dc.b -68,17,-9
           dc.b -55,-44,-3
           dc.b -59,40,0
           dc.b -69,-14,4
           dc.b -49,51,6
           dc.b -11,-70,2
           dc.b -53,44,15
           dc.b -29,-64,10
           dc.b -15,-69,6
           dc.b -34,-60,18
           dc.b -57,22,36
           dc.b -49,-37,35
           dc.b -37,52,31
           dc.b -10,70,9
           dc.b -3,71,3
           dc.b -33,-47,42
           dc.b -36,28,54
           dc.b -35,2,61
           dc.b 0,-71,1
           dc.b -16,-57,39
           dc.b -21,2,67
           dc.b -8,-61,35
           dc.b -7,-58,40
           dc.b -7,-5,70
           dc.b -1,-59,39
           dc.b 2,36,61
           dc.b 7,-5,70
           dc.b 4,-66,27
           dc.b 9,-58,39
           dc.b 15,51,47
           dc.b 8,-68,21
           dc.b 25,-42,52
           dc.b 14,-66,24
           dc.b 16,65,24
           dc.b 0,71,0
           dc.b 19,-65,21
           dc.b 29,-58,28
           dc.b 13,-69,10
           dc.b 56,-12,41
           dc.b 9,71,5
           dc.b 28,-64,15
           dc.b 10,-70,4
           dc.b 65,14,23
           dc.b 0,-71,0
           dc.b 12,70,2
           dc.b 67,22,9
           dc.b 59,39,4
           dc.b 16,-70,0
           dc.b 69,13,-4
           dc.b 22,68,-3
           dc.b 66,22,-14
           dc.b 66,17,-19
           dc.b 15,-69,-5
           dc.b 56,34,-25
           dc.b 62,11,-33
           dc.b 23,-66,-14
           dc.b 36,55,-26
           dc.b 30,59,-25
           dc.b 13,-69,-13
           dc.b 44,24,-49
           dc.b 14,67,-18
           dc.b 30,-46,-45
           dc.b 34,-22,-58
           dc.b 22,-49,-46
           dc.b 19,-49,-48
           dc.b 7,-67,-23
           dc.b 15,30,-63
           dc.b 8,-50,-49
           dc.b 2,-68,-22
           dc.b 0,-70,-12
           dc.b -2,-26,-65
           dc.b -4,59,-39
           dc.b -11,28,-64
           dc.b -8,-62,-34
           dc.b -16,-48,-50
           dc.b -1,71,-2
           dc.b 0,71,-1
           dc.b -16,-64,-27
           dc.b -38,-23,-56
           dc.b -36,-40,-46
           dc.b -28,-58,-31
           dc.b -48,24,-46
           dc.b -10,-70,-8
           dc.b -40,-50,-29
           dc.b -48,43,-30
           dc.b -43,-52,-23
           dc.b -16,69,-7
           dc.b -19,-68,-7
           dc.b -43,55,-12
           dc.b -59,38,-12
           dc.b -65,26,-9
           dc.b -69,13,-4
           dc.b -17,-69,0
           dc.b -62,33,4
           dc.b -69,16,9
           dc.b -69,-6,14
           dc.b -39,58,11
           dc.b -66,11,24
           dc.b -52,-41,23
           dc.b -29,-63,15
           dc.b -59,16,37
           dc.b -57,3,41
           dc.b -53,14,44
           dc.b -49,-17,47
           dc.b -36,46,40
           dc.b -27,56,34
           dc.b -32,-41,48
           dc.b -29,-42,50
           dc.b -26,38,54
           dc.b -7,68,19
           dc.b -5,69,17
           dc.b -5,68,22
           dc.b -7,55,44
           dc.b -4,58,40
           dc.b -2,12,69
           dc.b 0,-70,11
           dc.b 7,2,70
           dc.b 5,-62,33
           dc.b 17,-7,68
           dc.b 19,32,60
           dc.b 6,-69,15
           dc.b 30,-19,62
           dc.b 34,-22,58
           dc.b 32,42,48
           dc.b 23,61,29
           dc.b 29,-56,32
           dc.b 32,55,31
           dc.b 47,36,39
           dc.b 15,69,11
           dc.b 60,-11,37
           dc.b 22,-67,11
           dc.b 60,28,26
           dc.b 45,-53,16
           dc.b 11,70,3
           dc.b 44,55,9
           dc.b 23,-67,3
           dc.b 70,-3,4
           dc.b 71,-10,0
;
; ------------
; Sphere no 12
; ------------
;

sphere12    dc.b 69,-22,-4
           dc.b 61,-39,-8
           dc.b 37,63,-7
           dc.b 52,-48,-15
           dc.b 68,-11,-24
           dc.b 13,-72,-6
           dc.b 62,-17,-33
           dc.b 61,15,-38
           dc.b 58,16,-42
           dc.b 16,70,-13
           dc.b 18,-69,-18
           dc.b 44,31,-49
           dc.b 44,1,-57
           dc.b 21,-63,-31
           dc.b 30,-41,-52
           dc.b 32,5,-65
           dc.b 14,62,-36
           dc.b 20,-33,-61
           dc.b 0,-73,-2
           dc.b 12,15,-70
           dc.b 5,47,-55
           dc.b 1,62,-39
           dc.b -1,52,-51
           dc.b -7,-31,-66
           dc.b -10,40,-61
           dc.b -7,-67,-30
           dc.b -22,-1,-69
           dc.b -7,-71,-17
           dc.b -30,21,-62
           dc.b -28,46,-49
           dc.b -40,-2,-60
           dc.b -44,7,-57
           dc.b -46,-22,-52
           dc.b -52,9,-50
           dc.b -9,72,-7
           dc.b -53,-32,-38
           dc.b -59,-22,-37
           dc.b -47,-50,-25
           dc.b 0,-73,0
           dc.b -53,-46,-19
           dc.b -50,51,-14
           dc.b 0,74,0
           dc.b -70,17,-9
           dc.b -57,-45,-4
           dc.b -61,41,0
           dc.b -71,-15,5
           dc.b -50,53,7
           dc.b -11,-72,2
           dc.b -55,45,15
           dc.b -30,-66,10
           dc.b -15,-71,6
           dc.b -35,-62,18
           dc.b -59,22,37
           dc.b -50,-38,37
           dc.b -38,54,32
           dc.b -10,72,10
           dc.b -3,73,3
           dc.b -33,-48,43
           dc.b -38,28,56
           dc.b -36,2,63
           dc.b 0,-73,1
           dc.b -16,-59,40
           dc.b -22,2,69
           dc.b -9,-63,36
           dc.b -7,-60,41
           dc.b -7,-5,72
           dc.b -1,-61,40
           dc.b 2,37,63
           dc.b 7,-5,72
           dc.b 4,-68,27
           dc.b 10,-60,40
           dc.b 15,53,48
           dc.b 8,-69,22
           dc.b 25,-43,53
           dc.b 14,-68,24
           dc.b 16,67,24
           dc.b 0,73,0
           dc.b 20,-67,22
           dc.b 30,-60,29
           dc.b 13,-71,10
           dc.b 58,-12,42
           dc.b 9,73,5
           dc.b 29,-65,15
           dc.b 10,-72,4
           dc.b 67,15,24
           dc.b 0,-73,0
           dc.b 13,72,2
           dc.b 69,22,9
           dc.b 61,40,4
           dc.b 16,-72,0
           dc.b 71,14,-5
           dc.b 23,69,-3
           dc.b 68,22,-14
           dc.b 68,17,-19
           dc.b 15,-71,-5
           dc.b 58,35,-26
           dc.b 64,11,-34
           dc.b 23,-68,-14
           dc.b 37,57,-27
           dc.b 31,61,-26
           dc.b 14,-71,-13
           dc.b 46,25,-51
           dc.b 15,69,-19
           dc.b 31,-47,-46
           dc.b 35,-22,-60
           dc.b 23,-50,-48
           dc.b 20,-50,-50
           dc.b 8,-69,-24
           dc.b 16,31,-65
           dc.b 9,-52,-51
           dc.b 2,-69,-23
           dc.b 0,-72,-13
           dc.b -2,-27,-67
           dc.b -4,61,-40
           dc.b -11,28,-66
           dc.b -8,-64,-35
           dc.b -16,-49,-51
           dc.b -1,73,-2
           dc.b 0,73,-1
           dc.b -16,-65,-28
           dc.b -38,-24,-57
           dc.b -37,-41,-48
           dc.b -28,-59,-31
           dc.b -49,25,-47
           dc.b -11,-72,-9
           dc.b -42,-52,-30
           dc.b -50,44,-31
           dc.b -44,-54,-23
           dc.b -17,71,-7
           dc.b -19,-70,-7
           dc.b -44,57,-12
           dc.b -60,39,-12
           dc.b -67,27,-9
           dc.b -71,14,-5
           dc.b -17,-71,0
           dc.b -64,34,4
           dc.b -71,16,10
           dc.b -71,-6,15
           dc.b -40,60,11
           dc.b -68,11,24
           dc.b -54,-42,24
           dc.b -30,-65,15
           dc.b -61,16,38
           dc.b -59,3,42
           dc.b -55,15,46
           dc.b -51,-17,49
           dc.b -37,47,41
           dc.b -27,58,35
           dc.b -33,-42,49
           dc.b -29,-43,51
           dc.b -27,39,55
           dc.b -7,70,19
           dc.b -5,71,18
           dc.b -5,69,23
           dc.b -7,57,45
           dc.b -4,60,41
           dc.b -2,12,71
           dc.b 0,-72,11
           dc.b 7,2,72
           dc.b 6,-64,34
           dc.b 17,-7,70
           dc.b 20,33,61
           dc.b 6,-71,15
           dc.b 31,-20,63
           dc.b 35,-22,60
           dc.b 32,43,48
           dc.b 24,62,30
           dc.b 30,-58,33
           dc.b 33,57,31
           dc.b 49,37,41
           dc.b 16,71,11
           dc.b 61,-11,38
           dc.b 22,-69,12
           dc.b 62,28,27
           dc.b 46,-54,16
           dc.b 11,72,3
           dc.b 44,57,9
           dc.b 24,-69,3
           dc.b 72,-3,5
           dc.b 73,-10,0
;
; ------------
; Sphere no 13
; ------------
;

sphere13    dc.b 71,-23,-5
           dc.b 63,-40,-8
           dc.b 38,65,-8
           dc.b 54,-49,-15
           dc.b 70,-11,-25
           dc.b 13,-74,-6
           dc.b 64,-18,-34
           dc.b 62,15,-39
           dc.b 59,17,-43
           dc.b 16,72,-14
           dc.b 19,-70,-18
           dc.b 45,32,-50
           dc.b 46,1,-59
           dc.b 21,-65,-32
           dc.b 31,-42,-54
           dc.b 32,5,-67
           dc.b 14,64,-37
           dc.b 20,-34,-63
           dc.b 0,-75,-2
           dc.b 12,15,-72
           dc.b 6,48,-57
           dc.b 1,63,-40
           dc.b -1,53,-52
           dc.b -7,-32,-67
           dc.b -10,41,-62
           dc.b -7,-68,-31
           dc.b -23,-1,-71
           dc.b -7,-73,-17
           dc.b -31,22,-64
           dc.b -29,47,-51
           dc.b -41,-2,-62
           dc.b -46,7,-59
           dc.b -48,-23,-53
           dc.b -53,9,-52
           dc.b -9,74,-8
           dc.b -55,-33,-39
           dc.b -61,-23,-38
           dc.b -48,-51,-25
           dc.b 0,-75,0
           dc.b -55,-47,-20
           dc.b -51,52,-14
           dc.b 0,76,0
           dc.b -72,18,-10
           dc.b -58,-46,-4
           dc.b -63,42,0
           dc.b -73,-15,5
           dc.b -51,54,7
           dc.b -12,-74,2
           dc.b -56,46,16
           dc.b -31,-68,11
           dc.b -16,-73,7
           dc.b -36,-63,19
           dc.b -61,23,38
           dc.b -52,-39,38
           dc.b -39,55,32
           dc.b -10,74,10
           dc.b -3,75,3
           dc.b -35,-49,44
           dc.b -38,29,57
           dc.b -37,2,64
           dc.b 0,-75,1
           dc.b -16,-60,41
           dc.b -23,2,71
           dc.b -9,-65,37
           dc.b -7,-62,42
           dc.b -7,-5,74
           dc.b -1,-63,41
           dc.b 2,38,64
           dc.b 7,-5,74
           dc.b 5,-69,28
           dc.b 10,-62,41
           dc.b 16,54,49
           dc.b 8,-71,22
           dc.b 26,-44,54
           dc.b 14,-69,25
           dc.b 16,69,24
           dc.b 0,75,0
           dc.b 20,-69,22
           dc.b 30,-62,29
           dc.b 13,-73,11
           dc.b 59,-13,43
           dc.b 9,75,5
           dc.b 30,-67,15
           dc.b 11,-74,5
           dc.b 69,15,25
           dc.b 0,-75,0
           dc.b 13,74,2
           dc.b 71,23,10
           dc.b 62,41,4
           dc.b 17,-74,0
           dc.b 73,14,-5
           dc.b 23,71,-3
           dc.b 70,23,-14
           dc.b 70,18,-20
           dc.b 16,-73,-6
           dc.b 60,36,-26
           dc.b 66,11,-35
           dc.b 24,-69,-15
           dc.b 38,59,-27
           dc.b 32,63,-26
           dc.b 14,-73,-13
           dc.b 47,25,-52
           dc.b 15,71,-19
           dc.b 32,-48,-48
           dc.b 36,-23,-62
           dc.b 24,-51,-49
           dc.b 20,-51,-50
           dc.b 8,-70,-25
           dc.b 16,32,-65
           dc.b 9,-53,-52
           dc.b 2,-71,-23
           dc.b 0,-74,-13
           dc.b -2,-28,-69
           dc.b -4,63,-41
           dc.b -11,29,-67
           dc.b -9,-65,-36
           dc.b -17,-50,-53
           dc.b -1,75,-2
           dc.b 0,75,-1
           dc.b -17,-67,-29
           dc.b -39,-24,-58
           dc.b -38,-42,-49
           dc.b -29,-61,-32
           dc.b -51,25,-49
           dc.b -11,-74,-9
           dc.b -42,-53,-31
           dc.b -50,45,-31
           dc.b -45,-55,-23
           dc.b -17,73,-7
           dc.b -20,-72,-7
           dc.b -45,59,-12
           dc.b -62,40,-13
           dc.b -69,28,-9
           dc.b -73,14,-5
           dc.b -18,-73,0
           dc.b -66,35,4
           dc.b -73,17,10
           dc.b -73,-6,15
           dc.b -41,62,11
           dc.b -70,11,25
           dc.b -56,-43,25
           dc.b -30,-67,16
           dc.b -62,17,39
           dc.b -60,3,44
           dc.b -56,15,47
           dc.b -52,-18,50
           dc.b -38,48,43
           dc.b -28,59,36
           dc.b -34,-43,51
           dc.b -30,-44,52
           dc.b -28,40,57
           dc.b -8,72,20
           dc.b -5,73,18
           dc.b -5,71,23
           dc.b -8,59,46
           dc.b -4,62,42
           dc.b -2,13,73
           dc.b 0,-74,12
           dc.b 7,2,74
           dc.b 6,-66,35
           dc.b 18,-7,72
           dc.b 20,34,63
           dc.b 6,-73,16
           dc.b 32,-20,65
           dc.b 36,-23,62
           dc.b 34,44,50
           dc.b 24,64,31
           dc.b 30,-59,34
           dc.b 33,59,32
           dc.b 49,38,41
           dc.b 16,73,11
           dc.b 63,-11,39
           dc.b 23,-70,12
           dc.b 63,29,28
           dc.b 46,-56,17
           dc.b 12,74,3
           dc.b 45,59,9
           dc.b 24,-71,3
           dc.b 74,-3,5
           dc.b 75,-10,0
;
; ------------
; Sphere no 14
; ------------
;

sphere14    dc.b 73,-24,-5
           dc.b 65,-41,-9
           dc.b 39,66,-8
           dc.b 55,-51,-15
           dc.b 72,-12,-26
           dc.b 14,-76,-6
           dc.b 66,-18,-35
           dc.b 64,16,-40
           dc.b 61,17,-44
           dc.b 16,74,-14
           dc.b 19,-72,-18
           dc.b 46,32,-52
           dc.b 47,1,-60
           dc.b 22,-66,-33
           dc.b 32,-43,-55
           dc.b 33,5,-69
           dc.b 15,66,-38
           dc.b 21,-35,-65
           dc.b 0,-77,-3
           dc.b 13,16,-74
           dc.b 6,50,-58
           dc.b 1,65,-41
           dc.b -1,55,-54
           dc.b -7,-32,-69
           dc.b -11,42,-64
           dc.b -7,-70,-31
           dc.b -23,-1,-73
           dc.b -7,-75,-18
           dc.b -32,22,-66
           dc.b -30,49,-51
           dc.b -43,-2,-63
           dc.b -47,8,-60
           dc.b -49,-24,-54
           dc.b -55,9,-53
           dc.b -9,76,-8
           dc.b -56,-34,-41
           dc.b -62,-24,-39
           dc.b -50,-53,-26
           dc.b 0,-77,0
           dc.b -56,-49,-20
           dc.b -53,54,-15
           dc.b 0,78,0
           dc.b -74,18,-10
           dc.b -60,-48,-4
           dc.b -64,43,0
           dc.b -75,-16,5
           dc.b -53,56,7
           dc.b -12,-76,2
           dc.b -58,48,16
           dc.b -31,-70,11
           dc.b -16,-75,7
           dc.b -37,-65,19
           dc.b -62,24,39
           dc.b -53,-40,38
           dc.b -40,57,34
           dc.b -11,76,11
           dc.b -3,77,3
           dc.b -35,-51,45
           dc.b -39,30,58
           dc.b -38,2,66
           dc.b 0,-77,1
           dc.b -17,-62,42
           dc.b -23,2,73
           dc.b -9,-66,38
           dc.b -7,-63,43
           dc.b -8,-5,76
           dc.b -1,-64,42
           dc.b 2,39,66
           dc.b 8,-5,76
           dc.b 5,-71,29
           dc.b 10,-63,42
           dc.b 16,56,51
           dc.b 9,-73,23
           dc.b 27,-45,56
           dc.b 15,-71,25
           dc.b 17,71,25
           dc.b 0,77,0
           dc.b 20,-71,23
           dc.b 31,-63,30
           dc.b 13,-75,11
           dc.b 61,-13,44
           dc.b 10,77,6
           dc.b 30,-69,16
           dc.b 11,-76,5
           dc.b 71,16,25
           dc.b 0,-77,0
           dc.b 13,76,2
           dc.b 73,24,10
           dc.b 64,42,4
           dc.b 17,-76,0
           dc.b 75,14,-5
           dc.b 24,73,-3
           dc.b 72,24,-15
           dc.b 72,18,-20
           dc.b 16,-75,-6
           dc.b 62,37,-27
           dc.b 67,12,-36
           dc.b 25,-71,-15
           dc.b 39,60,-28
           dc.b 32,64,-27
           dc.b 15,-74,-14
           dc.b 48,26,-54
           dc.b 16,73,-20
           dc.b 32,-50,-48
           dc.b 37,-24,-64
           dc.b 24,-53,-51
           dc.b 21,-53,-52
           dc.b 8,-72,-25
           dc.b 16,32,-67
           dc.b 9,-55,-54
           dc.b 2,-73,-24
           dc.b 0,-76,-13
           dc.b -2,-29,-71
           dc.b -4,64,-42
           dc.b -12,30,-69
           dc.b -9,-67,-37
           dc.b -17,-52,-54
           dc.b -1,77,-3
           dc.b 0,77,-1
           dc.b -17,-69,-30
           dc.b -40,-25,-60
           dc.b -39,-43,-50
           dc.b -30,-63,-33
           dc.b -52,26,-50
           dc.b -12,-76,-10
           dc.b -44,-55,-32
           dc.b -52,46,-32
           dc.b -46,-57,-24
           dc.b -18,75,-8
           dc.b -20,-74,-7
           dc.b -47,60,-13
           dc.b -64,41,-13
           dc.b -71,29,-10
           dc.b -75,14,-5
           dc.b -18,-75,0
           dc.b -67,36,4
           dc.b -75,17,10
           dc.b -75,-6,16
           dc.b -42,63,12
           dc.b -72,12,26
           dc.b -57,-44,25
           dc.b -31,-68,16
           dc.b -64,17,40
           dc.b -62,4,45
           dc.b -58,16,48
           dc.b -53,-18,52
           dc.b -39,50,43
           dc.b -29,61,37
           dc.b -35,-44,52
           dc.b -31,-45,54
           dc.b -28,41,59
           dc.b -8,74,20
           dc.b -6,75,19
           dc.b -6,73,24
           dc.b -8,60,48
           dc.b -4,63,43
           dc.b -2,13,75
           dc.b 0,-76,12
           dc.b 8,2,76
           dc.b 6,-68,36
           dc.b 18,-8,74
           dc.b 21,35,65
           dc.b 6,-75,16
           dc.b 32,-21,66
           dc.b 37,-24,64
           dc.b 35,45,52
           dc.b 25,66,32
           dc.b 32,-61,35
           dc.b 35,60,34
           dc.b 51,39,43
           dc.b 16,74,12
           dc.b 65,-12,40
           dc.b 23,-72,12
           dc.b 64,30,28
           dc.b 48,-57,17
           dc.b 12,76,3
           dc.b 47,60,10
           dc.b 25,-73,3
           dc.b 76,-4,5
           dc.b 77,-10,0
;
; ------------
; Sphere no 15
; ------------
;

sphere15    dc.b 75,-24,-5
           dc.b 66,-42,-9
           dc.b 40,68,-8
           dc.b 57,-52,-16
           dc.b 74,-12,-27
           dc.b 14,-78,-6
           dc.b 67,-19,-36
           dc.b 66,16,-41
           dc.b 62,17,-45
           dc.b 17,76,-14
           dc.b 20,-74,-19
           dc.b 48,33,-53
           dc.b 48,1,-62
           dc.b 22,-68,-33
           dc.b 33,-44,-57
           dc.b 34,5,-71
           dc.b 15,67,-38
           dc.b 21,-36,-67
           dc.b 0,-79,-3
           dc.b 13,16,-76
           dc.b 6,51,-60
           dc.b 1,67,-42
           dc.b -1,56,-55
           dc.b -7,-33,-71
           dc.b -11,43,-65
           dc.b -7,-72,-32
           dc.b -24,-1,-75
           dc.b -7,-77,-18
           dc.b -33,23,-68
           dc.b -31,50,-53
           dc.b -44,-2,-65
           dc.b -48,8,-62
           dc.b -50,-24,-56
           dc.b -56,9,-54
           dc.b -9,78,-8
           dc.b -57,-35,-41
           dc.b -64,-24,-40
           dc.b -51,-54,-27
           dc.b 0,-79,0
           dc.b -58,-50,-21
           dc.b -54,55,-15
           dc.b 0,80,0
           dc.b -76,19,-10
           dc.b -62,-49,-4
           dc.b -66,44,0
           dc.b -77,-16,5
           dc.b -54,57,7
           dc.b -12,-78,2
           dc.b -60,49,17
           dc.b -32,-71,11
           dc.b -17,-77,7
           dc.b -37,-67,20
           dc.b -64,24,40
           dc.b -55,-41,39
           dc.b -41,58,34
           dc.b -11,78,11
           dc.b -3,79,3
           dc.b -36,-52,47
           dc.b -40,31,60
           dc.b -39,2,68
           dc.b 0,-79,1
           dc.b -17,-63,44
           dc.b -24,2,75
           dc.b -9,-68,39
           dc.b -7,-65,44
           dc.b -8,-5,78
           dc.b -1,-66,43
           dc.b 2,40,68
           dc.b 8,-5,78
           dc.b 5,-73,30
           dc.b 10,-65,43
           dc.b 16,57,52
           dc.b 9,-75,24
           dc.b 28,-47,57
           dc.b 15,-73,26
           dc.b 17,73,26
           dc.b 0,79,0
           dc.b 21,-73,23
           dc.b 32,-65,31
           dc.b 14,-77,12
           dc.b 63,-13,45
           dc.b 10,79,6
           dc.b 31,-71,16
           dc.b 11,-78,5
           dc.b 73,16,26
           dc.b 0,-79,0
           dc.b 14,78,3
           dc.b 75,24,10
           dc.b 66,43,4
           dc.b 17,-77,0
           dc.b 77,15,-5
           dc.b 25,75,-3
           dc.b 74,24,-15
           dc.b 74,19,-21
           dc.b 17,-77,-6
           dc.b 63,38,-28
           dc.b 69,12,-37
           dc.b 26,-73,-16
           dc.b 40,62,-29
           dc.b 33,66,-28
           dc.b 15,-76,-15
           dc.b 50,27,-55
           dc.b 16,75,-21
           dc.b 34,-51,-50
           dc.b 38,-24,-65
           dc.b 25,-54,-52
           dc.b 21,-54,-53
           dc.b 8,-74,-26
           dc.b 17,33,-69
           dc.b 9,-56,-55
           dc.b 2,-75,-25
           dc.b 0,-78,-14
           dc.b -2,-29,-73
           dc.b -4,66,-43
           dc.b -12,31,-71
           dc.b -9,-69,-38
           dc.b -18,-53,-56
           dc.b -1,79,-3
           dc.b 0,79,-1
           dc.b -18,-71,-31
           dc.b -41,-26,-62
           dc.b -40,-44,-52
           dc.b -31,-64,-34
           dc.b -53,27,-52
           dc.b -12,-78,-10
           dc.b -45,-56,-32
           dc.b -53,48,-33
           dc.b -47,-58,-25
           dc.b -18,77,-8
           dc.b -21,-76,-7
           dc.b -48,62,-13
           dc.b -65,42,-13
           dc.b -73,29,-10
           dc.b -77,15,-5
           dc.b -19,-77,0
           dc.b -69,37,4
           dc.b -76,17,10
           dc.b -77,-6,16
           dc.b -43,65,12
           dc.b -74,12,27
           dc.b -59,-45,26
           dc.b -32,-70,17
           dc.b -65,17,40
           dc.b -63,4,46
           dc.b -59,16,50
           dc.b -55,-19,53
           dc.b -40,51,45
           dc.b -30,63,38
           dc.b -36,-45,53
           dc.b -32,-47,55
           dc.b -29,42,60
           dc.b -8,76,21
           dc.b -6,77,19
           dc.b -6,75,25
           dc.b -8,62,49
           dc.b -4,65,44
           dc.b -2,13,77
           dc.b 0,-78,12
           dc.b 8,2,78
           dc.b 6,-69,37
           dc.b 19,-8,76
           dc.b 21,36,67
           dc.b 7,-77,17
           dc.b 33,-22,68
           dc.b 38,-24,65
           dc.b 35,47,53
           dc.b 25,67,33
           dc.b 32,-63,36
           dc.b 35,62,34
           dc.b 52,40,44
           dc.b 17,76,12
           dc.b 66,-12,41
           dc.b 24,-74,13
           dc.b 66,31,29
           dc.b 49,-59,18
           dc.b 12,78,3
           dc.b 48,62,10
           dc.b 26,-75,3
           dc.b 78,-4,5
           dc.b 79,-11,0
;
; ------------
; Sphere no 16
; ------------
;

sphere16    dc.b 76,-25,-5
           dc.b 68,-43,-9
           dc.b 41,70,-8
           dc.b 58,-53,-16
           dc.b 75,-12,-27
           dc.b 15,-80,-6
           dc.b 69,-19,-37
           dc.b 67,17,-42
           dc.b 63,18,-46
           dc.b 17,78,-14
           dc.b 20,-76,-20
           dc.b 49,34,-54
           dc.b 49,1,-63
           dc.b 23,-70,-34
           dc.b 33,-45,-58
           dc.b 35,5,-72
           dc.b 16,69,-39
           dc.b 22,-37,-69
           dc.b 0,-81,-3
           dc.b 13,17,-78
           dc.b 6,52,-61
           dc.b 1,68,-43
           dc.b -1,57,-56
           dc.b -7,-34,-73
           dc.b -11,44,-66
           dc.b -8,-74,-32
           dc.b -25,-1,-77
           dc.b -7,-79,-19
           dc.b -34,23,-70
           dc.b -31,51,-54
           dc.b -45,-2,-67
           dc.b -49,8,-63
           dc.b -51,-25,-57
           dc.b -58,9,-56
           dc.b -10,80,-8
           dc.b -59,-35,-42
           dc.b -65,-25,-40
           dc.b -52,-55,-27
           dc.b 0,-81,0
           dc.b -59,-51,-21
           dc.b -55,56,-15
           dc.b 0,82,0
           dc.b -78,19,-10
           dc.b -63,-50,-4
           dc.b -67,45,0
           dc.b -79,-17,5
           dc.b -55,58,7
           dc.b -13,-80,2
           dc.b -61,50,17
           dc.b -32,-73,11
           dc.b -17,-79,7
           dc.b -38,-68,20
           dc.b -65,25,40
           dc.b -56,-42,41
           dc.b -42,59,35
           dc.b -12,80,11
           dc.b -3,81,3
           dc.b -37,-53,48
           dc.b -41,32,62
           dc.b -40,2,70
           dc.b 0,-81,1
           dc.b -18,-65,45
           dc.b -25,2,77
           dc.b -10,-70,40
           dc.b -8,-67,46
           dc.b -8,-5,80
           dc.b -1,-67,44
           dc.b 2,41,70
           dc.b 8,-5,80
           dc.b 5,-75,31
           dc.b 11,-67,45
           dc.b 17,58,53
           dc.b 9,-77,24
           dc.b 28,-48,59
           dc.b 16,-75,27
           dc.b 18,74,27
           dc.b 0,81,0
           dc.b 22,-74,24
           dc.b 33,-67,32
           dc.b 14,-79,12
           dc.b 64,-14,47
           dc.b 10,80,6
           dc.b 32,-73,17
           dc.b 12,-80,5
           dc.b 75,17,27
           dc.b 0,-81,0
           dc.b 14,80,3
           dc.b 76,25,10
           dc.b 67,44,4
           dc.b 18,-79,0
           dc.b 79,15,-5
           dc.b 25,77,-3
           dc.b 75,25,-16
           dc.b 75,19,-21
           dc.b 17,-79,-6
           dc.b 64,39,-28
           dc.b 70,12,-37
           dc.b 27,-75,-16
           dc.b 41,63,-29
           dc.b 34,67,-28
           dc.b 15,-78,-15
           dc.b 51,28,-57
           dc.b 17,77,-22
           dc.b 34,-52,-51
           dc.b 38,-25,-66
           dc.b 25,-55,-53
           dc.b 22,-55,-54
           dc.b 8,-76,-27
           dc.b 17,34,-71
           dc.b 9,-57,-56
           dc.b 2,-77,-25
           dc.b 0,-80,-14
           dc.b -2,-30,-75
           dc.b -4,67,-44
           dc.b -13,32,-73
           dc.b -9,-71,-39
           dc.b -18,-54,-57
           dc.b -1,81,-3
           dc.b 0,81,-1
           dc.b -18,-73,-32
           dc.b -43,-26,-63
           dc.b -41,-45,-52
           dc.b -32,-66,-35
           dc.b -55,28,-53
           dc.b -13,-80,-10
           dc.b -46,-57,-33
           dc.b -55,49,-34
           dc.b -48,-59,-25
           dc.b -19,79,-8
           dc.b -21,-78,-7
           dc.b -49,63,-14
           dc.b -67,43,-14
           dc.b -75,30,-10
           dc.b -79,15,-5
           dc.b -19,-79,0
           dc.b -71,38,5
           dc.b -78,18,10
           dc.b -79,-7,16
           dc.b -45,67,12
           dc.b -75,12,27
           dc.b -61,-47,27
           dc.b -33,-72,17
           dc.b -66,18,41
           dc.b -65,4,47
           dc.b -61,17,51
           dc.b -56,-19,54
           dc.b -41,52,46
           dc.b -30,64,39
           dc.b -37,-47,55
           dc.b -33,-48,57
           dc.b -30,43,62
           dc.b -8,78,21
           dc.b -6,79,19
           dc.b -6,77,25
           dc.b -8,63,50
           dc.b -4,67,46
           dc.b -2,14,79
           dc.b 0,-80,13
           dc.b 8,2,80
           dc.b 6,-71,38
           dc.b 19,-8,78
           dc.b 22,37,69
           dc.b 7,-79,17
           dc.b 34,-22,70
           dc.b 38,-25,66
           dc.b 36,48,54
           dc.b 26,69,33
           dc.b 33,-64,37
           dc.b 36,63,35
           dc.b 54,41,45
           dc.b 17,78,12
           dc.b 67,-12,42
           dc.b 25,-76,13
           dc.b 68,32,30
           dc.b 50,-60,18
           dc.b 13,80,3
           dc.b 49,63,10
           dc.b 27,-77,3
           dc.b 80,-4,5
           dc.b 81,-11,0
;
; ------------
; Sphere no 17
; ------------
;

sphere17    dc.b 78,-25,-5
           dc.b 70,-44,-9
           dc.b 42,72,-8
           dc.b 60,-55,-17
           dc.b 77,-13,-28
           dc.b 15,-82,-6
           dc.b 71,-20,-38
           dc.b 69,17,-43
           dc.b 65,18,-47
           dc.b 18,80,-15
           dc.b 21,-78,-20
           dc.b 50,35,-56
           dc.b 51,1,-65
           dc.b 24,-72,-35
           dc.b 34,-46,-59
           dc.b 36,5,-74
           dc.b 16,71,-40
           dc.b 22,-38,-70
           dc.b 0,-83,-3
           dc.b 14,17,-80
           dc.b 6,53,-63
           dc.b 1,70,-44
           dc.b -2,59,-58
           dc.b -7,-35,-75
           dc.b -12,45,-68
           dc.b -8,-76,-33
           dc.b -25,-1,-78
           dc.b -7,-81,-19
           dc.b -35,24,-71
           dc.b -32,52,-56
           dc.b -46,-2,-68
           dc.b -51,8,-65
           dc.b -52,-25,-58
           dc.b -59,10,-57
           dc.b -10,82,-8
           dc.b -60,-36,-44
           dc.b -66,-25,-41
           dc.b -53,-57,-28
           dc.b 0,-83,0
           dc.b -61,-52,-22
           dc.b -57,58,-16
           dc.b 0,84,0
           dc.b -80,20,-11
           dc.b -65,-51,-4
           dc.b -69,46,0
           dc.b -81,-17,5
           dc.b -57,60,8
           dc.b -13,-82,2
           dc.b -63,51,18
           dc.b -33,-75,12
           dc.b -18,-81,8
           dc.b -39,-70,21
           dc.b -66,25,41
           dc.b -58,-43,42
           dc.b -43,61,36
           dc.b -12,82,11
           dc.b -3,83,3
           dc.b -38,-55,49
           dc.b -43,32,63
           dc.b -41,2,71
           dc.b 0,-83,1
           dc.b -18,-67,46
           dc.b -25,2,78
           dc.b -10,-72,41
           dc.b -8,-68,47
           dc.b -8,-5,82
           dc.b -1,-69,45
           dc.b 2,42,71
           dc.b 8,-5,82
           dc.b 5,-77,31
           dc.b 11,-68,46
           dc.b 17,60,55
           dc.b 10,-79,25
           dc.b 29,-49,60
           dc.b 16,-77,27
           dc.b 19,76,28
           dc.b 0,83,0
           dc.b 22,-76,25
           dc.b 34,-68,33
           dc.b 15,-81,12
           dc.b 66,-14,48
           dc.b 11,82,6
           dc.b 33,-74,17
           dc.b 12,-82,5
           dc.b 77,17,28
           dc.b 0,-83,0
           dc.b 15,82,3
           dc.b 78,25,10
           dc.b 69,45,4
           dc.b 18,-81,0
           dc.b 81,16,-5
           dc.b 26,79,-3
           dc.b 77,25,-16
           dc.b 77,20,-22
           dc.b 18,-81,-6
           dc.b 66,40,-29
           dc.b 72,13,-38
           dc.b 27,-77,-16
           dc.b 42,65,-30
           dc.b 35,69,-29
           dc.b 16,-80,-15
           dc.b 52,28,-57
           dc.b 17,78,-22
           dc.b 35,-53,-53
           dc.b 39,-25,-68
           dc.b 26,-57,-54
           dc.b 22,-57,-56
           dc.b 9,-78,-28
           dc.b 18,35,-73
           dc.b 10,-59,-58
           dc.b 2,-79,-26
           dc.b 0,-82,-15
           dc.b -2,-31,-76
           dc.b -4,69,-45
           dc.b -13,32,-75
           dc.b -10,-72,-40
           dc.b -19,-56,-58
           dc.b -1,83,-3
           dc.b 0,83,-1
           dc.b -19,-74,-32
           dc.b -44,-27,-65
           dc.b -42,-46,-54
           dc.b -32,-67,-36
           dc.b -56,28,-54
           dc.b -13,-82,-10
           dc.b -47,-59,-34
           dc.b -56,50,-35
           dc.b -50,-61,-26
           dc.b -19,81,-8
           dc.b -22,-80,-8
           dc.b -49,65,-14
           dc.b -69,44,-14
           dc.b -76,31,-10
           dc.b -81,16,-5
           dc.b -20,-81,0
           dc.b -73,39,5
           dc.b -80,18,11
           dc.b -81,-7,17
           dc.b -46,68,13
           dc.b -77,13,28
           dc.b -62,-48,27
           dc.b -34,-74,18
           dc.b -68,18,42
           dc.b -67,4,48
           dc.b -62,17,52
           dc.b -58,-20,56
           dc.b -42,53,47
           dc.b -31,66,40
           dc.b -38,-48,56
           dc.b -33,-49,58
           dc.b -31,44,63
           dc.b -8,80,22
           dc.b -6,81,19
           dc.b -6,79,26
           dc.b -9,65,51
           dc.b -5,68,47
           dc.b -2,14,81
           dc.b 0,-82,13
           dc.b 8,2,82
           dc.b 6,-73,39
           dc.b 20,-8,80
           dc.b 22,38,70
           dc.b 7,-81,18
           dc.b 35,-23,71
           dc.b 39,-25,68
           dc.b 37,49,55
           dc.b 27,71,34
           dc.b 34,-66,37
           dc.b 37,65,36
           dc.b 55,42,46
           dc.b 18,80,13
           dc.b 69,-13,43
           dc.b 26,-78,14
           dc.b 70,32,31
           dc.b 52,-62,19
           dc.b 13,82,3
           dc.b 50,65,10
           dc.b 27,-78,3
           dc.b 82,-4,5
           dc.b 83,-11,0
;
; ------------
; Sphere no 18
; ------------
;

sphere18    dc.b 80,-26,-5
           dc.b 71,-45,-10
           dc.b 43,73,-9
           dc.b 61,-56,-17
           dc.b 78,-13,-28
           dc.b 15,-84,-6
           dc.b 73,-20,-38
           dc.b 71,17,-44
           dc.b 67,19,-48
           dc.b 19,82,-16
           dc.b 21,-80,-20
           dc.b 51,36,-57
           dc.b 52,1,-66
           dc.b 24,-73,-36
           dc.b 35,-48,-61
           dc.b 37,5,-76
           dc.b 16,72,-41
           dc.b 23,-39,-72
           dc.b 0,-85,-3
           dc.b 14,17,-82
           dc.b 6,55,-64
           dc.b 1,72,-45
           dc.b -2,60,-59
           dc.b -8,-36,-76
           dc.b -12,46,-70
           dc.b -8,-77,-34
           dc.b -26,-1,-80
           dc.b -8,-83,-20
           dc.b -35,25,-73
           dc.b -33,54,-57
           dc.b -47,-3,-70
           dc.b -52,8,-66
           dc.b -54,-26,-60
           dc.b -61,10,-59
           dc.b -10,84,-8
           dc.b -62,-37,-45
           dc.b -68,-26,-42
           dc.b -54,-58,-29
           dc.b 0,-85,0
           dc.b -62,-54,-22
           dc.b -58,59,-16
           dc.b 0,86,0
           dc.b -82,20,-11
           dc.b -66,-52,-4
           dc.b -71,48,0
           dc.b -83,-17,5
           dc.b -58,61,8
           dc.b -13,-84,2
           dc.b -64,52,18
           dc.b -34,-77,12
           dc.b -18,-83,8
           dc.b -40,-72,21
           dc.b -68,26,42
           dc.b -59,-44,42
           dc.b -44,62,37
           dc.b -12,84,11
           dc.b -3,85,3
           dc.b -39,-56,50
           dc.b -44,33,65
           dc.b -42,3,73
           dc.b -1,-85,2
           dc.b -19,-68,47
           dc.b -26,3,80
           dc.b -10,-73,42
           dc.b -8,-70,48
           dc.b -8,-5,84
           dc.b -1,-71,47
           dc.b 2,43,73
           dc.b 8,-5,84
           dc.b 5,-79,32
           dc.b 11,-70,47
           dc.b 18,61,56
           dc.b 10,-81,25
           dc.b 30,-50,62
           dc.b 16,-79,28
           dc.b 19,78,28
           dc.b 0,85,0
           dc.b 22,-78,25
           dc.b 35,-70,34
           dc.b 15,-83,12
           dc.b 67,-14,49
           dc.b 11,84,6
           dc.b 34,-76,18
           dc.b 12,-84,5
           dc.b 78,17,28
           dc.b 0,-85,0
           dc.b 15,84,3
           dc.b 80,26,11
           dc.b 71,46,5
           dc.b 19,-83,0
           dc.b 83,16,-5
           dc.b 26,81,-3
           dc.b 79,26,-16
           dc.b 79,20,-22
           dc.b 18,-83,-6
           dc.b 68,41,-30
           dc.b 74,13,-39
           dc.b 27,-79,-17
           dc.b 43,66,-31
           dc.b 36,71,-30
           dc.b 16,-82,-15
           dc.b 53,29,-59
           dc.b 17,80,-22
           dc.b 36,-55,-53
           dc.b 40,-26,-70
           dc.b 27,-58,-55
           dc.b 23,-58,-57
           dc.b 9,-80,-28
           dc.b 18,36,-74
           dc.b 10,-60,-59
           dc.b 2,-81,-26
           dc.b 0,-84,-15
           dc.b -2,-32,-78
           dc.b -5,71,-47
           dc.b -13,33,-77
           dc.b -10,-74,-41
           dc.b -19,-57,-59
           dc.b -1,85,-3
           dc.b -1,85,-2
           dc.b -19,-76,-33
           dc.b -45,-27,-67
           dc.b -43,-48,-55
           dc.b -33,-69,-37
           dc.b -57,29,-55
           dc.b -13,-84,-10
           dc.b -48,-60,-35
           dc.b -57,51,-36
           dc.b -51,-62,-27
           dc.b -20,83,-8
           dc.b -23,-82,-8
           dc.b -51,66,-14
           dc.b -70,45,-14
           dc.b -78,32,-10
           dc.b -83,16,-5
           dc.b -20,-83,0
           dc.b -74,40,5
           dc.b -82,19,11
           dc.b -83,-7,17
           dc.b -47,70,13
           dc.b -78,13,28
           dc.b -63,-49,28
           dc.b -35,-75,18
           dc.b -70,19,43
           dc.b -68,4,49
           dc.b -64,17,53
           dc.b -59,-20,57
           dc.b -43,55,48
           dc.b -32,67,40
           dc.b -39,-49,58
           dc.b -34,-50,59
           dc.b -31,45,64
           dc.b -9,82,23
           dc.b -6,83,20
           dc.b -6,81,26
           dc.b -9,66,53
           dc.b -5,70,48
           dc.b -2,14,83
           dc.b 0,-84,13
           dc.b 8,3,84
           dc.b 7,-75,40
           dc.b 20,-8,82
           dc.b 23,39,72
           dc.b 7,-83,18
           dc.b 35,-23,73
           dc.b 40,-26,70
           dc.b 38,50,57
           dc.b 27,72,35
           dc.b 34,-67,38
           dc.b 38,66,37
           dc.b 56,43,47
           dc.b 18,82,13
           dc.b 71,-13,44
           dc.b 26,-80,14
           dc.b 72,33,32
           dc.b 53,-63,19
           dc.b 13,84,3
           dc.b 52,66,11
           dc.b 28,-80,4
           dc.b 84,-4,5
           dc.b 85,-11,0
;
; ------------
; Sphere no 19
; ------------
;

sphere19    dc.b 82,-27,-5
           dc.b 73,-46,-10
           dc.b 44,75,-9
           dc.b 63,-57,-18
           dc.b 80,-13,-29
           dc.b 16,-86,-7
           dc.b 75,-21,-39
           dc.b 72,18,-45
           dc.b 68,19,-49
           dc.b 19,84,-16
           dc.b 22,-82,-21
           dc.b 52,37,-58
           dc.b 53,1,-68
           dc.b 25,-75,-37
           dc.b 36,-49,-62
           dc.b 38,6,-78
           dc.b 17,74,-42
           dc.b 24,-39,-74
           dc.b 0,-87,-3
           dc.b 14,18,-84
           dc.b 7,56,-66
           dc.b 1,73,-46
           dc.b -2,62,-61
           dc.b -8,-37,-78
           dc.b -12,47,-71
           dc.b -8,-79,-35
           dc.b -26,-1,-82
           dc.b -8,-85,-20
           dc.b -36,25,-75
           dc.b -34,55,-58
           dc.b -48,-3,-72
           dc.b -53,9,-68
           dc.b -55,-27,-61
           dc.b -62,10,-60
           dc.b -11,86,-9
           dc.b -63,-38,-46
           dc.b -70,-27,-43
           dc.b -56,-60,-30
           dc.b 0,-87,0
           dc.b -63,-55,-23
           dc.b -60,61,-17
           dc.b 0,88,0
           dc.b -84,21,-11
           dc.b -68,-54,-4
           dc.b -72,49,0
           dc.b -85,-18,5
           dc.b -60,63,8
           dc.b -14,-86,3
           dc.b -66,54,19
           dc.b -35,-79,12
           dc.b -19,-85,8
           dc.b -41,-73,22
           dc.b -70,27,43
           dc.b -60,-45,44
           dc.b -45,64,38
           dc.b -12,86,12
           dc.b -4,87,4
           dc.b -40,-57,52
           dc.b -45,34,67
           dc.b -43,3,75
           dc.b -1,-87,2
           dc.b -19,-70,48
           dc.b -26,3,82
           dc.b -10,-75,43
           dc.b -8,-72,49
           dc.b -9,-6,86
           dc.b -1,-72,48
           dc.b 2,44,75
           dc.b 9,-6,86
           dc.b 5,-81,33
           dc.b 12,-72,48
           dc.b 18,63,58
           dc.b 10,-83,25
           dc.b 31,-51,63
           dc.b 17,-81,29
           dc.b 19,80,29
           dc.b 0,87,0
           dc.b 23,-80,26
           dc.b 35,-72,34
           dc.b 16,-85,13
           dc.b 69,-15,50
           dc.b 11,86,6
           dc.b 34,-78,18
           dc.b 13,-86,6
           dc.b 80,18,29
           dc.b 0,-87,0
           dc.b 15,86,3
           dc.b 82,27,11
           dc.b 72,47,5
           dc.b 19,-85,0
           dc.b 85,16,-5
           dc.b 27,83,-3
           dc.b 81,27,-17
           dc.b 81,21,-23
           dc.b 19,-85,-7
           dc.b 69,42,-30
           dc.b 75,13,-40
           dc.b 28,-81,-18
           dc.b 44,68,-32
           dc.b 37,72,-31
           dc.b 17,-84,-16
           dc.b 54,30,-60
           dc.b 18,82,-23
           dc.b 37,-56,-55
           dc.b 41,-27,-71
           dc.b 28,-60,-57
           dc.b 23,-60,-59
           dc.b 9,-82,-29
           dc.b 19,37,-76
           dc.b 10,-62,-61
           dc.b 2,-83,-27
           dc.b 0,-86,-15
           dc.b -2,-32,-80
           dc.b -5,72,-48
           dc.b -14,34,-79
           dc.b -10,-76,-42
           dc.b -20,-58,-61
           dc.b -1,87,-3
           dc.b -1,87,-2
           dc.b -19,-78,-33
           dc.b -46,-28,-68
           dc.b -44,-49,-56
           dc.b -34,-71,-37
           dc.b -58,30,-56
           dc.b -13,-86,-11
           dc.b -50,-62,-36
           dc.b -59,52,-37
           dc.b -52,-64,-28
           dc.b -20,85,-8
           dc.b -23,-84,-8
           dc.b -52,68,-15
           dc.b -72,46,-15
           dc.b -80,32,-11
           dc.b -85,16,-5
           dc.b -21,-85,0
           dc.b -76,41,5
           dc.b -84,19,11
           dc.b -85,-7,18
           dc.b -48,72,13
           dc.b -80,13,29
           dc.b -65,-50,29
           dc.b -36,-77,19
           dc.b -72,19,45
           dc.b -70,4,51
           dc.b -65,18,55
           dc.b -61,-21,59
           dc.b -44,56,49
           dc.b -33,69,42
           dc.b -40,-50,59
           dc.b -35,-51,61
           dc.b -32,46,66
           dc.b -9,84,23
           dc.b -6,85,20
           dc.b -6,83,27
           dc.b -9,68,54
           dc.b -5,72,49
           dc.b -3,15,85
           dc.b 0,-86,14
           dc.b 9,3,86
           dc.b 7,-76,41
           dc.b 21,-9,84
           dc.b 24,39,74
           dc.b 7,-85,19
           dc.b 36,-24,75
           dc.b 41,-27,71
           dc.b 39,51,58
           dc.b 28,74,36
           dc.b 36,-69,40
           dc.b 39,68,38
           dc.b 58,44,48
           dc.b 19,84,14
           dc.b 72,-13,45
           dc.b 27,-82,14
           dc.b 73,34,32
           dc.b 54,-65,19
           dc.b 14,86,4
           dc.b 53,68,11
           dc.b 29,-82,4
           dc.b 86,-4,6
           dc.b 87,-12,0
;
; ------------
; Sphere no 20
; ------------
;

sphere20    dc.b 84,-27,-5
           dc.b 75,-47,-10
           dc.b 44,77,-9
           dc.b 64,-59,-18
           dc.b 82,-14,-30
           dc.b 16,-88,-7
           dc.b 76,-21,-40
           dc.b 74,18,-46
           dc.b 70,20,-51
           dc.b 19,86,-16
           dc.b 23,-84,-22
           dc.b 54,38,-60
           dc.b 54,1,-70
           dc.b 25,-77,-38
           dc.b 37,-50,-64
           dc.b 39,6,-79
           dc.b 17,76,-43
           dc.b 24,-40,-76
           dc.b 0,-89,-3
           dc.b 15,18,-86
           dc.b 7,57,-67
           dc.b 1,75,-48
           dc.b -2,63,-62
           dc.b -8,-38,-80
           dc.b -13,49,-73
           dc.b -9,-81,-36
           dc.b -27,-1,-84
           dc.b -8,-86,-21
           dc.b -37,26,-77
           dc.b -34,56,-59
           dc.b -49,-3,-73
           dc.b -54,9,-70
           dc.b -56,-27,-63
           dc.b -64,10,-61
           dc.b -11,88,-9
           dc.b -64,-39,-47
           dc.b -72,-27,-45
           dc.b -57,-61,-30
           dc.b 0,-89,0
           dc.b -64,-56,-23
           dc.b -61,62,-17
           dc.b 0,90,0
           dc.b -86,21,-12
           dc.b -69,-55,-4
           dc.b -74,50,0
           dc.b -87,-18,6
           dc.b -61,64,8
           dc.b -14,-88,3
           dc.b -67,55,19
           dc.b -36,-80,13
           dc.b -19,-87,8
           dc.b -43,-75,23
           dc.b -72,27,45
           dc.b -62,-46,45
           dc.b -46,65,39
           dc.b -12,88,12
           dc.b -4,89,4
           dc.b -41,-59,52
           dc.b -45,35,67
           dc.b -44,3,77
           dc.b -1,-89,2
           dc.b -20,-71,50
           dc.b -27,3,84
           dc.b -11,-77,44
           dc.b -8,-73,50
           dc.b -9,-6,88
           dc.b -1,-74,49
           dc.b 2,45,76
           dc.b 9,-6,88
           dc.b 6,-82,34
           dc.b 12,-73,49
           dc.b 19,64,58
           dc.b 10,-85,26
           dc.b 31,-52,64
           dc.b 17,-82,30
           dc.b 20,82,29
           dc.b 0,89,0
           dc.b 24,-82,26
           dc.b 36,-73,35
           dc.b 16,-87,13
           dc.b 71,-15,51
           dc.b 11,88,7
           dc.b 35,-80,18
           dc.b 13,-88,6
           dc.b 82,18,30
           dc.b 0,-89,0
           dc.b 16,88,3
           dc.b 84,27,11
           dc.b 74,49,5
           dc.b 20,-87,0
           dc.b 87,17,-6
           dc.b 28,85,-4
           dc.b 83,27,-17
           dc.b 83,21,-23
           dc.b 19,-87,-7
           dc.b 71,43,-31
           dc.b 77,14,-41
           dc.b 29,-82,-18
           dc.b 45,69,-32
           dc.b 38,74,-32
           dc.b 17,-86,-16
           dc.b 56,30,-62
           dc.b 18,84,-23
           dc.b 38,-57,-56
           dc.b 42,-27,-73
           dc.b 28,-61,-58
           dc.b 24,-61,-60
           dc.b 9,-84,-30
           dc.b 19,38,-78
           dc.b 10,-63,-62
           dc.b 3,-85,-28
           dc.b 0,-88,-16
           dc.b -2,-33,-82
           dc.b -5,74,-49
           dc.b -14,35,-80
           dc.b -10,-77,-43
           dc.b -20,-60,-62
           dc.b -1,89,-3
           dc.b -1,89,-2
           dc.b -20,-80,-34
           dc.b -47,-29,-70
           dc.b -45,-50,-58
           dc.b -34,-72,-38
           dc.b -60,30,-58
           dc.b -13,-88,-11
           dc.b -50,-63,-37
           dc.b -60,54,-37
           dc.b -53,-65,-28
           dc.b -21,86,-9
           dc.b -24,-86,-8
           dc.b -53,69,-15
           dc.b -74,47,-15
           dc.b -82,33,-11
           dc.b -87,17,-6
           dc.b -21,-87,0
           dc.b -78,42,5
           dc.b -86,20,12
           dc.b -87,-7,18
           dc.b -49,73,14
           dc.b -82,14,30
           dc.b -66,-51,29
           dc.b -37,-79,19
           dc.b -73,20,46
           dc.b -72,4,52
           dc.b -67,18,56
           dc.b -62,-21,60
           dc.b -45,57,50
           dc.b -33,70,43
           dc.b -40,-51,60
           dc.b -36,-52,62
           dc.b -33,47,68
           dc.b -9,86,24
           dc.b -7,86,21
           dc.b -7,85,28
           dc.b -9,69,55
           dc.b -5,73,50
           dc.b -3,15,87
           dc.b 0,-88,14
           dc.b 9,3,88
           dc.b 7,-78,42
           dc.b 21,-9,86
           dc.b 24,40,76
           dc.b 7,-87,19
           dc.b 37,-24,77
           dc.b 42,-27,73
           dc.b 40,52,59
           dc.b 28,76,37
           dc.b 36,-70,40
           dc.b 40,69,38
           dc.b 58,45,49
           dc.b 19,86,14
           dc.b 74,-14,46
           dc.b 28,-84,15
           dc.b 74,35,33
           dc.b 56,-66,20
           dc.b 14,88,4
           dc.b 54,69,11
           dc.b 29,-84,4
           dc.b 88,-4,6
           dc.b 89,-12,0
