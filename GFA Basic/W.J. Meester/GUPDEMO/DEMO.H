/* resource set indicies for DEMO */

#define MENU     0	/* menu tree */

#define MINIKEY  1	/* form/dialog */

#define DEMOBOX  2	/* form/dialog */
#define NAME     2	/* FTEXT in tree DEMOBOX */
#define TOUCH    3	/* BUTTON in tree DEMOBOX */
#define AGE      4	/* FTEXT in tree DEMOBOX */
#define MALE     5	/* BUTTON in tree DEMOBOX */
#define SUBSCR   7	/* BUTTON in tree DEMOBOX */
#define NUMBER   10	/* FBOXTEXT in tree DEMOBOX */
#define BAR      12	/* BOX in tree DEMOBOX */
#define SLIDER   13	/* BOX in tree DEMOBOX */
#define OK       15	/* BUTTON in tree DEMOBOX */

#define STORAGE  3	/* form/dialog */

#define DESKTOP  4	/* form/dialog */

#define INFO     5	/* form/dialog */
#define VERSION  1	/* FTEXT in tree INFO */

#define NOLOWRES 0	/* Alert string index */

#define NOMEMORY 1	/* Alert string index */

#define ERROR    2	/* Alert string index */

#define FATAL    3	/* Alert string index */

#define MISSING  4	/* Alert string index */

