;***** „hnlich FOR NEXT *****
;KAPA5.TOS
;
;ASM4.s
;
         MOVE.W   #100,D0
SCHLEIFE:
;
; Alles was hier kommt wird 101 mal ausgef�hrt
;
          DBRA D0,SCHLEIFE
;
;******** QUIT ******* �bertrage von oben
END


