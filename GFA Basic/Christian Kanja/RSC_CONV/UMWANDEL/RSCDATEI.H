#define TIT_TXT6 3
#define TIT_TXT3 2
#define TIT_TXT4 4
#define TIT_TXT5 5
#define TIT_TXT2 7
#define TIT_OK 6
#define SECTOR 1
#define SEC_TITL 1
#define SEC_ANZ 3
#define SEC_STAR 2
#define SEC_TXT 6
#define SEC_OK 4
#define SEC_CAN 5
#define BPB_INFO 3
#define BPB_TITL 1
#define BPB_CLUS 3
#define BPB_BSEC 2
#define BPB_BCLU 4
#define BPB_DIRL 5
#define BPB_FAT2 7
#define BPB_FATL 6
#define BPB_OK 8
#define BPB_CLU1 9
#define BPB_CLUA 10
#define COPY 4
#define COP_SOU 1
#define COPY_TIT 3
#define COP_DEST 2
#define PA_TITLE 1
#define PARAM 0
#define PA_SECT 2
#define PA_TRACK 3
#define PA_SOUR 5
#define PA_SID 4
#define PA_DEST 6
#define PA_DES_B 9
#define PA_DES_A 8
#define PA_FMT 10
#define PA_VER 11
#define PA_CAN 13
#define PA_OK 12
#define PA_SOU_A 15
#define PA_SOU_B 16
#define PA_TR_79 18
#define PA_TR_81 19
#define PA_SE_9 21
#define PA_SE_10 22
#define PA_SID_2 25
#define PA_SID_1 24
#define PA_FMT_Y 27
#define PA_FMT_N 28
#define PA_VER_E 30
#define PA_VER_A 31
#define TITEL 2
#define TIT_TXT1 1
