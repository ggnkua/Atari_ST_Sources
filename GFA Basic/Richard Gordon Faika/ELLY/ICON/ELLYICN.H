/* Resource Datei Indizes f�r ELLYICN */

#define ELLY_ICN         0   /* Formular/Dialog */
