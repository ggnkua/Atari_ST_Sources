/* GFA_TC.H	*/
/* convert GFA-BASIC 3.0 Array <-> Turbo C 1.1 double array	*/

void gfa_tc(void *src,void*dst,int cnt);
void tc_gfa(void *src,void*dst,int cnt);
