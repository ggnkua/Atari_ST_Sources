/* Indice du ressource pour SMTPGEM */

#define ENVELOPE 0   /* Formulaire/Dialogue */
#define DRAWING  1   /* USERDEF dans l'arbre ENVELOPE */
#define SENDIT   3   /* IBOX dans l'arbre ENVELOPE */
#define OPTION   5   /* IBOX dans l'arbre ENVELOPE */
