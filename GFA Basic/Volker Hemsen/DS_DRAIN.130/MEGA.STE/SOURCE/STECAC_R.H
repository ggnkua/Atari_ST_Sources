extern void rsrc_init(void);

extern OBJECT TDIAL[];
#define DD16 2
#define DDCACHE 6
#define DDVERIFY 14
#define DDKLICK 4
#define DDREPEAT 8
#define DDASC7 12
#define DDOK 16
#define DDAB 18
#define DDBLIT 10
#define DDSAVE 17
