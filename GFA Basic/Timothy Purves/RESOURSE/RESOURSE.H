#define DIALOG 0  	/* TREE */
#define NUM 3  	/* OBJECT in TREE #0 */
#define STRING 10  	/* OBJECT in TREE #0 */
#define TOGGLE 12  	/* OBJECT in TREE #0 */
#define DAYS 16  	/* OBJECT in TREE #0 */
#define SEX 6  	/* OBJECT in TREE #0 */
#define CANCEL 24  	/* OBJECT in TREE #0 */
#define OK 25  	/* OBJECT in TREE #0 */
