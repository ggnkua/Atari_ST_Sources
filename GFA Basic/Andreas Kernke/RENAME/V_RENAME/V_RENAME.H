#define D_BOX_1 0  	/* TREE */
#define LW_A 4  	/* OBJECT in TREE #0 */
#define LW_B 5  	/* OBJECT in TREE #0 */
#define V_NAME 6  	/* OBJECT in TREE #0 */
#define REN_BTN 7  	/* OBJECT in TREE #0 */
#define END_BTN 8  	/* OBJECT in TREE #0 */
