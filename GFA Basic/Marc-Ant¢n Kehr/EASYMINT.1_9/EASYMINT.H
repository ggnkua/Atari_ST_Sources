/* Resource Datei Indizes f�r EASYMINT */

#define SYSTEM           0   /* Formular/Dialog */

#define FVT_ASCI         1   /* Formular/Dialog */

#define FVT_ALST         2   /* Formular/Dialog */

#define FVT_WORK         3   /* Formular/Dialog */

#define FVT_PROG         4   /* Formular/Dialog */

#define FVT_POPU         5   /* Formular/Dialog */
#define LW_C             29  /* BUTTON in Baum FVT_POPU */
#define LW_D             30  /* BUTTON in Baum FVT_POPU */
#define LW_E             31  /* BUTTON in Baum FVT_POPU */
#define LW_F             32  /* BUTTON in Baum FVT_POPU */
#define LW_G             33  /* BUTTON in Baum FVT_POPU */
#define LW_H             34  /* BUTTON in Baum FVT_POPU */
#define LW_I             35  /* BUTTON in Baum FVT_POPU */
#define LW_J             36  /* BUTTON in Baum FVT_POPU */
#define LW_K             37  /* BUTTON in Baum FVT_POPU */
#define LW_L             38  /* BUTTON in Baum FVT_POPU */
#define LW_M             39  /* BUTTON in Baum FVT_POPU */
#define LW_N             40  /* BUTTON in Baum FVT_POPU */
#define LW_O             41  /* BUTTON in Baum FVT_POPU */
#define LW_P             42  /* BUTTON in Baum FVT_POPU */
#define LW_Q             43  /* BUTTON in Baum FVT_POPU */
#define LW_R             44  /* BUTTON in Baum FVT_POPU */
#define LW_S             45  /* BUTTON in Baum FVT_POPU */
#define LW_T             46  /* BUTTON in Baum FVT_POPU */
#define LW_U             47  /* BUTTON in Baum FVT_POPU */
#define LW_V             48  /* BUTTON in Baum FVT_POPU */
#define LW_W             49  /* BUTTON in Baum FVT_POPU */
#define LW_X             50  /* BUTTON in Baum FVT_POPU */
#define LW_Y             51  /* BUTTON in Baum FVT_POPU */
#define LW_Z             52  /* BUTTON in Baum FVT_POPU */
#define LW_1             53  /* BUTTON in Baum FVT_POPU */
#define LW_2             54  /* BUTTON in Baum FVT_POPU */
#define LW_3             55  /* BUTTON in Baum FVT_POPU */
#define LW_4             56  /* BUTTON in Baum FVT_POPU */
#define LW_5             57  /* BUTTON in Baum FVT_POPU */
#define LW_6             58  /* BUTTON in Baum FVT_POPU */
#define EXT_C            60  /* BUTTON in Baum FVT_POPU */
#define EXT_D            61  /* BUTTON in Baum FVT_POPU */
#define EXT_E            62  /* BUTTON in Baum FVT_POPU */
#define EXT_F            63  /* BUTTON in Baum FVT_POPU */
#define EXT_G            64  /* BUTTON in Baum FVT_POPU */
#define EXT_H            65  /* BUTTON in Baum FVT_POPU */
#define EXT_I            66  /* BUTTON in Baum FVT_POPU */
#define EXT_J            67  /* BUTTON in Baum FVT_POPU */
#define EXT_K            68  /* BUTTON in Baum FVT_POPU */
#define EXT_L            69  /* BUTTON in Baum FVT_POPU */
#define EXT_M            70  /* BUTTON in Baum FVT_POPU */
#define EXT_N            71  /* BUTTON in Baum FVT_POPU */
#define EXT_O            72  /* BUTTON in Baum FVT_POPU */
#define EXT_P            73  /* BUTTON in Baum FVT_POPU */
#define EXT_Q            74  /* BUTTON in Baum FVT_POPU */
#define EXT_R            75  /* BUTTON in Baum FVT_POPU */
#define EXT_S            76  /* BUTTON in Baum FVT_POPU */
#define EXT_T            77  /* BUTTON in Baum FVT_POPU */
#define EXT_U            78  /* BUTTON in Baum FVT_POPU */
#define EXT_V            79  /* BUTTON in Baum FVT_POPU */
#define EXT_W            80  /* BUTTON in Baum FVT_POPU */
#define EXT_X            81  /* BUTTON in Baum FVT_POPU */
#define EXT_Y            82  /* BUTTON in Baum FVT_POPU */
#define EXT_Z            83  /* BUTTON in Baum FVT_POPU */
#define EXT_1            84  /* BUTTON in Baum FVT_POPU */
#define EXT_2            85  /* BUTTON in Baum FVT_POPU */
#define EXT_3            86  /* BUTTON in Baum FVT_POPU */
#define EXT_4            87  /* BUTTON in Baum FVT_POPU */
#define EXT_5            88  /* BUTTON in Baum FVT_POPU */
#define EXT_6            89  /* BUTTON in Baum FVT_POPU */

#define FVT_MAUS         6   /* Formular/Dialog */
#define SMILEMOUSE       2   /* IBOX in Baum FVT_MAUS */

#define ABOUT            7   /* Formular/Dialog */
#define VERSION1         3   /* TEXT in Baum ABOUT */
#define VERSION2         5   /* TEXT in Baum ABOUT */
#define VERSION3         6   /* TEXT in Baum ABOUT */
#define VERSION4         7   /* TEXT in Baum ABOUT */
#define VERSION5         8   /* TEXT in Baum ABOUT */
#define ABOUTOK          9   /* BUTTON in Baum ABOUT */

#define MAINMENU         8   /* Menuebaum */
#define MM_ABOUT         7   /* STRING in Baum MAINMENU */
#define MM_QUIT          16  /* STRING in Baum MAINMENU */

#define PRE              9   /* Formular/Dialog */
#define PRE_INFO         2   /* USERDEF in Baum PRE */
#define PAKETE           4   /* BUTTON in Baum PRE */
#define NET              5   /* BUTTON in Baum PRE */
#define DEVEL            6   /* BUTTON in Baum PRE */
#define LIBS             7   /* BUTTON in Baum PRE */
#define X11              8   /* BUTTON in Baum PRE */
#define RPMSJA           10  /* BUTTON in Baum PRE */
#define FILECHECK        12  /* BUTTON in Baum PRE */
#define SHUTDOWN         13  /* BUTTON in Baum PRE */
#define MICO             14  /* BUTTON in Baum PRE */
#define PREABBR          15  /* BUTTON in Baum PRE */
#define PREOK            16  /* BUTTON in Baum PRE */

#define PFADE            10  /* Formular/Dialog */
#define PF_INFO          2   /* USERDEF in Baum PFADE */
#define LOGIN            4   /* BUTTON in Baum PFADE */
#define NAES_DRKT        5   /* BUTTON in Baum PFADE */
#define XAAESSTRT        6   /* BUTTON in Baum PFADE */
#define PLAINTOS         7   /* BUTTON in Baum PFADE */
#define NAESPFAD         10  /* FBOXTEXT in Baum PFADE */
#define NAESCAR          11  /* BUTTON in Baum PFADE */
#define XAAESPFAD        14  /* FBOXTEXT in Baum PFADE */
#define PATHABBR         15  /* BUTTON in Baum PFADE */
#define PATHOK           16  /* BUTTON in Baum PFADE */

#define MESSAGE          11  /* Formular/Dialog */
#define MES1             2   /* TEXT in Baum MESSAGE */
#define MES2             3   /* TEXT in Baum MESSAGE */
#define MES3             4   /* TEXT in Baum MESSAGE */
#define MES4             5   /* TEXT in Baum MESSAGE */
#define MES5             6   /* TEXT in Baum MESSAGE */
#define MES6             7   /* TEXT in Baum MESSAGE */
#define MES7             8   /* TEXT in Baum MESSAGE */
#define INFOABBR         9   /* BUTTON in Baum MESSAGE */
#define MES_OK           10  /* BUTTON in Baum MESSAGE */

#define MESSAGE2         12  /* Formular/Dialog */
#define MES1_00          2   /* TEXT in Baum MESSAGE2 */
#define MES2_00          3   /* TEXT in Baum MESSAGE2 */
#define MES3_00          4   /* TEXT in Baum MESSAGE2 */
#define MES4_00          5   /* TEXT in Baum MESSAGE2 */
#define MES5_00          6   /* TEXT in Baum MESSAGE2 */
#define MES6_00          7   /* TEXT in Baum MESSAGE2 */
#define MES7_00          8   /* TEXT in Baum MESSAGE2 */
#define INF2ABBR         9   /* BUTTON in Baum MESSAGE2 */
#define MES_OK_00        10  /* BUTTON in Baum MESSAGE2 */

#define STARTPRG         13  /* Formular/Dialog */
#define APPNAME          2   /* BUTTON in Baum STARTPRG */

#define NIC              14  /* Formular/Dialog */
#define NIC_INFO         2   /* USERDEF in Baum NIC */
#define KUERZEL          4   /* FBOXTEXT in Baum NIC */
#define IPADR            6   /* FBOXTEXT in Baum NIC */
#define NETMASK          8   /* FBOXTEXT in Baum NIC */
#define DEFAULTR         9   /* TEXT in Baum NIC */
#define GATEWAY          10  /* FBOXTEXT in Baum NIC */
#define DNS              12  /* FBOXTEXT in Baum NIC */
#define DOMAIN           13  /* TEXT in Baum NIC */
#define DOMAINE          14  /* FBOXTEXT in Baum NIC */
#define HN               16  /* FBOXTEXT in Baum NIC */
#define NW_ABBR          17  /* BUTTON in Baum NIC */
#define NW_OK            18  /* BUTTON in Baum NIC */

#define PPP              15  /* Formular/Dialog */
#define ISPNAME          3   /* FBOXTEXT in Baum PPP */
#define PPP_INFO         4   /* USERDEF in Baum PPP */
#define ATZ              6   /* FBOXTEXT in Baum PPP */
#define TIMEOUT          8   /* FBOXTEXT in Baum PPP */
#define DEVICE           10  /* BOXTEXT in Baum PPP */
#define SPEED            13  /* BOXTEXT in Baum PPP */
#define ISPNUMBER        16  /* FBOXTEXT in Baum PPP */
#define USER             18  /* FBOXTEXT in Baum PPP */
#define PASSWD           20  /* FBOXTEXT in Baum PPP */
#define NAMESERVER       22  /* FBOXTEXT in Baum PPP */
#define PPPDOMAIN        24  /* FBOXTEXT in Baum PPP */
#define LOCALIP          28  /* FBOXTEXT in Baum PPP */
#define REMOTEIP         30  /* FBOXTEXT in Baum PPP */
#define PPP_ABBR         31  /* BUTTON in Baum PPP */
#define PPP_OK           32  /* BUTTON in Baum PPP */

#define PREINST          16  /* Formular/Dialog */
#define PREINFO          2   /* USERDEF in Baum PREINST */
#define COMPI            4   /* BOXTEXT in Baum PREINST */
#define BOOT             7   /* BOXTEXT in Baum PREINST */
#define EXT2             10  /* BOXTEXT in Baum PREINST */
#define PABBR            12  /* BUTTON in Baum PREINST */
#define POK              13  /* BUTTON in Baum PREINST */
