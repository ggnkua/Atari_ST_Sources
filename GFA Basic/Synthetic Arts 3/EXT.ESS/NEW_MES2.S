$ TRAMES message 0 $
INVERs HORIZONT,INVERs VERTICAL,INVERSE COULEUR,SCROLL ,SCROLL ,SCROLL ,SCROLL ,EFFACE,SUR ECRAN,*
HORIZONTAL FLIP,VERTICAL FLIP,INVERT,SCROLL ,SCROLL ,SCROLL ,SCROLL ,ERASE,TAKE ON SCREEN,*

$ Message 1: Options acces disque $
PLACE DISPONIBLE,RENOMMER FICHIER,CREER DOSSIER,,CHARGE ECRAN,,CHARGE 6 ECRANS,CHARGE X ECRANS,CHARGE PAR FAT,CHARGE AVEC COMPTEUR,,,
FORMATAGE,EFFACER FICHIER,,,SAUVE ECRAN,,SAUVE 6 ECRANS,SAUVE X ECRANS,SAUVE AUTO,SAUVE AVEC COMPTEUR,,,,,*
FREE SPACE,RENAME FILE,MAKE FOLDER,,LOAD SCREEN,,LOAD 6 SCREENS,LOAD X SCREENS,LOAD BY FAT,LOAD WITH COUNTER,,,
FORMAT,DELETE FILE,,,SAVE SCREEN,SAVE 6 SCREENS,SAVE X SCREENS,AUTO SAVE,SAVE WITH COUNTER,,,,,*

$ OUT message 2 $
CRAYON,LIGNE,PEINTURE,,RECTANGLE,REC PLEIN,X:,GRILLE,*
PEN,LINE,FILL,,BOX,FILLd BOX,X:,GRID,*

$ UTIL message 3 $
CRAYON,LIGNE,PEINTURE,BLOCS,LOUPE STATIQUE,AEROGRAPHE,PINCEAU,RECTANGLE,CERCLE,ELLIPSE,POLYGONE,COURBE DE BEZIER,TEXTE,GOMME,ENTOURE/AntiALIAS,REMPLACE COULEUR,AutoDEGRADE,*
PEN,LINE,FILL,BLOCKS,MAGNIFY,AIRBRUSH,BRUSH,BOX,CIRCLE,ELLIPSE,POLYGON,BEZIER's CURVES,TEXT,ERASER,SURROUND/AntiALIAS,REPLACE COLORS,AutoDEGRADE,*

$ SETCO message 4 $
VUE,CYCLING,CHARGE,SAUVE,UNDO,ECHANGE,ROTAT� >,ROTAT� <,INVERSE,LUM +/-,PALETTE,SELECT�,DEGRADE,MEM <,MEM >,*
VIEW,CYCLING,LOAD,SAVE,UNDO,SWAP,ROTAT� >,ROTAT� <,INVERT,LIGHT +/-,COLORS,SELECT,GRADIENT,MEM <,MEM >,*

$ DATS message 5 $
INFO,,QUITTER,ANIMATION,ECRANS,PALETTE,LIGNES,TRAMES,PINCEAUX,REPLACEMt,AEROGRAPh,DIVERS,FULL,CLAVIER,SOURIS,VIDEO CLIC,AUTO LOAD,*
INFO,,QUIT,ANIMATION,SCREENS,COLORS,LINES,SHAPES,BRUSHES,REPLACE,AIRBRUSH,OTHERS,FULL,KEYBOARD,MOUSE,VIDEO CLIC,AUTO LOAD,*

$ message 6 $
Zoom,H Invt,V Invt,Rotat�,H Dist,V Dist,H Sin,V Sin,*
Zoom,H Flip,V Flip,Rotat�,H Dist,V Dist,H Sin,V Sin,*

$ message 7 $
QUITTER:||Vous n'avez pas|Sauvegard� les derniers|changements,*
QUIT:||You haven't Saved|all changes,*

$ message 8 $
QUITTE|Annule,*
QUIT|Cancel,*

$ message 9 $
ATTENTION||Les Palettes vont etre|Converties au|format STF,*
WARNING||The Colours will be|Converted to|the STF format,*

$ message 10 $
Ok|Annule,*
Ok|Cancel,*

$ message 11 $
Zoom,*
Scale,*

$ message 12 $
Place disponible sur|lecteur , Octets,*
Free space on|drive    , Bytes,*

$ message 13 $
Il Existe d�j�|un Fichier|portant ce nom,*
This File|already Exists,*

$ message 14 $
ATTENTION|Ce Fichier Existe d�j�,*
WARNING|This File already Exists,*

$ message 15 $
ECRASE|Annule,*
REPLACE|Cancel,*

$ message 16 $
Choisissez un chemin et les masques,Choisir un prefixe,Formats de chargement,Formats de sauvegarde,*
Choose path and the masks,Choose a prefix,Loading formats,Saving formats,*

$ message 17 $
Programme,Compilation...,Erreur: 'END' non trouv�,Erreur: Ecran n:, n'existe pas,Erreur: piste trop longue,Erreur de syntaxe,Appuyez sur une touche,*
Program,Compiling...,Error: 'END' expected,Error: screen n:, doesn't exists,Error: track too long,Syntax error,Press any key,*

$ message 18 $
ATTENTION:||Cet Ecran est Prot�g�,*
WARNING:||This Screen is Protected,*

$ message 19 $
CHARGE|Annule,*
LOAD|Cancel,*

$ message 20 $
Charge Ecran OVERSCAN|ATTENTION:|Un ou Plusieurs|des quatre ecrans|sont Prot�g�(s),*
Load OVERSCAN Screen|WARNING:|One or Few|of the four Screens|is Protected,*

$ message 21 $
N&B,CL,*
B&W,CL,*

$ message 22 $
Voulez-vous garder|le Bit d'Information Flipping|au cours de la Conversion,GARDER|MASQUER,*
Do you want to keep|the Flipping Information Bit|during Convertion,KEEP|MASK,*

$ message 23 $
Tous les �crans|Les �crans prot�g�s,*
All screens|Protected screens,*

$ message 24 $
ATTENTION:||Le Formatage Efface|toutes les Donnees|d'une disquette,*
WARNING:||Format will Erase|all the Datas|on the disk,*

$ message 25 $
Sur le Lecteur,*
On Drive,*

$ message 26 $
Nombre de Secteurs par Piste,*
Number of Sectors per Track,*

$ message 27 $
Nombre de Pistes,*
Number of Tracks,*

$ message 28 $
Simple Face|ou|Double Face:,*
Single Side|or|Double Side:,*

$ message 29 $
SIMPLE|DOUBLE,*
SINGLE|DOUBLE,*

$ message 30 $
EFFACER FICHIER|,*
ERASE FILE|,*

$ message 31 $
EFFACE|Annule,*
ERASE|Cancel,*

$ message 32 $
Vous ne pouvez pas Entourer|avec la couleur de fond,*
You can't Surround|with the background color,*

$ message 33 $
 |Pas de Point de d�part, |Pas de Point d'arriv�e,*
 |No Start point, |No Destination point,*

$ message 34 $
 |Trop de Points de d�part,*
 |Too many Start points,*

$ message 35 $
 |Trop de Points d'arriv�e,*
 |Too many Destination points,*

$ message 36 $
|Etes-vous sur de vouloir|Stopper le D�grad� automatique,*
|Are you sure you want to|Stop Automatic gradient,*

$ message 37 $
CURSEUR PANNEAU,CURSEUR DESSIN,CLAVIER,PANNEAUX,DESSIN,LOUPE,*
PANEL CURSOR,DRAWING CURSOR,KEYBOARD,PANEL,DRAWING,MAGNIFIER,*

$ message 38 $
COPIER|Annule,*
COPY|Cancel,*

$ message 39 $
Pas assez de M�moire|pour un Ecran OVERSCAN,*
Not enought Memory|for an OVERSCAN Screen,*

$ message 40 $
ATTENTION|Ce fichier n'est pas un|fichier ,*
WARNING|This file is not a|file ,*

$ message 41 $
Fichier INTROUVABLE,ATTENTION|Ce Disque ne poss�de|plus assez de Place|pour Sauvegarder|ce Fichier,Erreur Disque,Erreur Inconnue n:|,*
File NOT FOUND,WARNING|There's not enought|Free Space on this Disk|to Save this File,Disk Error,Unknown Error n:|,*

$ message 42 $
UTILISEZ LES FLECHES CURSEUR...,*
USE ARROW KEYS...,*

$ message 43 $
ECRAN:,*
SCREEN:,*

$ message 44 $
ANIMER,*
ANIMAT,*

$ message 45 $
BLITTER,,SYNCHRONISATION,FRANCAIS,,SAUVE PR,CHARGE PR,*
BLITTER,,SYNCHRONIZATION,ENGLISH,,SAVE PREF,LOAD PREF,*

$ message 46 $
CHARGER,SAUVER,*
LOAD,SAVE,*

$ message 47 $
CHARGE ECRAN,CHARGE ECRAN OVERSCAN,*
LOAD SCREEN,LOAD OVERSCAN SCREEN,*

$ message 48 $
SAUVE ECRAN N�,SAUVE ECRAN OVERSCAN,*
SAVE SCREEN N�,SAVE OVERSCAN SCREEN,*

$ message 49 $
BOUCLEE,AVANT/ARRIERE,*
LOOPED,->/<-,*

$ message 50 $
ANIME,VITESSE,*
ANIMATE,SPEED,*

$ message 51 $
MONOCHROm,COULEUR,*
MONOCHROm,COLOR,*

$ message 52 $
ROND,RECTANGLE,*
CIRCULAR,RECTANGULAR,*

$ message 53 $
ESTOMPE,NORMAL,*
STUMP,NORMAL,*

$ message 54 $
RAY: ,*
RAYON: ,*

$ message 55 $
ATTENTION:|ERREUR DURANT FORMATAGE,*
WARNING:|ERROR DURING FORMAT,*

$ message 56 $
FRANCAIS,ANGLAIS,*
FRENCH,ENGLISH,*

$ message 57 $
  X  4,
  X  5,
  X  6,
  X  7,
  X  8,
  X  9,
  X  10,
  X  11,
  X  12,
  X  13,
  X  14,
  X  15,
  X  16,
  X  17,*
  X  4,
  X  5,
  X  6,
  X  7,
  X  8,
  X  9,
  X  10,
  X  11,
  X  12,
  X  13,
  X  14,
  X  15,
  X  16,
  X  17,*
 
$ message 58 $
Langue,*
Language,*

$ message 59 $
Trames,*
Shapes,*

$ message 60 $
Pr�f�rence,*
Preference,*

$ message 61 $
Bloc,*
Block,*

$ Message 62: menu mode palette $
Stf,Stf �tendue,Ste,Ste �tendue,* 
Stf,Stf extended,Ste,Ste extended,* 

$ Message 63 $
Le Super-S�lecteur Palette|n'est pas Accessible|en mode STE Etendu,*
The Colours Super-Selector|is not Available|in STE Extended mode,*

$ Message 64: liste des actions pour raccourcis clavier: mode touche 2 $
UNDO,PLEIN ECRAN/DEMI ECRAN,TEST POINT,
OPTIONS,EDITE COULEUR,EDITE PINCEAU,EDITE TRAME,OVERSCAN,PARAMETRES SOURIS,SUPERVISEUR ECRANS,ACCES DISQUES,
ECRAN 1,ECRAN 2,ECRAN 3,ECRAN 4,ECRAN 5,ECRAN 6,
CRAYON,LIGNE,PEINTURE,BLOC,LOUPE,AEROGRAPHE,PINCEAU,RECTANGLE,CERCLE,ELLIPSE,POLYGONE,COURBES DE BEZIER,TEXTE,GOMME,ENTOURE/LISSAGE,REMPLACE COULEURS,DEGRADE AUTOMATIQUE,
ACTION 1,ACTION 2,ACTION 3,ACTION 4,ACTION 5,ACTION 6,ACTION 7,ACTION 8,ACTION 9,ACTION 10,
COULEUR 1,COULEUR 2,COULEUR 3,COULEUR 4,COULEUR 5,COULEUR 6,COULEUR 7,COULEUR 8,COULEUR 9,COULEUR 10,COULEUR 11,COULEUR 12,COULEUR 13,COULEUR 14,COULEUR 15,COULEUR 16,
COULEUR COURANTE ?,REVENIR D'UNE FONCTION,MOITIE SUPERIEURE ECRAN,MOITIE MEDIANNE ECRAN,MOITIE INFERIEURE ECRAN,DESELECTIONNE TOUCHE,~,*

UNDO,FULL SCREEN/HALF SCREEN,TEST POINT,
OPTIONS,EDIT COLOUR,EDIT BRUSH,EDIT SHAPE,OVERSCAN,MOUSE PARAMETERS,SCREEN MANAGER,DISK ACCES,
SCREEN 1,SCREEN 2,SCREEN 3,SCREEN 4,SCREEN 5,SCREEN 6,
PEN,LINE,FILL,BLOCK,MAGNIFIER,AIRBRUSH,BRUSH,RECTANGLE,CIRCLE,ELLIPSE,POLYGONE,BEZIER CURVES,TEXT,ERASER,SURROUND/ANTI-ALIAS,REPLACE COLOURS,AUTOMATIC GRADIENT,
ACTION 1,ACTION 2,ACTION 3,ACTION 4,ACTION 5,ACTION 6,ACTION 7,ACTION 8,ACTION 9,ACTION 10,
COLOUR 1,COLOUR 2,COLOUR 3,COLOUR 4,COLOUR 5,COLOUR 6,COLOUR 7,COLOUR 8,COLOUR 9,COLOUR 10,COLOUR 11,COLOUR 12,COLOUR 13,COLOUR 14,COLOUR 15,COLOUR 16,
USED COLOUR ?,RETURN FROM A FUNCTION,HALF TOP SCREEN,HALF MEDIUM SCREEN,HALF BOTTOM SCREEN,UNSELECT KEY,~,*

$ Message 65: liste des actions pour raccourcis clavier: mode touche 0 $
FIXE DEPLACEMENTS X,FIXE DEPLACEMENTS Y,SPECIALS,~,*
FIX X MOVES,FIX Y MOVES,SPECIALS,~,*

$ Message 66: liste des actions pour raccourcis clavier: mode touche 1 $
INDICATEUR LIGNE (LOUPE),LOUPE EN PLEIN ECRAN,REDIMMENSIONNE OUTIL,~,*
LINE CURSOR (MAGNIFIER),MAGNIFIER IN FULL SCREEN ,SIZE UP TOOL,~,*

$ Message 67: Format de chargement: extensions $
???,NEO,RGH,P??,KID,SP?,IMG,TNY,ART,SD?,PAC,*
???,NEO,RGH,P??,KID,SP?,IMG,TNY,ART,SD?,PAC,*

$ Message 68: Format de chargement: noms $
Bit Image,Neochrome,ZZ Rought,Degas,KID,Spectrum,Img,Tiny,Art director,Dali,Stad,*
Bit Image,Neochrome,ZZ Rought,Degas,KID,Spectrum,Img,Tiny,Art director,Dali,Stad,*

$ Message 69: Format de sauvegarde: extensions $
???,NEO,RGH,PI1,PC1,KID,SD0,TNY,TGA,*
???,NEO,RGH,PI1,PC1,KID,SD0,TNY,TGA,*

$ Message 70: Format de sauvegarde: noms $
Bit image,Neochrome,ZZ Rought,Degas,Degas compress�,KID,Dali,Tiny,Targa,*
Bit image,Neochrome,ZZ Rought,Degas,Degas compress�,KID,Dali,Tiny,Targa,*

$ Message 71: Textes parametrages clavier $
Repartition de ,*
Repartition de ,*

$ Message 72: Options editeur programme $
F1: Sauver,F2: Charger,F3: Nouveau,F10: Compile,UNDO:Abandon,,,,,*
F1: Save,F2: Load,F3: New,F10: Compil,UNDO: Abort,,,,,*

$ Message 73: Menu sauvegarde palette $
Sauve palette,Sauve palette ASM,Sauvegarde palette,*
Save colours,Save ASM colours,Save colours,*

$ Message 74 $
EXIT,*
EXIT,*

$ Message 75 $
Taper une touche pour interrompre,*
Press any key to interupt,*

$ Message 76 $
Sauver bloc,Charger bloc,*
Save block,Load block,*

$ Message 77 $
Pour des raisons techniques|inherentes aux machines|l'Overscan ne fonctionne pas|sur TT ou FALCON,*
The Overscan option doesn't|work on TT or FALCON,*

$ Message 78 $
NOUVEAU PROGRAMME|Etes-vous sur ?,*
NEW PROGRAM|Are you sure?,*

$ Message 79 $
Programme,*
Program,*

$ Message 80 $
Tous les ecrans,Ecrans de la 'video zone',*
All screens,'Video zone' screens,*

$ Message 81 $
|Tous les ecrans de la 'Video Zone'|sont prot�g�s...|,*
|All 'Video Zone' screen|are protected...|,*

$ Message 82 $
Entrez le numero de l'ecran qui sera,utilis� comme cadran N:,*
Enter the number of the screen that,will be used as part N:,*

$ Message 83 $
Sauve �cran TARGA,Rouge,Vert,Bleu,*
Save TARGA screen,Red,Green,Blue,*

$ Message 84 $

�������������ʗ���ܗ�������������������ؠ�����������������ߌ�ы�����։͏���,
��������������ǂ��������~�����|��{��z���y��xڻ��͸��vۏ�uў�����s������΋�r��q,
�����ƺ̇����p������̣ɾĸ�Ĺ�p����q�q�ź��ŷr���s��ô�����u��u·v���˼Լ�y�����,
���ν����}�������������������Ʌ�����ڇ�͢�嶹������褍�����ݏ���������������,
�������Ǻ�����й��ż���ʘ����,*

�������������ʗ��������������ڕ����������נ������ސ�����܎��Ҍ�����Њ�������,
�Ά�������ӝ߃ެ����ŀ������ٖ�}��|�Ǽ����Ր����w�����Ҝ������tЧ��ǻ�ǻ�r����q�,
q�ĶqŹ�p�����Ĺ��p��pĸ�̴���ı��˲ź��q��Ķr�����s����t�ʶ����»v�ˑ�xԤ������,
�ד{������}�������ԁ������ߖ�������������ì�������������, ,*

$ Message 85 $
DIGITALISATION| |Nombre d'image(s) par seconde|Actuel = ,*
DIGITALIZATION| |Number of picture(s) per second|Current = ,*

$ Message 86 $
Pas de Signal de Synchronisation,*
No Synchronization Signal,*

