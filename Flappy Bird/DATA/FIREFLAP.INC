	move.l	#$FFFEFFFE,d0
	lea		8(a1),a1
	and.l	d0,(a1)+
	and.l	d0,(a1)+
	move.l	#$07FF07FF,d1
	and.l	d1,(a1)+
	and.l	d1,(a1)

	move.l	#$FFF8FFF8,d2
	lea		148(a1),a1
	and.l	d2,(a1)+
	move.w	#$0001,d3
	or.w	d3,-2(a1)
	and.l	d2,(a1)+
	move.l	#$03FF03FF,d4
	and.l	d4,(a1)+
	or.w	#$D800,-2(a1)
	and.l	d4,(a1)

	move.l	#$FFF0FFF0,d5
	lea		148(a1),a1
	and.w	d5,(a1)
	or.w	d3,(a1)+
	and.w	d5,(a1)
	move.w	#$0007,d6
	or.w	d6,(a1)+
	and.l	d5,(a1)+
	move.l	#$01FF01FF,d7
	and.w	d7,(a1)
	or.w	#$8000,(a1)+
	and.w	d7,(a1)
	or.w	#$BC00,(a1)+
	and.l	d7,(a1)

	move.l	#$FFE0FFE0,d0
	lea		148(a1),a1
	and.w	d0,(a1)
	or.w	d6,(a1)+
	and.w	d0,(a1)
	or.w	#$000F,(a1)+
	and.l	d0,(a1)+
	move.l	#$00FF00FF,d1
	and.w	d1,(a1)
	move.w	#$A000,d2
	or.w	d2,(a1)+
	and.w	d1,(a1)
	move.w	#$BA00,d3
	or.w	d3,(a1)+
	and.l	d1,(a1)

	move.l	#$FFC0FFC0,d4
	lea		148(a1),a1
	and.w	d4,(a1)
	move.w	#$001F,d5
	or.w	d5,(a1)+
	and.w	d4,(a1)
	or.w	d5,(a1)+
	and.l	d4,(a1)+
	and.w	d1,(a1)
	or.w	d2,(a1)+
	and.w	d1,(a1)
	or.w	d3,(a1)+
	and.l	d1,(a1)

	lea		148(a1),a1
	and.w	d4,(a1)
	or.w	d5,(a1)+
	and.w	d4,(a1)
	or.w	d5,(a1)+
	and.l	d4,(a1)+
	and.w	d1,(a1)
	or.w	#$D000,(a1)+
	and.w	d1,(a1)
	or.w	#$DE00,(a1)+
	and.l	d1,(a1)

	lea		148(a1),a1
	and.w	d4,(a1)
	move.w	#$0001,d6
	or.w	d6,(a1)+
	and.w	d4,(a1)
	or.w	d6,(a1)+
	and.l	d4,(a1)+
	move.l	#$007F007F,d7
	and.w	d7,(a1)
	move.w	#$E000,d0
	or.w	d0,(a1)+
	and.w	d7,(a1)
	or.w	d0,(a1)+
	and.l	d7,(a1)

	move.l	#$FF80FF80,d1
	lea		148(a1),a1
	and.w	d1,(a1)
	or.w	#$0022,(a1)+
	and.w	d1,(a1)
	or.w	#$003E,(a1)+
	and.l	d1,(a1)+
	move.l	#$003F003F,d2
	and.w	d2,(a1)
	move.w	#$DF80,d3
	or.w	d3,(a1)+
	and.w	d2,(a1)
	or.w	d3,(a1)+
	and.l	d2,(a1)

	lea		148(a1),a1
	and.w	d1,(a1)
	or.w	d6,(a1)+
	and.w	d1,(a1)
	or.w	#$003D,(a1)+
	and.l	d1,(a1)+
	and.w	d7,(a1)
	move.w	#$A000,d4
	or.w	d4,(a1)+
	and.w	d7,(a1)
	or.w	d4,(a1)+
	and.l	d7,(a1)

	lea		148(a1),a1
	and.w	d1,(a1)
	or.w	#$000B,(a1)+
	and.w	d1,(a1)
	or.w	#$003B,(a1)+
	and.l	d1,(a1)+
	and.w	d7,(a1)
	move.w	#$DF00,d5
	or.w	d5,(a1)+
	and.w	d7,(a1)
	or.w	d5,(a1)+
	and.l	d7,(a1)

	move.l	#$FEC0FEC0,d6
	lea		148(a1),a1
	and.w	d6,(a1)
	move.w	#$0003,d7
	or.w	d7,(a1)+
	and.w	d6,(a1)
	or.w	d7,(a1)+
	and.l	d6,(a1)+
	move.l	#$00FF00FF,d0
	and.w	d0,(a1)
	move.w	#$E000,d1
	or.w	d1,(a1)+
	and.w	d0,(a1)
	or.w	d1,(a1)+
	and.l	d0,(a1)

	move.l	#$FEFCFEFC,d2
	lea		148(a1),a1
	and.l	d2,(a1)+
	and.l	d2,(a1)+
	move.l	#$1FFF1FFF,d3
	and.l	d3,(a1)+
	and.l	d3,(a1)

	move.l	#$FF7FFF7F,d4
	lea		148(a1),a1
	and.l	d4,(a1)+
	and.l	d4,(a1)

	move.l	#$FF8FFF8F,d5
	lea		156(a1),a1
	and.l	d5,(a1)+
	and.l	d5,(a1)

	move.l	#$FEFFFEFF,d6
	lea		156(a1),a1
	and.l	d6,(a1)+
	and.l	d6,(a1)

	move.l	#$FF3FFF3F,d7
	lea		156(a1),a1
	and.l	d7,(a1)+
	and.l	d7,(a1)

	move.l	#$7FFF7FFF,d0
	lea		644(a1),a1
	and.l	d0,(a1)+
	and.l	d0,(a1)

	move.l	#$FFFEFFFE,d1
	lea		148(a1),a1
	and.l	d1,(a1)+
	and.l	d1,(a1)+
	move.l	#$3FFF3FFF,d2
	and.l	d2,(a1)+
	and.l	d2,(a1)

	move.l	#$FFFCFFFC,d3
	lea		148(a1),a1
	and.l	d3,(a1)+
	and.l	d3,(a1)+
	move.l	#$1FFF1FFF,d4
	and.l	d4,(a1)+
	and.l	d4,(a1)

	lea		148(a1),a1
	and.l	d1,(a1)+
	and.l	d1,(a1)+
	and.l	d2,(a1)+
	and.l	d2,(a1)

	lea		148(a1),a1
	and.l	d1,(a1)+
	and.l	d1,(a1)+
	and.l	d2,(a1)+
	and.l	d2,(a1)

	lea		148(a1),a1
	and.l	d1,(a1)+
	and.l	d1,(a1)+
	and.l	d2,(a1)+
	and.l	d2,(a1)

	lea		1108(a1),a1
	and.l	d1,(a1)+
	and.l	d1,(a1)

	move.l	#$80008000,d5
	lea		148(a1),a1
	and.l	d5,(a1)+
	or.w	d0,-2(a1)
	and.l	d5,(a1)+
	move.l	#$0FFE0FFE,d6
	and.l	d6,(a1)+
	move.w	#$F000,d7
	or.w	d7,-2(a1)
	and.l	d6,(a1)+
	move.l	#$FFF0FFF0,d0
	and.l	d0,(a1)+
	move.w	#$000F,d1
	or.w	d1,-2(a1)
	and.l	d0,(a1)+
	move.l	#$00010001,d2
	and.l	d2,(a1)+
	move.w	#$FFFE,d3
	or.w	d3,-2(a1)
	and.l	d2,(a1)

	lea		132(a1),a1
	and.l	d5,(a1)+
	move.w	#$7FFF,d4
	or.w	d4,-2(a1)
	and.l	d5,(a1)+
	or.w	#$3FFF,-2(a1)
	move.l	#$07EE07EE,d5
	and.l	d5,(a1)+
	or.w	#$F800,-2(a1)
	and.l	d5,(a1)+
	or.w	d7,-2(a1)
	move.l	#$EFE0EFE0,d6
	and.l	d6,(a1)+
	or.w	#$001F,-2(a1)
	and.l	d6,(a1)+
	or.w	d1,-2(a1)
	and.l	d2,(a1)+
	or.w	d3,-2(a1)
	and.l	d2,(a1)
	or.w	#$FFFC,2(a1)

	move.l	#$80008000,d7
	lea		132(a1),a1
	and.l	d7,(a1)+
	or.w	d4,-2(a1)
	and.l	d7,(a1)+
	or.w	#$3146,-2(a1)
	move.l	#$03F703F7,d0
	and.l	d0,(a1)+
	move.w	#$FC00,d1
	or.w	d1,-2(a1)
	and.l	d0,(a1)+
	or.w	#$3800,-2(a1)
	move.l	#$DFC0DFC0,d2
	and.l	d2,(a1)+
	or.w	#$003F,-2(a1)
	and.l	d2,(a1)+
	or.w	#$001C,-2(a1)
	move.l	#$00010001,d3
	and.l	d3,(a1)+
	move.w	#$FFFE,d4
	or.w	d4,-2(a1)
	and.l	d3,(a1)
	or.w	#$518C,2(a1)

	lea		132(a1),a1
	and.l	d7,(a1)+
	move.w	#$7FFF,d5
	or.w	d5,-2(a1)
	and.l	d7,(a1)+
	or.w	#$375A,-2(a1)
	move.l	#$01FF01FF,d6
	and.l	d6,(a1)+
	or.w	#$FE00,-2(a1)
	and.l	d6,(a1)+
	or.w	d1,-2(a1)
	move.l	#$FF80FF80,d7
	and.l	d7,(a1)+
	or.w	#$007F,-2(a1)
	and.l	d7,(a1)+
	or.w	#$003D,-2(a1)
	and.l	d3,(a1)+
	or.w	d4,-2(a1)
	and.l	d3,(a1)
	or.w	#$D6BC,2(a1)

	move.l	#$80008000,d0
	lea		132(a1),a1
	and.l	d0,(a1)+
	or.w	d5,-2(a1)
	and.l	d0,(a1)+
	or.w	#$315A,-2(a1)
	move.l	#$00FE00FE,d1
	and.l	d1,(a1)+
	or.w	#$FF00,-2(a1)
	and.l	d1,(a1)+
	or.w	#$3E00,-2(a1)
	move.l	#$7F007F00,d2
	and.l	d2,(a1)+
	or.w	#$00FF,-2(a1)
	and.l	d2,(a1)+
	or.w	#$007C,-2(a1)
	and.l	d3,(a1)+
	or.w	d4,-2(a1)
	and.l	d3,(a1)
	or.w	#$568C,2(a1)

	lea		132(a1),a1
	and.l	d0,(a1)+
	or.w	d5,-2(a1)
	and.l	d0,(a1)+
	or.w	#$3746,-2(a1)
	move.l	#$01FC01FC,d3
	and.l	d3,(a1)+
	or.w	#$FE01,-2(a1)
	and.l	d3,(a1)+
	or.w	#$FC00,-2(a1)
	move.l	#$3F803F80,d4
	and.l	d4,(a1)+
	or.w	#$807F,-2(a1)
	and.l	d4,(a1)+
	or.w	#$003D,-2(a1)
	move.l	#$00010001,d5
	and.l	d5,(a1)+
	move.w	#$FFFE,d6
	or.w	d6,-2(a1)
	and.l	d5,(a1)
	or.w	#$D1BC,2(a1)

	lea		132(a1),a1
	and.l	d0,(a1)+
	move.w	#$7FFF,d7
	or.w	d7,-2(a1)
	and.l	d0,(a1)+
	or.w	#$375A,-2(a1)
	move.l	#$03FC03FC,d0
	and.l	d0,(a1)+
	or.w	#$FC01,-2(a1)
	and.l	d0,(a1)+
	or.w	#$3800,-2(a1)
	move.l	#$3FC03FC0,d1
	and.l	d1,(a1)+
	or.w	#$803F,-2(a1)
	and.l	d1,(a1)+
	or.w	#$001D,-2(a1)
	and.l	d5,(a1)+
	or.w	d6,-2(a1)
	and.l	d5,(a1)
	or.w	#$D68C,2(a1)

	move.l	#$80008000,d2
	lea		132(a1),a1
	and.l	d2,(a1)+
	or.w	d7,-2(a1)
	and.l	d2,(a1)+
	or.w	#$3FFF,-2(a1)
	move.l	#$07FC07FC,d3
	and.l	d3,(a1)+
	or.w	#$F801,-2(a1)
	and.l	d3,(a1)+
	or.w	#$F000,-2(a1)
	move.l	#$3FE03FE0,d4
	and.l	d4,(a1)+
	or.w	#$801F,-2(a1)
	and.l	d4,(a1)+
	or.w	#$000F,-2(a1)
	and.l	d5,(a1)+
	or.w	d6,-2(a1)
	and.l	d5,(a1)
	or.w	#$FFFC,2(a1)

	lea		132(a1),a1
	and.l	d2,(a1)+
	or.w	d7,-2(a1)
	and.l	d2,(a1)+
	move.l	#$0FFC0FFC,d5
	and.l	d5,(a1)+
	or.w	#$F001,-2(a1)
	and.l	d5,(a1)+
	move.l	#$0FF00FF0,d6
	and.l	d6,(a1)+
	or.w	#$800F,-2(a1)
	and.l	d6,(a1)+
	move.l	#$00010001,d7
	and.l	d7,(a1)+
	or.w	#$FFFE,-2(a1)
	and.l	d7,(a1)

	move.l	#$FFF8FFF8,d0
	lea		140(a1),a1
	and.l	d0,(a1)+
	or.w	d7,-2(a1)
	and.l	d0,(a1)+
	move.l	#$07FF07FF,d1
	and.l	d1,(a1)+
	or.w	#$F000,-2(a1)
	and.l	d1,(a1)

	move.l	#$FFF0FFF0,d2
	lea		148(a1),a1
	and.l	d2,(a1)+
	or.w	#$0005,-2(a1)
	and.l	d2,(a1)+
	move.l	#$03FF03FF,d3
	and.l	d3,(a1)+
	move.w	#$F800,d4
	or.w	d4,-2(a1)
	and.l	d3,(a1)

	lea		148(a1),a1
	and.l	d2,(a1)+
	move.w	#$0007,d5
	or.w	d5,-2(a1)
	and.l	d2,(a1)+
	and.l	d3,(a1)+
	or.w	d4,-2(a1)
	and.l	d3,(a1)

	lea		148(a1),a1
	and.l	d2,(a1)+
	or.w	d5,-2(a1)
	and.l	d2,(a1)+
	and.l	d3,(a1)+
	or.w	d4,-2(a1)
	and.l	d3,(a1)

	lea		148(a1),a1
	and.w	d0,(a1)
	or.w	#$0002,(a1)+
	and.w	d0,(a1)
	or.w	#$0003,(a1)+
	and.l	d0,(a1)+
	and.l	d3,(a1)+
	or.w	d4,-2(a1)
	and.l	d3,(a1)

	move.l	#$FFFCFFFC,d6
	lea		148(a1),a1
	and.w	d6,(a1)
	or.w	d7,(a1)+
	and.w	d6,(a1)
	or.w	d7,(a1)+
	and.l	d6,(a1)+
	and.w	d3,(a1)
	or.w	#$0800,(a1)+
	and.w	d3,(a1)
	or.w	d4,(a1)+
	and.l	d3,(a1)

	move.l	#$FFFEFFFE,d7
	lea		148(a1),a1
	and.l	d7,(a1)+
	and.l	d7,(a1)+
	and.w	d1,(a1)
	move.w	#$F000,d0
	or.w	d0,(a1)+
	and.w	d1,(a1)
	or.w	d0,(a1)+
	and.l	d1,(a1)

	lea		148(a1),a1
	and.l	d7,(a1)+
	and.l	d7,(a1)+
	and.l	d1,(a1)+
	and.l	d1,(a1)
